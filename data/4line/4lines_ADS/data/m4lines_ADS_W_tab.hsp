*** Created by ADS, Keysight ***
*** HSPICE netlist file for tabular W-element data ***

.subckt ckt_m4lines_ADS_W in1 in2 in3 in4 inref out1 out2 out3 out4 outref Length=1
W1 in1 in2 in3 in4 inref out1 out2 out3 out4 outref N=4 L=Length TABLEMODEL=m4lines_ADS_W
.model m4lines_ADS_W w modeltype=table n=4
+ lmodel=lmod_m4lines_ADS_W cmodel=cmod_m4lines_ADS_W
+ rmodel=rmod_m4lines_ADS_W gmodel=gmod_m4lines_ADS_W

.model lmod_m4lines_ADS_W sp n=4 valtype=real
+ interpolation=spline
+ extrapolation=step
+ spacing=nonuniform
+ dc=
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ infinity=
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ data=700
+ 100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 1900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 2900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 3900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 4900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 5900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 6900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 7900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 8900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 9900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 10900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 11900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 12900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 13900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 14900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 15900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 16900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 17900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 18900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 19900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 20900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 21900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 22900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 23900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 24900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 25900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 26900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 27900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 28900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 29900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 30900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 31900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 32900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 33900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 34900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 35900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 36900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 37900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 38900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 39900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 40900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 41900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 42900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 43900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 44900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 45900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 46900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 47900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 48900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 49900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 50900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 51900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 52900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 53900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 54900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 55900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 56900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 57900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 58900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 59900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 60900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 61900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 62900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 63900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 64900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 65900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 66900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 67900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 68900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69100000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69200000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69300000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69400000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69500000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69600000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69700000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69800000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 69900000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07
+ 70000000000
+ 4.12794306737e-07
+ 1.52367114e-07  4.09320510335e-07
+ 4.85327901752e-08  9.53873553683e-08  4.09320510335e-07
+ 2.78652167525e-08  4.85327901752e-08  1.52367114e-07  4.12794306737e-07

.model cmod_m4lines_ADS_W sp n=4 valtype=real
+ interpolation=spline
+ extrapolation=step
+ spacing=nonuniform
+ dc=
+ 8.41367043503e-11
+ -2.07645771956e-11  8.58145787573e-11
+ -8.96003752687e-13  -9.96590641528e-12  8.58145787573e-11
+ -3.69776303575e-13  -8.96003752687e-13  -2.07645771956e-11  8.41367043503e-11
+ infinity=
+ 8.13730643599e-11
+ -2.02657951465e-11  8.30335896281e-11
+ -8.92890511866e-13  -9.75207720374e-12  8.30335896281e-11
+ -3.71036910392e-13  -8.92890511866e-13  -2.02657951465e-11  8.13730643599e-11
+ data=700
+ 100000000
+ 8.41367043503e-11
+ -2.07645771956e-11  8.58145787573e-11
+ -8.96003752687e-13  -9.96590641528e-12  8.58145787573e-11
+ -3.69776303575e-13  -8.96003752687e-13  -2.07645771956e-11  8.41367043503e-11
+ 200000000
+ 8.38441764821e-11
+ -2.07117897982e-11  8.55202157938e-11
+ -8.95679827475e-13  -9.94327953117e-12  8.55202157938e-11
+ -3.69913965037e-13  -8.95679827475e-13  -2.07117897982e-11  8.38441764821e-11
+ 300000000
+ 8.36730586999e-11
+ -2.06809111121e-11  8.53480245424e-11
+ -8.9549031054e-13  -9.93004361727e-12  8.53480245424e-11
+ -3.69994467009e-13  -8.9549031054e-13  -2.06809111121e-11  8.36730586999e-11
+ 400000000
+ 8.3551648739e-11
+ -2.065900231e-11  8.52258529379e-11
+ -8.95355823566e-13  -9.92065256291e-12  8.52258529379e-11
+ -3.70051567001e-13  -8.95355823566e-13  -2.065900231e-11  8.3551648739e-11
+ 500000000
+ 8.34574758879e-11
+ -2.06420085034e-11  8.51310893065e-11
+ -8.95251490031e-13  -9.91336827697e-12  8.51310893065e-11
+ -3.70095844088e-13  -8.95251490031e-13  -2.06420085034e-11  8.34574758879e-11
+ 600000000
+ 8.33805310928e-11
+ -2.06281235369e-11  8.50536618055e-11
+ -8.95166229228e-13  -9.90741656724e-12  8.50536618055e-11
+ -3.70132010437e-13  -8.95166229228e-13  -2.06281235369e-11  8.33805310928e-11
+ 700000000
+ 8.33154752192e-11
+ -2.06163839522e-11  8.49881978074e-11
+ -8.95094130354e-13  -9.90238445603e-12  8.49881978074e-11
+ -3.70162579653e-13  -8.95094130354e-13  -2.06163839522e-11  8.33154752192e-11
+ 800000000
+ 8.325912128e-11
+ -2.06062146505e-11  8.49314903325e-11
+ -8.95031665185e-13  -9.89802543244e-12  8.49314903325e-11
+ -3.70189052129e-13  -8.95031665185e-13  -2.06062146505e-11  8.325912128e-11
+ 900000000
+ 8.3209413603e-11
+ -2.05972446812e-11  8.48814708128e-11
+ -8.94976557937e-13  -9.89418049189e-12  8.48814708128e-11
+ -3.70212395649e-13  -8.94976557937e-13  -2.05972446812e-11  8.3209413603e-11
+ 1000000000
+ 8.31649485897e-11
+ -2.0589220762e-11  8.4836726845e-11
+ -8.94927254723e-13  -9.89074106717e-12  8.4836726845e-11
+ -3.70233271006e-13  -8.94927254723e-13  -2.0589220762e-11  8.31649485897e-11
+ 1100000000
+ 8.31247251103e-11
+ -2.05819622368e-11  8.4796251019e-11
+ -8.94882647217e-13  -9.88762972169e-12  8.4796251019e-11
+ -3.70252149518e-13  -8.94882647217e-13  -2.05819622368e-11  8.31247251103e-11
+ 1200000000
+ 8.30880039678e-11
+ -2.0575335716e-11  8.47592995006e-11
+ -8.94841917071e-13  -9.88478927916e-12  8.47592995006e-11
+ -3.70269379188e-13  -8.94841917071e-13  -2.0575335716e-11  8.30880039678e-11
+ 1300000000
+ 8.30542238076e-11
+ -2.05692399018e-11  8.47253074139e-11
+ -8.94804442823e-13  -9.88217631926e-12  8.47253074139e-11
+ -3.70285224293e-13  -8.94804442823e-13  -2.05692399018e-11  8.30542238076e-11
+ 1400000000
+ 8.30229482801e-11
+ -2.05635960541e-11  8.46938356719e-11
+ -8.94769741399e-13  -9.8797570907e-12  8.46938356719e-11
+ -3.70299890259e-13  -8.94769741399e-13  -2.05635960541e-11  8.30229482801e-11
+ 1500000000
+ 8.29938314759e-11
+ -2.05583417526e-11  8.46645361952e-11
+ -8.94737429853e-13  -9.87750483764e-12  8.46645361952e-11
+ -3.70313539935e-13  -8.94737429853e-13  -2.05583417526e-11  8.29938314759e-11
+ 1600000000
+ 8.29665945395e-11
+ -2.05534266774e-11  8.4637128379e-11
+ -8.94707199468e-13  -9.87539799085e-12  8.4637128379e-11
+ -3.70326304602e-13  -8.94707199468e-13  -2.05534266774e-11  8.29665945395e-11
+ 1700000000
+ 8.29410093849e-11
+ -2.05488096699e-11  8.46113827066e-11
+ -8.94678797737e-13  -9.87341890807e-12  8.46113827066e-11
+ -3.70338291638e-13  -8.94678797737e-13  -2.05488096699e-11  8.29410093849e-11
+ 1800000000
+ 8.29168870736e-11
+ -2.05444566356e-11  8.45871090541e-11
+ -8.94652015489e-13  -9.87155297505e-12  8.45871090541e-11
+ -3.70349589993e-13  -8.94652015489e-13  -2.05444566356e-11  8.29168870736e-11
+ 1900000000
+ 8.28940693384e-11
+ -2.05403390149e-11  8.45641481616e-11
+ -8.9462667751e-13  -9.86978794994e-12  8.45641481616e-11
+ -3.70360274177e-13  -8.9462667751e-13  -2.05403390149e-11  8.28940693384e-11
+ 2000000000
+ 8.28724222841e-11
+ -2.05364326461e-11  8.45423652938e-11
+ -8.94602635568e-13  -9.86811347606e-12  8.45423652938e-11
+ -3.70370407225e-13  -8.94602635568e-13  -2.05364326461e-11  8.28724222841e-11
+ 2100000000
+ 8.28518316266e-11
+ -2.05327169064e-11  8.45216454499e-11
+ -8.94579763141e-13  -9.86652071363e-12  8.45216454499e-11
+ -3.7038004294e-13  -8.94579763141e-13  -2.05327169064e-11  8.28518316266e-11
+ 2200000000
+ 8.28321990411e-11
+ -2.05291740529e-11  8.45018896881e-11
+ -8.94557951377e-13  -9.8650020573e-12  8.45018896881e-11
+ -3.70389227611e-13  -8.94557951377e-13  -2.05291740529e-11  8.28321990411e-11
+ 2300000000
+ 8.28134393219e-11
+ -2.05257887101e-11  8.44830122682e-11
+ -8.94537105945e-13  -9.86355091649e-12  8.44830122682e-11
+ -3.70398001353e-13  -8.94537105945e-13  -2.05257887101e-11  8.28134393219e-11
+ 2400000000
+ 8.27954781477e-11
+ -2.05225474664e-11  8.44649384027e-11
+ -8.94517144565e-13  -9.86216154248e-12  8.44649384027e-11
+ -3.70406399154e-13  -8.94517144565e-13  -2.05225474664e-11  8.27954781477e-11
+ 2500000000
+ 8.27782503031e-11
+ -2.05194385536e-11  8.44476024671e-11
+ -8.94497995041e-13  -9.86082889094e-12  8.44476024671e-11
+ -3.70414451716e-13  -8.94497995041e-13  -2.05194385536e-11  8.27782503031e-11
+ 2600000000
+ 8.27616982493e-11
+ -2.05164515888e-11  8.44309465617e-11
+ -8.9447959367e-13  -9.85954851127e-12  8.44309465617e-11
+ -3.70422186128e-13  -8.9447959367e-13  -2.05164515888e-11  8.27616982493e-11
+ 2700000000
+ 8.27457709647e-11
+ -2.05135773649e-11  8.44149193447e-11
+ -8.9446188397e-13  -9.85831645701e-12  8.44149193447e-11
+ -3.7042962641e-13  -8.9446188397e-13  -2.05135773649e-11  8.27457709647e-11
+ 2800000000
+ 8.27304229962e-11
+ -2.05108076799e-11  8.43994750781e-11
+ -8.94444815618e-13  -9.85712921238e-12  8.43994750781e-11
+ -3.70436793961e-13  -8.94444815618e-13  -2.05108076799e-11  8.27304229962e-11
+ 2900000000
+ 8.27156136774e-11
+ -2.05081351954e-11  8.43845728402e-11
+ -8.94428343595e-13  -9.85598363188e-12  8.43845728402e-11
+ -3.70443707925e-13  -8.94428343595e-13  -2.05081351954e-11  8.27156136774e-11
+ 3000000000
+ 8.27013064791e-11
+ -2.05055533196e-11  8.43701758726e-11
+ -8.9441242746e-13  -9.85487688999e-12  8.43701758726e-11
+ -3.704503855e-13  -8.9441242746e-13  -2.05055533196e-11  8.27013064791e-11
+ 3100000000
+ 8.26874684664e-11
+ -2.05030561095e-11  8.43562510339e-11
+ -8.94397030751e-13  -9.85380643923e-12  8.43562510339e-11
+ -3.70456842191e-13  -8.94397030751e-13  -2.05030561095e-11  8.26874684664e-11
+ 3200000000
+ 8.26740698423e-11
+ -2.05006381879e-11  8.43427683403e-11
+ -8.9438212048e-13  -9.85276997484e-12  8.43427683403e-11
+ -3.70463092026e-13  -8.9438212048e-13  -2.05006381879e-11  8.26740698423e-11
+ 3300000000
+ 8.26610835612e-11
+ -2.04982946745e-11  8.43297005762e-11
+ -8.94367666706e-13  -9.85176540484e-12  8.43297005762e-11
+ -3.70469147737e-13  -8.94367666706e-13  -2.04982946745e-11  8.26610835612e-11
+ 3400000000
+ 8.26484850001e-11
+ -2.04960211261e-11  8.43170229645e-11
+ -8.94353642169e-13  -9.85079082467e-12  8.43170229645e-11
+ -3.70475020917e-13  -8.94353642169e-13  -2.04960211261e-11  8.26484850001e-11
+ 3500000000
+ 8.2636251678e-11
+ -2.04938134858e-11  8.43047128829e-11
+ -8.94340021981e-13  -9.84984449545e-12  8.43047128829e-11
+ -3.70480722149e-13  -8.94340021981e-13  -2.04938134858e-11  8.2636251678e-11
+ 3600000000
+ 8.26243630139e-11
+ -2.04916680398e-11  8.42927496214e-11
+ -8.94326783357e-13  -9.84892482525e-12  8.42927496214e-11
+ -3.70486261122e-13  -8.94326783357e-13  -2.04916680398e-11  8.26243630139e-11
+ 3700000000
+ 8.26128001192e-11
+ -2.04895813796e-11  8.42811141729e-11
+ -8.94313905386e-13  -9.84803035305e-12  8.42811141729e-11
+ -3.70491646729e-13  -8.94313905386e-13  -2.04895813796e-11  8.26128001192e-11
+ 3800000000
+ 8.26015456164e-11
+ -2.04875503694e-11  8.4269789051e-11
+ -8.9430136883e-13  -9.84715973473e-12  8.4269789051e-11
+ -3.70496887151e-13  -8.9430136883e-13  -2.04875503694e-11  8.26015456164e-11
+ 3900000000
+ 8.25905834827e-11
+ -2.04855721179e-11  8.42587581323e-11
+ -8.9428915595e-13  -9.84631173092e-12  8.42587581323e-11
+ -3.70501989931e-13  -8.9428915595e-13  -2.04855721179e-11  8.25905834827e-11
+ 4000000000
+ 8.25798989124e-11
+ -2.04836439532e-11  8.42480065181e-11
+ -8.94277250355e-13  -9.84548519641e-12  8.42480065181e-11
+ -3.70506962039e-13  -8.94277250355e-13  -2.04836439532e-11  8.25798989124e-11
+ 4100000000
+ 8.25694781967e-11
+ -2.04817634017e-11  8.42375204137e-11
+ -8.94265636869e-13  -9.84467907084e-12  8.42375204137e-11
+ -3.70511809929e-13  -8.94265636869e-13  -2.04817634017e-11  8.25694781967e-11
+ 4200000000
+ 8.2559308618e-11
+ -2.04799281685e-11  8.42272870218e-11
+ -8.94254301411e-13  -9.84389237053e-12  8.42272870218e-11
+ -3.70516539588e-13  -8.94254301411e-13  -2.04799281685e-11  8.2559308618e-11
+ 4300000000
+ 8.25493783566e-11
+ -2.04781361205e-11  8.42172944485e-11
+ -8.94243230897e-13  -9.84312418121e-12  8.42172944485e-11
+ -3.70521156582e-13  -8.94243230897e-13  -2.04781361205e-11  8.25493783566e-11
+ 4400000000
+ 8.25396764082e-11
+ -2.04763852721e-11  8.42075316203e-11
+ -8.94232413144e-13  -9.84237365172e-12  8.42075316203e-11
+ -3.7052566609e-13  -8.94232413144e-13  -2.04763852721e-11  8.25396764082e-11
+ 4500000000
+ 8.25301925103e-11
+ -2.04746737715e-11  8.41979882106e-11
+ -8.9422183679e-13  -9.84163998827e-12  8.41979882106e-11
+ -3.70530072944e-13  -8.9422183679e-13  -2.04746737715e-11  8.25301925103e-11
+ 4600000000
+ 8.25209170773e-11
+ -2.04729998887e-11  8.41886545735e-11
+ -8.94211491224e-13  -9.84092244941e-12  8.41886545735e-11
+ -3.70534381656e-13  -8.94211491224e-13  -2.04729998887e-11  8.25209170773e-11
+ 4700000000
+ 8.25118411421e-11
+ -2.04713620058e-11  8.41795216857e-11
+ -8.94201366518e-13  -9.84022034155e-12  8.41795216857e-11
+ -3.70538596449e-13  -8.94201366518e-13  -2.04713620058e-11  8.25118411421e-11
+ 4800000000
+ 8.25029563041e-11
+ -2.04697586068e-11  8.41705810938e-11
+ -8.94191453372e-13  -9.83953301489e-12  8.41705810938e-11
+ -3.70542721277e-13  -8.94191453372e-13  -2.04697586068e-11  8.25029563041e-11
+ 4900000000
+ 8.24942546822e-11
+ -2.04681882695e-11  8.41618248674e-11
+ -8.94181743062e-13  -9.83885985986e-12  8.41618248674e-11
+ -3.70546759849e-13  -8.94181743062e-13  -2.04681882695e-11  8.24942546822e-11
+ 5000000000
+ 8.24857288731e-11
+ -2.04666496581e-11  8.41532455568e-11
+ -8.9417222739e-13  -9.83820030381e-12  8.41532455568e-11
+ -3.70550715653e-13  -8.9417222739e-13  -2.04666496581e-11  8.24857288731e-11
+ 5100000000
+ 8.24773719135e-11
+ -2.04651415158e-11  8.41448361548e-11
+ -8.94162898648e-13  -9.83755380814e-12  8.41448361548e-11
+ -3.70554591965e-13  -8.94162898648e-13  -2.04651415158e-11  8.24773719135e-11
+ 5200000000
+ 8.24691772456e-11
+ -2.04636626595e-11  8.41365900627e-11
+ -8.94153749577e-13  -9.83691986559e-12  8.41365900627e-11
+ -3.70558391874e-13  -8.94153749577e-13  -2.04636626595e-11  8.24691772456e-11
+ 5300000000
+ 8.24611386865e-11
+ -2.04622119734e-11  8.41285010586e-11
+ -8.9414477333e-13  -9.83629799794e-12  8.41285010586e-11
+ -3.70562118289e-13  -8.9414477333e-13  -2.04622119734e-11  8.24611386865e-11
+ 5400000000
+ 8.24532504e-11
+ -2.04607884043e-11  8.41205632698e-11
+ -8.94135963448e-13  -9.83568775375e-12  8.41205632698e-11
+ -3.70565773959e-13  -8.94135963448e-13  -2.04607884043e-11  8.24532504e-11
+ 5500000000
+ 8.24455068711e-11
+ -2.0459390957e-11  8.41127711467e-11
+ -8.94127313823e-13  -9.83508870645e-12  8.41127711467e-11
+ -3.7056936148e-13  -8.94127313823e-13  -2.0459390957e-11  8.24455068711e-11
+ 5600000000
+ 8.24379028832e-11
+ -2.04580186902e-11  8.41051194399e-11
+ -8.94118818683e-13  -9.83450045253e-12  8.41051194399e-11
+ -3.70572883308e-13  -8.94118818683e-13  -2.04580186902e-11  8.24379028832e-11
+ 5700000000
+ 8.24304334963e-11
+ -2.04566707124e-11  8.40976031786e-11
+ -8.94110472556e-13  -9.8339226099e-12  8.40976031786e-11
+ -3.70576341768e-13  -8.94110472556e-13  -2.04566707124e-11  8.24304334963e-11
+ 5800000000
+ 8.24230940286e-11
+ -2.04553461788e-11  8.40902176515e-11
+ -8.94102270261e-13  -9.83335481641e-12  8.40902176515e-11
+ -3.70579739064e-13  -8.94102270261e-13  -2.04553461788e-11  8.24230940286e-11
+ 5900000000
+ 8.24158800382e-11
+ -2.04540442879e-11  8.40829583888e-11
+ -8.94094206879e-13  -9.83279672849e-12  8.40829583888e-11
+ -3.70583077289e-13  -8.94094206879e-13  -2.04540442879e-11  8.24158800382e-11
+ 6000000000
+ 8.24087873073e-11
+ -2.04527642785e-11  8.40758211462e-11
+ -8.94086277741e-13  -9.83224801989e-12  8.40758211462e-11
+ -3.70586358426e-13  -8.94086277741e-13  -2.04527642785e-11  8.24087873073e-11
+ 6100000000
+ 8.24018118269e-11
+ -2.04515054273e-11  8.40688018898e-11
+ -8.94078478409e-13  -9.83170838053e-12  8.40688018898e-11
+ -3.70589584365e-13  -8.94078478409e-13  -2.04515054273e-11  8.24018118269e-11
+ 6200000000
+ 8.23949497842e-11
+ -2.04502670461e-11  8.40618967825e-11
+ -8.94070804662e-13  -9.83117751548e-12  8.40618967825e-11
+ -3.70592756899e-13  -8.94070804662e-13  -2.04502670461e-11  8.23949497842e-11
+ 6300000000
+ 8.23881975488e-11
+ -2.04490484798e-11  8.40551021715e-11
+ -8.9406325248e-13  -9.83065514394e-12  8.40551021715e-11
+ -3.70595877737e-13  -8.9406325248e-13  -2.04490484798e-11  8.23881975488e-11
+ 6400000000
+ 8.23815516624e-11
+ -2.04478491045e-11  8.40484145766e-11
+ -8.94055818036e-13  -9.8301409984e-12  8.40484145766e-11
+ -3.70598948509e-13  -8.94055818036e-13  -2.04478491045e-11  8.23815516624e-11
+ 6500000000
+ 8.2375008827e-11
+ -2.0446668325e-11  8.40418306792e-11
+ -8.94048497677e-13  -9.82963482379e-12  8.40418306792e-11
+ -3.70601970766e-13  -8.94048497677e-13  -2.0446668325e-11  8.2375008827e-11
+ 6600000000
+ 8.23685658961e-11
+ -2.04455055735e-11  8.4035347313e-11
+ -8.94041287921e-13  -9.82913637671e-12  8.4035347313e-11
+ -3.70604945991e-13  -8.94041287921e-13  -2.04455055735e-11  8.23685658961e-11
+ 6700000000
+ 8.23622198651e-11
+ -2.04443603077e-11  8.40289614545e-11
+ -8.94034185441e-13  -9.82864542475e-12  8.40289614545e-11
+ -3.70607875596e-13  -8.94034185441e-13  -2.04443603077e-11  8.23622198651e-11
+ 6800000000
+ 8.23559678627e-11
+ -2.04432320096e-11  8.40226702144e-11
+ -8.94027187059e-13  -9.82816174583e-12  8.40226702144e-11
+ -3.70610760935e-13  -8.94027187059e-13  -2.04432320096e-11  8.23559678627e-11
+ 6900000000
+ 8.23498071435e-11
+ -2.04421201838e-11  8.40164708303e-11
+ -8.94020289734e-13  -9.8276851276e-12  8.40164708303e-11
+ -3.706136033e-13  -8.94020289734e-13  -2.04421201838e-11  8.23498071435e-11
+ 7000000000
+ 8.23437350807e-11
+ -2.04410243562e-11  8.40103606588e-11
+ -8.94013490559e-13  -9.82721536687e-12  8.40103606588e-11
+ -3.70616403926e-13  -8.94013490559e-13  -2.04410243562e-11  8.23437350807e-11
+ 7100000000
+ 8.23377491593e-11
+ -2.0439944073e-11  8.40043371689e-11
+ -8.9400678675e-13  -9.8267522691e-12  8.40043371689e-11
+ -3.70619163999e-13  -8.9400678675e-13  -2.0439944073e-11  8.23377491593e-11
+ 7200000000
+ 8.23318469696e-11
+ -2.04388788994e-11  8.3998397936e-11
+ -8.94000175639e-13  -9.82629564792e-12  8.3998397936e-11
+ -3.70621884653e-13  -8.94000175639e-13  -2.04388788994e-11  8.23318469696e-11
+ 7300000000
+ 8.23260262018e-11
+ -2.04378284185e-11  8.39925406359e-11
+ -8.93993654668e-13  -9.82584532465e-12  8.39925406359e-11
+ -3.70624566975e-13  -8.93993654668e-13  -2.04378284185e-11  8.23260262018e-11
+ 7400000000
+ 8.23202846404e-11
+ -2.04367922306e-11  8.39867630389e-11
+ -8.93987221386e-13  -9.82540112794e-12  8.39867630389e-11
+ -3.70627212009e-13  -8.93987221386e-13  -2.04367922306e-11  8.23202846404e-11
+ 7500000000
+ 8.2314620159e-11
+ -2.0435769952e-11  8.39810630056e-11
+ -8.93980873437e-13  -9.82496289331e-12  8.39810630056e-11
+ -3.70629820754e-13  -8.93980873437e-13  -2.0435769952e-11  8.2314620159e-11
+ 7600000000
+ 8.23090307158e-11
+ -2.04347612142e-11  8.39754384812e-11
+ -8.93974608562e-13  -9.82453046282e-12  8.39754384812e-11
+ -3.70632394173e-13  -8.93974608562e-13  -2.04347612142e-11  8.23090307158e-11
+ 7700000000
+ 8.23035143491e-11
+ -2.04337656632e-11  8.39698874916e-11
+ -8.93968424589e-13  -9.82410368473e-12  8.39698874916e-11
+ -3.70634933189e-13  -8.93968424589e-13  -2.04337656632e-11  8.23035143491e-11
+ 7800000000
+ 8.2298069173e-11
+ -2.04327829586e-11  8.39644081393e-11
+ -8.93962319429e-13  -9.82368241319e-12  8.39644081393e-11
+ -3.7063743869e-13  -8.93962319429e-13  -2.04327829586e-11  8.2298069173e-11
+ 7900000000
+ 8.22926933738e-11
+ -2.04318127733e-11  8.39589985991e-11
+ -8.93956291075e-13  -9.82326650789e-12  8.39589985991e-11
+ -3.70639911529e-13  -8.93956291075e-13  -2.04318127733e-11  8.22926933738e-11
+ 8000000000
+ 8.22873852062e-11
+ -2.04308547923e-11  8.39536571148e-11
+ -8.93950337596e-13  -9.82285583384e-12  8.39536571148e-11
+ -3.70642352529e-13  -8.93950337596e-13  -2.04308547923e-11  8.22873852062e-11
+ 8100000000
+ 8.228214299e-11
+ -2.04299087123e-11  8.39483819955e-11
+ -8.93944457129e-13  -9.82245026108e-12  8.39483819955e-11
+ -3.70644762481e-13  -8.93944457129e-13  -2.04299087123e-11  8.228214299e-11
+ 8200000000
+ 8.22769651067e-11
+ -2.04289742414e-11  8.39431716127e-11
+ -8.93938647885e-13  -9.82204966442e-12  8.39431716127e-11
+ -3.70647142146e-13  -8.93938647885e-13  -2.04289742414e-11  8.22769651067e-11
+ 8300000000
+ 8.22718499968e-11
+ -2.04280510981e-11  8.39380243972e-11
+ -8.93932908136e-13  -9.82165392323e-12  8.39380243972e-11
+ -3.70649492258e-13  -8.93932908136e-13  -2.04280510981e-11  8.22718499968e-11
+ 8400000000
+ 8.22667961568e-11
+ -2.0427139011e-11  8.39329388359e-11
+ -8.93927236218e-13  -9.82126292123e-12  8.39329388359e-11
+ -3.70651813526e-13  -8.93927236218e-13  -2.0427139011e-11  8.22667961568e-11
+ 8500000000
+ 8.22618021366e-11
+ -2.04262377185e-11  8.39279134696e-11
+ -8.93921630525e-13  -9.82087654623e-12  8.39279134696e-11
+ -3.70654106632e-13  -8.93921630525e-13  -2.04262377185e-11  8.22618021366e-11
+ 8600000000
+ 8.22568665369e-11
+ -2.04253469682e-11  8.39229468904e-11
+ -8.93916089509e-13  -9.82049469001e-12  8.39229468904e-11
+ -3.70656372234e-13  -8.93916089509e-13  -2.04253469682e-11  8.22568665369e-11
+ 8700000000
+ 8.22519880071e-11
+ -2.04244665162e-11  8.3918037739e-11
+ -8.93910611674e-13  -9.8201172481e-12  8.3918037739e-11
+ -3.70658610969e-13  -8.93910611674e-13  -2.04244665162e-11  8.22519880071e-11
+ 8800000000
+ 8.22471652426e-11
+ -2.04235961273e-11  8.39131847028e-11
+ -8.93905195576e-13  -9.81974411961e-12  8.39131847028e-11
+ -3.70660823452e-13  -8.93905195576e-13  -2.04235961273e-11  8.22471652426e-11
+ 8900000000
+ 8.22423969834e-11
+ -2.04227355739e-11  8.39083865138e-11
+ -8.93899839819e-13  -9.81937520704e-12  8.39083865138e-11
+ -3.70663010274e-13  -8.93899839819e-13  -2.04227355739e-11  8.22423969834e-11
+ 9000000000
+ 8.22376820115e-11
+ -2.04218846363e-11  8.39036419464e-11
+ -8.93894543056e-13  -9.81901041621e-12  8.39036419464e-11
+ -3.70665172009e-13  -8.93894543056e-13  -2.04218846363e-11  8.22376820115e-11
+ 9100000000
+ 8.22330191494e-11
+ -2.04210431021e-11  8.38989498156e-11
+ -8.93889303983e-13  -9.81864965603e-12  8.38989498156e-11
+ -3.70667309213e-13  -8.93889303983e-13  -2.04210431021e-11  8.22330191494e-11
+ 9200000000
+ 8.2228407258e-11
+ -2.04202107656e-11  8.38943089754e-11
+ -8.93884121339e-13  -9.81829283839e-12  8.38943089754e-11
+ -3.7066942242e-13  -8.93884121339e-13  -2.04202107656e-11  8.2228407258e-11
+ 9300000000
+ 8.22238452354e-11
+ -2.04193874281e-11  8.38897183167e-11
+ -8.93878993904e-13  -9.81793987807e-12  8.38897183167e-11
+ -3.7067151215e-13  -8.93878993904e-13  -2.04193874281e-11  8.22238452354e-11
+ 9400000000
+ 8.2219332015e-11
+ -2.0418572897e-11  8.38851767663e-11
+ -8.93873920497e-13  -9.81759069255e-12  8.38851767663e-11
+ -3.70673578905e-13  -8.93873920497e-13  -2.0418572897e-11  8.2219332015e-11
+ 9500000000
+ 8.22148665638e-11
+ -2.0417766986e-11  8.3880683285e-11
+ -8.93868899974e-13  -9.81724520195e-12  8.3880683285e-11
+ -3.70675623172e-13  -8.93868899974e-13  -2.0417766986e-11  8.22148665638e-11
+ 9600000000
+ 8.22104478817e-11
+ -2.04169695145e-11  8.3876236866e-11
+ -8.93863931229e-13  -9.81690332889e-12  8.3876236866e-11
+ -3.7067764542e-13  -8.93863931229e-13  -2.04169695145e-11  8.22104478817e-11
+ 9700000000
+ 8.22060749993e-11
+ -2.04161803078e-11  8.3871836534e-11
+ -8.93859013188e-13  -9.81656499841e-12  8.3871836534e-11
+ -3.70679646107e-13  -8.93859013188e-13  -2.04161803078e-11  8.22060749993e-11
+ 9800000000
+ 8.22017469772e-11
+ -2.04153991961e-11  8.38674813438e-11
+ -8.93854144811e-13  -9.81623013784e-12  8.38674813438e-11
+ -3.70681625675e-13  -8.93854144811e-13  -2.04153991961e-11  8.22017469772e-11
+ 9900000000
+ 8.21974629046e-11
+ -2.04146260153e-11  8.38631703788e-11
+ -8.9384932509e-13  -9.81589867673e-12  8.38631703788e-11
+ -3.70683584552e-13  -8.9384932509e-13  -2.04146260153e-11  8.21974629046e-11
+ 10000000000
+ 8.21932218982e-11
+ -2.04138606058e-11  8.38589027501e-11
+ -8.93844553046e-13  -9.81557054675e-12  8.38589027501e-11
+ -3.70685523155e-13  -8.93844553046e-13  -2.04138606058e-11  8.21932218982e-11
+ 10100000000
+ 8.2189023101e-11
+ -2.04131028131e-11  8.38546775955e-11
+ -8.93839827732e-13  -9.81524568162e-12  8.38546775955e-11
+ -3.70687441886e-13  -8.93839827732e-13  -2.04131028131e-11  8.2189023101e-11
+ 10200000000
+ 8.21848656814e-11
+ -2.0412352487e-11  8.38504940779e-11
+ -8.93835148227e-13  -9.81492401701e-12  8.38504940779e-11
+ -3.70689341138e-13  -8.93835148227e-13  -2.0412352487e-11  8.21848656814e-11
+ 10300000000
+ 8.21807488319e-11
+ -2.0411609482e-11  8.38463513851e-11
+ -8.93830513636e-13  -9.81460549048e-12  8.38463513851e-11
+ -3.7069122129e-13  -8.93830513636e-13  -2.0411609482e-11  8.21807488319e-11
+ 10400000000
+ 8.21766717689e-11
+ -2.04108736565e-11  8.38422487282e-11
+ -8.93825923092e-13  -9.81429004139e-12  8.38422487282e-11
+ -3.70693082712e-13  -8.93825923092e-13  -2.04108736565e-11  8.21766717689e-11
+ 10500000000
+ 8.21726337308e-11
+ -2.04101448731e-11  8.38381853411e-11
+ -8.93821375751e-13  -9.81397761085e-12  8.38381853411e-11
+ -3.70694925761e-13  -8.93821375751e-13  -2.04101448731e-11  8.21726337308e-11
+ 10600000000
+ 8.21686339778e-11
+ -2.04094229983e-11  8.38341604793e-11
+ -8.93816870796e-13  -9.81366814163e-12  8.38341604793e-11
+ -3.70696750787e-13  -8.93816870796e-13  -2.04094229983e-11  8.21686339778e-11
+ 10700000000
+ 8.21646717912e-11
+ -2.04087079025e-11  8.38301734195e-11
+ -8.9381240743e-13  -9.81336157814e-12  8.38301734195e-11
+ -3.70698558127e-13  -8.9381240743e-13  -2.04087079025e-11  8.21646717912e-11
+ 10800000000
+ 8.2160746472e-11
+ -2.04079994595e-11  8.38262234584e-11
+ -8.93807984879e-13  -9.81305786632e-12  8.38262234584e-11
+ -3.70700348111e-13  -8.93807984879e-13  -2.04079994595e-11  8.2160746472e-11
+ 10900000000
+ 8.21568573407e-11
+ -2.04072975467e-11  8.38223099123e-11
+ -8.93803602392e-13  -9.81275695361e-12  8.38223099123e-11
+ -3.70702121059e-13  -8.93803602392e-13  -2.04072975467e-11  8.21568573407e-11
+ 11000000000
+ 8.21530037365e-11
+ -2.04066020448e-11  8.3818432116e-11
+ -8.93799259236e-13  -9.81245878888e-12  8.3818432116e-11
+ -3.70703877281e-13  -8.93799259236e-13  -2.04066020448e-11  8.21530037365e-11
+ 11100000000
+ 8.21491850163e-11
+ -2.04059128378e-11  8.38145894226e-11
+ -8.93794954699e-13  -9.81216332241e-12  8.38145894226e-11
+ -3.70705617081e-13  -8.93794954699e-13  -2.04059128378e-11  8.21491850163e-11
+ 11200000000
+ 8.21454005545e-11
+ -2.04052298128e-11  8.38107812026e-11
+ -8.9379068809e-13  -9.81187050579e-12  8.38107812026e-11
+ -3.70707340752e-13  -8.9379068809e-13  -2.04052298128e-11  8.21454005545e-11
+ 11300000000
+ 8.21416497422e-11
+ -2.04045528599e-11  8.3807006843e-11
+ -8.93786458733e-13  -9.81158029193e-12  8.3807006843e-11
+ -3.70709048582e-13  -8.93786458733e-13  -2.04045528599e-11  8.21416497422e-11
+ 11400000000
+ 8.21379319864e-11
+ -2.04038818722e-11  8.38032657474e-11
+ -8.93782265973e-13  -9.81129263498e-12  8.38032657474e-11
+ -3.7071074085e-13  -8.93782265973e-13  -2.04038818722e-11  8.21379319864e-11
+ 11500000000
+ 8.21342467098e-11
+ -2.04032167454e-11  8.37995573347e-11
+ -8.9377810917e-13  -9.81100749026e-12  8.37995573347e-11
+ -3.70712417827e-13  -8.9377810917e-13  -2.04032167454e-11  8.21342467098e-11
+ 11600000000
+ 8.213059335e-11
+ -2.0402557378e-11  8.37958810391e-11
+ -8.93773987702e-13  -9.81072481428e-12  8.37958810391e-11
+ -3.70714079779e-13  -8.93773987702e-13  -2.0402557378e-11  8.213059335e-11
+ 11700000000
+ 8.21269713592e-11
+ -2.04019036713e-11  8.37922363093e-11
+ -8.93769900962e-13  -9.81044456467e-12  8.37922363093e-11
+ -3.70715726962e-13  -8.93769900962e-13  -2.04019036713e-11  8.21269713592e-11
+ 11800000000
+ 8.21233802036e-11
+ -2.04012555288e-11  8.3788622608e-11
+ -8.93765848359e-13  -9.81016670014e-12  8.3788622608e-11
+ -3.7071735963e-13  -8.93765848359e-13  -2.04012555288e-11  8.21233802036e-11
+ 11900000000
+ 8.21198193627e-11
+ -2.04006128567e-11  8.37850394116e-11
+ -8.93761829317e-13  -9.80989118042e-12  8.37850394116e-11
+ -3.70718978026e-13  -8.93761829317e-13  -2.04006128567e-11  8.21198193627e-11
+ 12000000000
+ 8.21162883292e-11
+ -2.03999755634e-11  8.37814862097e-11
+ -8.93757843275e-13  -9.80961796629e-12  8.37814862097e-11
+ -3.70720582389e-13  -8.93757843275e-13  -2.03999755634e-11  8.21162883292e-11
+ 12100000000
+ 8.21127866085e-11
+ -2.03993435597e-11  8.37779625044e-11
+ -8.93753889684e-13  -9.80934701947e-12  8.37779625044e-11
+ -3.70722172952e-13  -8.93753889684e-13  -2.03993435597e-11  8.21127866085e-11
+ 12200000000
+ 8.21093137182e-11
+ -2.03987167584e-11  8.37744678104e-11
+ -8.93749968012e-13  -9.80907830266e-12  8.37744678104e-11
+ -3.70723749943e-13  -8.93749968012e-13  -2.03987167584e-11  8.21093137182e-11
+ 12300000000
+ 8.21058691875e-11
+ -2.03980950748e-11  8.37710016539e-11
+ -8.93746077735e-13  -9.80881177945e-12  8.37710016539e-11
+ -3.70725313583e-13  -8.93746077735e-13  -2.03980950748e-11  8.21058691875e-11
+ 12400000000
+ 8.21024525574e-11
+ -2.03974784258e-11  8.37675635729e-11
+ -8.93742218347e-13  -9.80854741432e-12  8.37675635729e-11
+ -3.70726864088e-13  -8.93742218347e-13  -2.03974784258e-11  8.21024525574e-11
+ 12500000000
+ 8.20990633795e-11
+ -2.03968667307e-11  8.37641531165e-11
+ -8.93738389352e-13  -9.80828517261e-12  8.37641531165e-11
+ -3.70728401669e-13  -8.93738389352e-13  -2.03968667307e-11  8.20990633795e-11
+ 12600000000
+ 8.20957012166e-11
+ -2.03962599104e-11  8.37607698444e-11
+ -8.93734590264e-13  -9.80802502048e-12  8.37607698444e-11
+ -3.70729926532e-13  -8.93734590264e-13  -2.03962599104e-11  8.20957012166e-11
+ 12700000000
+ 8.20923656416e-11
+ -2.03956578881e-11  8.3757413327e-11
+ -8.93730820611e-13  -9.8077669249e-12  8.3757413327e-11
+ -3.70731438878e-13  -8.93730820611e-13  -2.03956578881e-11  8.20923656416e-11
+ 12800000000
+ 8.20890562374e-11
+ -2.03950605883e-11  8.37540831447e-11
+ -8.93727079932e-13  -9.80751085362e-12  8.37540831447e-11
+ -3.70732938903e-13  -8.93727079932e-13  -2.03950605883e-11  8.20890562374e-11
+ 12900000000
+ 8.20857725968e-11
+ -2.03944679375e-11  8.37507788876e-11
+ -8.93723367775e-13  -9.80725677513e-12  8.37507788876e-11
+ -3.707344268e-13  -8.93723367775e-13  -2.03944679375e-11  8.20857725968e-11
+ 13000000000
+ 8.20825143219e-11
+ -2.03938798641e-11  8.37475001553e-11
+ -8.93719683701e-13  -9.80700465865e-12  8.37475001553e-11
+ -3.70735902755e-13  -8.93719683701e-13  -2.03938798641e-11  8.20825143219e-11
+ 13100000000
+ 8.20792810241e-11
+ -2.03932962979e-11  8.37442465568e-11
+ -8.93716027278e-13  -9.80675447414e-12  8.37442465568e-11
+ -3.70737366951e-13  -8.93716027278e-13  -2.03932962979e-11  8.20792810241e-11
+ 13200000000
+ 8.20760723236e-11
+ -2.03927171703e-11  8.37410177098e-11
+ -8.93712398087e-13  -9.8065061922e-12  8.37410177098e-11
+ -3.70738819568e-13  -8.93712398087e-13  -2.03927171703e-11  8.20760723236e-11
+ 13300000000
+ 8.20728878491e-11
+ -2.03921424143e-11  8.37378132409e-11
+ -8.93708795716e-13  -9.80625978413e-12  8.37378132409e-11
+ -3.7074026078e-13  -8.93708795716e-13  -2.03921424143e-11  8.20728878491e-11
+ 13400000000
+ 8.20697272377e-11
+ -2.03915719645e-11  8.37346327847e-11
+ -8.93705219763e-13  -9.80601522186e-12  8.37346327847e-11
+ -3.70741690757e-13  -8.93705219763e-13  -2.03915719645e-11  8.20697272377e-11
+ 13500000000
+ 8.20665901347e-11
+ -2.03910057568e-11  8.37314759845e-11
+ -8.93701669837e-13  -9.80577247793e-12  8.37314759845e-11
+ -3.70743109668e-13  -8.93701669837e-13  -2.03910057568e-11  8.20665901347e-11
+ 13600000000
+ 8.20634761931e-11
+ -2.03904437287e-11  8.37283424909e-11
+ -8.93698145552e-13  -9.80553152553e-12  8.37283424909e-11
+ -3.70744517674e-13  -8.93698145552e-13  -2.03904437287e-11  8.20634761931e-11
+ 13700000000
+ 8.20603850737e-11
+ -2.03898858189e-11  8.37252319626e-11
+ -8.93694646534e-13  -9.8052923384e-12  8.37252319626e-11
+ -3.70745914937e-13  -8.93694646534e-13  -2.03898858189e-11  8.20603850737e-11
+ 13800000000
+ 8.20573164445e-11
+ -2.03893319674e-11  8.37221440657e-11
+ -8.93691172414e-13  -9.80505489086e-12  8.37221440657e-11
+ -3.70747301611e-13  -8.93691172414e-13  -2.03893319674e-11  8.20573164445e-11
+ 13900000000
+ 8.20542699808e-11
+ -2.03887821158e-11  8.37190784733e-11
+ -8.93687722833e-13  -9.80481915782e-12  8.37190784733e-11
+ -3.70748677851e-13  -8.93687722833e-13  -2.03887821158e-11  8.20542699808e-11
+ 14000000000
+ 8.20512453649e-11
+ -2.03882362067e-11  8.37160348658e-11
+ -8.9368429744e-13  -9.80458511468e-12  8.37160348658e-11
+ -3.70750043805e-13  -8.9368429744e-13  -2.03882362067e-11  8.20512453649e-11
+ 14100000000
+ 8.20482422858e-11
+ -2.03876941839e-11  8.37130129302e-11
+ -8.9368089589e-13  -9.80435273741e-12  8.37130129302e-11
+ -3.70751399621e-13  -8.9368089589e-13  -2.03876941839e-11  8.20482422858e-11
+ 14200000000
+ 8.20452604392e-11
+ -2.03871559926e-11  8.37100123602e-11
+ -8.93677517847e-13  -9.80412200244e-12  8.37100123602e-11
+ -3.70752745441e-13  -8.93677517847e-13  -2.03871559926e-11  8.20452604392e-11
+ 14300000000
+ 8.20422995271e-11
+ -2.0386621579e-11  8.37070328562e-11
+ -8.9367416298e-13  -9.80389288675e-12  8.37070328562e-11
+ -3.70754081405e-13  -8.9367416298e-13  -2.0386621579e-11  8.20422995271e-11
+ 14400000000
+ 8.20393592579e-11
+ -2.03860908904e-11  8.37040741245e-11
+ -8.93670830966e-13  -9.80366536777e-12  8.37040741245e-11
+ -3.70755407651e-13  -8.93670830966e-13  -2.03860908904e-11  8.20393592579e-11
+ 14500000000
+ 8.20364393459e-11
+ -2.03855638753e-11  8.37011358776e-11
+ -8.9366752149e-13  -9.80343942339e-12  8.37011358776e-11
+ -3.70756724314e-13  -8.9366752149e-13  -2.03855638753e-11  8.20364393459e-11
+ 14600000000
+ 8.20335395112e-11
+ -2.03850404832e-11  8.36982178341e-11
+ -8.93664234241e-13  -9.80321503199e-12  8.36982178341e-11
+ -3.70758031524e-13  -8.93664234241e-13  -2.03850404832e-11  8.20335395112e-11
+ 14700000000
+ 8.203065948e-11
+ -2.03845206647e-11  8.36953197182e-11
+ -8.93660968916e-13  -9.80299217236e-12  8.36953197182e-11
+ -3.70759329412e-13  -8.93660968916e-13  -2.03845206647e-11  8.203065948e-11
+ 14800000000
+ 8.20277989836e-11
+ -2.03840043713e-11  8.36924412598e-11
+ -8.93657725219e-13  -9.80277082374e-12  8.36924412598e-11
+ -3.70760618103e-13  -8.93657725219e-13  -2.03840043713e-11  8.20277989836e-11
+ 14900000000
+ 8.2024957759e-11
+ -2.03834915555e-11  8.3689582194e-11
+ -8.93654502857e-13  -9.80255096579e-12  8.3689582194e-11
+ -3.70761897722e-13  -8.93654502857e-13  -2.03834915555e-11  8.2024957759e-11
+ 15000000000
+ 8.20221355486e-11
+ -2.03829821709e-11  8.36867422617e-11
+ -8.93651301545e-13  -9.80233257856e-12  8.36867422617e-11
+ -3.70763168389e-13  -8.93651301545e-13  -2.03829821709e-11  8.20221355486e-11
+ 15100000000
+ 8.20193320996e-11
+ -2.03824761718e-11  8.36839212085e-11
+ -8.93648121004e-13  -9.80211564251e-12  8.36839212085e-11
+ -3.70764430224e-13  -8.93648121004e-13  -2.03824761718e-11  8.20193320996e-11
+ 15200000000
+ 8.20165471645e-11
+ -2.03819735136e-11  8.36811187853e-11
+ -8.9364496096e-13  -9.80190013849e-12  8.36811187853e-11
+ -3.70765683344e-13  -8.9364496096e-13  -2.03819735136e-11  8.20165471645e-11
+ 15300000000
+ 8.20137805004e-11
+ -2.03814741525e-11  8.36783347478e-11
+ -8.93641821143e-13  -9.80168604773e-12  8.36783347478e-11
+ -3.70766927861e-13  -8.93641821143e-13  -2.03814741525e-11  8.20137805004e-11
+ 15400000000
+ 8.20110318695e-11
+ -2.03809780454e-11  8.36755688565e-11
+ -8.93638701291e-13  -9.80147335181e-12  8.36755688565e-11
+ -3.7076816389e-13  -8.93638701291e-13  -2.03809780454e-11  8.20110318695e-11
+ 15500000000
+ 8.20083010382e-11
+ -2.03804851504e-11  8.36728208765e-11
+ -8.93635601145e-13  -9.80126203269e-12  8.36728208765e-11
+ -3.70769391538e-13  -8.93635601145e-13  -2.03804851504e-11  8.20083010382e-11
+ 15600000000
+ 8.20055877777e-11
+ -2.0379995426e-11  8.36700905776e-11
+ -8.93632520451e-13  -9.80105207265e-12  8.36700905776e-11
+ -3.70770610915e-13  -8.93632520451e-13  -2.0379995426e-11  8.20055877777e-11
+ 15700000000
+ 8.20028918636e-11
+ -2.03795088319e-11  8.36673777339e-11
+ -8.93629458961e-13  -9.80084345434e-12  8.36673777339e-11
+ -3.70771822126e-13  -8.93629458961e-13  -2.03795088319e-11  8.20028918636e-11
+ 15800000000
+ 8.20002130755e-11
+ -2.03790253281e-11  8.36646821236e-11
+ -8.93626416432e-13  -9.80063616072e-12  8.36646821236e-11
+ -3.70773025274e-13  -8.93626416432e-13  -2.03790253281e-11  8.20002130755e-11
+ 15900000000
+ 8.19975511975e-11
+ -2.03785448758e-11  8.36620035295e-11
+ -8.93623392623e-13  -9.80043017508e-12  8.36620035295e-11
+ -3.70774220461e-13  -8.93623392623e-13  -2.03785448758e-11  8.19975511975e-11
+ 16000000000
+ 8.19949060176e-11
+ -2.03780674368e-11  8.36593417382e-11
+ -8.93620387301e-13  -9.80022548102e-12  8.36593417382e-11
+ -3.70775407788e-13  -8.93620387301e-13  -2.03780674368e-11  8.19949060176e-11
+ 16100000000
+ 8.19922773276e-11
+ -2.03775929733e-11  8.36566965404e-11
+ -8.93617400235e-13  -9.80002206245e-12  8.36566965404e-11
+ -3.70776587352e-13  -8.93617400235e-13  -2.03775929733e-11  8.19922773276e-11
+ 16200000000
+ 8.19896649236e-11
+ -2.03771214487e-11  8.36540677306e-11
+ -8.93614431199e-13  -9.79981990357e-12  8.36540677306e-11
+ -3.70777759248e-13  -8.93614431199e-13  -2.03771214487e-11  8.19896649236e-11
+ 16300000000
+ 8.1987068605e-11
+ -2.03766528268e-11  8.36514551072e-11
+ -8.93611479971e-13  -9.7996189889e-12  8.36514551072e-11
+ -3.70778923572e-13  -8.93611479971e-13  -2.03766528268e-11  8.1987068605e-11
+ 16400000000
+ 8.19844881752e-11
+ -2.0376187072e-11  8.36488584722e-11
+ -8.93608546334e-13  -9.79941930322e-12  8.36488584722e-11
+ -3.70780080416e-13  -8.93608546334e-13  -2.0376187072e-11  8.19844881752e-11
+ 16500000000
+ 8.19819234411e-11
+ -2.03757241496e-11  8.36462776313e-11
+ -8.93605630073e-13  -9.79922083157e-12  8.36462776313e-11
+ -3.70781229871e-13  -8.93605630073e-13  -2.03757241496e-11  8.19819234411e-11
+ 16600000000
+ 8.19793742129e-11
+ -2.03752640252e-11  8.36437123938e-11
+ -8.93602730979e-13  -9.79902355931e-12  8.36437123938e-11
+ -3.70782372027e-13  -8.93602730979e-13  -2.03752640252e-11  8.19793742129e-11
+ 16700000000
+ 8.19768403046e-11
+ -2.03748066653e-11  8.36411625721e-11
+ -8.93599848845e-13  -9.79882747202e-12  8.36411625721e-11
+ -3.7078350697e-13  -8.93599848845e-13  -2.03748066653e-11  8.19768403046e-11
+ 16800000000
+ 8.19743215332e-11
+ -2.0374352037e-11  8.36386279823e-11
+ -8.9359698347e-13  -9.79863255556e-12  8.36386279823e-11
+ -3.70784634787e-13  -8.9359698347e-13  -2.0374352037e-11  8.19743215332e-11
+ 16900000000
+ 8.19718177191e-11
+ -2.03739001077e-11  8.36361084436e-11
+ -8.93594134653e-13  -9.79843879604e-12  8.36361084436e-11
+ -3.70785755563e-13  -8.93594134653e-13  -2.03739001077e-11  8.19718177191e-11
+ 17000000000
+ 8.19693286858e-11
+ -2.03734508456e-11  8.36336037786e-11
+ -8.93591302201e-13  -9.7982461798e-12  8.36336037786e-11
+ -3.70786869381e-13  -8.93591302201e-13  -2.03734508456e-11  8.19693286858e-11
+ 17100000000
+ 8.19668542601e-11
+ -2.03730042195e-11  8.36311138127e-11
+ -8.9358848592e-13  -9.79805469345e-12  8.36311138127e-11
+ -3.70787976322e-13  -8.9358848592e-13  -2.03730042195e-11  8.19668542601e-11
+ 17200000000
+ 8.19643942717e-11
+ -2.03725601986e-11  8.36286383746e-11
+ -8.93585685623e-13  -9.79786432381e-12  8.36286383746e-11
+ -3.70789076466e-13  -8.93585685623e-13  -2.03725601986e-11  8.19643942717e-11
+ 17300000000
+ 8.19619485531e-11
+ -2.03721187528e-11  8.3626177296e-11
+ -8.93582901124e-13  -9.79767505793e-12  8.3626177296e-11
+ -3.70790169892e-13  -8.93582901124e-13  -2.03721187528e-11  8.19619485531e-11
+ 17400000000
+ 8.195951694e-11
+ -2.03716798523e-11  8.36237304112e-11
+ -8.93580132242e-13  -9.7974868831e-12  8.36237304112e-11
+ -3.70791256678e-13  -8.93580132242e-13  -2.03716798523e-11  8.195951694e-11
+ 17500000000
+ 8.19570992707e-11
+ -2.03712434681e-11  8.36212975578e-11
+ -8.93577378796e-13  -9.79729978681e-12  8.36212975578e-11
+ -3.707923369e-13  -8.93577378796e-13  -2.03712434681e-11  8.19570992707e-11
+ 17600000000
+ 8.19546953864e-11
+ -2.03708095713e-11  8.36188785758e-11
+ -8.93574640612e-13  -9.79711375677e-12  8.36188785758e-11
+ -3.70793410632e-13  -8.93574640612e-13  -2.03708095713e-11  8.19546953864e-11
+ 17700000000
+ 8.19523051309e-11
+ -2.03703781339e-11  8.36164733081e-11
+ -8.93571917516e-13  -9.79692878092e-12  8.36164733081e-11
+ -3.70794477948e-13  -8.93571917516e-13  -2.03703781339e-11  8.19523051309e-11
+ 17800000000
+ 8.19499283506e-11
+ -2.03699491282e-11  8.36140816002e-11
+ -8.93569209339e-13  -9.79674484737e-12  8.36140816002e-11
+ -3.70795538921e-13  -8.93569209339e-13  -2.03699491282e-11  8.19499283506e-11
+ 17900000000
+ 8.19475648948e-11
+ -2.03695225268e-11  8.36117033003e-11
+ -8.93566515913e-13  -9.79656194445e-12  8.36117033003e-11
+ -3.70796593621e-13  -8.93566515913e-13  -2.03695225268e-11  8.19475648948e-11
+ 18000000000
+ 8.19452146149e-11
+ -2.03690983031e-11  8.3609338259e-11
+ -8.93563837075e-13  -9.79638006067e-12  8.3609338259e-11
+ -3.70797642118e-13  -8.93563837075e-13  -2.03690983031e-11  8.19452146149e-11
+ 18100000000
+ 8.19428773649e-11
+ -2.03686764307e-11  8.36069863294e-11
+ -8.93561172662e-13  -9.79619918476e-12  8.36069863294e-11
+ -3.70798684481e-13  -8.93561172662e-13  -2.03686764307e-11  8.19428773649e-11
+ 18200000000
+ 8.19405530014e-11
+ -2.03682568836e-11  8.36046473671e-11
+ -8.93558522515e-13  -9.7960193056e-12  8.36046473671e-11
+ -3.70799720777e-13  -8.93558522515e-13  -2.03682568836e-11  8.19405530014e-11
+ 18300000000
+ 8.19382413833e-11
+ -2.03678396365e-11  8.36023212301e-11
+ -8.93555886479e-13  -9.79584041228e-12  8.36023212301e-11
+ -3.70800751074e-13  -8.93555886479e-13  -2.03678396365e-11  8.19382413833e-11
+ 18400000000
+ 8.19359423715e-11
+ -2.03674246642e-11  8.36000077785e-11
+ -8.93553264399e-13  -9.79566249406e-12  8.36000077785e-11
+ -3.70801775436e-13  -8.93553264399e-13  -2.03674246642e-11  8.19359423715e-11
+ 18500000000
+ 8.19336558295e-11
+ -2.03670119422e-11  8.35977068749e-11
+ -8.93550656125e-13  -9.79548554037e-12  8.35977068749e-11
+ -3.70802793927e-13  -8.93550656125e-13  -2.03670119422e-11  8.19336558295e-11
+ 18600000000
+ 8.19313816229e-11
+ -2.03666014461e-11  8.35954183842e-11
+ -8.93548061508e-13  -9.79530954081e-12  8.35954183842e-11
+ -3.70803806612e-13  -8.93548061508e-13  -2.03666014461e-11  8.19313816229e-11
+ 18700000000
+ 8.19291196195e-11
+ -2.0366193152e-11  8.35931421731e-11
+ -8.935454804e-13  -9.79513448516e-12  8.35931421731e-11
+ -3.70804813551e-13  -8.935454804e-13  -2.0366193152e-11  8.19291196195e-11
+ 18800000000
+ 8.19268696891e-11
+ -2.03657870366e-11  8.35908781109e-11
+ -8.93542912659e-13  -9.79496036334e-12  8.35908781109e-11
+ -3.70805814808e-13  -8.93542912659e-13  -2.03657870366e-11  8.19268696891e-11
+ 18900000000
+ 8.19246317037e-11
+ -2.03653830767e-11  8.35886260685e-11
+ -8.93540358142e-13  -9.79478716546e-12  8.35886260685e-11
+ -3.7080681044e-13  -8.93540358142e-13  -2.03653830767e-11  8.19246317037e-11
+ 19000000000
+ 8.19224055373e-11
+ -2.03649812495e-11  8.35863859193e-11
+ -8.9353781671e-13  -9.79461488177e-12  8.35863859193e-11
+ -3.70807800509e-13  -8.9353781671e-13  -2.03649812495e-11  8.19224055373e-11
+ 19100000000
+ 8.19201910658e-11
+ -2.03645815327e-11  8.35841575383e-11
+ -8.93535288225e-13  -9.79444350268e-12  8.35841575383e-11
+ -3.70808785073e-13  -8.93535288225e-13  -2.03645815327e-11  8.19201910658e-11
+ 19200000000
+ 8.19179881671e-11
+ -2.03641839043e-11  8.35819408028e-11
+ -8.93532772553e-13  -9.79427301873e-12  8.35819408028e-11
+ -3.70809764188e-13  -8.93532772553e-13  -2.03641839043e-11  8.19179881671e-11
+ 19300000000
+ 8.1915796721e-11
+ -2.03637883425e-11  8.35797355917e-11
+ -8.9353026956e-13  -9.79410342063e-12  8.35797355917e-11
+ -3.70810737912e-13  -8.9353026956e-13  -2.03637883425e-11  8.1915796721e-11
+ 19400000000
+ 8.19136166093e-11
+ -2.0363394826e-11  8.35775417861e-11
+ -8.93527779116e-13  -9.79393469924e-12  8.35775417861e-11
+ -3.708117063e-13  -8.93527779116e-13  -2.0363394826e-11  8.19136166093e-11
+ 19500000000
+ 8.19114477153e-11
+ -2.03630033338e-11  8.35753592686e-11
+ -8.9352530109e-13  -9.79376684553e-12  8.35753592686e-11
+ -3.70812669408e-13  -8.9352530109e-13  -2.03630033338e-11  8.19114477153e-11
+ 19600000000
+ 8.19092899245e-11
+ -2.03626138451e-11  8.35731879238e-11
+ -8.93522835357e-13  -9.79359985063e-12  8.35731879238e-11
+ -3.70813627288e-13  -8.93522835357e-13  -2.03626138451e-11  8.19092899245e-11
+ 19700000000
+ 8.19071431237e-11
+ -2.03622263397e-11  8.35710276381e-11
+ -8.93520381791e-13  -9.79343370581e-12  8.35710276381e-11
+ -3.70814579995e-13  -8.93520381791e-13  -2.03622263397e-11  8.19071431237e-11
+ 19800000000
+ 8.19050072018e-11
+ -2.03618407973e-11  8.35688782995e-11
+ -8.9351794027e-13  -9.79326840247e-12  8.35688782995e-11
+ -3.7081552758e-13  -8.9351794027e-13  -2.03618407973e-11  8.19050072018e-11
+ 19900000000
+ 8.19028820491e-11
+ -2.03614571983e-11  8.35667397978e-11
+ -8.93515510671e-13  -9.79310393212e-12  8.35667397978e-11
+ -3.70816470096e-13  -8.93515510671e-13  -2.03614571983e-11  8.19028820491e-11
+ 20000000000
+ 8.19007675579e-11
+ -2.03610755232e-11  8.35646120243e-11
+ -8.93513092875e-13  -9.79294028642e-12  8.35646120243e-11
+ -3.70817407592e-13  -8.93513092875e-13  -2.03610755232e-11  8.19007675579e-11
+ 20100000000
+ 8.18986636217e-11
+ -2.03606957528e-11  8.3562494872e-11
+ -8.93510686765e-13  -9.79277745714e-12  8.3562494872e-11
+ -3.7081834012e-13  -8.93510686765e-13  -2.03606957528e-11  8.18986636217e-11
+ 20200000000
+ 8.18965701359e-11
+ -2.03603178681e-11  8.35603882357e-11
+ -8.93508292225e-13  -9.79261543619e-12  8.35603882357e-11
+ -3.70819267728e-13  -8.93508292225e-13  -2.03603178681e-11  8.18965701359e-11
+ 20300000000
+ 8.18944869972e-11
+ -2.03599418506e-11  8.35582920114e-11
+ -8.9350590914e-13  -9.79245421559e-12  8.35582920114e-11
+ -3.70820190465e-13  -8.9350590914e-13  -2.03599418506e-11  8.18944869972e-11
+ 20400000000
+ 8.1892414104e-11
+ -2.0359567682e-11  8.3556206097e-11
+ -8.93503537398e-13  -9.79229378747e-12  8.3556206097e-11
+ -3.70821108379e-13  -8.93503537398e-13  -2.0359567682e-11  8.1892414104e-11
+ 20500000000
+ 8.18903513562e-11
+ -2.0359195344e-11  8.35541303915e-11
+ -8.93501176888e-13  -9.79213414408e-12  8.35541303915e-11
+ -3.70822021517e-13  -8.93501176888e-13  -2.0359195344e-11  8.18903513562e-11
+ 20600000000
+ 8.1888298655e-11
+ -2.03588248191e-11  8.35520647957e-11
+ -8.93498827501e-13  -9.7919752778e-12  8.35520647957e-11
+ -3.70822929926e-13  -8.93498827501e-13  -2.03588248191e-11  8.1888298655e-11
+ 20700000000
+ 8.18862559033e-11
+ -2.03584560895e-11  8.35500092117e-11
+ -8.93496489129e-13  -9.79181718109e-12  8.35500092117e-11
+ -3.7082383365e-13  -8.93496489129e-13  -2.03584560895e-11  8.18862559033e-11
+ 20800000000
+ 8.18842230051e-11
+ -2.0358089138e-11  8.35479635431e-11
+ -8.93494161666e-13  -9.79165984655e-12  8.35479635431e-11
+ -3.70824732736e-13  -8.93494161666e-13  -2.0358089138e-11  8.18842230051e-11
+ 20900000000
+ 8.18821998659e-11
+ -2.03577239476e-11  8.35459276948e-11
+ -8.93491845007e-13  -9.79150326686e-12  8.35459276948e-11
+ -3.70825627228e-13  -8.93491845007e-13  -2.03577239476e-11  8.18821998659e-11
+ 21000000000
+ 8.18801863927e-11
+ -2.03573605014e-11  8.3543901573e-11
+ -8.9348953905e-13  -9.79134743483e-12  8.3543901573e-11
+ -3.7082651717e-13  -8.9348953905e-13  -2.03573605014e-11  8.18801863927e-11
+ 21100000000
+ 8.18781824936e-11
+ -2.03569987828e-11  8.35418850854e-11
+ -8.93487243692e-13  -9.79119234335e-12  8.35418850854e-11
+ -3.70827402605e-13  -8.93487243692e-13  -2.03569987828e-11  8.18781824936e-11
+ 21200000000
+ 8.18761880781e-11
+ -2.03566387757e-11  8.35398781409e-11
+ -8.93484958834e-13  -9.79103798542e-12  8.35398781409e-11
+ -3.70828283575e-13  -8.93484958834e-13  -2.03566387757e-11  8.18761880781e-11
+ 21300000000
+ 8.18742030571e-11
+ -2.03562804637e-11  8.35378806498e-11
+ -8.93482684377e-13  -9.79088435414e-12  8.35378806498e-11
+ -3.70829160122e-13  -8.93482684377e-13  -2.03562804637e-11  8.18742030571e-11
+ 21400000000
+ 8.18722273425e-11
+ -2.03559238311e-11  8.35358925236e-11
+ -8.93480420223e-13  -9.79073144271e-12  8.35358925236e-11
+ -3.70830032289e-13  -8.93480420223e-13  -2.03559238311e-11  8.18722273425e-11
+ 21500000000
+ 8.18702608476e-11
+ -2.03555688623e-11  8.35339136748e-11
+ -8.93478166276e-13  -9.79057924441e-12  8.35339136748e-11
+ -3.70830900115e-13  -8.93478166276e-13  -2.03555688623e-11  8.18702608476e-11
+ 21600000000
+ 8.18683034869e-11
+ -2.03552155417e-11  8.35319440176e-11
+ -8.93475922441e-13  -9.79042775264e-12  8.35319440176e-11
+ -3.70831763641e-13  -8.93475922441e-13  -2.03552155417e-11  8.18683034869e-11
+ 21700000000
+ 8.18663551761e-11
+ -2.03548638542e-11  8.3529983467e-11
+ -8.93473688626e-13  -9.79027696087e-12  8.3529983467e-11
+ -3.70832622908e-13  -8.93473688626e-13  -2.03548638542e-11  8.18663551761e-11
+ 21800000000
+ 8.18644158319e-11
+ -2.03545137848e-11  8.35280319393e-11
+ -8.93471464739e-13  -9.79012686267e-12  8.35280319393e-11
+ -3.70833477953e-13  -8.93471464739e-13  -2.03545137848e-11  8.18644158319e-11
+ 21900000000
+ 8.18624853724e-11
+ -2.03541653186e-11  8.3526089352e-11
+ -8.93469250687e-13  -9.78997745168e-12  8.3526089352e-11
+ -3.70834328815e-13  -8.93469250687e-13  -2.03541653186e-11  8.18624853724e-11
+ 22000000000
+ 8.18605637166e-11
+ -2.0353818441e-11  8.35241556236e-11
+ -8.93467046382e-13  -9.78982872165e-12  8.35241556236e-11
+ -3.70835175533e-13  -8.93467046383e-13  -2.0353818441e-11  8.18605637166e-11
+ 22100000000
+ 8.18586507847e-11
+ -2.03534731377e-11  8.35222306739e-11
+ -8.93464851736e-13  -9.78968066642e-12  8.35222306739e-11
+ -3.70836018145e-13  -8.93464851736e-13  -2.03534731377e-11  8.18586507847e-11
+ 22200000000
+ 8.1856746498e-11
+ -2.03531293945e-11  8.35203144236e-11
+ -8.93462666661e-13  -9.78953327987e-12  8.35203144236e-11
+ -3.70836856687e-13  -8.93462666661e-13  -2.03531293945e-11  8.1856746498e-11
+ 22300000000
+ 8.18548507787e-11
+ -2.03527871973e-11  8.35184067945e-11
+ -8.93460491071e-13  -9.78938655602e-12  8.35184067945e-11
+ -3.70837691195e-13  -8.93460491071e-13  -2.03527871973e-11  8.18548507787e-11
+ 22400000000
+ 8.18529635504e-11
+ -2.03524465322e-11  8.35165077095e-11
+ -8.93458324882e-13  -9.78924048893e-12  8.35165077095e-11
+ -3.70838521707e-13  -8.93458324882e-13  -2.03524465322e-11  8.18529635504e-11
+ 22500000000
+ 8.18510847373e-11
+ -2.03521073857e-11  8.35146170926e-11
+ -8.93456168009e-13  -9.78909507276e-12  8.35146170926e-11
+ -3.70839348257e-13  -8.93456168009e-13  -2.03521073857e-11  8.18510847373e-11
+ 22600000000
+ 8.18492142648e-11
+ -2.03517697444e-11  8.35127348687e-11
+ -8.93454020371e-13  -9.78895030173e-12  8.35127348687e-11
+ -3.7084017088e-13  -8.93454020371e-13  -2.03517697444e-11  8.18492142648e-11
+ 22700000000
+ 8.18473520594e-11
+ -2.03514335948e-11  8.35108609637e-11
+ -8.93451881885e-13  -9.78880617015e-12  8.35108609637e-11
+ -3.70840989612e-13  -8.93451881885e-13  -2.03514335948e-11  8.18473520594e-11
+ 22800000000
+ 8.18454980485e-11
+ -2.03510989239e-11  8.35089953045e-11
+ -8.93449752471e-13  -9.7886626724e-12  8.35089953045e-11
+ -3.70841804486e-13  -8.93449752471e-13  -2.03510989239e-11  8.18454980485e-11
+ 22900000000
+ 8.18436521602e-11
+ -2.03507657188e-11  8.3507137819e-11
+ -8.93447632051e-13  -9.78851980294e-12  8.3507137819e-11
+ -3.70842615537e-13  -8.93447632051e-13  -2.03507657188e-11  8.18436521602e-11
+ 23000000000
+ 8.18418143239e-11
+ -2.03504339667e-11  8.3505288436e-11
+ -8.93445520544e-13  -9.78837755629e-12  8.3505288436e-11
+ -3.70843422797e-13  -8.93445520544e-13  -2.03504339667e-11  8.18418143239e-11
+ 23100000000
+ 8.18399844698e-11
+ -2.03501036549e-11  8.35034470852e-11
+ -8.93443417875e-13  -9.78823592706e-12  8.35034470852e-11
+ -3.708442263e-13  -8.93443417875e-13  -2.03501036549e-11  8.18399844698e-11
+ 23200000000
+ 8.18381625289e-11
+ -2.03497747712e-11  8.35016136973e-11
+ -8.93441323967e-13  -9.78809490991e-12  8.35016136973e-11
+ -3.70845026077e-13  -8.93441323967e-13  -2.03497747712e-11  8.18381625289e-11
+ 23300000000
+ 8.18363484332e-11
+ -2.03494473031e-11  8.34997882037e-11
+ -8.93439238745e-13  -9.78795449957e-12  8.34997882037e-11
+ -3.70845822162e-13  -8.93439238745e-13  -2.03494473031e-11  8.18363484332e-11
+ 23400000000
+ 8.18345421155e-11
+ -2.03491212386e-11  8.3497970537e-11
+ -8.93437162134e-13  -9.78781469086e-12  8.3497970537e-11
+ -3.70846614584e-13  -8.93437162134e-13  -2.03491212386e-11  8.18345421155e-11
+ 23500000000
+ 8.18327435095e-11
+ -2.03487965656e-11  8.34961606304e-11
+ -8.93435094061e-13  -9.78767547865e-12  8.34961606304e-11
+ -3.70847403377e-13  -8.93435094061e-13  -2.03487965656e-11  8.18327435095e-11
+ 23600000000
+ 8.18309525498e-11
+ -2.03484732725e-11  8.3494358418e-11
+ -8.93433034453e-13  -9.78753685787e-12  8.3494358418e-11
+ -3.7084818857e-13  -8.93433034453e-13  -2.03484732725e-11  8.18309525498e-11
+ 23700000000
+ 8.18291691718e-11
+ -2.03481513475e-11  8.34925638348e-11
+ -8.93430983239e-13  -9.78739882353e-12  8.34925638348e-11
+ -3.70848970194e-13  -8.93430983239e-13  -2.03481513475e-11  8.18291691718e-11
+ 23800000000
+ 8.18273933116e-11
+ -2.03478307791e-11  8.34907768167e-11
+ -8.93428940348e-13  -9.78726137068e-12  8.34907768167e-11
+ -3.7084974828e-13  -8.93428940348e-13  -2.03478307791e-11  8.18273933116e-11
+ 23900000000
+ 8.18256249062e-11
+ -2.03475115559e-11  8.34889973001e-11
+ -8.9342690571e-13  -9.78712449446e-12  8.34889973001e-11
+ -3.70850522855e-13  -8.9342690571e-13  -2.03475115559e-11  8.18256249062e-11
+ 24000000000
+ 8.18238638934e-11
+ -2.03471936668e-11  8.34872252224e-11
+ -8.93424879258e-13  -9.78698819005e-12  8.34872252224e-11
+ -3.70851293951e-13  -8.93424879258e-13  -2.03471936668e-11  8.18238638934e-11
+ 24100000000
+ 8.18221102117e-11
+ -2.03468771005e-11  8.3485460522e-11
+ -8.93422860921e-13  -9.7868524527e-12  8.3485460522e-11
+ -3.70852061596e-13  -8.93422860921e-13  -2.03468771005e-11  8.18221102117e-11
+ 24200000000
+ 8.18203638006e-11
+ -2.03465618463e-11  8.34837031376e-11
+ -8.93420850635e-13  -9.78671727772e-12  8.34837031376e-11
+ -3.70852825818e-13  -8.93420850635e-13  -2.03465618463e-11  8.18203638006e-11
+ 24300000000
+ 8.18186246e-11
+ -2.03462478932e-11  8.3481953009e-11
+ -8.93418848331e-13  -9.78658266047e-12  8.3481953009e-11
+ -3.70853586646e-13  -8.93418848331e-13  -2.03462478932e-11  8.18186246e-11
+ 24400000000
+ 8.18168925507e-11
+ -2.03459352306e-11  8.34802100767e-11
+ -8.93416853944e-13  -9.78644859637e-12  8.34802100767e-11
+ -3.70854344108e-13  -8.93416853944e-13  -2.03459352306e-11  8.18168925507e-11
+ 24500000000
+ 8.18151675944e-11
+ -2.03456238479e-11  8.34784742817e-11
+ -8.93414867411e-13  -9.7863150809e-12  8.34784742817e-11
+ -3.7085509823e-13  -8.93414867411e-13  -2.03456238479e-11  8.18151675944e-11
+ 24600000000
+ 8.18134496732e-11
+ -2.03453137347e-11  8.3476745566e-11
+ -8.93412888666e-13  -9.7861821096e-12  8.3476745566e-11
+ -3.70855849041e-13  -8.93412888666e-13  -2.03453137347e-11  8.18134496732e-11
+ 24700000000
+ 8.18117387302e-11
+ -2.03450048808e-11  8.34750238722e-11
+ -8.93410917647e-13  -9.78604967805e-12  8.34750238722e-11
+ -3.70856596567e-13  -8.93410917647e-13  -2.03450048808e-11  8.18117387302e-11
+ 24800000000
+ 8.18100347088e-11
+ -2.03446972759e-11  8.34733091436e-11
+ -8.93408954292e-13  -9.78591778189e-12  8.34733091436e-11
+ -3.70857340835e-13  -8.93408954292e-13  -2.03446972759e-11  8.18100347088e-11
+ 24900000000
+ 8.18083375536e-11
+ -2.034439091e-11  8.34716013241e-11
+ -8.93406998538e-13  -9.78578641681e-12  8.34716013241e-11
+ -3.7085808187e-13  -8.93406998538e-13  -2.034439091e-11  8.18083375536e-11
+ 25000000000
+ 8.18066472094e-11
+ -2.03440857731e-11  8.34699003585e-11
+ -8.93405050325e-13  -9.78565557857e-12  8.34699003585e-11
+ -3.70858819699e-13  -8.93405050325e-13  -2.03440857731e-11  8.18066472094e-11
+ 25100000000
+ 8.1804963622e-11
+ -2.03437818555e-11  8.34682061919e-11
+ -8.93403109592e-13  -9.78552526296e-12  8.34682061919e-11
+ -3.70859554348e-13  -8.93403109592e-13  -2.03437818555e-11  8.1804963622e-11
+ 25200000000
+ 8.18032867375e-11
+ -2.03434791475e-11  8.34665187704e-11
+ -8.93401176281e-13  -9.78539546581e-12  8.34665187704e-11
+ -3.70860285841e-13  -8.93401176281e-13  -2.03434791475e-11  8.18032867375e-11
+ 25300000000
+ 8.18016165031e-11
+ -2.03431776396e-11  8.34648380406e-11
+ -8.93399250332e-13  -9.78526618304e-12  8.34648380406e-11
+ -3.70861014204e-13  -8.93399250332e-13  -2.03431776396e-11  8.18016165031e-11
+ 25400000000
+ 8.17999528662e-11
+ -2.03428773221e-11  8.34631639497e-11
+ -8.93397331688e-13  -9.78513741059e-12  8.34631639497e-11
+ -3.70861739461e-13  -8.93397331688e-13  -2.03428773221e-11  8.17999528662e-11
+ 25500000000
+ 8.17982957749e-11
+ -2.03425781858e-11  8.34614964456e-11
+ -8.9339542029e-13  -9.78500914444e-12  8.34614964456e-11
+ -3.70862461637e-13  -8.9339542029e-13  -2.03425781858e-11  8.17982957749e-11
+ 25600000000
+ 8.17966451783e-11
+ -2.03422802215e-11  8.34598354768e-11
+ -8.93393516083e-13  -9.78488138063e-12  8.34598354768e-11
+ -3.70863180755e-13  -8.93393516083e-13  -2.03422802215e-11  8.17966451783e-11
+ 25700000000
+ 8.17950010255e-11
+ -2.034198342e-11  8.34581809922e-11
+ -8.9339161901e-13  -9.78475411526e-12  8.34581809922e-11
+ -3.70863896841e-13  -8.9339161901e-13  -2.034198342e-11  8.17950010255e-11
+ 25800000000
+ 8.17933632666e-11
+ -2.03416877723e-11  8.34565329417e-11
+ -8.93389729016e-13  -9.78462734445e-12  8.34565329417e-11
+ -3.70864609916e-13  -8.93389729016e-13  -2.03416877723e-11  8.17933632666e-11
+ 25900000000
+ 8.17917318521e-11
+ -2.03413932695e-11  8.34548912755e-11
+ -8.93387846047e-13  -9.78450106438e-12  8.34548912755e-11
+ -3.70865320005e-13  -8.93387846047e-13  -2.03413932695e-11  8.17917318521e-11
+ 26000000000
+ 8.17901067333e-11
+ -2.03410999027e-11  8.34532559443e-11
+ -8.93385970047e-13  -9.78437527127e-12  8.34532559443e-11
+ -3.7086602713e-13  -8.93385970047e-13  -2.03410999027e-11  8.17901067333e-11
+ 26100000000
+ 8.17884878617e-11
+ -2.03408076632e-11  8.34516268996e-11
+ -8.93384100964e-13  -9.78424996138e-12  8.34516268996e-11
+ -3.70866731315e-13  -8.93384100964e-13  -2.03408076632e-11  8.17884878617e-11
+ 26200000000
+ 8.17868751897e-11
+ -2.03405165425e-11  8.34500040933e-11
+ -8.93382238745e-13  -9.78412513102e-12  8.34500040933e-11
+ -3.70867432581e-13  -8.93382238745e-13  -2.03405165425e-11  8.17868751897e-11
+ 26300000000
+ 8.178526867e-11
+ -2.0340226532e-11  8.34483874779e-11
+ -8.93380383338e-13  -9.78400077654e-12  8.34483874779e-11
+ -3.70868130951e-13  -8.93380383338e-13  -2.0340226532e-11  8.178526867e-11
+ 26400000000
+ 8.17836682559e-11
+ -2.03399376233e-11  8.34467770065e-11
+ -8.9337853469e-13  -9.78387689433e-12  8.34467770065e-11
+ -3.70868826447e-13  -8.9337853469e-13  -2.03399376233e-11  8.17836682559e-11
+ 26500000000
+ 8.17820739014e-11
+ -2.0339649808e-11  8.34451726327e-11
+ -8.93376692751e-13  -9.78375348082e-12  8.34451726327e-11
+ -3.70869519091e-13  -8.93376692751e-13  -2.0339649808e-11  8.17820739014e-11
+ 26600000000
+ 8.17804855609e-11
+ -2.03393630779e-11  8.34435743105e-11
+ -8.93374857471e-13  -9.78363053248e-12  8.34435743105e-11
+ -3.70870208903e-13  -8.93374857471e-13  -2.03393630779e-11  8.17804855609e-11
+ 26700000000
+ 8.17789031891e-11
+ -2.03390774249e-11  8.34419819946e-11
+ -8.93373028799e-13  -9.78350804583e-12  8.34419819946e-11
+ -3.70870895906e-13  -8.93373028799e-13  -2.03390774249e-11  8.17789031891e-11
+ 26800000000
+ 8.17773267415e-11
+ -2.0338792841e-11  8.344039564e-11
+ -8.93371206686e-13  -9.7833860174e-12  8.344039564e-11
+ -3.7087158012e-13  -8.93371206686e-13  -2.0338792841e-11  8.17773267415e-11
+ 26900000000
+ 8.17757561741e-11
+ -2.03385093182e-11  8.34388152025e-11
+ -8.93369391083e-13  -9.78326444381e-12  8.34388152025e-11
+ -3.70872261567e-13  -8.93369391083e-13  -2.03385093182e-11  8.17757561741e-11
+ 27000000000
+ 8.17741914432e-11
+ -2.03382268485e-11  8.34372406381e-11
+ -8.93367581941e-13  -9.78314332166e-12  8.34372406381e-11
+ -3.70872940266e-13  -8.93367581941e-13  -2.03382268485e-11  8.17741914432e-11
+ 27100000000
+ 8.17726325057e-11
+ -2.03379454243e-11  8.34356719034e-11
+ -8.93365779215e-13  -9.78302264763e-12  8.34356719034e-11
+ -3.70873616237e-13  -8.93365779215e-13  -2.03379454243e-11  8.17726325057e-11
+ 27200000000
+ 8.17710793189e-11
+ -2.03376650378e-11  8.34341089556e-11
+ -8.93363982855e-13  -9.78290241841e-12  8.34341089556e-11
+ -3.70874289502e-13  -8.93363982855e-13  -2.03376650378e-11  8.17710793189e-11
+ 27300000000
+ 8.17695318408e-11
+ -2.03373856815e-11  8.34325517521e-11
+ -8.93362192815e-13  -9.78278263075e-12  8.34325517521e-11
+ -3.7087496008e-13  -8.93362192815e-13  -2.03373856815e-11  8.17695318408e-11
+ 27400000000
+ 8.17679900294e-11
+ -2.03371073478e-11  8.3431000251e-11
+ -8.93360409049e-13  -9.78266328142e-12  8.3431000251e-11
+ -3.7087562799e-13  -8.93360409049e-13  -2.03371073478e-11  8.17679900294e-11
+ 27500000000
+ 8.17664538437e-11
+ -2.03368300292e-11  8.34294544109e-11
+ -8.93358631512e-13  -9.78254436722e-12  8.34294544109e-11
+ -3.70876293252e-13  -8.93358631512e-13  -2.03368300292e-11  8.17664538437e-11
+ 27600000000
+ 8.17649232428e-11
+ -2.03365537183e-11  8.34279141905e-11
+ -8.93356860158e-13  -9.782425885e-12  8.34279141905e-11
+ -3.70876955885e-13  -8.93356860158e-13  -2.03365537183e-11  8.17649232428e-11
+ 27700000000
+ 8.17633981863e-11
+ -2.0336278408e-11  8.34263795494e-11
+ -8.93355094943e-13  -9.78230783164e-12  8.34263795494e-11
+ -3.70877615908e-13  -8.93355094943e-13  -2.0336278408e-11  8.17633981863e-11
+ 27800000000
+ 8.17618786342e-11
+ -2.0336004091e-11  8.34248504473e-11
+ -8.93353335822e-13  -9.78219020405e-12  8.34248504473e-11
+ -3.7087827334e-13  -8.93353335822e-13  -2.0336004091e-11  8.17618786342e-11
+ 27900000000
+ 8.17603645472e-11
+ -2.03357307602e-11  8.34233268445e-11
+ -8.93351582752e-13  -9.78207299917e-12  8.34233268445e-11
+ -3.708789282e-13  -8.93351582752e-13  -2.03357307602e-11  8.17603645472e-11
+ 28000000000
+ 8.17588558861e-11
+ -2.03354584085e-11  8.34218087016e-11
+ -8.93349835689e-13  -9.78195621398e-12  8.34218087016e-11
+ -3.70879580505e-13  -8.93349835689e-13  -2.03354584085e-11  8.17588558861e-11
+ 28100000000
+ 8.17573526123e-11
+ -2.03351870289e-11  8.34202959798e-11
+ -8.9334809459e-13  -9.7818398455e-12  8.34202959798e-11
+ -3.70880230275e-13  -8.9334809459e-13  -2.03351870289e-11  8.17573526123e-11
+ 28200000000
+ 8.17558546875e-11
+ -2.03349166146e-11  8.34187886406e-11
+ -8.93346359414e-13  -9.78172389075e-12  8.34187886406e-11
+ -3.70880877526e-13  -8.93346359414e-13  -2.03349166146e-11  8.17558546875e-11
+ 28300000000
+ 8.17543620738e-11
+ -2.03346471587e-11  8.34172866458e-11
+ -8.93344630118e-13  -9.78160834682e-12  8.34172866458e-11
+ -3.70881522278e-13  -8.93344630118e-13  -2.03346471587e-11  8.17543620738e-11
+ 28400000000
+ 8.17528747339e-11
+ -2.03343786544e-11  8.34157899579e-11
+ -8.93342906661e-13  -9.78149321082e-12  8.34157899579e-11
+ -3.70882164547e-13  -8.93342906661e-13  -2.03343786544e-11  8.17528747339e-11
+ 28500000000
+ 8.17513926307e-11
+ -2.03341110951e-11  8.34142985395e-11
+ -8.93341189002e-13  -9.78137847986e-12  8.34142985395e-11
+ -3.70882804351e-13  -8.93341189002e-13  -2.03341110951e-11  8.17513926307e-11
+ 28600000000
+ 8.17499157275e-11
+ -2.03338444742e-11  8.34128123538e-11
+ -8.933394771e-13  -9.78126415113e-12  8.34128123538e-11
+ -3.70883441708e-13  -8.933394771e-13  -2.03338444742e-11  8.17499157275e-11
+ 28700000000
+ 8.17484439881e-11
+ -2.03335787851e-11  8.34113313642e-11
+ -8.93337770915e-13  -9.78115022181e-12  8.34113313642e-11
+ -3.70884076633e-13  -8.93337770915e-13  -2.03335787851e-11  8.17484439881e-11
+ 28800000000
+ 8.17469773766e-11
+ -2.03333140213e-11  8.34098555347e-11
+ -8.93336070408e-13  -9.78103668913e-12  8.34098555347e-11
+ -3.70884709145e-13  -8.93336070408e-13  -2.03333140213e-11  8.17469773766e-11
+ 28900000000
+ 8.17455158574e-11
+ -2.03330501765e-11  8.34083848295e-11
+ -8.93334375539e-13  -9.78092355033e-12  8.34083848295e-11
+ -3.7088533926e-13  -8.93334375539e-13  -2.03330501765e-11  8.17455158574e-11
+ 29000000000
+ 8.17440593954e-11
+ -2.03327872442e-11  8.34069192132e-11
+ -8.93332686269e-13  -9.78081080271e-12  8.34069192132e-11
+ -3.70885966995e-13  -8.93332686269e-13  -2.03327872442e-11  8.17440593954e-11
+ 29100000000
+ 8.17426079559e-11
+ -2.03325252183e-11  8.34054586509e-11
+ -8.9333100256e-13  -9.78069844357e-12  8.34054586509e-11
+ -3.70886592365e-13  -8.9333100256e-13  -2.03325252183e-11  8.17426079559e-11
+ 29200000000
+ 8.17411615043e-11
+ -2.03322640924e-11  8.34040031078e-11
+ -8.93329324373e-13  -9.78058647025e-12  8.34040031078e-11
+ -3.70887215387e-13  -8.93329324373e-13  -2.03322640924e-11  8.17411615043e-11
+ 29300000000
+ 8.17397200067e-11
+ -2.03320038605e-11  8.34025525497e-11
+ -8.93327651671e-13  -9.78047488011e-12  8.34025525497e-11
+ -3.70887836078e-13  -8.93327651671e-13  -2.03320038605e-11  8.17397200067e-11
+ 29400000000
+ 8.17382834292e-11
+ -2.03317445164e-11  8.34011069426e-11
+ -8.93325984417e-13  -9.78036367054e-12  8.34011069426e-11
+ -3.70888454452e-13  -8.93325984417e-13  -2.03317445164e-11  8.17382834292e-11
+ 29500000000
+ 8.17368517385e-11
+ -2.03314860542e-11  8.3399666253e-11
+ -8.93324322573e-13  -9.78025283896e-12  8.3399666253e-11
+ -3.70889070526e-13  -8.93324322573e-13  -2.03314860542e-11  8.17368517385e-11
+ 29600000000
+ 8.17354249015e-11
+ -2.03312284679e-11  8.33982304476e-11
+ -8.93322666103e-13  -9.78014238281e-12  8.33982304476e-11
+ -3.70889684316e-13  -8.93322666103e-13  -2.03312284679e-11  8.17354249015e-11
+ 29700000000
+ 8.17340028856e-11
+ -2.03309717515e-11  8.33967994935e-11
+ -8.93321014971e-13  -9.78003229957e-12  8.33967994935e-11
+ -3.70890295836e-13  -8.93321014971e-13  -2.03309717515e-11  8.17340028856e-11
+ 29800000000
+ 8.17325856584e-11
+ -2.03307158992e-11  8.3395373358e-11
+ -8.9331936914e-13  -9.77992258673e-12  8.3395373358e-11
+ -3.70890905102e-13  -8.9331936914e-13  -2.03307158992e-11  8.17325856584e-11
+ 29900000000
+ 8.17311731877e-11
+ -2.03304609053e-11  8.3393952009e-11
+ -8.93317728576e-13  -9.7798132418e-12  8.3393952009e-11
+ -3.70891512129e-13  -8.93317728576e-13  -2.03304609053e-11  8.17311731877e-11
+ 30000000000
+ 8.17297654419e-11
+ -2.0330206764e-11  8.33925354145e-11
+ -8.93316093244e-13  -9.77970426235e-12  8.33925354145e-11
+ -3.70892116933e-13  -8.93316093244e-13  -2.0330206764e-11  8.17297654419e-11
+ 30100000000
+ 8.17283623896e-11
+ -2.03299534696e-11  8.33911235429e-11
+ -8.93314463107e-13  -9.77959564592e-12  8.33911235429e-11
+ -3.70892719527e-13  -8.93314463107e-13  -2.03299534696e-11  8.17283623896e-11
+ 30200000000
+ 8.17269639996e-11
+ -2.03297010165e-11  8.33897163629e-11
+ -8.93312838133e-13  -9.77948739013e-12  8.33897163629e-11
+ -3.70893319926e-13  -8.93312838133e-13  -2.03297010165e-11  8.17269639996e-11
+ 30300000000
+ 8.17255702411e-11
+ -2.03294493993e-11  8.33883138434e-11
+ -8.93311218287e-13  -9.77937949258e-12  8.33883138434e-11
+ -3.70893918145e-13  -8.93311218287e-13  -2.03294493993e-11  8.17255702411e-11
+ 30400000000
+ 8.17241810836e-11
+ -2.03291986123e-11  8.33869159539e-11
+ -8.93309603535e-13  -9.77927195092e-12  8.33869159539e-11
+ -3.70894514199e-13  -8.93309603535e-13  -2.03291986123e-11  8.17241810836e-11
+ 30500000000
+ 8.1722796497e-11
+ -2.03289486501e-11  8.33855226639e-11
+ -8.93307993844e-13  -9.77916476281e-12  8.33855226639e-11
+ -3.70895108101e-13  -8.93307993844e-13  -2.03289486501e-11  8.1722796497e-11
+ 30600000000
+ 8.17214164514e-11
+ -2.03286995073e-11  8.33841339433e-11
+ -8.9330638918e-13  -9.77905792594e-12  8.33841339433e-11
+ -3.70895699865e-13  -8.9330638918e-13  -2.03286995073e-11  8.17214164514e-11
+ 30700000000
+ 8.17200409171e-11
+ -2.03284511787e-11  8.33827497624e-11
+ -8.93304789511e-13  -9.77895143802e-12  8.33827497624e-11
+ -3.70896289506e-13  -8.93304789511e-13  -2.03284511787e-11  8.17200409171e-11
+ 30800000000
+ 8.17186698649e-11
+ -2.03282036588e-11  8.33813700916e-11
+ -8.93303194805e-13  -9.77884529678e-12  8.33813700916e-11
+ -3.70896877038e-13  -8.93303194805e-13  -2.03282036588e-11  8.17186698649e-11
+ 30900000000
+ 8.17173032657e-11
+ -2.03279569425e-11  8.33799949018e-11
+ -8.93301605029e-13  -9.77873949998e-12  8.33799949018e-11
+ -3.70897462473e-13  -8.93301605029e-13  -2.03279569425e-11  8.17173032657e-11
+ 31000000000
+ 8.17159410907e-11
+ -2.03277110245e-11  8.3378624164e-11
+ -8.93300020152e-13  -9.77863404539e-12  8.3378624164e-11
+ -3.70898045826e-13  -8.93300020152e-13  -2.03277110245e-11  8.17159410907e-11
+ 31100000000
+ 8.17145833115e-11
+ -2.03274658998e-11  8.33772578496e-11
+ -8.93298440141e-13  -9.77852893082e-12  8.33772578496e-11
+ -3.70898627109e-13  -8.93298440141e-13  -2.03274658998e-11  8.17145833115e-11
+ 31200000000
+ 8.17132298999e-11
+ -2.03272215632e-11  8.33758959301e-11
+ -8.93296864967e-13  -9.77842415407e-12  8.33758959301e-11
+ -3.70899206337e-13  -8.93296864967e-13  -2.03272215632e-11  8.17132298999e-11
+ 31300000000
+ 8.1711880828e-11
+ -2.03269780097e-11  8.33745383775e-11
+ -8.93295294597e-13  -9.778319713e-12  8.33745383775e-11
+ -3.70899783522e-13  -8.93295294597e-13  -2.03269780097e-11  8.1711880828e-11
+ 31400000000
+ 8.1710536068e-11
+ -2.03267352344e-11  8.3373185164e-11
+ -8.93293729001e-13  -9.77821560545e-12  8.3373185164e-11
+ -3.70900358678e-13  -8.93293729001e-13  -2.03267352344e-11  8.1710536068e-11
+ 31500000000
+ 8.17091955927e-11
+ -2.03264932322e-11  8.3371836262e-11
+ -8.9329216815e-13  -9.77811182932e-12  8.3371836262e-11
+ -3.70900931817e-13  -8.9329216815e-13  -2.03264932322e-11  8.17091955927e-11
+ 31600000000
+ 8.17078593749e-11
+ -2.03262519982e-11  8.33704916442e-11
+ -8.93290612012e-13  -9.7780083825e-12  8.33704916442e-11
+ -3.70901502952e-13  -8.93290612012e-13  -2.03262519982e-11  8.17078593749e-11
+ 31700000000
+ 8.17065273876e-11
+ -2.03260115277e-11  8.33691512835e-11
+ -8.93289060558e-13  -9.77790526292e-12  8.33691512835e-11
+ -3.70902072095e-13  -8.93289060558e-13  -2.03260115277e-11  8.17065273876e-11
+ 31800000000
+ 8.17051996044e-11
+ -2.03257718158e-11  8.33678151531e-11
+ -8.93287513759e-13  -9.77780246851e-12  8.33678151531e-11
+ -3.7090263926e-13  -8.93287513759e-13  -2.03257718158e-11  8.17051996044e-11
+ 31900000000
+ 8.17038759987e-11
+ -2.03255328578e-11  8.33664832266e-11
+ -8.93285971585e-13  -9.77769999723e-12  8.33664832266e-11
+ -3.70903204458e-13  -8.93285971585e-13  -2.03255328578e-11  8.17038759987e-11
+ 32000000000
+ 8.17025565445e-11
+ -2.03252946489e-11  8.33651554776e-11
+ -8.93284434008e-13  -9.77759784707e-12  8.33651554776e-11
+ -3.70903767703e-13  -8.93284434008e-13  -2.03252946489e-11  8.17025565445e-11
+ 32100000000
+ 8.1701241216e-11
+ -2.03250571845e-11  8.336383188e-11
+ -8.93282900999e-13  -9.77749601602e-12  8.336383188e-11
+ -3.70904329005e-13  -8.93282900999e-13  -2.03250571845e-11  8.1701241216e-11
+ 32200000000
+ 8.16999299874e-11
+ -2.032482046e-11  8.33625124082e-11
+ -8.93281372529e-13  -9.77739450211e-12  8.33625124082e-11
+ -3.70904888378e-13  -8.93281372529e-13  -2.032482046e-11  8.16999299874e-11
+ 32300000000
+ 8.16986228333e-11
+ -2.03245844707e-11  8.33611970365e-11
+ -8.9327984857e-13  -9.77729330335e-12  8.33611970365e-11
+ -3.70905445832e-13  -8.9327984857e-13  -2.03245844707e-11  8.16986228333e-11
+ 32400000000
+ 8.16973197287e-11
+ -2.03243492121e-11  8.33598857396e-11
+ -8.93278329095e-13  -9.77719241782e-12  8.33598857396e-11
+ -3.70906001381e-13  -8.93278329095e-13  -2.03243492121e-11  8.16973197287e-11
+ 32500000000
+ 8.16960206485e-11
+ -2.03241146797e-11  8.33585784923e-11
+ -8.93276814076e-13  -9.77709184357e-12  8.33585784923e-11
+ -3.70906555036e-13  -8.93276814076e-13  -2.03241146797e-11  8.16960206485e-11
+ 32600000000
+ 8.1694725568e-11
+ -2.03238808691e-11  8.335727527e-11
+ -8.93275303486e-13  -9.7769915787e-12  8.335727527e-11
+ -3.70907106807e-13  -8.93275303486e-13  -2.03238808691e-11  8.1694725568e-11
+ 32700000000
+ 8.16934344629e-11
+ -2.03236477759e-11  8.33559760478e-11
+ -8.93273797297e-13  -9.77689162132e-12  8.33559760478e-11
+ -3.70907656708e-13  -8.93273797297e-13  -2.03236477759e-11  8.16934344629e-11
+ 32800000000
+ 8.16921473088e-11
+ -2.03234153957e-11  8.33546808015e-11
+ -8.93272295482e-13  -9.77679196955e-12  8.33546808015e-11
+ -3.70908204749e-13  -8.93272295482e-13  -2.03234153957e-11  8.16921473088e-11
+ 32900000000
+ 8.16908640817e-11
+ -2.0323183724e-11  8.33533895069e-11
+ -8.93270798016e-13  -9.77669262153e-12  8.33533895069e-11
+ -3.70908750942e-13  -8.93270798016e-13  -2.0323183724e-11  8.16908640817e-11
+ 33000000000
+ 8.16895847578e-11
+ -2.03229527568e-11  8.33521021399e-11
+ -8.93269304871e-13  -9.77659357542e-12  8.33521021399e-11
+ -3.70909295297e-13  -8.93269304871e-13  -2.03229527568e-11  8.16895847578e-11
+ 33100000000
+ 8.16883093135e-11
+ -2.03227224896e-11  8.33508186768e-11
+ -8.93267816022e-13  -9.77649482939e-12  8.33508186768e-11
+ -3.70909837827e-13  -8.93267816022e-13  -2.03227224896e-11  8.16883093135e-11
+ 33200000000
+ 8.16870377254e-11
+ -2.03224929182e-11  8.33495390942e-11
+ -8.93266331442e-13  -9.77639638165e-12  8.33495390942e-11
+ -3.70910378541e-13  -8.93266331442e-13  -2.03224929182e-11  8.16870377254e-11
+ 33300000000
+ 8.16857699704e-11
+ -2.03222640386e-11  8.33482633686e-11
+ -8.93264851107e-13  -9.77629823038e-12  8.33482633686e-11
+ -3.70910917451e-13  -8.93264851107e-13  -2.03222640386e-11  8.16857699704e-11
+ 33400000000
+ 8.16845060255e-11
+ -2.03220358465e-11  8.33469914771e-11
+ -8.9326337499e-13  -9.77620037382e-12  8.33469914771e-11
+ -3.70911454568e-13  -8.9326337499e-13  -2.03220358465e-11  8.16845060255e-11
+ 33500000000
+ 8.16832458679e-11
+ -2.03218083378e-11  8.33457233966e-11
+ -8.93261903066e-13  -9.77610281021e-12  8.33457233966e-11
+ -3.70911989902e-13  -8.93261903066e-13  -2.03218083378e-11  8.16832458679e-11
+ 33600000000
+ 8.16819894751e-11
+ -2.03215815085e-11  8.33444591046e-11
+ -8.93260435311e-13  -9.77600553781e-12  8.33444591046e-11
+ -3.70912523465e-13  -8.93260435311e-13  -2.03215815085e-11  8.16819894751e-11
+ 33700000000
+ 8.16807368247e-11
+ -2.03213553545e-11  8.33431985784e-11
+ -8.932589717e-13  -9.77590855488e-12  8.33431985784e-11
+ -3.70913055265e-13  -8.932589717e-13  -2.03213553545e-11  8.16807368247e-11
+ 33800000000
+ 8.16794878945e-11
+ -2.03211298718e-11  8.33419417959e-11
+ -8.93257512208e-13  -9.77581185971e-12  8.33419417959e-11
+ -3.70913585315e-13  -8.93257512208e-13  -2.03211298718e-11  8.16794878945e-11
+ 33900000000
+ 8.16782426627e-11
+ -2.03209050565e-11  8.33406887349e-11
+ -8.9325605681e-13  -9.7757154506e-12  8.33406887349e-11
+ -3.70914113624e-13  -8.9325605681e-13  -2.03209050565e-11  8.16782426627e-11
+ 34000000000
+ 8.16770011075e-11
+ -2.03206809047e-11  8.33394393735e-11
+ -8.93254605484e-13  -9.77561932587e-12  8.33394393735e-11
+ -3.70914640203e-13  -8.93254605484e-13  -2.03206809047e-11  8.16770011075e-11
+ 34100000000
+ 8.16757632073e-11
+ -2.03204574124e-11  8.333819369e-11
+ -8.93253158204e-13  -9.77552348385e-12  8.333819369e-11
+ -3.70915165061e-13  -8.93253158204e-13  -2.03204574124e-11  8.16757632073e-11
+ 34200000000
+ 8.16745289406e-11
+ -2.03202345758e-11  8.33369516629e-11
+ -8.93251714947e-13  -9.77542792289e-12  8.33369516629e-11
+ -3.70915688209e-13  -8.93251714947e-13  -2.03202345758e-11  8.16745289406e-11
+ 34300000000
+ 8.16732982864e-11
+ -2.03200123911e-11  8.33357132709e-11
+ -8.93250275691e-13  -9.77533264135e-12  8.33357132709e-11
+ -3.70916209657e-13  -8.93250275691e-13  -2.03200123911e-11  8.16732982864e-11
+ 34400000000
+ 8.16720712236e-11
+ -2.03197908545e-11  8.33344784928e-11
+ -8.9324884041e-13  -9.7752376376e-12  8.33344784928e-11
+ -3.70916729414e-13  -8.9324884041e-13  -2.03197908545e-11  8.16720712236e-11
+ 34500000000
+ 8.16708477313e-11
+ -2.03195699621e-11  8.33332473077e-11
+ -8.93247409083e-13  -9.77514291003e-12  8.33332473077e-11
+ -3.70917247491e-13  -8.93247409083e-13  -2.03195699621e-11  8.16708477313e-11
+ 34600000000
+ 8.1669627789e-11
+ -2.03193497104e-11  8.33320196948e-11
+ -8.93245981687e-13  -9.77504845705e-12  8.33320196948e-11
+ -3.70917763897e-13  -8.93245981687e-13  -2.03193497104e-11  8.1669627789e-11
+ 34700000000
+ 8.16684113761e-11
+ -2.03191300956e-11  8.33307956335e-11
+ -8.93244558199e-13  -9.77495427707e-12  8.33307956335e-11
+ -3.70918278642e-13  -8.93244558199e-13  -2.03191300956e-11  8.16684113761e-11
+ 34800000000
+ 8.16671984725e-11
+ -2.0318911114e-11  8.33295751034e-11
+ -8.93243138596e-13  -9.77486036852e-12  8.33295751034e-11
+ -3.70918791735e-13  -8.93243138596e-13  -2.0318911114e-11  8.16671984725e-11
+ 34900000000
+ 8.16659890579e-11
+ -2.0318692762e-11  8.33283580843e-11
+ -8.93241722857e-13  -9.77476672985e-12  8.33283580843e-11
+ -3.70919303186e-13  -8.93241722857e-13  -2.0318692762e-11  8.16659890579e-11
+ 35000000000
+ 8.16647831124e-11
+ -2.0318475036e-11  8.3327144556e-11
+ -8.93240310958e-13  -9.77467335952e-12  8.3327144556e-11
+ -3.70919813004e-13  -8.93240310958e-13  -2.0318475036e-11  8.16647831124e-11
+ 35100000000
+ 8.16635806162e-11
+ -2.03182579325e-11  8.33259344988e-11
+ -8.93238902879e-13  -9.77458025599e-12  8.33259344988e-11
+ -3.70920321199e-13  -8.93238902879e-13  -2.03182579325e-11  8.16635806162e-11
+ 35200000000
+ 8.16623815499e-11
+ -2.03180414479e-11  8.33247278928e-11
+ -8.93237498597e-13  -9.77448741775e-12  8.33247278928e-11
+ -3.70920827779e-13  -8.93237498597e-13  -2.03180414479e-11  8.16623815499e-11
+ 35300000000
+ 8.16611858938e-11
+ -2.03178255786e-11  8.33235247185e-11
+ -8.93236098092e-13  -9.77439484329e-12  8.33235247185e-11
+ -3.70921332755e-13  -8.93236098092e-13  -2.03178255786e-11  8.16611858938e-11
+ 35400000000
+ 8.16599936288e-11
+ -2.03176103213e-11  8.33223249565e-11
+ -8.93234701341e-13  -9.77430253113e-12  8.33223249565e-11
+ -3.70921836134e-13  -8.93234701341e-13  -2.03176103213e-11  8.16599936288e-11
+ 35500000000
+ 8.16588047356e-11
+ -2.03173956725e-11  8.33211285876e-11
+ -8.93233308323e-13  -9.77421047978e-12  8.33211285876e-11
+ -3.70922337926e-13  -8.93233308323e-13  -2.03173956725e-11  8.16588047356e-11
+ 35600000000
+ 8.16576191955e-11
+ -2.03171816287e-11  8.33199355927e-11
+ -8.93231919019e-13  -9.77411868779e-12  8.33199355927e-11
+ -3.7092283814e-13  -8.93231919019e-13  -2.03171816287e-11  8.16576191955e-11
+ 35700000000
+ 8.16564369896e-11
+ -2.03169681866e-11  8.33187459529e-11
+ -8.93230533406e-13  -9.7740271537e-12  8.33187459529e-11
+ -3.70923336785e-13  -8.93230533406e-13  -2.03169681866e-11  8.16564369896e-11
+ 35800000000
+ 8.16552580993e-11
+ -2.03167553428e-11  8.33175596495e-11
+ -8.93229151464e-13  -9.77393587606e-12  8.33175596495e-11
+ -3.7092383387e-13  -8.93229151464e-13  -2.03167553428e-11  8.16552580993e-11
+ 35900000000
+ 8.1654082506e-11
+ -2.0316543094e-11  8.33163766639e-11
+ -8.93227773173e-13  -9.77384485345e-12  8.33163766639e-11
+ -3.70924329402e-13  -8.93227773173e-13  -2.0316543094e-11  8.1654082506e-11
+ 36000000000
+ 8.16529101915e-11
+ -2.03163314368e-11  8.33151969777e-11
+ -8.93226398512e-13  -9.77375408445e-12  8.33151969777e-11
+ -3.70924823392e-13  -8.93226398512e-13  -2.03163314368e-11  8.16529101915e-11
+ 36100000000
+ 8.16517411377e-11
+ -2.0316120368e-11  8.33140205724e-11
+ -8.93225027461e-13  -9.77366356766e-12  8.33140205724e-11
+ -3.70925315847e-13  -8.93225027461e-13  -2.0316120368e-11  8.16517411377e-11
+ 36200000000
+ 8.16505753264e-11
+ -2.03159098844e-11  8.33128474302e-11
+ -8.93223660001e-13  -9.77357330168e-12  8.33128474302e-11
+ -3.70925806775e-13  -8.93223660001e-13  -2.03159098844e-11  8.16505753264e-11
+ 36300000000
+ 8.16494127399e-11
+ -2.03156999826e-11  8.33116775329e-11
+ -8.93222296112e-13  -9.77348328513e-12  8.33116775329e-11
+ -3.70926296186e-13  -8.93222296112e-13  -2.03156999826e-11  8.16494127399e-11
+ 36400000000
+ 8.16482533603e-11
+ -2.03154906596e-11  8.33105108627e-11
+ -8.93220935773e-13  -9.77339351665e-12  8.33105108627e-11
+ -3.70926784088e-13  -8.93220935773e-13  -2.03154906596e-11  8.16482533603e-11
+ 36500000000
+ 8.16470971702e-11
+ -2.03152819121e-11  8.33093474019e-11
+ -8.93219578966e-13  -9.77330399486e-12  8.33093474019e-11
+ -3.70927270488e-13  -8.93219578966e-13  -2.03152819121e-11  8.16470971702e-11
+ 36600000000
+ 8.16459441521e-11
+ -2.0315073737e-11  8.33081871331e-11
+ -8.93218225672e-13  -9.77321471842e-12  8.33081871331e-11
+ -3.70927755396e-13  -8.93218225672e-13  -2.0315073737e-11  8.16459441521e-11
+ 36700000000
+ 8.16447942887e-11
+ -2.03148661312e-11  8.33070300387e-11
+ -8.9321687587e-13  -9.77312568601e-12  8.33070300387e-11
+ -3.70928238819e-13  -8.9321687587e-13  -2.03148661312e-11  8.16447942887e-11
+ 36800000000
+ 8.16436475629e-11
+ -2.03146590915e-11  8.33058761016e-11
+ -8.93215529542e-13  -9.77303689628e-12  8.33058761016e-11
+ -3.70928720765e-13  -8.93215529542e-13  -2.03146590915e-11  8.16436475629e-11
+ 36900000000
+ 8.16425039577e-11
+ -2.0314452615e-11  8.33047253047e-11
+ -8.9321418667e-13  -9.77294834792e-12  8.33047253047e-11
+ -3.70929201242e-13  -8.9321418667e-13  -2.0314452615e-11  8.16425039577e-11
+ 37000000000
+ 8.16413634561e-11
+ -2.03142466986e-11  8.33035776309e-11
+ -8.93212847234e-13  -9.77286003963e-12  8.33035776309e-11
+ -3.70929680259e-13  -8.93212847234e-13  -2.03142466986e-11  8.16413634561e-11
+ 37100000000
+ 8.16402260415e-11
+ -2.03140413391e-11  8.33024330635e-11
+ -8.93211511217e-13  -9.77277197012e-12  8.33024330635e-11
+ -3.70930157823e-13  -8.93211511217e-13  -2.03140413391e-11  8.16402260415e-11
+ 37200000000
+ 8.16390916973e-11
+ -2.03138365338e-11  8.33012915856e-11
+ -8.93210178599e-13  -9.7726841381e-12  8.33012915856e-11
+ -3.70930633942e-13  -8.93210178599e-13  -2.03138365338e-11  8.16390916973e-11
+ 37300000000
+ 8.1637960407e-11
+ -2.03136322795e-11  8.33001531809e-11
+ -8.93208849363e-13  -9.7725965423e-12  8.33001531809e-11
+ -3.70931108623e-13  -8.93208849363e-13  -2.03136322795e-11  8.1637960407e-11
+ 37400000000
+ 8.16368321543e-11
+ -2.03134285734e-11  8.32990178327e-11
+ -8.9320752349e-13  -9.77250918145e-12  8.32990178327e-11
+ -3.70931581875e-13  -8.9320752349e-13  -2.03134285734e-11  8.16368321543e-11
+ 37500000000
+ 8.16357069229e-11
+ -2.03132254125e-11  8.32978855249e-11
+ -8.93206200962e-13  -9.7724220543e-12  8.32978855249e-11
+ -3.70932053705e-13  -8.93206200962e-13  -2.03132254125e-11  8.16357069229e-11
+ 37600000000
+ 8.16345846968e-11
+ -2.03130227939e-11  8.32967562413e-11
+ -8.93204881762e-13  -9.77233515961e-12  8.32967562413e-11
+ -3.70932524121e-13  -8.93204881762e-13  -2.03130227939e-11  8.16345846968e-11
+ 37700000000
+ 8.16334654601e-11
+ -2.03128207147e-11  8.32956299658e-11
+ -8.93203565873e-13  -9.77224849615e-12  8.32956299658e-11
+ -3.70932993129e-13  -8.93203565873e-13  -2.03128207147e-11  8.16334654601e-11
+ 37800000000
+ 8.1632349197e-11
+ -2.03126191722e-11  8.32945066825e-11
+ -8.93202253275e-13  -9.77216206269e-12  8.32945066825e-11
+ -3.70933460739e-13  -8.93202253275e-13  -2.03126191722e-11  8.1632349197e-11
+ 37900000000
+ 8.16312358917e-11
+ -2.03124181633e-11  8.32933863755e-11
+ -8.93200943953e-13  -9.77207585802e-12  8.32933863755e-11
+ -3.70933926956e-13  -8.93200943953e-13  -2.03124181633e-11  8.16312358917e-11
+ 38000000000
+ 8.16301255287e-11
+ -2.03122176855e-11  8.32922690294e-11
+ -8.93199637889e-13  -9.77198988093e-12  8.32922690294e-11
+ -3.70934391788e-13  -8.93199637889e-13  -2.03122176855e-11  8.16301255287e-11
+ 38100000000
+ 8.16290180925e-11
+ -2.03120177357e-11  8.32911546284e-11
+ -8.93198335066e-13  -9.77190413024e-12  8.32911546284e-11
+ -3.70934855243e-13  -8.93198335066e-13  -2.03120177357e-11  8.16290180925e-11
+ 38200000000
+ 8.16279135679e-11
+ -2.03118183114e-11  8.32900431573e-11
+ -8.93197035467e-13  -9.77181860474e-12  8.32900431573e-11
+ -3.70935317328e-13  -8.93197035467e-13  -2.03118183114e-11  8.16279135679e-11
+ 38300000000
+ 8.16268119396e-11
+ -2.03116194097e-11  8.32889346006e-11
+ -8.93195739074e-13  -9.77173330328e-12  8.32889346006e-11
+ -3.70935778049e-13  -8.93195739074e-13  -2.03116194097e-11  8.16268119396e-11
+ 38400000000
+ 8.16257131925e-11
+ -2.0311421028e-11  8.32878289432e-11
+ -8.93194445872e-13  -9.77164822468e-12  8.32878289432e-11
+ -3.70936237415e-13  -8.93194445872e-13  -2.0311421028e-11  8.16257131925e-11
+ 38500000000
+ 8.16246173118e-11
+ -2.03112231634e-11  8.32867261701e-11
+ -8.93193155844e-13  -9.77156336778e-12  8.32867261701e-11
+ -3.70936695432e-13  -8.93193155844e-13  -2.03112231634e-11  8.16246173118e-11
+ 38600000000
+ 8.16235242824e-11
+ -2.03110258134e-11  8.32856262663e-11
+ -8.93191868973e-13  -9.77147873144e-12  8.32856262663e-11
+ -3.70937152106e-13  -8.93191868973e-13  -2.03110258134e-11  8.16235242824e-11
+ 38700000000
+ 8.16224340897e-11
+ -2.03108289754e-11  8.3284529217e-11
+ -8.93190585244e-13  -9.77139431452e-12  8.3284529217e-11
+ -3.70937607446e-13  -8.93190585244e-13  -2.03108289754e-11  8.16224340897e-11
+ 38800000000
+ 8.16213467191e-11
+ -2.03106326465e-11  8.32834350075e-11
+ -8.93189304639e-13  -9.77131011588e-12  8.32834350075e-11
+ -3.70938061457e-13  -8.93189304639e-13  -2.03106326465e-11  8.16213467191e-11
+ 38900000000
+ 8.16202621561e-11
+ -2.03104368243e-11  8.32823436232e-11
+ -8.93188027142e-13  -9.77122613441e-12  8.32823436232e-11
+ -3.70938514148e-13  -8.93188027142e-13  -2.03104368243e-11  8.16202621561e-11
+ 39000000000
+ 8.16191803863e-11
+ -2.03102415061e-11  8.32812550495e-11
+ -8.93186752739e-13  -9.77114236899e-12  8.32812550495e-11
+ -3.70938965523e-13  -8.93186752739e-13  -2.03102415061e-11  8.16191803863e-11
+ 39100000000
+ 8.16181013953e-11
+ -2.03100466894e-11  8.32801692722e-11
+ -8.93185481413e-13  -9.77105881851e-12  8.32801692722e-11
+ -3.70939415591e-13  -8.93185481413e-13  -2.03100466894e-11  8.16181013953e-11
+ 39200000000
+ 8.1617025169e-11
+ -2.03098523716e-11  8.32790862769e-11
+ -8.93184213148e-13  -9.77097548188e-12  8.32790862769e-11
+ -3.70939864358e-13  -8.93184213148e-13  -2.03098523716e-11  8.1617025169e-11
+ 39300000000
+ 8.16159516934e-11
+ -2.03096585501e-11  8.32780060496e-11
+ -8.93182947929e-13  -9.77089235801e-12  8.32780060496e-11
+ -3.70940311831e-13  -8.93182947929e-13  -2.03096585501e-11  8.16159516934e-11
+ 39400000000
+ 8.16148809545e-11
+ -2.03094652225e-11  8.32769285761e-11
+ -8.9318168574e-13  -9.77080944583e-12  8.32769285761e-11
+ -3.70940758015e-13  -8.9318168574e-13  -2.03094652225e-11  8.16148809545e-11
+ 39500000000
+ 8.16138129384e-11
+ -2.03092723862e-11  8.32758538425e-11
+ -8.93180426567e-13  -9.77072674425e-12  8.32758538425e-11
+ -3.70941202918e-13  -8.93180426567e-13  -2.03092723862e-11  8.16138129384e-11
+ 39600000000
+ 8.16127476314e-11
+ -2.03090800388e-11  8.3274781835e-11
+ -8.93179170393e-13  -9.77064425222e-12  8.3274781835e-11
+ -3.70941646546e-13  -8.93179170393e-13  -2.03090800388e-11  8.16127476314e-11
+ 39700000000
+ 8.16116850199e-11
+ -2.03088881778e-11  8.32737125398e-11
+ -8.93177917203e-13  -9.77056196868e-12  8.32737125398e-11
+ -3.70942088906e-13  -8.93177917203e-13  -2.03088881778e-11  8.16116850199e-11
+ 39800000000
+ 8.16106250902e-11
+ -2.03086968008e-11  8.32726459434e-11
+ -8.93176666984e-13  -9.77047989259e-12  8.32726459434e-11
+ -3.70942530003e-13  -8.93176666984e-13  -2.03086968008e-11  8.16106250902e-11
+ 39900000000
+ 8.1609567829e-11
+ -2.03085059052e-11  8.32715820321e-11
+ -8.93175419719e-13  -9.7703980229e-12  8.32715820321e-11
+ -3.70942969845e-13  -8.93175419719e-13  -2.03085059052e-11  8.1609567829e-11
+ 40000000000
+ 8.1608513223e-11
+ -2.03083154888e-11  8.32705207927e-11
+ -8.93174175394e-13  -9.77031635858e-12  8.32705207927e-11
+ -3.70943408437e-13  -8.93174175394e-13  -2.03083154888e-11  8.1608513223e-11
+ 40100000000
+ 8.16074612588e-11
+ -2.03081255492e-11  8.32694622117e-11
+ -8.93172933995e-13  -9.77023489861e-12  8.32694622117e-11
+ -3.70943845785e-13  -8.93172933995e-13  -2.03081255492e-11  8.16074612588e-11
+ 40200000000
+ 8.16064119234e-11
+ -2.03079360839e-11  8.32684062759e-11
+ -8.93171695507e-13  -9.77015364197e-12  8.32684062759e-11
+ -3.70944281897e-13  -8.93171695507e-13  -2.03079360839e-11  8.16064119234e-11
+ 40300000000
+ 8.16053652036e-11
+ -2.03077470906e-11  8.32673529723e-11
+ -8.93170459915e-13  -9.77007258766e-12  8.32673529723e-11
+ -3.70944716778e-13  -8.93170459915e-13  -2.03077470906e-11  8.16053652036e-11
+ 40400000000
+ 8.16043210867e-11
+ -2.0307558567e-11  8.32663022878e-11
+ -8.93169227205e-13  -9.76999173467e-12  8.32663022878e-11
+ -3.70945150434e-13  -8.93169227205e-13  -2.0307558567e-11  8.16043210867e-11
+ 40500000000
+ 8.16032795596e-11
+ -2.03073705107e-11  8.32652542094e-11
+ -8.93167997363e-13  -9.769911082e-12  8.32652542094e-11
+ -3.70945582871e-13  -8.93167997363e-13  -2.03073705107e-11  8.16032795596e-11
+ 40600000000
+ 8.16022406097e-11
+ -2.03071829195e-11  8.32642087243e-11
+ -8.93166770374e-13  -9.76983062868e-12  8.32642087243e-11
+ -3.70946014095e-13  -8.93166770374e-13  -2.03071829195e-11  8.16022406097e-11
+ 40700000000
+ 8.16012042244e-11
+ -2.03069957911e-11  8.32631658198e-11
+ -8.93165546226e-13  -9.76975037373e-12  8.32631658198e-11
+ -3.70946444113e-13  -8.93165546226e-13  -2.03069957911e-11  8.16012042244e-11
+ 40800000000
+ 8.16001703909e-11
+ -2.03068091231e-11  8.32621254833e-11
+ -8.93164324903e-13  -9.76967031616e-12  8.32621254833e-11
+ -3.70946872929e-13  -8.93164324903e-13  -2.03068091231e-11  8.16001703909e-11
+ 40900000000
+ 8.15991390969e-11
+ -2.03066229134e-11  8.32610877022e-11
+ -8.93163106392e-13  -9.76959045502e-12  8.32610877022e-11
+ -3.7094730055e-13  -8.93163106392e-13  -2.03066229134e-11  8.15991390969e-11
+ 41000000000
+ 8.159811033e-11
+ -2.03064371598e-11  8.3260052464e-11
+ -8.9316189068e-13  -9.76951078934e-12  8.3260052464e-11
+ -3.70947726983e-13  -8.9316189068e-13  -2.03064371598e-11  8.159811033e-11
+ 41100000000
+ 8.15970840779e-11
+ -2.03062518599e-11  8.32590197563e-11
+ -8.93160677752e-13  -9.76943131819e-12  8.32590197563e-11
+ -3.70948152231e-13  -8.93160677752e-13  -2.03062518599e-11  8.15970840779e-11
+ 41200000000
+ 8.15960603283e-11
+ -2.03060670117e-11  8.3257989567e-11
+ -8.93159467595e-13  -9.7693520406e-12  8.3257989567e-11
+ -3.70948576302e-13  -8.93159467595e-13  -2.03060670117e-11  8.15960603283e-11
+ 41300000000
+ 8.15950390693e-11
+ -2.03058826128e-11  8.32569618837e-11
+ -8.93158260197e-13  -9.76927295566e-12  8.32569618837e-11
+ -3.70948999201e-13  -8.93158260197e-13  -2.03058826128e-11  8.15950390693e-11
+ 41400000000
+ 8.15940202886e-11
+ -2.03056986612e-11  8.32559366944e-11
+ -8.93157055542e-13  -9.76919406242e-12  8.32559366944e-11
+ -3.70949420934e-13  -8.93157055542e-13  -2.03056986612e-11  8.15940202886e-11
+ 41500000000
+ 8.15930039745e-11
+ -2.03055151547e-11  8.32549139871e-11
+ -8.93155853619e-13  -9.76911535996e-12  8.32549139871e-11
+ -3.70949841506e-13  -8.93155853619e-13  -2.03055151547e-11  8.15930039745e-11
+ 41600000000
+ 8.1591990115e-11
+ -2.03053320911e-11  8.32538937499e-11
+ -8.93154654414e-13  -9.76903684737e-12  8.32538937499e-11
+ -3.70950260923e-13  -8.93154654414e-13  -2.03053320911e-11  8.1591990115e-11
+ 41700000000
+ 8.15909786985e-11
+ -2.03051494683e-11  8.32528759709e-11
+ -8.93153457915e-13  -9.76895852374e-12  8.32528759709e-11
+ -3.7095067919e-13  -8.93153457915e-13  -2.03051494683e-11  8.15909786985e-11
+ 41800000000
+ 8.15899697131e-11
+ -2.03049672843e-11  8.32518606383e-11
+ -8.93152264107e-13  -9.76888038816e-12  8.32518606383e-11
+ -3.70951096314e-13  -8.93152264107e-13  -2.03049672843e-11  8.15899697131e-11
+ 41900000000
+ 8.15889631473e-11
+ -2.03047855369e-11  8.32508477405e-11
+ -8.93151072979e-13  -9.76880243973e-12  8.32508477405e-11
+ -3.70951512298e-13  -8.93151072979e-13  -2.03047855369e-11  8.15889631473e-11
+ 42000000000
+ 8.15879589896e-11
+ -2.0304604224e-11  8.32498372659e-11
+ -8.93149884517e-13  -9.76872467757e-12  8.32498372659e-11
+ -3.7095192715e-13  -8.93149884517e-13  -2.0304604224e-11  8.15879589896e-11
+ 42100000000
+ 8.15869572286e-11
+ -2.03044233437e-11  8.3248829203e-11
+ -8.93148698709e-13  -9.76864710079e-12  8.3248829203e-11
+ -3.70952340873e-13  -8.93148698709e-13  -2.03044233437e-11  8.15869572286e-11
+ 42200000000
+ 8.15859578529e-11
+ -2.03042428937e-11  8.32478235404e-11
+ -8.93147515543e-13  -9.76856970851e-12  8.32478235404e-11
+ -3.70952753475e-13  -8.93147515543e-13  -2.03042428937e-11  8.15859578529e-11
+ 42300000000
+ 8.15849608512e-11
+ -2.03040628722e-11  8.32468202667e-11
+ -8.93146335006e-13  -9.76849249987e-12  8.32468202667e-11
+ -3.70953164958e-13  -8.93146335006e-13  -2.03040628722e-11  8.15849608512e-11
+ 42400000000
+ 8.15839662124e-11
+ -2.0303883277e-11  8.32458193706e-11
+ -8.93145157085e-13  -9.76841547398e-12  8.32458193706e-11
+ -3.70953575331e-13  -8.93145157085e-13  -2.0303883277e-11  8.15839662124e-11
+ 42500000000
+ 8.15829739253e-11
+ -2.03037041062e-11  8.32448208411e-11
+ -8.93143981768e-13  -9.76833863e-12  8.32448208411e-11
+ -3.70953984596e-13  -8.93143981768e-13  -2.03037041062e-11  8.15829739253e-11
+ 42600000000
+ 8.15819839788e-11
+ -2.03035253578e-11  8.32438246669e-11
+ -8.93142809043e-13  -9.76826196708e-12  8.32438246669e-11
+ -3.7095439276e-13  -8.93142809043e-13  -2.03035253578e-11  8.15819839788e-11
+ 42700000000
+ 8.15809963622e-11
+ -2.03033470298e-11  8.32428308371e-11
+ -8.93141638898e-13  -9.76818548435e-12  8.32428308371e-11
+ -3.70954799828e-13  -8.93141638898e-13  -2.03033470298e-11  8.15809963622e-11
+ 42800000000
+ 8.15800110643e-11
+ -2.03031691203e-11  8.32418393406e-11
+ -8.93140471321e-13  -9.76810918099e-12  8.32418393406e-11
+ -3.70955205804e-13  -8.93140471321e-13  -2.03031691203e-11  8.15800110643e-11
+ 42900000000
+ 8.15790280746e-11
+ -2.03029916272e-11  8.32408501667e-11
+ -8.931393063e-13  -9.76803305616e-12  8.32408501667e-11
+ -3.70955610694e-13  -8.931393063e-13  -2.03029916272e-11  8.15790280746e-11
+ 43000000000
+ 8.15780473821e-11
+ -2.03028145487e-11  8.32398633046e-11
+ -8.93138143823e-13  -9.76795710902e-12  8.32398633046e-11
+ -3.70956014504e-13  -8.93138143823e-13  -2.03028145487e-11  8.15780473821e-11
+ 43100000000
+ 8.15770689763e-11
+ -2.03026378828e-11  8.32388787434e-11
+ -8.93136983877e-13  -9.76788133876e-12  8.32388787434e-11
+ -3.70956417237e-13  -8.93136983877e-13  -2.03026378828e-11  8.15770689763e-11
+ 43200000000
+ 8.15760928466e-11
+ -2.03024616277e-11  8.32378964727e-11
+ -8.93135826453e-13  -9.76780574455e-12  8.32378964727e-11
+ -3.70956818899e-13  -8.93135826453e-13  -2.03024616277e-11  8.15760928466e-11
+ 43300000000
+ 8.15751189826e-11
+ -2.03022857814e-11  8.32369164817e-11
+ -8.93134671537e-13  -9.76773032559e-12  8.32369164817e-11
+ -3.70957219496e-13  -8.93134671537e-13  -2.03022857814e-11  8.15751189826e-11
+ 43400000000
+ 8.15741473736e-11
+ -2.0302110342e-11  8.323593876e-11
+ -8.93133519119e-13  -9.76765508105e-12  8.323593876e-11
+ -3.70957619031e-13  -8.93133519119e-13  -2.0302110342e-11  8.15741473736e-11
+ 43500000000
+ 8.15731780095e-11
+ -2.03019353078e-11  8.32349632972e-11
+ -8.93132369186e-13  -9.76758001016e-12  8.32349632972e-11
+ -3.70958017509e-13  -8.93132369186e-13  -2.03019353078e-11  8.15731780095e-11
+ 43600000000
+ 8.15722108798e-11
+ -2.03017606767e-11  8.3233990083e-11
+ -8.93131221728e-13  -9.7675051121e-12  8.3233990083e-11
+ -3.70958414936e-13  -8.93131221728e-13  -2.03017606767e-11  8.15722108798e-11
+ 43700000000
+ 8.15712459744e-11
+ -2.0301586447e-11  8.32330191069e-11
+ -8.93130076733e-13  -9.76743038608e-12  8.32330191069e-11
+ -3.70958811317e-13  -8.93130076733e-13  -2.0301586447e-11  8.15712459744e-11
+ 43800000000
+ 8.15702832832e-11
+ -2.03014126169e-11  8.32320503589e-11
+ -8.9312893419e-13  -9.76735583133e-12  8.32320503589e-11
+ -3.70959206656e-13  -8.9312893419e-13  -2.03014126169e-11  8.15702832832e-11
+ 43900000000
+ 8.1569322796e-11
+ -2.03012391845e-11  8.32310838288e-11
+ -8.93127794087e-13  -9.76728144707e-12  8.32310838288e-11
+ -3.70959600957e-13  -8.93127794087e-13  -2.03012391845e-11  8.1569322796e-11
+ 44000000000
+ 8.15683645029e-11
+ -2.0301066148e-11  8.32301195064e-11
+ -8.93126656415e-13  -9.76720723251e-12  8.32301195064e-11
+ -3.70959994227e-13  -8.93126656415e-13  -2.0301066148e-11  8.15683645029e-11
+ 44100000000
+ 8.15674083939e-11
+ -2.03008935056e-11  8.32291573819e-11
+ -8.93125521161e-13  -9.76713318689e-12  8.32291573819e-11
+ -3.70960386468e-13  -8.93125521161e-13  -2.03008935056e-11  8.15674083939e-11
+ 44200000000
+ 8.15664544591e-11
+ -2.03007212556e-11  8.32281974452e-11
+ -8.93124388314e-13  -9.76705930944e-12  8.32281974452e-11
+ -3.70960777686e-13  -8.93124388314e-13  -2.03007212556e-11  8.15664544591e-11
+ 44300000000
+ 8.15655026887e-11
+ -2.03005493962e-11  8.32272396866e-11
+ -8.93123257865e-13  -9.76698559941e-12  8.32272396866e-11
+ -3.70961167886e-13  -8.93123257865e-13  -2.03005493962e-11  8.15655026887e-11
+ 44400000000
+ 8.15645530729e-11
+ -2.03003779255e-11  8.32262840961e-11
+ -8.93122129801e-13  -9.76691205605e-12  8.32262840961e-11
+ -3.70961557072e-13  -8.93122129801e-13  -2.03003779255e-11  8.15645530729e-11
+ 44500000000
+ 8.15636056022e-11
+ -2.0300206842e-11  8.32253306641e-11
+ -8.93121004113e-13  -9.7668386786e-12  8.32253306641e-11
+ -3.70961945249e-13  -8.93121004113e-13  -2.0300206842e-11  8.15636056022e-11
+ 44600000000
+ 8.15626602669e-11
+ -2.03000361438e-11  8.32243793809e-11
+ -8.9311988079e-13  -9.76676546632e-12  8.32243793809e-11
+ -3.70962332421e-13  -8.9311988079e-13  -2.03000361438e-11  8.15626602669e-11
+ 44700000000
+ 8.15617170574e-11
+ -2.02998658292e-11  8.32234302368e-11
+ -8.93118759821e-13  -9.76669241847e-12  8.32234302368e-11
+ -3.70962718593e-13  -8.93118759821e-13  -2.02998658292e-11  8.15617170574e-11
+ 44800000000
+ 8.15607759643e-11
+ -2.02996958965e-11  8.32224832224e-11
+ -8.93117641195e-13  -9.76661953433e-12  8.32224832224e-11
+ -3.70963103769e-13  -8.93117641195e-13  -2.02996958965e-11  8.15607759643e-11
+ 44900000000
+ 8.15598369781e-11
+ -2.0299526344e-11  8.32215383281e-11
+ -8.93116524903e-13  -9.76654681315e-12  8.32215383281e-11
+ -3.70963487953e-13  -8.93116524903e-13  -2.0299526344e-11  8.15598369781e-11
+ 45000000000
+ 8.15589000895e-11
+ -2.029935717e-11  8.32205955446e-11
+ -8.93115410934e-13  -9.76647425423e-12  8.32205955446e-11
+ -3.70963871151e-13  -8.93115410934e-13  -2.029935717e-11  8.15589000895e-11
+ 45100000000
+ 8.15579652892e-11
+ -2.02991883729e-11  8.32196548625e-11
+ -8.93114299277e-13  -9.76640185683e-12  8.32196548625e-11
+ -3.70964253365e-13  -8.93114299277e-13  -2.02991883729e-11  8.15579652892e-11
+ 45200000000
+ 8.15570325679e-11
+ -2.02990199509e-11  8.32187162725e-11
+ -8.93113189923e-13  -9.76632962024e-12  8.32187162725e-11
+ -3.70964634602e-13  -8.93113189923e-13  -2.02990199509e-11  8.15570325679e-11
+ 45300000000
+ 8.15561019166e-11
+ -2.02988519024e-11  8.32177797653e-11
+ -8.9311208286e-13  -9.76625754376e-12  8.32177797653e-11
+ -3.70965014865e-13  -8.9311208286e-13  -2.02988519024e-11  8.15561019166e-11
+ 45400000000
+ 8.1555173326e-11
+ -2.02986842258e-11  8.32168453319e-11
+ -8.9311097808e-13  -9.76618562668e-12  8.32168453319e-11
+ -3.70965394158e-13  -8.9311097808e-13  -2.02986842258e-11  8.1555173326e-11
+ 45500000000
+ 8.15542467871e-11
+ -2.02985169195e-11  8.3215912963e-11
+ -8.93109875573e-13  -9.7661138683e-12  8.3215912963e-11
+ -3.70965772485e-13  -8.93109875573e-13  -2.02985169195e-11  8.15542467871e-11
+ 45600000000
+ 8.1553322291e-11
+ -2.02983499818e-11  8.32149826497e-11
+ -8.93108775327e-13  -9.76604226793e-12  8.32149826497e-11
+ -3.70966149852e-13  -8.93108775327e-13  -2.02983499818e-11  8.1553322291e-11
+ 45700000000
+ 8.15523998287e-11
+ -2.02981834111e-11  8.3214054383e-11
+ -8.93107677333e-13  -9.76597082487e-12  8.3214054383e-11
+ -3.70966526261e-13  -8.93107677333e-13  -2.02981834111e-11  8.15523998287e-11
+ 45800000000
+ 8.15514793913e-11
+ -2.02980172057e-11  8.32131281539e-11
+ -8.93106581582e-13  -9.76589953844e-12  8.32131281539e-11
+ -3.70966901718e-13  -8.93106581582e-13  -2.02980172057e-11  8.15514793913e-11
+ 45900000000
+ 8.15505609701e-11
+ -2.02978513642e-11  8.32122039536e-11
+ -8.93105488064e-13  -9.76582840795e-12  8.32122039536e-11
+ -3.70967276226e-13  -8.93105488064e-13  -2.02978513642e-11  8.15505609701e-11
+ 46000000000
+ 8.15496445562e-11
+ -2.0297685885e-11  8.32112817732e-11
+ -8.93104396769e-13  -9.76575743273e-12  8.32112817732e-11
+ -3.7096764979e-13  -8.93104396769e-13  -2.0297685885e-11  8.15496445562e-11
+ 46100000000
+ 8.1548730141e-11
+ -2.02975207664e-11  8.3210361604e-11
+ -8.93103307687e-13  -9.76568661211e-12  8.3210361604e-11
+ -3.70968022413e-13  -8.93103307687e-13  -2.02975207664e-11  8.1548730141e-11
+ 46200000000
+ 8.15478177157e-11
+ -2.02973560069e-11  8.32094434374e-11
+ -8.93102220809e-13  -9.76561594542e-12  8.32094434374e-11
+ -3.709683941e-13  -8.93102220809e-13  -2.02973560069e-11  8.15478177157e-11
+ 46300000000
+ 8.1546907272e-11
+ -2.02971916049e-11  8.32085272646e-11
+ -8.93101136125e-13  -9.76554543199e-12  8.32085272646e-11
+ -3.70968764855e-13  -8.93101136125e-13  -2.02971916049e-11  8.1546907272e-11
+ 46400000000
+ 8.15459988011e-11
+ -2.0297027559e-11  8.3207613077e-11
+ -8.93100053626e-13  -9.76547507116e-12  8.3207613077e-11
+ -3.70969134681e-13  -8.93100053626e-13  -2.0297027559e-11  8.15459988011e-11
+ 46500000000
+ 8.15450922946e-11
+ -2.02968638676e-11  8.32067008662e-11
+ -8.93098973303e-13  -9.76540486228e-12  8.32067008662e-11
+ -3.70969503583e-13  -8.93098973303e-13  -2.02968638676e-11  8.15450922946e-11
+ 46600000000
+ 8.15441877441e-11
+ -2.02967005291e-11  8.32057906237e-11
+ -8.93097895146e-13  -9.76533480469e-12  8.32057906237e-11
+ -3.70969871565e-13  -8.93097895146e-13  -2.02967005291e-11  8.15441877441e-11
+ 46700000000
+ 8.15432851413e-11
+ -2.02965375421e-11  8.3204882341e-11
+ -8.93096819146e-13  -9.76526489775e-12  8.3204882341e-11
+ -3.7097023863e-13  -8.93096819146e-13  -2.02965375421e-11  8.15432851413e-11
+ 46800000000
+ 8.15423844778e-11
+ -2.0296374905e-11  8.32039760099e-11
+ -8.93095745293e-13  -9.76519514082e-12  8.32039760099e-11
+ -3.70970604783e-13  -8.93095745293e-13  -2.0296374905e-11  8.15423844778e-11
+ 46900000000
+ 8.15414857453e-11
+ -2.02962126164e-11  8.32030716219e-11
+ -8.93094673579e-13  -9.76512553326e-12  8.32030716219e-11
+ -3.70970970027e-13  -8.93094673579e-13  -2.02962126164e-11  8.15414857453e-11
+ 47000000000
+ 8.15405889357e-11
+ -2.02960506748e-11  8.32021691687e-11
+ -8.93093603994e-13  -9.76505607442e-12  8.32021691687e-11
+ -3.70971334367e-13  -8.93093603994e-13  -2.02960506748e-11  8.15405889357e-11
+ 47100000000
+ 8.15396940408e-11
+ -2.02958890787e-11  8.32012686423e-11
+ -8.9309253653e-13  -9.76498676369e-12  8.32012686423e-11
+ -3.70971697806e-13  -8.9309253653e-13  -2.02958890787e-11  8.15396940408e-11
+ 47200000000
+ 8.15388010525e-11
+ -2.02957278266e-11  8.32003700345e-11
+ -8.93091471177e-13  -9.76491760043e-12  8.32003700345e-11
+ -3.70972060348e-13  -8.93091471177e-13  -2.02957278266e-11  8.15388010525e-11
+ 47300000000
+ 8.15379099627e-11
+ -2.02955669171e-11  8.31994733371e-11
+ -8.93090407927e-13  -9.76484858403e-12  8.31994733371e-11
+ -3.70972421996e-13  -8.93090407927e-13  -2.02955669171e-11  8.15379099627e-11
+ 47400000000
+ 8.15370207634e-11
+ -2.02954063488e-11  8.31985785421e-11
+ -8.93089346771e-13  -9.76477971385e-12  8.31985785421e-11
+ -3.70972782755e-13  -8.93089346771e-13  -2.02954063488e-11  8.15370207634e-11
+ 47500000000
+ 8.15361334467e-11
+ -2.02952461202e-11  8.31976856415e-11
+ -8.93088287699e-13  -9.76471098929e-12  8.31976856415e-11
+ -3.70973142628e-13  -8.93088287699e-13  -2.02952461202e-11  8.15361334467e-11
+ 47600000000
+ 8.15352480047e-11
+ -2.02950862299e-11  8.31967946273e-11
+ -8.93087230704e-13  -9.76464240974e-12  8.31967946273e-11
+ -3.7097350162e-13  -8.93087230704e-13  -2.02950862299e-11  8.15352480047e-11
+ 47700000000
+ 8.15343644296e-11
+ -2.02949266765e-11  8.31959054917e-11
+ -8.93086175776e-13  -9.76457397459e-12  8.31959054917e-11
+ -3.70973859733e-13  -8.93086175776e-13  -2.02949266765e-11  8.15343644296e-11
+ 47800000000
+ 8.15334827134e-11
+ -2.02947674585e-11  8.31950182267e-11
+ -8.93085122907e-13  -9.76450568323e-12  8.31950182267e-11
+ -3.70974216971e-13  -8.93085122907e-13  -2.02947674585e-11  8.15334827134e-11
+ 47900000000
+ 8.15326028486e-11
+ -2.02946085746e-11  8.31941328247e-11
+ -8.93084072088e-13  -9.76443753507e-12  8.31941328247e-11
+ -3.70974573338e-13  -8.93084072088e-13  -2.02946085746e-11  8.15326028486e-11
+ 48000000000
+ 8.15317248273e-11
+ -2.02944500234e-11  8.31932492777e-11
+ -8.93083023311e-13  -9.7643695295e-12  8.31932492777e-11
+ -3.70974928838e-13  -8.93083023311e-13  -2.02944500234e-11  8.15317248273e-11
+ 48100000000
+ 8.15308486419e-11
+ -2.02942918035e-11  8.31923675783e-11
+ -8.93081976567e-13  -9.76430166595e-12  8.31923675783e-11
+ -3.70975283474e-13  -8.93081976567e-13  -2.02942918035e-11  8.15308486419e-11
+ 48200000000
+ 8.15299742848e-11
+ -2.02941339135e-11  8.31914877186e-11
+ -8.93080931848e-13  -9.76423394381e-12  8.31914877186e-11
+ -3.70975637251e-13  -8.93080931848e-13  -2.02941339135e-11  8.15299742848e-11
+ 48300000000
+ 8.15291017485e-11
+ -2.02939763521e-11  8.3190609691e-11
+ -8.93079889146e-13  -9.76416636251e-12  8.3190609691e-11
+ -3.7097599017e-13  -8.93079889146e-13  -2.02939763521e-11  8.15291017485e-11
+ 48400000000
+ 8.15282310254e-11
+ -2.02938191178e-11  8.31897334881e-11
+ -8.93078848451e-13  -9.76409892146e-12  8.31897334881e-11
+ -3.70976342236e-13  -8.93078848451e-13  -2.02938191178e-11  8.15282310254e-11
+ 48500000000
+ 8.15273621081e-11
+ -2.02936622094e-11  8.31888591022e-11
+ -8.93077809756e-13  -9.76403162009e-12  8.31888591022e-11
+ -3.70976693453e-13  -8.93077809756e-13  -2.02936622094e-11  8.15273621081e-11
+ 48600000000
+ 8.15264949891e-11
+ -2.02935056256e-11  8.3187986526e-11
+ -8.93076773054e-13  -9.76396445782e-12  8.3187986526e-11
+ -3.70977043824e-13  -8.93076773054e-13  -2.02935056256e-11  8.15264949891e-11
+ 48700000000
+ 8.15256296611e-11
+ -2.02933493649e-11  8.3187115752e-11
+ -8.93075738334e-13  -9.76389743407e-12  8.3187115752e-11
+ -3.70977393352e-13  -8.93075738334e-13  -2.02933493649e-11  8.15256296611e-11
+ 48800000000
+ 8.15247661167e-11
+ -2.02931934261e-11  8.31862467728e-11
+ -8.9307470559e-13  -9.7638305483e-12  8.31862467728e-11
+ -3.70977742041e-13  -8.9307470559e-13  -2.02931934261e-11  8.15247661167e-11
+ 48900000000
+ 8.15239043487e-11
+ -2.02930378078e-11  8.31853795811e-11
+ -8.93073674813e-13  -9.76376379992e-12  8.31853795811e-11
+ -3.70978089894e-13  -8.93073674813e-13  -2.02930378078e-11  8.15239043487e-11
+ 49000000000
+ 8.15230443498e-11
+ -2.02928825088e-11  8.31845141696e-11
+ -8.93072645996e-13  -9.76369718838e-12  8.31845141696e-11
+ -3.70978436915e-13  -8.93072645996e-13  -2.02928825088e-11  8.15230443498e-11
+ 49100000000
+ 8.15221861128e-11
+ -2.02927275277e-11  8.31836505311e-11
+ -8.9307161913e-13  -9.76363071312e-12  8.31836505311e-11
+ -3.70978783107e-13  -8.9307161913e-13  -2.02927275277e-11  8.15221861128e-11
+ 49200000000
+ 8.15213296305e-11
+ -2.02925728633e-11  8.31827886584e-11
+ -8.93070594207e-13  -9.7635643736e-12  8.31827886584e-11
+ -3.70979128474e-13  -8.93070594207e-13  -2.02925728633e-11  8.15213296305e-11
+ 49300000000
+ 8.15204748959e-11
+ -2.02924185142e-11  8.31819285442e-11
+ -8.9306957122e-13  -9.76349816926e-12  8.31819285442e-11
+ -3.70979473018e-13  -8.9306957122e-13  -2.02924185142e-11  8.15204748959e-11
+ 49400000000
+ 8.15196219019e-11
+ -2.02922644792e-11  8.31810701816e-11
+ -8.9306855016e-13  -9.76343209955e-12  8.31810701816e-11
+ -3.70979816743e-13  -8.9306855016e-13  -2.02922644792e-11  8.15196219019e-11
+ 49500000000
+ 8.15187706415e-11
+ -2.02921107571e-11  8.31802135634e-11
+ -8.93067531021e-13  -9.76336616393e-12  8.31802135634e-11
+ -3.70980159653e-13  -8.93067531021e-13  -2.02921107571e-11  8.15187706415e-11
+ 49600000000
+ 8.15179211076e-11
+ -2.02919573465e-11  8.31793586826e-11
+ -8.93066513793e-13  -9.76330036186e-12  8.31793586826e-11
+ -3.70980501751e-13  -8.93066513793e-13  -2.02919573465e-11  8.15179211076e-11
+ 49700000000
+ 8.15170732934e-11
+ -2.02918042462e-11  8.31785055323e-11
+ -8.93065498471e-13  -9.7632346928e-12  8.31785055323e-11
+ -3.70980843039e-13  -8.93065498471e-13  -2.02918042462e-11  8.15170732934e-11
+ 49800000000
+ 8.15162271919e-11
+ -2.0291651455e-11  8.31776541054e-11
+ -8.93064485045e-13  -9.76316915623e-12  8.31776541054e-11
+ -3.70981183522e-13  -8.93064485045e-13  -2.0291651455e-11  8.15162271919e-11
+ 49900000000
+ 8.15153827963e-11
+ -2.02914989717e-11  8.31768043951e-11
+ -8.93063473508e-13  -9.7631037516e-12  8.31768043951e-11
+ -3.70981523203e-13  -8.93063473508e-13  -2.02914989717e-11  8.15153827963e-11
+ 50000000000
+ 8.15145400998e-11
+ -2.02913467949e-11  8.31759563946e-11
+ -8.93062463854e-13  -9.7630384784e-12  8.31759563946e-11
+ -3.70981862084e-13  -8.93062463854e-13  -2.02913467949e-11  8.15145400998e-11
+ 50100000000
+ 8.15136990956e-11
+ -2.02911949235e-11  8.3175110097e-11
+ -8.93061456073e-13  -9.7629733361e-12  8.3175110097e-11
+ -3.70982200169e-13  -8.93061456073e-13  -2.02911949235e-11  8.15136990956e-11
+ 50200000000
+ 8.1512859777e-11
+ -2.02910433563e-11  8.31742654956e-11
+ -8.9306045016e-13  -9.76290832418e-12  8.31742654956e-11
+ -3.7098253746e-13  -8.9306045016e-13  -2.02910433563e-11  8.1512859777e-11
+ 50300000000
+ 8.15120221373e-11
+ -2.02908920921e-11  8.31734225835e-11
+ -8.93059446105e-13  -9.76284344212e-12  8.31734225835e-11
+ -3.70982873963e-13  -8.93059446105e-13  -2.02908920921e-11  8.15120221373e-11
+ 50400000000
+ 8.15111861698e-11
+ -2.02907411296e-11  8.31725813542e-11
+ -8.93058443903e-13  -9.7627786894e-12  8.31725813542e-11
+ -3.70983209678e-13  -8.93058443903e-13  -2.02907411296e-11  8.15111861698e-11
+ 50500000000
+ 8.15103518679e-11
+ -2.02905904676e-11  8.31717418009e-11
+ -8.93057443546e-13  -9.76271406552e-12  8.31717418009e-11
+ -3.7098354461e-13  -8.93057443546e-13  -2.02905904676e-11  8.15103518679e-11
+ 50600000000
+ 8.1509519225e-11
+ -2.02904401051e-11  8.31709039171e-11
+ -8.93056445026e-13  -9.76264956997e-12  8.31709039171e-11
+ -3.70983878761e-13  -8.93056445026e-13  -2.02904401051e-11  8.1509519225e-11
+ 50700000000
+ 8.15086882347e-11
+ -2.02902900407e-11  8.31700676962e-11
+ -8.93055448336e-13  -9.76258520224e-12  8.31700676962e-11
+ -3.70984212135e-13  -8.93055448336e-13  -2.02902900407e-11  8.15086882347e-11
+ 50800000000
+ 8.15078588903e-11
+ -2.02901402734e-11  8.31692331316e-11
+ -8.9305445347e-13  -9.76252096182e-12  8.31692331316e-11
+ -3.70984544735e-13  -8.9305445347e-13  -2.02901402734e-11  8.15078588903e-11
+ 50900000000
+ 8.15070311856e-11
+ -2.0289990802e-11  8.31684002168e-11
+ -8.93053460419e-13  -9.76245684823e-12  8.31684002168e-11
+ -3.70984876564e-13  -8.93053460419e-13  -2.0289990802e-11  8.15070311856e-11
+ 51000000000
+ 8.15062051139e-11
+ -2.02898416252e-11  8.31675689454e-11
+ -8.93052469177e-13  -9.76239286095e-12  8.31675689454e-11
+ -3.70985207624e-13  -8.93052469177e-13  -2.02898416252e-11  8.15062051139e-11
+ 51100000000
+ 8.1505380669e-11
+ -2.0289692742e-11  8.3166739311e-11
+ -8.93051479737e-13  -9.76232899951e-12  8.3166739311e-11
+ -3.70985537919e-13  -8.93051479737e-13  -2.0289692742e-11  8.1505380669e-11
+ 51200000000
+ 8.15045578445e-11
+ -2.02895441512e-11  8.31659113072e-11
+ -8.93050492091e-13  -9.76226526341e-12  8.31659113072e-11
+ -3.70985867451e-13  -8.93050492091e-13  -2.02895441512e-11  8.15045578445e-11
+ 51300000000
+ 8.15037366341e-11
+ -2.02893958517e-11  8.31650849276e-11
+ -8.93049506234e-13  -9.76220165215e-12  8.31650849276e-11
+ -3.70986196225e-13  -8.93049506234e-13  -2.02893958517e-11  8.15037366341e-11
+ 51400000000
+ 8.15029170316e-11
+ -2.02892478423e-11  8.31642601658e-11
+ -8.93048522157e-13  -9.76213816526e-12  8.31642601658e-11
+ -3.70986524242e-13  -8.93048522157e-13  -2.02892478423e-11  8.15029170316e-11
+ 51500000000
+ 8.15020990306e-11
+ -2.02891001219e-11  8.31634370158e-11
+ -8.93047539853e-13  -9.76207480225e-12  8.31634370158e-11
+ -3.70986851505e-13  -8.93047539853e-13  -2.02891001219e-11  8.15020990306e-11
+ 51600000000
+ 8.15012826251e-11
+ -2.02889526894e-11  8.31626154711e-11
+ -8.93046559317e-13  -9.76201156265e-12  8.31626154711e-11
+ -3.70987178018e-13  -8.93046559317e-13  -2.02889526894e-11  8.15012826251e-11
+ 51700000000
+ 8.15004678088e-11
+ -2.02888055437e-11  8.31617955257e-11
+ -8.93045580541e-13  -9.76194844598e-12  8.31617955257e-11
+ -3.70987503784e-13  -8.93045580541e-13  -2.02888055437e-11  8.15004678088e-11
+ 51800000000
+ 8.14996545755e-11
+ -2.02886586837e-11  8.31609771733e-11
+ -8.93044603519e-13  -9.76188545175e-12  8.31609771733e-11
+ -3.70987828805e-13  -8.93044603519e-13  -2.02886586837e-11  8.14996545755e-11
+ 51900000000
+ 8.14988429194e-11
+ -2.02885121082e-11  8.31601604078e-11
+ -8.93043628243e-13  -9.76182257951e-12  8.31601604078e-11
+ -3.70988153084e-13  -8.93043628243e-13  -2.02885121082e-11  8.14988429194e-11
+ 52000000000
+ 8.14980328341e-11
+ -2.02883658163e-11  8.31593452231e-11
+ -8.93042654707e-13  -9.76175982879e-12  8.31593452231e-11
+ -3.70988476624e-13  -8.93042654707e-13  -2.02883658163e-11  8.14980328341e-11
+ 52100000000
+ 8.14972243138e-11
+ -2.02882198067e-11  8.31585316132e-11
+ -8.93041682905e-13  -9.76169719911e-12  8.31585316132e-11
+ -3.70988799428e-13  -8.93041682905e-13  -2.02882198067e-11  8.14972243138e-11
+ 52200000000
+ 8.14964173525e-11
+ -2.02880740785e-11  8.3157719572e-11
+ -8.93040712829e-13  -9.76163469002e-12  8.3157719572e-11
+ -3.70989121498e-13  -8.93040712829e-13  -2.02880740785e-11  8.14964173525e-11
+ 52300000000
+ 8.14956119442e-11
+ -2.02879286305e-11  8.31569090936e-11
+ -8.93039744473e-13  -9.76157230105e-12  8.31569090936e-11
+ -3.70989442838e-13  -8.93039744473e-13  -2.02879286305e-11  8.14956119442e-11
+ 52400000000
+ 8.1494808083e-11
+ -2.02877834617e-11  8.3156100172e-11
+ -8.93038777831e-13  -9.76151003175e-12  8.3156100172e-11
+ -3.7098976345e-13  -8.93038777831e-13  -2.02877834617e-11  8.1494808083e-11
+ 52500000000
+ 8.1494005763e-11
+ -2.02876385709e-11  8.31552928012e-11
+ -8.93037812896e-13  -9.76144788166e-12  8.31552928012e-11
+ -3.70990083338e-13  -8.93037812896e-13  -2.02876385709e-11  8.1494005763e-11
+ 52600000000
+ 8.14932049783e-11
+ -2.02874939573e-11  8.31544869755e-11
+ -8.93036849662e-13  -9.76138585033e-12  8.31544869755e-11
+ -3.70990402503e-13  -8.93036849662e-13  -2.02874939573e-11  8.14932049783e-11
+ 52700000000
+ 8.14924057232e-11
+ -2.02873496197e-11  8.31536826889e-11
+ -8.93035888121e-13  -9.76132393731e-12  8.31536826889e-11
+ -3.70990720948e-13  -8.93035888121e-13  -2.02873496197e-11  8.14924057232e-11
+ 52800000000
+ 8.14916079918e-11
+ -2.0287205557e-11  8.31528799356e-11
+ -8.93034928269e-13  -9.76126214216e-12  8.31528799356e-11
+ -3.70991038677e-13  -8.93034928269e-13  -2.0287205557e-11  8.14916079918e-11
+ 52900000000
+ 8.14908117785e-11
+ -2.02870617682e-11  8.31520787098e-11
+ -8.93033970097e-13  -9.76120046442e-12  8.31520787098e-11
+ -3.70991355692e-13  -8.93033970097e-13  -2.02870617682e-11  8.14908117785e-11
+ 53000000000
+ 8.14900170774e-11
+ -2.02869182524e-11  8.31512790058e-11
+ -8.93033013601e-13  -9.76113890365e-12  8.31512790058e-11
+ -3.70991671995e-13  -8.93033013601e-13  -2.02869182524e-11  8.14900170774e-11
+ 53100000000
+ 8.14892238829e-11
+ -2.02867750084e-11  8.31504808178e-11
+ -8.93032058774e-13  -9.76107745942e-12  8.31504808178e-11
+ -3.7099198759e-13  -8.93032058774e-13  -2.02867750084e-11  8.14892238829e-11
+ 53200000000
+ 8.14884321894e-11
+ -2.02866320353e-11  8.31496841402e-11
+ -8.93031105609e-13  -9.76101613129e-12  8.31496841402e-11
+ -3.70992302479e-13  -8.93031105609e-13  -2.02866320353e-11  8.14884321894e-11
+ 53300000000
+ 8.14876419912e-11
+ -2.0286489332e-11  8.31488889674e-11
+ -8.930301541e-13  -9.76095491883e-12  8.31488889674e-11
+ -3.70992616665e-13  -8.930301541e-13  -2.0286489332e-11  8.14876419912e-11
+ 53400000000
+ 8.14868532828e-11
+ -2.02863468976e-11  8.31480952936e-11
+ -8.93029204241e-13  -9.76089382159e-12  8.31480952936e-11
+ -3.70992930149e-13  -8.93029204241e-13  -2.02863468976e-11  8.14868532828e-11
+ 53500000000
+ 8.14860660585e-11
+ -2.02862047309e-11  8.31473031133e-11
+ -8.93028256026e-13  -9.76083283915e-12  8.31473031133e-11
+ -3.70993242936e-13  -8.93028256026e-13  -2.02862047309e-11  8.14860660585e-11
+ 53600000000
+ 8.14852803129e-11
+ -2.02860628311e-11  8.31465124209e-11
+ -8.93027309449e-13  -9.76077197109e-12  8.31465124209e-11
+ -3.70993555027e-13  -8.93027309449e-13  -2.02860628311e-11  8.14852803129e-11
+ 53700000000
+ 8.14844960404e-11
+ -2.02859211971e-11  8.31457232109e-11
+ -8.93026364504e-13  -9.76071121698e-12  8.31457232109e-11
+ -3.70993866425e-13  -8.93026364504e-13  -2.02859211971e-11  8.14844960404e-11
+ 53800000000
+ 8.14837132356e-11
+ -2.0285779828e-11  8.31449354778e-11
+ -8.93025421185e-13  -9.76065057639e-12  8.31449354778e-11
+ -3.70994177133e-13  -8.93025421185e-13  -2.0285779828e-11  8.14837132356e-11
+ 53900000000
+ 8.14829318931e-11
+ -2.02856387228e-11  8.31441492161e-11
+ -8.93024479485e-13  -9.76059004891e-12  8.31441492161e-11
+ -3.70994487153e-13  -8.93024479485e-13  -2.02856387228e-11  8.14829318931e-11
+ 54000000000
+ 8.14821520074e-11
+ -2.02854978804e-11  8.31433644205e-11
+ -8.93023539398e-13  -9.76052963411e-12  8.31433644205e-11
+ -3.70994796488e-13  -8.93023539398e-13  -2.02854978804e-11  8.14821520074e-11
+ 54100000000
+ 8.14813735732e-11
+ -2.02853573e-11  8.31425810854e-11
+ -8.9302260092e-13  -9.76046933159e-12  8.31425810854e-11
+ -3.7099510514e-13  -8.9302260092e-13  -2.02853573e-11  8.14813735732e-11
+ 54200000000
+ 8.14805965851e-11
+ -2.02852169805e-11  8.31417992055e-11
+ -8.93021664043e-13  -9.76040914092e-12  8.31417992055e-11
+ -3.70995413112e-13  -8.93021664043e-13  -2.02852169805e-11  8.14805965851e-11
+ 54300000000
+ 8.14798210378e-11
+ -2.0285076921e-11  8.31410187754e-11
+ -8.93020728762e-13  -9.7603490617e-12  8.31410187754e-11
+ -3.70995720406e-13  -8.93020728762e-13  -2.0285076921e-11  8.14798210378e-11
+ 54400000000
+ 8.14790469261e-11
+ -2.02849371205e-11  8.31402397899e-11
+ -8.93019795072e-13  -9.76028909351e-12  8.31402397899e-11
+ -3.70996027025e-13  -8.93019795072e-13  -2.02849371205e-11  8.14790469261e-11
+ 54500000000
+ 8.14782742446e-11
+ -2.02847975782e-11  8.31394622436e-11
+ -8.93018862965e-13  -9.76022923596e-12  8.31394622436e-11
+ -3.70996332972e-13  -8.93018862965e-13  -2.02847975782e-11  8.14782742446e-11
+ 54600000000
+ 8.14775029881e-11
+ -2.0284658293e-11  8.31386861313e-11
+ -8.93017932437e-13  -9.76016948863e-12  8.31386861313e-11
+ -3.70996638248e-13  -8.93017932437e-13  -2.0284658293e-11  8.14775029881e-11
+ 54700000000
+ 8.14767331515e-11
+ -2.0284519264e-11  8.31379114477e-11
+ -8.93017003482e-13  -9.76010985113e-12  8.31379114477e-11
+ -3.70996942856e-13  -8.93017003482e-13  -2.0284519264e-11  8.14767331515e-11
+ 54800000000
+ 8.14759647296e-11
+ -2.02843804903e-11  8.31371381877e-11
+ -8.93016076093e-13  -9.76005032305e-12  8.31371381877e-11
+ -3.70997246799e-13  -8.93016076093e-13  -2.02843804903e-11  8.14759647296e-11
+ 54900000000
+ 8.14751977171e-11
+ -2.0284241971e-11  8.3136366346e-11
+ -8.93015150266e-13  -9.759990904e-12  8.3136366346e-11
+ -3.70997550079e-13  -8.93015150266e-13  -2.0284241971e-11  8.14751977171e-11
+ 55000000000
+ 8.14744321091e-11
+ -2.02841037051e-11  8.31355959175e-11
+ -8.93014225995e-13  -9.75993159358e-12  8.31355959175e-11
+ -3.70997852699e-13  -8.93014225995e-13  -2.02841037051e-11  8.14744321091e-11
+ 55100000000
+ 8.14736679004e-11
+ -2.02839656916e-11  8.31348268972e-11
+ -8.93013303274e-13  -9.7598723914e-12  8.31348268972e-11
+ -3.7099815466e-13  -8.93013303274e-13  -2.02839656916e-11  8.14736679004e-11
+ 55200000000
+ 8.1472905086e-11
+ -2.02838279298e-11  8.31340592798e-11
+ -8.93012382097e-13  -9.75981329706e-12  8.31340592798e-11
+ -3.70998455966e-13  -8.93012382097e-13  -2.02838279298e-11  8.1472905086e-11
+ 55300000000
+ 8.14721436608e-11
+ -2.02836904187e-11  8.31332930604e-11
+ -8.93011462458e-13  -9.75975431018e-12  8.31332930604e-11
+ -3.70998756618e-13  -8.93011462458e-13  -2.02836904187e-11  8.14721436608e-11
+ 55400000000
+ 8.14713836198e-11
+ -2.02835531574e-11  8.31325282339e-11
+ -8.93010544354e-13  -9.75969543037e-12  8.31325282339e-11
+ -3.70999056619e-13  -8.93010544354e-13  -2.02835531574e-11  8.14713836198e-11
+ 55500000000
+ 8.1470624958e-11
+ -2.02834161449e-11  8.31317647953e-11
+ -8.93009627777e-13  -9.75963665724e-12  8.31317647953e-11
+ -3.70999355971e-13  -8.93009627777e-13  -2.02834161449e-11  8.1470624958e-11
+ 55600000000
+ 8.14698676706e-11
+ -2.02832793805e-11  8.31310027397e-11
+ -8.93008712722e-13  -9.75957799042e-12  8.31310027397e-11
+ -3.70999654678e-13  -8.93008712722e-13  -2.02832793805e-11  8.14698676706e-11
+ 55700000000
+ 8.14691117525e-11
+ -2.02831428632e-11  8.31302420619e-11
+ -8.93007799184e-13  -9.75951942951e-12  8.31302420619e-11
+ -3.7099995274e-13  -8.93007799184e-13  -2.02831428632e-11  8.14691117525e-11
+ 55800000000
+ 8.14683571989e-11
+ -2.0283006592e-11  8.31294827573e-11
+ -8.93006887157e-13  -9.75946097415e-12  8.31294827573e-11
+ -3.7100025016e-13  -8.93006887157e-13  -2.0283006592e-11  8.14683571989e-11
+ 55900000000
+ 8.14676040049e-11
+ -2.02828705663e-11  8.31287248207e-11
+ -8.93005976637e-13  -9.75940262395e-12  8.31287248207e-11
+ -3.71000546941e-13  -8.93005976637e-13  -2.02828705663e-11  8.14676040049e-11
+ 56000000000
+ 8.14668521656e-11
+ -2.0282734785e-11  8.31279682474e-11
+ -8.93005067617e-13  -9.75934437854e-12  8.31279682474e-11
+ -3.71000843085e-13  -8.93005067617e-13  -2.0282734785e-11  8.14668521656e-11
+ 56100000000
+ 8.14661016763e-11
+ -2.02825992473e-11  8.31272130325e-11
+ -8.93004160093e-13  -9.75928623755e-12  8.31272130325e-11
+ -3.71001138594e-13  -8.93004160093e-13  -2.02825992473e-11  8.14661016763e-11
+ 56200000000
+ 8.14653525321e-11
+ -2.02824639523e-11  8.31264591712e-11
+ -8.93003254058e-13  -9.75922820061e-12  8.31264591712e-11
+ -3.7100143347e-13  -8.93003254058e-13  -2.02824639523e-11  8.14653525321e-11
+ 56300000000
+ 8.14646047283e-11
+ -2.02823288992e-11  8.31257066586e-11
+ -8.93002349509e-13  -9.75917026734e-12  8.31257066586e-11
+ -3.71001727716e-13  -8.93002349509e-13  -2.02823288992e-11  8.14646047283e-11
+ 56400000000
+ 8.14638582601e-11
+ -2.02821940871e-11  8.31249554901e-11
+ -8.93001446439e-13  -9.75911243739e-12  8.31249554901e-11
+ -3.71002021334e-13  -8.93001446439e-13  -2.02821940871e-11  8.14638582601e-11
+ 56500000000
+ 8.14631131229e-11
+ -2.02820595152e-11  8.31242056608e-11
+ -8.93000544843e-13  -9.75905471038e-12  8.31242056608e-11
+ -3.71002314326e-13  -8.93000544843e-13  -2.02820595152e-11  8.14631131229e-11
+ 56600000000
+ 8.14623693118e-11
+ -2.02819251827e-11  8.31234571661e-11
+ -8.92999644716e-13  -9.75899708596e-12  8.31234571661e-11
+ -3.71002606694e-13  -8.92999644716e-13  -2.02819251827e-11  8.14623693118e-11
+ 56700000000
+ 8.14616268224e-11
+ -2.02817910886e-11  8.31227100012e-11
+ -8.92998746053e-13  -9.75893956376e-12  8.31227100012e-11
+ -3.7100289844e-13  -8.92998746053e-13  -2.02817910886e-11  8.14616268224e-11
+ 56800000000
+ 8.14608856498e-11
+ -2.02816572321e-11  8.31219641615e-11
+ -8.92997848849e-13  -9.75888214342e-12  8.31219641615e-11
+ -3.71003189568e-13  -8.92997848849e-13  -2.02816572321e-11  8.14608856498e-11
+ 56900000000
+ 8.14601457895e-11
+ -2.02815236124e-11  8.31212196424e-11
+ -8.92996953099e-13  -9.75882482458e-12  8.31212196424e-11
+ -3.71003480078e-13  -8.92996953099e-13  -2.02815236124e-11  8.14601457895e-11
+ 57000000000
+ 8.1459407237e-11
+ -2.02813902288e-11  8.31204764391e-11
+ -8.92996058797e-13  -9.7587676069e-12  8.31204764391e-11
+ -3.71003769973e-13  -8.92996058797e-13  -2.02813902288e-11  8.1459407237e-11
+ 57100000000
+ 8.14586699875e-11
+ -2.02812570802e-11  8.31197345471e-11
+ -8.92995165939e-13  -9.75871049001e-12  8.31197345471e-11
+ -3.71004059255e-13  -8.92995165939e-13  -2.02812570802e-11  8.14586699875e-11
+ 57200000000
+ 8.14579340367e-11
+ -2.0281124166e-11  8.31189939619e-11
+ -8.92994274519e-13  -9.75865347357e-12  8.31189939619e-11
+ -3.71004347927e-13  -8.92994274519e-13  -2.0281124166e-11  8.14579340367e-11
+ 57300000000
+ 8.14571993799e-11
+ -2.02809914854e-11  8.31182546788e-11
+ -8.92993384533e-13  -9.75859655723e-12  8.31182546788e-11
+ -3.7100463599e-13  -8.92993384533e-13  -2.02809914854e-11  8.14571993799e-11
+ 57400000000
+ 8.14564660126e-11
+ -2.02808590374e-11  8.31175166934e-11
+ -8.92992495976e-13  -9.75853974063e-12  8.31175166934e-11
+ -3.71004923447e-13  -8.92992495976e-13  -2.02808590374e-11  8.14564660126e-11
+ 57500000000
+ 8.14557339305e-11
+ -2.02807268213e-11  8.31167800012e-11
+ -8.92991608842e-13  -9.75848302344e-12  8.31167800012e-11
+ -3.71005210299e-13  -8.92991608842e-13  -2.02807268213e-11  8.14557339305e-11
+ 57600000000
+ 8.1455003129e-11
+ -2.02805948364e-11  8.31160445976e-11
+ -8.92990723126e-13  -9.7584264053e-12  8.31160445976e-11
+ -3.71005496549e-13  -8.92990723126e-13  -2.02805948364e-11  8.1455003129e-11
+ 57700000000
+ 8.14542736037e-11
+ -2.02804630817e-11  8.31153104782e-11
+ -8.92989838825e-13  -9.75836988587e-12  8.31153104782e-11
+ -3.71005782199e-13  -8.92989838825e-13  -2.02804630817e-11  8.14542736037e-11
+ 57800000000
+ 8.14535453502e-11
+ -2.02803315565e-11  8.31145776386e-11
+ -8.92988955932e-13  -9.75831346483e-12  8.31145776386e-11
+ -3.71006067251e-13  -8.92988955932e-13  -2.02803315565e-11  8.14535453502e-11
+ 57900000000
+ 8.14528183641e-11
+ -2.028020026e-11  8.31138460744e-11
+ -8.92988074443e-13  -9.75825714181e-12  8.31138460744e-11
+ -3.71006351707e-13  -8.92988074443e-13  -2.028020026e-11  8.14528183641e-11
+ 58000000000
+ 8.14520926411e-11
+ -2.02800691915e-11  8.31131157812e-11
+ -8.92987194353e-13  -9.75820091649e-12  8.31131157812e-11
+ -3.71006635569e-13  -8.92987194353e-13  -2.02800691915e-11  8.14520926411e-11
+ 58100000000
+ 8.14513681768e-11
+ -2.02799383501e-11  8.31123867546e-11
+ -8.92986315658e-13  -9.75814478854e-12  8.31123867546e-11
+ -3.71006918839e-13  -8.92986315658e-13  -2.02799383501e-11  8.14513681768e-11
+ 58200000000
+ 8.14506449669e-11
+ -2.0279807735e-11  8.31116589902e-11
+ -8.92985438353e-13  -9.75808875761e-12  8.31116589902e-11
+ -3.71007201519e-13  -8.92985438353e-13  -2.0279807735e-11  8.14506449669e-11
+ 58300000000
+ 8.14499230071e-11
+ -2.02796773456e-11  8.31109324839e-11
+ -8.92984562432e-13  -9.75803282338e-12  8.31109324839e-11
+ -3.71007483611e-13  -8.92984562432e-13  -2.02796773456e-11  8.14499230071e-11
+ 58400000000
+ 8.14492022932e-11
+ -2.02795471809e-11  8.31102072311e-11
+ -8.92983687892e-13  -9.75797698552e-12  8.31102072311e-11
+ -3.71007765117e-13  -8.92983687892e-13  -2.02795471809e-11  8.14492022932e-11
+ 58500000000
+ 8.14484828209e-11
+ -2.02794172404e-11  8.31094832278e-11
+ -8.92982814726e-13  -9.7579212437e-12  8.31094832278e-11
+ -3.7100804604e-13  -8.92982814726e-13  -2.02794172404e-11  8.14484828209e-11
+ 58600000000
+ 8.14477645859e-11
+ -2.02792875231e-11  8.31087604696e-11
+ -8.92981942932e-13  -9.75786559758e-12  8.31087604696e-11
+ -3.7100832638e-13  -8.92981942932e-13  -2.02792875231e-11  8.14477645859e-11
+ 58700000000
+ 8.14470475841e-11
+ -2.02791580283e-11  8.31080389523e-11
+ -8.92981072504e-13  -9.75781004685e-12  8.31080389523e-11
+ -3.71008606141e-13  -8.92981072504e-13  -2.02791580283e-11  8.14470475841e-11
+ 58800000000
+ 8.14463318113e-11
+ -2.02790287553e-11  8.31073186717e-11
+ -8.92980203437e-13  -9.75775459118e-12  8.31073186717e-11
+ -3.71008885324e-13  -8.92980203437e-13  -2.02790287553e-11  8.14463318113e-11
+ 58900000000
+ 8.14456172633e-11
+ -2.02788997033e-11  8.31065996236e-11
+ -8.92979335727e-13  -9.75769923025e-12  8.31065996236e-11
+ -3.71009163931e-13  -8.92979335727e-13  -2.02788997033e-11  8.14456172633e-11
+ 59000000000
+ 8.14449039359e-11
+ -2.02787708716e-11  8.31058818038e-11
+ -8.9297846937e-13  -9.75764396374e-12  8.31058818038e-11
+ -3.71009441964e-13  -8.9297846937e-13  -2.02787708716e-11  8.14449039359e-11
+ 59100000000
+ 8.14441918252e-11
+ -2.02786422594e-11  8.31051652082e-11
+ -8.9297760436e-13  -9.75758879133e-12  8.31051652082e-11
+ -3.71009719425e-13  -8.9297760436e-13  -2.02786422594e-11  8.14441918252e-11
+ 59200000000
+ 8.14434809268e-11
+ -2.02785138661e-11  8.31044498326e-11
+ -8.92976740693e-13  -9.75753371271e-12  8.31044498326e-11
+ -3.71009996316e-13  -8.92976740693e-13  -2.02785138661e-11  8.14434809268e-11
+ 59300000000
+ 8.14427712369e-11
+ -2.02783856907e-11  8.31037356731e-11
+ -8.92975878365e-13  -9.75747872755e-12  8.31037356731e-11
+ -3.71010272638e-13  -8.92975878365e-13  -2.02783856907e-11  8.14427712369e-11
+ 59400000000
+ 8.14420627513e-11
+ -2.02782577327e-11  8.31030227254e-11
+ -8.92975017371e-13  -9.75742383555e-12  8.31030227254e-11
+ -3.71010548395e-13  -8.92975017371e-13  -2.02782577327e-11  8.14420627513e-11
+ 59500000000
+ 8.14413554659e-11
+ -2.02781299913e-11  8.31023109855e-11
+ -8.92974157707e-13  -9.75736903639e-12  8.31023109855e-11
+ -3.71010823587e-13  -8.92974157707e-13  -2.02781299913e-11  8.14413554659e-11
+ 59600000000
+ 8.14406493768e-11
+ -2.02780024658e-11  8.31016004493e-11
+ -8.92973299368e-13  -9.75731432976e-12  8.31016004493e-11
+ -3.71011098216e-13  -8.92973299368e-13  -2.02780024658e-11  8.14406493768e-11
+ 59700000000
+ 8.143994448e-11
+ -2.02778751554e-11  8.3100891113e-11
+ -8.9297244235e-13  -9.75725971535e-12  8.3100891113e-11
+ -3.71011372285e-13  -8.9297244235e-13  -2.02778751554e-11  8.143994448e-11
+ 59800000000
+ 8.14392407715e-11
+ -2.02777480594e-11  8.31001829723e-11
+ -8.92971586649e-13  -9.75720519285e-12  8.31001829723e-11
+ -3.71011645795e-13  -8.92971586649e-13  -2.02777480594e-11  8.14392407715e-11
+ 59900000000
+ 8.14385382473e-11
+ -2.02776211772e-11  8.30994760234e-11
+ -8.92970732259e-13  -9.75715076197e-12  8.30994760234e-11
+ -3.71011918748e-13  -8.92970732259e-13  -2.02776211772e-11  8.14385382473e-11
+ 60000000000
+ 8.14378369035e-11
+ -2.0277494508e-11  8.30987702624e-11
+ -8.92969879177e-13  -9.75709642239e-12  8.30987702624e-11
+ -3.71012191146e-13  -8.92969879177e-13  -2.0277494508e-11  8.14378369035e-11
+ 60100000000
+ 8.14371367362e-11
+ -2.0277368051e-11  8.30980656851e-11
+ -8.92969027399e-13  -9.7570421738e-12  8.30980656851e-11
+ -3.71012462991e-13  -8.92969027399e-13  -2.0277368051e-11  8.14371367362e-11
+ 60200000000
+ 8.14364377414e-11
+ -2.02772418057e-11  8.30973622879e-11
+ -8.9296817692e-13  -9.75698801592e-12  8.30973622879e-11
+ -3.71012734285e-13  -8.9296817692e-13  -2.02772418057e-11  8.14364377414e-11
+ 60300000000
+ 8.14357399154e-11
+ -2.02771157712e-11  8.30966600666e-11
+ -8.92967327735e-13  -9.75693394844e-12  8.30966600666e-11
+ -3.71013005029e-13  -8.92967327735e-13  -2.02771157712e-11  8.14357399154e-11
+ 60400000000
+ 8.14350432542e-11
+ -2.0276989947e-11  8.30959590175e-11
+ -8.92966479841e-13  -9.75687997106e-12  8.30959590175e-11
+ -3.71013275226e-13  -8.92966479841e-13  -2.0276989947e-11  8.14350432542e-11
+ 60500000000
+ 8.1434347754e-11
+ -2.02768643323e-11  8.30952591367e-11
+ -8.92965633233e-13  -9.75682608348e-12  8.30952591367e-11
+ -3.71013544876e-13  -8.92965633233e-13  -2.02768643323e-11  8.1434347754e-11
+ 60600000000
+ 8.1433653411e-11
+ -2.02767389263e-11  8.30945604203e-11
+ -8.92964787907e-13  -9.75677228541e-12  8.30945604203e-11
+ -3.71013813983e-13  -8.92964787907e-13  -2.02767389263e-11  8.1433653411e-11
+ 60700000000
+ 8.14329602213e-11
+ -2.02766137285e-11  8.30938628645e-11
+ -8.92963943859e-13  -9.75671857655e-12  8.30938628645e-11
+ -3.71014082547e-13  -8.92963943859e-13  -2.02766137285e-11  8.14329602213e-11
+ 60800000000
+ 8.14322681813e-11
+ -2.02764887382e-11  8.30931664656e-11
+ -8.92963101085e-13  -9.75666495661e-12  8.30931664656e-11
+ -3.71014350571e-13  -8.92963101085e-13  -2.02764887382e-11  8.14322681813e-11
+ 60900000000
+ 8.1431577287e-11
+ -2.02763639546e-11  8.30924712196e-11
+ -8.9296225958e-13  -9.75661142531e-12  8.30924712196e-11
+ -3.71014618056e-13  -8.9296225958e-13  -2.02763639546e-11  8.1431577287e-11
+ 61000000000
+ 8.14308875349e-11
+ -2.02762393771e-11  8.30917771229e-11
+ -8.9296141934e-13  -9.75655798234e-12  8.30917771229e-11
+ -3.71014885004e-13  -8.9296141934e-13  -2.02762393771e-11  8.14308875349e-11
+ 61100000000
+ 8.14301989211e-11
+ -2.02761150051e-11  8.30910841717e-11
+ -8.92960580362e-13  -9.75650462743e-12  8.30910841717e-11
+ -3.71015151417e-13  -8.92960580362e-13  -2.02761150051e-11  8.14301989211e-11
+ 61200000000
+ 8.1429511442e-11
+ -2.02759908378e-11  8.30903923623e-11
+ -8.9295974264e-13  -9.75645136028e-12  8.30903923623e-11
+ -3.71015417296e-13  -8.9295974264e-13  -2.02759908378e-11  8.1429511442e-11
+ 61300000000
+ 8.14288250938e-11
+ -2.02758668745e-11  8.30897016909e-11
+ -8.92958906172e-13  -9.75639818061e-12  8.30897016909e-11
+ -3.71015682644e-13  -8.92958906172e-13  -2.02758668745e-11  8.14288250938e-11
+ 61400000000
+ 8.14281398729e-11
+ -2.02757431147e-11  8.30890121539e-11
+ -8.92958070953e-13  -9.75634508814e-12  8.30890121539e-11
+ -3.71015947461e-13  -8.92958070953e-13  -2.02757431147e-11  8.14281398729e-11
+ 61500000000
+ 8.14274557756e-11
+ -2.02756195577e-11  8.30883237475e-11
+ -8.92957236978e-13  -9.75629208257e-12  8.30883237475e-11
+ -3.7101621175e-13  -8.92957236978e-13  -2.02756195577e-11  8.14274557756e-11
+ 61600000000
+ 8.14267727983e-11
+ -2.02754962028e-11  8.30876364682e-11
+ -8.92956404244e-13  -9.75623916364e-12  8.30876364682e-11
+ -3.71016475513e-13  -8.92956404244e-13  -2.02754962028e-11  8.14267727983e-11
+ 61700000000
+ 8.14260909374e-11
+ -2.02753730493e-11  8.30869503122e-11
+ -8.92955572747e-13  -9.75618633107e-12  8.30869503122e-11
+ -3.71016738751e-13  -8.92955572747e-13  -2.02753730493e-11  8.14260909374e-11
+ 61800000000
+ 8.14254101892e-11
+ -2.02752500966e-11  8.30862652759e-11
+ -8.92954742483e-13  -9.75613358456e-12  8.30862652759e-11
+ -3.71017001466e-13  -8.92954742483e-13  -2.02752500966e-11  8.14254101892e-11
+ 61900000000
+ 8.14247305502e-11
+ -2.02751273441e-11  8.30855813558e-11
+ -8.92953913448e-13  -9.75608092385e-12  8.30855813558e-11
+ -3.71017263659e-13  -8.92953913448e-13  -2.02751273441e-11  8.14247305502e-11
+ 62000000000
+ 8.14240520168e-11
+ -2.0275004791e-11  8.30848985483e-11
+ -8.92953085638e-13  -9.75602834866e-12  8.30848985483e-11
+ -3.71017525333e-13  -8.92953085638e-13  -2.0275004791e-11  8.14240520168e-11
+ 62100000000
+ 8.14233745855e-11
+ -2.02748824369e-11  8.30842168497e-11
+ -8.92952259049e-13  -9.75597585871e-12  8.30842168497e-11
+ -3.71017786488e-13  -8.92952259049e-13  -2.02748824369e-11  8.14233745855e-11
+ 62200000000
+ 8.14226982527e-11
+ -2.0274760281e-11  8.30835362565e-11
+ -8.92951433677e-13  -9.75592345373e-12  8.30835362565e-11
+ -3.71018047127e-13  -8.92951433677e-13  -2.0274760281e-11  8.14226982527e-11
+ 62300000000
+ 8.1422023015e-11
+ -2.02746383227e-11  8.30828567653e-11
+ -8.92950609518e-13  -9.75587113346e-12  8.30828567653e-11
+ -3.71018307251e-13  -8.92950609518e-13  -2.02746383227e-11  8.1422023015e-11
+ 62400000000
+ 8.14213488687e-11
+ -2.02745165613e-11  8.30821783724e-11
+ -8.92949786569e-13  -9.75581889761e-12  8.30821783724e-11
+ -3.71018566862e-13  -8.92949786569e-13  -2.02745165613e-11  8.14213488687e-11
+ 62500000000
+ 8.14206758105e-11
+ -2.02743949963e-11  8.30815010743e-11
+ -8.92948964825e-13  -9.75576674592e-12  8.30815010743e-11
+ -3.71018825962e-13  -8.92948964825e-13  -2.02743949963e-11  8.14206758105e-11
+ 62600000000
+ 8.14200038368e-11
+ -2.0274273627e-11  8.30808248676e-11
+ -8.92948144282e-13  -9.75571467812e-12  8.30808248676e-11
+ -3.71019084551e-13  -8.92948144282e-13  -2.0274273627e-11  8.14200038368e-11
+ 62700000000
+ 8.14193329443e-11
+ -2.02741524528e-11  8.30801497488e-11
+ -8.92947324938e-13  -9.75566269395e-12  8.30801497488e-11
+ -3.71019342633e-13  -8.92947324938e-13  -2.02741524528e-11  8.14193329443e-11
+ 62800000000
+ 8.14186631294e-11
+ -2.02740314731e-11  8.30794757145e-11
+ -8.92946506787e-13  -9.75561079314e-12  8.30794757145e-11
+ -3.71019600207e-13  -8.92946506787e-13  -2.02740314731e-11  8.14186631294e-11
+ 62900000000
+ 8.14179943888e-11
+ -2.02739106872e-11  8.30788027611e-11
+ -8.92945689827e-13  -9.75555897542e-12  8.30788027611e-11
+ -3.71019857277e-13  -8.92945689827e-13  -2.02739106872e-11  8.14179943888e-11
+ 63000000000
+ 8.14173267191e-11
+ -2.02737900946e-11  8.30781308854e-11
+ -8.92944874053e-13  -9.75550724053e-12  8.30781308854e-11
+ -3.71020113844e-13  -8.92944874053e-13  -2.02737900946e-11  8.14173267191e-11
+ 63100000000
+ 8.14166601168e-11
+ -2.02736696946e-11  8.30774600838e-11
+ -8.92944059462e-13  -9.75545558822e-12  8.30774600838e-11
+ -3.71020369908e-13  -8.92944059462e-13  -2.02736696946e-11  8.14166601168e-11
+ 63200000000
+ 8.14159945787e-11
+ -2.02735494866e-11  8.3076790353e-11
+ -8.9294324605e-13  -9.75540401821e-12  8.3076790353e-11
+ -3.71020625472e-13  -8.9294324605e-13  -2.02735494866e-11  8.14159945787e-11
+ 63300000000
+ 8.14153301013e-11
+ -2.027342947e-11  8.30761216896e-11
+ -8.92942433814e-13  -9.75535253025e-12  8.30761216896e-11
+ -3.71020880538e-13  -8.92942433814e-13  -2.027342947e-11  8.14153301013e-11
+ 63400000000
+ 8.14146666814e-11
+ -2.02733096443e-11  8.30754540903e-11
+ -8.92941622749e-13  -9.75530112409e-12  8.30754540903e-11
+ -3.71021135106e-13  -8.92941622749e-13  -2.02733096443e-11  8.14146666814e-11
+ 63500000000
+ 8.14140043155e-11
+ -2.02731900087e-11  8.30747875517e-11
+ -8.92940812852e-13  -9.75524979946e-12  8.30747875517e-11
+ -3.71021389179e-13  -8.92940812852e-13  -2.02731900087e-11  8.14140043155e-11
+ 63600000000
+ 8.14133430005e-11
+ -2.02730705628e-11  8.30741220705e-11
+ -8.92940004119e-13  -9.75519855611e-12  8.30741220705e-11
+ -3.71021642758e-13  -8.92940004119e-13  -2.02730705628e-11  8.14133430005e-11
+ 63700000000
+ 8.1412682733e-11
+ -2.02729513059e-11  8.30734576434e-11
+ -8.92939196547e-13  -9.75514739379e-12  8.30734576434e-11
+ -3.71021895845e-13  -8.92939196547e-13  -2.02729513059e-11  8.1412682733e-11
+ 63800000000
+ 8.14120235097e-11
+ -2.02728322375e-11  8.30727942671e-11
+ -8.92938390132e-13  -9.75509631224e-12  8.30727942671e-11
+ -3.71022148441e-13  -8.92938390132e-13  -2.02728322375e-11  8.14120235097e-11
+ 63900000000
+ 8.14113653274e-11
+ -2.02727133569e-11  8.30721319383e-11
+ -8.9293758487e-13  -9.75504531121e-12  8.30721319383e-11
+ -3.71022400547e-13  -8.9293758487e-13  -2.02727133569e-11  8.14113653274e-11
+ 64000000000
+ 8.14107081828e-11
+ -2.02725946636e-11  8.30714706537e-11
+ -8.92936780758e-13  -9.75499439045e-12  8.30714706537e-11
+ -3.71022652165e-13  -8.92936780758e-13  -2.02725946636e-11  8.14107081828e-11
+ 64100000000
+ 8.14100520728e-11
+ -2.02724761569e-11  8.30708104102e-11
+ -8.92935977793e-13  -9.75494354971e-12  8.30708104102e-11
+ -3.71022903298e-13  -8.92935977793e-13  -2.02724761569e-11  8.14100520728e-11
+ 64200000000
+ 8.1409396994e-11
+ -2.02723578364e-11  8.30701512044e-11
+ -8.9293517597e-13  -9.75489278874e-12  8.30701512044e-11
+ -3.71023153945e-13  -8.9293517597e-13  -2.02723578364e-11  8.1409396994e-11
+ 64300000000
+ 8.14087429434e-11
+ -2.02722397013e-11  8.30694930332e-11
+ -8.92934375286e-13  -9.75484210729e-12  8.30694930332e-11
+ -3.71023404109e-13  -8.92934375286e-13  -2.02722397013e-11  8.14087429434e-11
+ 64400000000
+ 8.14080899177e-11
+ -2.02721217513e-11  8.30688358933e-11
+ -8.92933575738e-13  -9.75479150512e-12  8.30688358933e-11
+ -3.71023653792e-13  -8.92933575738e-13  -2.02721217513e-11  8.14080899177e-11
+ 64500000000
+ 8.14074379137e-11
+ -2.02720039856e-11  8.30681797815e-11
+ -8.92932777323e-13  -9.75474098199e-12  8.30681797815e-11
+ -3.71023902994e-13  -8.92932777323e-13  -2.02720039856e-11  8.14074379137e-11
+ 64600000000
+ 8.14067869283e-11
+ -2.02718864037e-11  8.30675246948e-11
+ -8.92931980035e-13  -9.75469053764e-12  8.30675246948e-11
+ -3.71024151717e-13  -8.92931980035e-13  -2.02718864037e-11  8.14067869283e-11
+ 64700000000
+ 8.14061369584e-11
+ -2.02717690051e-11  8.30668706299e-11
+ -8.92931183873e-13  -9.75464017184e-12  8.30668706299e-11
+ -3.71024399963e-13  -8.92931183873e-13  -2.02717690051e-11  8.14061369584e-11
+ 64800000000
+ 8.14054880008e-11
+ -2.02716517891e-11  8.30662175837e-11
+ -8.92930388833e-13  -9.75458988435e-12  8.30662175837e-11
+ -3.71024647734e-13  -8.92930388833e-13  -2.02716517891e-11  8.14054880008e-11
+ 64900000000
+ 8.14048400525e-11
+ -2.02715347553e-11  8.3065565553e-11
+ -8.92929594911e-13  -9.75453967491e-12  8.3065565553e-11
+ -3.71024895029e-13  -8.92929594911e-13  -2.02715347553e-11  8.14048400525e-11
+ 65000000000
+ 8.14041931102e-11
+ -2.0271417903e-11  8.30649145348e-11
+ -8.92928802104e-13  -9.75448954331e-12  8.30649145348e-11
+ -3.71025141852e-13  -8.92928802104e-13  -2.0271417903e-11  8.14041931102e-11
+ 65100000000
+ 8.14035471711e-11
+ -2.02713012317e-11  8.3064264526e-11
+ -8.92928010408e-13  -9.75443948929e-12  8.3064264526e-11
+ -3.71025388204e-13  -8.92928010408e-13  -2.02713012317e-11  8.14035471711e-11
+ 65200000000
+ 8.14029022319e-11
+ -2.02711847409e-11  8.30636155233e-11
+ -8.92927219821e-13  -9.75438951262e-12  8.30636155233e-11
+ -3.71025634085e-13  -8.92927219821e-13  -2.02711847409e-11  8.14029022319e-11
+ 65300000000
+ 8.14022582896e-11
+ -2.02710684299e-11  8.30629675239e-11
+ -8.92926430338e-13  -9.75433961306e-12  8.30629675239e-11
+ -3.71025879498e-13  -8.92926430338e-13  -2.02710684299e-11  8.14022582896e-11
+ 65400000000
+ 8.14016153413e-11
+ -2.02709522984e-11  8.30623205246e-11
+ -8.92925641956e-13  -9.75428979038e-12  8.30623205246e-11
+ -3.71026124444e-13  -8.92925641956e-13  -2.02709522984e-11  8.14016153413e-11
+ 65500000000
+ 8.14009733838e-11
+ -2.02708363456e-11  8.30616745224e-11
+ -8.92924854672e-13  -9.75424004434e-12  8.30616745224e-11
+ -3.71026368923e-13  -8.92924854672e-13  -2.02708363456e-11  8.14009733838e-11
+ 65600000000
+ 8.14003324142e-11
+ -2.02707205711e-11  8.30610295143e-11
+ -8.92924068483e-13  -9.75419037472e-12  8.30610295143e-11
+ -3.71026612939e-13  -8.92924068483e-13  -2.02707205711e-11  8.14003324142e-11
+ 65700000000
+ 8.13996924294e-11
+ -2.02706049743e-11  8.30603854971e-11
+ -8.92923283386e-13  -9.75414078127e-12  8.30603854971e-11
+ -3.71026856492e-13  -8.92923283386e-13  -2.02706049743e-11  8.13996924294e-11
+ 65800000000
+ 8.13990534265e-11
+ -2.02704895547e-11  8.30597424681e-11
+ -8.92922499376e-13  -9.75409126378e-12  8.30597424681e-11
+ -3.71027099583e-13  -8.92922499376e-13  -2.02704895547e-11  8.13990534265e-11
+ 65900000000
+ 8.13984154025e-11
+ -2.02703743117e-11  8.3059100424e-11
+ -8.92921716451e-13  -9.754041822e-12  8.3059100424e-11
+ -3.71027342214e-13  -8.92921716451e-13  -2.02703743117e-11  8.13984154025e-11
+ 66000000000
+ 8.13977783545e-11
+ -2.02702592449e-11  8.30584593621e-11
+ -8.92920934607e-13  -9.75399245571e-12  8.30584593621e-11
+ -3.71027584387e-13  -8.92920934607e-13  -2.02702592449e-11  8.13977783545e-11
+ 66100000000
+ 8.13971422795e-11
+ -2.02701443536e-11  8.30578192793e-11
+ -8.92920153842e-13  -9.75394316469e-12  8.30578192793e-11
+ -3.71027826102e-13  -8.92920153842e-13  -2.02701443536e-11  8.13971422795e-11
+ 66200000000
+ 8.13965071746e-11
+ -2.02700296374e-11  8.30571801726e-11
+ -8.92919374152e-13  -9.7538939487e-12  8.30571801726e-11
+ -3.71028067361e-13  -8.92919374152e-13  -2.02700296374e-11  8.13965071746e-11
+ 66300000000
+ 8.13958730368e-11
+ -2.02699150958e-11  8.30565420391e-11
+ -8.92918595533e-13  -9.75384480752e-12  8.30565420391e-11
+ -3.71028308165e-13  -8.92918595533e-13  -2.02699150958e-11  8.13958730368e-11
+ 66400000000
+ 8.13952398633e-11
+ -2.02698007281e-11  8.3055904876e-11
+ -8.92917817983e-13  -9.75379574093e-12  8.3055904876e-11
+ -3.71028548517e-13  -8.92917817983e-13  -2.02698007281e-11  8.13952398633e-11
+ 66500000000
+ 8.13946076511e-11
+ -2.02696865339e-11  8.30552686803e-11
+ -8.92917041498e-13  -9.7537467487e-12  8.30552686803e-11
+ -3.71028788416e-13  -8.92917041498e-13  -2.02696865339e-11  8.13946076511e-11
+ 66600000000
+ 8.13939763975e-11
+ -2.02695725127e-11  8.30546334491e-11
+ -8.92916266076e-13  -9.75369783062e-12  8.30546334491e-11
+ -3.71029027866e-13  -8.92916266076e-13  -2.02695725127e-11  8.13939763975e-11
+ 66700000000
+ 8.13933460995e-11
+ -2.02694586639e-11  8.30539991795e-11
+ -8.92915491712e-13  -9.75364898644e-12  8.30539991795e-11
+ -3.71029266866e-13  -8.92915491712e-13  -2.02694586639e-11  8.13933460995e-11
+ 66800000000
+ 8.13927167542e-11
+ -2.02693449871e-11  8.30533658686e-11
+ -8.92914718405e-13  -9.75360021597e-12  8.30533658686e-11
+ -3.71029505418e-13  -8.92914718405e-13  -2.02693449871e-11  8.13927167542e-11
+ 66900000000
+ 8.13920883589e-11
+ -2.02692314817e-11  8.30527335137e-11
+ -8.92913946149e-13  -9.75355151898e-12  8.30527335137e-11
+ -3.71029743523e-13  -8.92913946149e-13  -2.02692314817e-11  8.13920883589e-11
+ 67000000000
+ 8.13914609108e-11
+ -2.02691181471e-11  8.30521021118e-11
+ -8.92913174944e-13  -9.75350289524e-12  8.30521021118e-11
+ -3.71029981184e-13  -8.92913174944e-13  -2.02691181471e-11  8.13914609108e-11
+ 67100000000
+ 8.13908344069e-11
+ -2.0269004983e-11  8.30514716602e-11
+ -8.92912404785e-13  -9.75345434455e-12  8.30514716602e-11
+ -3.71030218401e-13  -8.92912404785e-13  -2.0269004983e-11  8.13908344069e-11
+ 67200000000
+ 8.13902088445e-11
+ -2.02688919888e-11  8.30508421559e-11
+ -8.92911635669e-13  -9.75340586669e-12  8.30508421559e-11
+ -3.71030455175e-13  -8.92911635669e-13  -2.02688919888e-11  8.13902088445e-11
+ 67300000000
+ 8.13895842209e-11
+ -2.0268779164e-11  8.30502135963e-11
+ -8.92910867594e-13  -9.75335746143e-12  8.30502135963e-11
+ -3.71030691509e-13  -8.92910867594e-13  -2.0268779164e-11  8.13895842209e-11
+ 67400000000
+ 8.13889605331e-11
+ -2.02686665081e-11  8.30495859785e-11
+ -8.92910100555e-13  -9.75330912857e-12  8.30495859785e-11
+ -3.71030927402e-13  -8.92910100555e-13  -2.02686665081e-11  8.13889605331e-11
+ 67500000000
+ 8.13883377786e-11
+ -2.02685540206e-11  8.30489592997e-11
+ -8.92909334551e-13  -9.75326086789e-12  8.30489592997e-11
+ -3.71031162857e-13  -8.92909334551e-13  -2.02685540206e-11  8.13883377786e-11
+ 67600000000
+ 8.13877159545e-11
+ -2.02684417009e-11  8.30483335572e-11
+ -8.92908569578e-13  -9.75321267918e-12  8.30483335572e-11
+ -3.71031397874e-13  -8.92908569578e-13  -2.02684417009e-11  8.13877159545e-11
+ 67700000000
+ 8.13870950581e-11
+ -2.02683295487e-11  8.30477087481e-11
+ -8.92907805633e-13  -9.75316456223e-12  8.30477087481e-11
+ -3.71031632456e-13  -8.92907805633e-13  -2.02683295487e-11  8.13870950581e-11
+ 67800000000
+ 8.13864750866e-11
+ -2.02682175634e-11  8.30470848699e-11
+ -8.92907042713e-13  -9.75311651682e-12  8.30470848699e-11
+ -3.71031866603e-13  -8.92907042713e-13  -2.02682175634e-11  8.13864750866e-11
+ 67900000000
+ 8.13858560374e-11
+ -2.02681057445e-11  8.30464619196e-11
+ -8.92906280815e-13  -9.75306854275e-12  8.30464619196e-11
+ -3.71032100316e-13  -8.92906280815e-13  -2.02681057445e-11  8.13858560374e-11
+ 68000000000
+ 8.13852379077e-11
+ -2.02679940916e-11  8.30458398947e-11
+ -8.92905519936e-13  -9.75302063981e-12  8.30458398947e-11
+ -3.71032333598e-13  -8.92905519936e-13  -2.02679940916e-11  8.13852379077e-11
+ 68100000000
+ 8.13846206949e-11
+ -2.0267882604e-11  8.30452187924e-11
+ -8.92904760073e-13  -9.75297280778e-12  8.30452187924e-11
+ -3.71032566448e-13  -8.92904760073e-13  -2.0267882604e-11  8.13846206949e-11
+ 68200000000
+ 8.13840043962e-11
+ -2.02677712815e-11  8.304459861e-11
+ -8.92904001223e-13  -9.75292504647e-12  8.304459861e-11
+ -3.71032798869e-13  -8.92904001223e-13  -2.02677712815e-11  8.13840043962e-11
+ 68300000000
+ 8.13833890091e-11
+ -2.02676601235e-11  8.30439793448e-11
+ -8.92903243384e-13  -9.75287735567e-12  8.30439793448e-11
+ -3.71033030862e-13  -8.92903243384e-13  -2.02676601235e-11  8.13833890091e-11
+ 68400000000
+ 8.13827745308e-11
+ -2.02675491294e-11  8.30433609942e-11
+ -8.92902486551e-13  -9.75282973516e-12  8.30433609942e-11
+ -3.71033262427e-13  -8.92902486551e-13  -2.02675491294e-11  8.13827745308e-11
+ 68500000000
+ 8.13821609587e-11
+ -2.02674382989e-11  8.30427435555e-11
+ -8.92901730723e-13  -9.75278218475e-12  8.30427435555e-11
+ -3.71033493567e-13  -8.92901730723e-13  -2.02674382989e-11  8.13821609587e-11
+ 68600000000
+ 8.13815482902e-11
+ -2.02673276314e-11  8.3042127026e-11
+ -8.92900975897e-13  -9.75273470423e-12  8.3042127026e-11
+ -3.71033724282e-13  -8.92900975897e-13  -2.02673276314e-11  8.13815482902e-11
+ 68700000000
+ 8.13809365227e-11
+ -2.02672171266e-11  8.30415114031e-11
+ -8.92900222068e-13  -9.7526872934e-12  8.30415114031e-11
+ -3.71033954574e-13  -8.92900222068e-13  -2.02672171266e-11  8.13809365227e-11
+ 68800000000
+ 8.13803256535e-11
+ -2.02671067838e-11  8.30408966842e-11
+ -8.92899469236e-13  -9.75263995206e-12  8.30408966842e-11
+ -3.71034184444e-13  -8.92899469236e-13  -2.02671067838e-11  8.13803256535e-11
+ 68900000000
+ 8.137971568e-11
+ -2.02669966027e-11  8.30402828667e-11
+ -8.92898717396e-13  -9.75259268001e-12  8.30402828667e-11
+ -3.71034413892e-13  -8.92898717396e-13  -2.02669966027e-11  8.137971568e-11
+ 69000000000
+ 8.13791065998e-11
+ -2.02668865827e-11  8.3039669948e-11
+ -8.92897966546e-13  -9.75254547704e-12  8.3039669948e-11
+ -3.71034642921e-13  -8.92897966546e-13  -2.02668865827e-11  8.13791065998e-11
+ 69100000000
+ 8.13784984101e-11
+ -2.02667767235e-11  8.30390579254e-11
+ -8.92897216683e-13  -9.75249834296e-12  8.30390579254e-11
+ -3.71034871532e-13  -8.92897216683e-13  -2.02667767235e-11  8.13784984101e-11
+ 69200000000
+ 8.13778911084e-11
+ -2.02666670245e-11  8.30384467964e-11
+ -8.92896467804e-13  -9.75245127757e-12  8.30384467964e-11
+ -3.71035099725e-13  -8.92896467804e-13  -2.02666670245e-11  8.13778911084e-11
+ 69300000000
+ 8.13772846922e-11
+ -2.02665574852e-11  8.30378365585e-11
+ -8.92895719906e-13  -9.75240428067e-12  8.30378365585e-11
+ -3.71035327502e-13  -8.92895719906e-13  -2.02665574852e-11  8.13772846922e-11
+ 69400000000
+ 8.13766791589e-11
+ -2.02664481054e-11  8.3037227209e-11
+ -8.92894972987e-13  -9.75235735207e-12  8.3037227209e-11
+ -3.71035554864e-13  -8.92894972987e-13  -2.02664481054e-11  8.13766791589e-11
+ 69500000000
+ 8.13760745061e-11
+ -2.02663388844e-11  8.30366187454e-11
+ -8.92894227044e-13  -9.75231049156e-12  8.30366187454e-11
+ -3.71035781813e-13  -8.92894227044e-13  -2.02663388844e-11  8.13760745061e-11
+ 69600000000
+ 8.13754707311e-11
+ -2.02662298218e-11  8.30360111652e-11
+ -8.92893482073e-13  -9.75226369896e-12  8.30360111652e-11
+ -3.71036008349e-13  -8.92893482073e-13  -2.02662298218e-11  8.13754707311e-11
+ 69700000000
+ 8.13748678315e-11
+ -2.02661209171e-11  8.30354044659e-11
+ -8.92892738073e-13  -9.75221697407e-12  8.30354044659e-11
+ -3.71036234474e-13  -8.92892738073e-13  -2.02661209171e-11  8.13748678315e-11
+ 69800000000
+ 8.13742658047e-11
+ -2.026601217e-11  8.3034798645e-11
+ -8.9289199504e-13  -9.7521703167e-12  8.3034798645e-11
+ -3.71036460189e-13  -8.9289199504e-13  -2.026601217e-11  8.13742658047e-11
+ 69900000000
+ 8.13736646484e-11
+ -2.026590358e-11  8.30341936998e-11
+ -8.92891252972e-13  -9.75212372666e-12  8.30341936998e-11
+ -3.71036685495e-13  -8.92891252972e-13  -2.026590358e-11  8.13736646484e-11
+ 70000000000
+ 8.13730643599e-11
+ -2.02657951465e-11  8.30335896281e-11
+ -8.92890511866e-13  -9.75207720374e-12  8.30335896281e-11
+ -3.71036910392e-13  -8.92890511866e-13  -2.02657951465e-11  8.13730643599e-11

.model rmod_m4lines_ADS_W sp n=4 valtype=real
+ interpolation=spline
+ extrapolation=step
+ spacing=nonuniform
+ dc=
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ infinity=
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ data=700
+ 100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 1900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 2900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 3900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 4900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 5900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 6900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 7900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 8900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 9900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 10900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 11900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 12900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 13900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 14900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 15900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 16900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 17900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 18900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 19900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 20900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 21900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 22900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 23900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 24900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 25900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 26900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 27900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 28900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 29900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 30900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 31900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 32900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 33900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 34900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 35900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 36900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 37900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 38900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 39900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 40900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 41900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 42900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 43900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 44900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 45900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 46900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 47900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 48900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 49900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 50900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 51900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 52900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 53900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 54900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 55900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 56900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 57900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 58900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 59900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 60900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 61900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 62900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 63900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 64900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 65900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 66900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 67900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 68900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69100000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69200000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69300000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69400000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69500000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69600000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69700000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69800000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 69900000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0
+ 70000000000
+ 0
+ 0  0
+ 0  0  0
+ 0  0  0  0

.model gmod_m4lines_ADS_W sp n=4 valtype=real
+ interpolation=spline
+ extrapolation=step
+ spacing=nonuniform
+ dc=
+ 0.000416391012646
+ -7.53280378342e-05  0.000418997887916
+ -5.57473677842e-07  -3.23650311002e-05  0.000418997887916
+ -1.92648444124e-07  -5.57473677842e-07  -7.53280378342e-05  0.000416391012646
+ infinity=
+ 0.278604736444
+ -0.0504231133617  0.280310562341
+ -0.000381553530573  -0.0216739518097  0.280310562341
+ -0.000148993470755  -0.000381553530573  -0.0504231133617  0.278604736444
+ data=700
+ 100000000
+ 0.000416391012646
+ -7.53280378342e-05  0.000418997887916
+ -5.57473677842e-07  -3.23650311002e-05  0.000418997887916
+ -1.92648444124e-07  -5.57473677842e-07  -7.53280378342e-05  0.000416391012646
+ 200000000
+ 0.000832756440801
+ -0.000150658179204  0.000837958042828
+ -1.11758146038e-06  -6.47339097542e-05  0.000837958042828
+ -3.91555119932e-07  -1.11758146038e-06  -0.000150658179204  0.000832756440801
+ 300000000
+ 0.00124907819682
+ -0.000225982959085  0.00125686973052
+ -1.6786372043e-06  -9.7101595125e-05  0.00125686973052
+ -5.92806486456e-07  -1.6786372043e-06  -0.000225982959085  0.00124907819682
+ 400000000
+ 0.00166535299959
+ -0.000301300892696  0.00167573123641
+ -2.24028326763e-06  -0.000129467059561  0.00167573123641
+ -7.955709659e-07  -2.24028326763e-06  -0.000301300892696  0.00166535299959
+ 500000000
+ 0.00208157929081
+ -0.000376611274864  0.00209454174619
+ -2.80234979429e-06  -0.000161829814998  0.00209454174619
+ -9.9945361427e-07  -2.80234979429e-06  -0.000376611274864  0.00208157929081
+ 600000000
+ 0.00249775615267
+ -0.000451913690254  0.00251330078024
+ -3.36473674124e-06  -0.00019418957397  0.00251330078024
+ -1.2042218146e-06  -3.36473674124e-06  -0.000451913690254  0.00249775615267
+ 700000000
+ 0.00291388297869
+ -0.000527207864427  0.00293200802166
+ -3.92737800334e-06  -0.000226546146533  0.00293200802166
+ -1.40972186134e-06  -3.92737800334e-06  -0.000527207864427  0.00291388297869
+ 800000000
+ 0.00332995933787
+ -0.000602493602329  0.00335066324523
+ -4.490226597e-06  -0.000258899397684  0.00335066324523
+ -1.61584450966e-06  -4.490226597e-06  -0.000602493602329  0.00332995933787
+ 900000000
+ 0.00374598490792
+ -0.000677770758118  0.00376926628253
+ -5.0532473926e-06  -0.000291249226482  0.00376926628253
+ -1.82250807723e-06  -5.0532473926e-06  -0.000677770758118  0.00374598490792
+ 1000000000
+ 0.0041619594387
+ -0.000753039218594  0.00418781700286
+ -5.61641312256e-06  -0.000323595554578  0.00418781700286
+ -2.02964916233e-06  -5.61641312256e-06  -0.000753039218594  0.0041619594387
+ 1100000000
+ 0.00457788273038
+ -0.000828298893326  0.0046063153018
+ -6.17970200369e-06  -0.000355938319381  0.0046063153018
+ -2.23721711529e-06  -6.17970200369e-06  -0.000828298893326  0.00457788273038
+ 1200000000
+ 0.00499375461964
+ -0.000903549708402  0.00502476109404
+ -6.74309623164e-06  -0.000388277469734  0.00502476109404
+ -2.44517053794e-06  -6.74309623164e-06  -0.000903549708402  0.00499375461964
+ 1300000000
+ 0.0054095749705
+ -0.000978791602275  0.0054431543085
+ -7.30658098081e-06  -0.000420612963039  0.0054431543085
+ -2.65347495822e-06  -7.30658098081e-06  -0.000978791602275  0.0054095749705
+ 1400000000
+ 0.00582534366796
+ -0.0010540245229  0.00586149488512
+ -7.87014371387e-06  -0.000452944763272  0.00586149488512
+ -2.86210122465e-06  -7.87014371387e-06  -0.0010540245229  0.00582534366796
+ 1500000000
+ 0.00624106061349
+ -0.00112924842569  0.00627978277242
+ -8.43377368949e-06  -0.000485272839572  0.00627978277242
+ -3.07102436174e-06  -8.43377368949e-06  -0.00112924842569  0.00624106061349
+ 1600000000
+ 0.00665672572177
+ -0.00120446327202  0.00669801792583
+ -8.99746160196e-06  -0.000517597165202  0.00669801792583
+ -3.28022273208e-06  -8.99746160196e-06  -0.00120446327202  0.00665672572177
+ 1700000000
+ 0.00707233891814
+ -0.00127966902809  0.00711620030635
+ -9.56119931121e-06  -0.000549917716773  0.00711620030635
+ -3.48967740855e-06  -9.56119931121e-06  -0.00127966902809  0.00707233891814
+ 1800000000
+ 0.00748790013675
+ -0.0013548656641  0.00753432987959
+ -1.01249796366e-05  -0.000582234473657  0.00753432987959
+ -3.69937169488e-06  -1.01249796366e-05  -0.0013548656641  0.00748790013675
+ 1900000000
+ 0.00790340931911
+ -0.00143005315357  0.007952406615
+ -1.06887961967e-05  -0.000614547417519  0.007952406615
+ -3.90929075297e-06  -1.06887961967e-05  -0.00143005315357  0.00790340931911
+ 2000000000
+ 0.00831886641287
+ -0.00150523147281  0.00837043048524
+ -1.12526432827e-05  -0.000646856531959  0.00837043048524
+ -4.1194213089e-06  -1.12526432827e-05  -0.00150523147281  0.00831886641287
+ 2100000000
+ 0.00873427137095
+ -0.00158040060048  0.00878840146574
+ -1.18165157575e-05  -0.000679161802218  0.00878840146574
+ -4.32975141791e-06  -1.18165157575e-05  -0.00158040060048  0.00873427137095
+ 2200000000
+ 0.00914962415075
+ -0.00165556051732  0.00920631953424
+ -1.23804089738e-05  -0.000711463214947  0.00920631953424
+ -4.54027027415e-06  -1.23804089738e-05  -0.00165556051732  0.00914962415075
+ 2300000000
+ 0.00956492471356
+ -0.00173071120577  0.00962418467055
+ -1.29443187073e-05  -0.00074376075801  0.00962418467055
+ -4.75096805521e-06  -1.29443187073e-05  -0.00173071120577  0.00956492471356
+ 2400000000
+ 0.00998017302405
+ -0.00180585264986  0.0100419968562
+ -1.35082411013e-05  -0.000776054420329  0.0100419968562
+ -4.96183579362e-06  -1.35082411013e-05  -0.00180585264986  0.00998017302405
+ 2500000000
+ 0.0103953690498
+ -0.0018809848349  0.0104597560744
+ -1.4072172621e-05  -0.00080834419175  0.0104597560744
+ -5.17286526987e-06  -1.4072172621e-05  -0.0018809848349  0.0103953690498
+ 2600000000
+ 0.0108105127611
+ -0.0019561077474  0.0108774623094
+ -1.46361100143e-05  -0.000840630062934  0.0108774623094
+ -5.38404892257e-06  -1.46361100143e-05  -0.0019561077474  0.0108105127611
+ 2700000000
+ 0.0112256041305
+ -0.00203122137492  0.0112951155471
+ -1.52000502796e-05  -0.000872912025259  0.0112951155471
+ -5.5953797724e-06  -1.52000502796e-05  -0.00203122137492  0.0112256041305
+ 2800000000
+ 0.0116406431324
+ -0.00210632570592  0.0117127157741
+ -1.5763990638e-05  -0.000905190070744  0.0117127157741
+ -5.80685135739e-06  -1.5763990638e-05  -0.00210632570592  0.0116406431324
+ 2900000000
+ 0.0120556297433
+ -0.00218142072971  0.0121302629781
+ -1.63279285089e-05  -0.000937464191979  0.0121302629781
+ -6.01845767745e-06  -1.63279285089e-05  -0.00218142072971  0.0120556297433
+ 3000000000
+ 0.0124705639412
+ -0.00225650643632  0.0125477571477
+ -1.68918614901e-05  -0.000969734382065  0.0125477571477
+ -6.23019314652e-06  -1.68918614901e-05  -0.00225650643632  0.0124705639412
+ 3100000000
+ 0.0128854457055
+ -0.00233158281645  0.0129651982721
+ -1.74557873394e-05  -0.00100200063457  0.0129651982721
+ -6.44205255118e-06  -1.74557873394e-05  -0.00233158281645  0.0128854457055
+ 3200000000
+ 0.0133002750172
+ -0.0024066498614  0.0133825863414
+ -1.80197039594e-05  -0.00103426294346  0.0133825863414
+ -6.65403101451e-06  -1.80197039594e-05  -0.0024066498614  0.0133002750172
+ 3300000000
+ 0.0137150518582
+ -0.00248170756304  0.0137999213463
+ -1.8583609384e-05  -0.0010665213031  0.0137999213463
+ -6.86612396454e-06  -1.8583609384e-05  -0.00248170756304  0.0137150518582
+ 3400000000
+ 0.0141297762117
+ -0.00255675591369  0.0142172032778
+ -1.9147501766e-05  -0.00109877570818  0.0142172032778
+ -7.07832710656e-06  -1.9147501766e-05  -0.00255675591369  0.0141297762117
+ 3500000000
+ 0.0145444480618
+ -0.00263179490615  0.0146344321279
+ -1.97113793674e-05  -0.00113102615372  0.0146344321279
+ -7.29063639854e-06  -1.97113793674e-05  -0.00263179490615  0.0145444480618
+ 3600000000
+ 0.0149590673934
+ -0.00270682453365  0.0150516078886
+ -2.0275240549e-05  -0.00116327263501  0.0150516078886
+ -7.50304802956e-06  -2.0275240549e-05  -0.00270682453365  0.0149590673934
+ 3700000000
+ 0.0153736341926
+ -0.00278184478975  0.0154687305527
+ -2.08390837632e-05  -0.00119551514761  0.0154687305527
+ -7.71555840047e-06  -2.08390837632e-05  -0.00278184478975  0.0153736341926
+ 3800000000
+ 0.0157881484459
+ -0.0028568556684  0.0158858001131
+ -2.14029075458e-05  -0.00122775368731  0.0158858001131
+ -7.92816410676e-06  -2.14029075458e-05  -0.0028568556684  0.0157881484459
+ 3900000000
+ 0.0162026101407
+ -0.00293185716385  0.0163028165634
+ -2.19667105098e-05  -0.00125998825015  0.0163028165634
+ -8.14086192314e-06  -2.19667105098e-05  -0.00293185716385  0.0162026101407
+ 4000000000
+ 0.0166170192649
+ -0.00300684927065  0.0167197798973
+ -2.25304913393e-05  -0.00129221883234  0.0167197798973
+ -8.3536487898e-06  -2.25304913393e-05  -0.00300684927065  0.0166170192649
+ 4100000000
+ 0.0170313758073
+ -0.00308183198364  0.0171366901089
+ -2.30942487843e-05  -0.0013244454303  0.0171366901089
+ -8.56652179994e-06  -2.30942487843e-05  -0.00308183198364  0.0170313758073
+ 4200000000
+ 0.017445679757
+ -0.00315680529788  0.0175535471926
+ -2.36579816557e-05  -0.00135666804061  0.0175535471926
+ -8.77947818861e-06  -2.36579816557e-05  -0.00315680529788  0.017445679757
+ 4300000000
+ 0.0178599311037
+ -0.00323176920869  0.017970351143
+ -2.42216888211e-05  -0.00138888666004  0.017970351143
+ -8.99251532255e-06  -2.42216888211e-05  -0.00323176920869  0.0178599311037
+ 4400000000
+ 0.0182741298375
+ -0.00330672371161  0.0183871019551
+ -2.47853692008e-05  -0.00142110128548  0.0183871019551
+ -9.20563069102e-06  -2.47853692008e-05  -0.00330672371161  0.0182741298375
+ 4500000000
+ 0.0186882759492
+ -0.00338166880237  0.018803799624
+ -2.53490217642e-05  -0.00145331191397  0.018803799624
+ -9.41882189742e-06  -2.53490217642e-05  -0.00338166880237  0.0186882759492
+ 4600000000
+ 0.0191023694297
+ -0.0034566044769  0.0192204441451
+ -2.59126455265e-05  -0.00148551854271  0.019220444145
+ -9.6320866517e-06  -2.59126455265e-05  -0.0034566044769  0.0191023694297
+ 4700000000
+ 0.0195164102705
+ -0.0035315307313  0.0196370355139
+ -2.64762395458e-05  -0.00151772116899  0.0196370355139
+ -9.84542276338e-06  -2.64762395458e-05  -0.0035315307313  0.0195164102705
+ 4800000000
+ 0.0199303984634
+ -0.00360644756186  0.0200535737262
+ -2.70398029202e-05  -0.00154991979021  0.0200535737262
+ -1.00588281352e-05  -2.70398029202e-05  -0.00360644756186  0.0199303984634
+ 4900000000
+ 0.0203443340007
+ -0.003681354965  0.020470058778
+ -2.76033347854e-05  -0.00158211440392  0.020470058778
+ -1.02723007574e-05  -2.76033347854e-05  -0.003681354965  0.0203443340007
+ 5000000000
+ 0.0207582168748
+ -0.00375625293729  0.0208864906655
+ -2.81668343124e-05  -0.00161430500773  0.0208864906655
+ -1.04858387022e-05  -2.81668343124e-05  -0.00375625293729  0.0207582168748
+ 5100000000
+ 0.0211720470785
+ -0.00383114147545  0.0213028693849
+ -2.87303007055e-05  -0.00164649159936  0.0213028693849
+ -1.06994401188e-05  -2.87303007055e-05  -0.00383114147545  0.0211720470785
+ 5200000000
+ 0.0215858246048
+ -0.00390602057632  0.0217191949326
+ -2.92937332001e-05  -0.00167867417663  0.0217191949326
+ -1.09131032293e-05  -2.92937332001e-05  -0.00390602057632  0.0215858246048
+ 5300000000
+ 0.0219995494473
+ -0.00398089023688  0.0221354673052
+ -2.98571310609e-05  -0.00171085273743  0.0221354673052
+ -1.11268263239e-05  -2.98571310609e-05  -0.00398089023688  0.0219995494473
+ 5400000000
+ 0.0224132215994
+ -0.0040557504542  0.0225516864995
+ -3.04204935806e-05  -0.00174302727973  0.0225516864995
+ -1.13406077574e-05  -3.04204935806e-05  -0.0040557504542  0.0224132215994
+ 5500000000
+ 0.0228268410551
+ -0.00413060122548  0.0229678525123
+ -3.0983820078e-05  -0.00177519780159  0.0229678525123
+ -1.15544459458e-05  -3.0983820078e-05  -0.00413060122548  0.0228268410551
+ 5600000000
+ 0.0232404078084
+ -0.00420544254801  0.0233839653406
+ -3.15471098966e-05  -0.00180736430114  0.0233839653406
+ -1.17683393624e-05  -3.15471098966e-05  -0.00420544254801  0.0232404078084
+ 5700000000
+ 0.0236539218537
+ -0.00428027441919  0.0238000249815
+ -3.21103624035e-05  -0.00183952677655  0.0238000249815
+ -1.19822865351e-05  -3.21103624035e-05  -0.00428027441919  0.0236539218537
+ 5800000000
+ 0.0240673831854
+ -0.00435509683649  0.024216031432
+ -3.2673576988e-05  -0.00187168522608  0.024216031432
+ -1.21962860435e-05  -3.2673576988e-05  -0.00435509683649  0.0240673831854
+ 5900000000
+ 0.0244807917983
+ -0.0044299097975  0.0246319846897
+ -3.32367530603e-05  -0.00190383964806  0.0246319846897
+ -1.24103365162e-05  -3.32367530603e-05  -0.0044299097975  0.0244807917983
+ 6000000000
+ 0.0248941476873
+ -0.00450471329987  0.0250478847517
+ -3.37998900508e-05  -0.00193599004084  0.0250478847517
+ -1.26244366282e-05  -3.37998900508e-05  -0.00450471329987  0.0248941476873
+ 6100000000
+ 0.0253074508474
+ -0.00457950734133  0.0254637316157
+ -3.43629874088e-05  -0.00196813640286  0.0254637316157
+ -1.28385850989e-05  -3.43629874088e-05  -0.00457950734133  0.0253074508474
+ 6200000000
+ 0.0257207012739
+ -0.0046542919197  0.0258795252792
+ -3.49260446017e-05  -0.0020002787326  0.0258795252792
+ -1.30527806894e-05  -3.49260446017e-05  -0.0046542919197  0.0257207012739
+ 6300000000
+ 0.0261338989622
+ -0.00472906703286  0.0262952657398
+ -3.5489061114e-05  -0.00203241702858  0.0262952657398
+ -1.3267022201e-05  -3.5489061114e-05  -0.00472906703286  0.0261338989622
+ 6400000000
+ 0.0265470439078
+ -0.00480383267876  0.0267109529953
+ -3.60520364468e-05  -0.00206455128939  0.0267109529953
+ -1.34813084729e-05  -3.60520364468e-05  -0.00480383267876  0.0265470439078
+ 6500000000
+ 0.0269601361065
+ -0.00487858885542  0.0271265870435
+ -3.66149701165e-05  -0.00209668151363  0.0271265870435
+ -1.36956383807e-05  -3.66149701165e-05  -0.00487858885542  0.0269601361065
+ 6600000000
+ 0.027373175554
+ -0.00495333556091  0.0275421678823
+ -3.71778616546e-05  -0.00212880769998  0.0275421678823
+ -1.39100108344e-05  -3.71778616546e-05  -0.00495333556091  0.027373175554
+ 6700000000
+ 0.0277861622464
+ -0.00502807279338  0.0279576955097
+ -3.77407106067e-05  -0.00216092984715  0.0279576955097
+ -1.41244247773e-05  -3.77407106067e-05  -0.00502807279338  0.0277861622464
+ 6800000000
+ 0.0281990961797
+ -0.00510280055102  0.0283731699237
+ -3.83035165321e-05  -0.00219304795386  0.0283731699237
+ -1.43388791841e-05  -3.83035165321e-05  -0.00510280055102  0.0281990961797
+ 6900000000
+ 0.0286119773501
+ -0.00517751883208  0.0287885911224
+ -3.88662790029e-05  -0.00222516201891  0.0287885911224
+ -1.45533730597e-05  -3.88662790029e-05  -0.00517751883208  0.0286119773501
+ 7000000000
+ 0.029024805754
+ -0.00525222763486  0.0292039591039
+ -3.94289976038e-05  -0.00225727204111  0.0292039591039
+ -1.47679054377e-05  -3.94289976038e-05  -0.00525222763486  0.029024805754
+ 7100000000
+ 0.0294375813879
+ -0.0053269269577  0.0296192738664
+ -3.99916719311e-05  -0.00228937801932  0.0296192738664
+ -1.49824753796e-05  -3.99916719311e-05  -0.0053269269577  0.0294375813879
+ 7200000000
+ 0.0298503042482
+ -0.00540161679902  0.0300345354083
+ -4.05543015928e-05  -0.00232147995242  0.0300345354083
+ -1.51970819731e-05  -4.05543015928e-05  -0.00540161679902  0.0298503042482
+ 7300000000
+ 0.0302629743316
+ -0.00547629715724  0.0304497437278
+ -4.11168862075e-05  -0.00235357783931  0.0304497437278
+ -1.54117243313e-05  -4.11168862075e-05  -0.00547629715724  0.0302629743316
+ 7400000000
+ 0.030675591635
+ -0.00555096803087  0.0308648988233
+ -4.16794254045e-05  -0.00238567167896  0.0308648988233
+ -1.56264015916e-05  -4.16794254045e-05  -0.00555096803087  0.030675591635
+ 7500000000
+ 0.031088156155
+ -0.00562562941842  0.0312800006933
+ -4.22419188231e-05  -0.00241776147034  0.0312800006933
+ -1.58411129148e-05  -4.22419188231e-05  -0.00562562941842  0.031088156155
+ 7600000000
+ 0.0315006678887
+ -0.00570028131847  0.0316950493362
+ -4.2804366112e-05  -0.00244984721244  0.0316950493362
+ -1.6055857484e-05  -4.2804366112e-05  -0.00570028131847  0.0315006678887
+ 7700000000
+ 0.0319131268331
+ -0.00577492372963  0.0321100447505
+ -4.33667669294e-05  -0.00248192890429  0.0321100447505
+ -1.62706345038e-05  -4.33667669294e-05  -0.00577492372963  0.0319131268331
+ 7800000000
+ 0.0323255329853
+ -0.00584955665054  0.0325249869348
+ -4.39291209423e-05  -0.00251400654496  0.0325249869348
+ -1.64854431995e-05  -4.39291209423e-05  -0.00584955665054  0.0323255329853
+ 7900000000
+ 0.0327378863424
+ -0.00592418007989  0.0329398758878
+ -4.44914278261e-05  -0.00254608013352  0.0329398758878
+ -1.67002828162e-05  -4.44914278261e-05  -0.00592418007989  0.0327378863424
+ 8000000000
+ 0.0331501869018
+ -0.00599879401639  0.033354711608
+ -4.50536872648e-05  -0.00257814966907  0.033354711608
+ -1.69151526182e-05  -4.50536872648e-05  -0.00599879401639  0.0331501869018
+ 8100000000
+ 0.0335624346607
+ -0.00607339845879  0.0337694940941
+ -4.56158989499e-05  -0.00261021515075  0.0337694940941
+ -1.71300518882e-05  -4.56158989499e-05  -0.00607339845879  0.0335624346607
+ 8200000000
+ 0.0339746296166
+ -0.00614799340587  0.034184223345
+ -4.61780625807e-05  -0.0026422765777  0.034184223345
+ -1.73449799264e-05  -4.61780625807e-05  -0.00614799340587  0.0339746296166
+ 8300000000
+ 0.034386771767
+ -0.00622257885645  0.0345988993593
+ -4.6740177864e-05  -0.00267433394908  0.0345988993593
+ -1.75599360503e-05  -4.6740177864e-05  -0.00622257885645  0.034386771767
+ 8400000000
+ 0.0347988611094
+ -0.00629715480936  0.0350135221358
+ -4.73022445133e-05  -0.0027063872641  0.0350135221358
+ -1.77749195938e-05  -4.73022445133e-05  -0.00629715480936  0.0347988611094
+ 8500000000
+ 0.0352108976414
+ -0.00637172126349  0.0354280916735
+ -4.78642622493e-05  -0.00273843652196  0.0354280916735
+ -1.79899299066e-05  -4.78642622493e-05  -0.00637172126349  0.0352108976414
+ 8600000000
+ 0.0356228813607
+ -0.00644627821771  0.0358426079711
+ -4.8426230799e-05  -0.00277048172189  0.0358426079711
+ -1.82049663538e-05  -4.8426230799e-05  -0.00644627821771  0.0356228813607
+ 8700000000
+ 0.036034812265
+ -0.00652082567097  0.0362570710275
+ -4.8988149896e-05  -0.00280252286313  0.0362570710275
+ -1.84200283152e-05  -4.8988149896e-05  -0.00652082567097  0.036034812265
+ 8800000000
+ 0.0364466903521
+ -0.00659536362222  0.0366714808418
+ -4.95500192798e-05  -0.00283455994496  0.0366714808418
+ -1.86351151848e-05  -4.95500192798e-05  -0.00659536362222  0.0364466903521
+ 8900000000
+ 0.0368585156199
+ -0.00666989207042  0.0370858374128
+ -5.0111838696e-05  -0.00286659296665  0.0370858374128
+ -1.88502263705e-05  -5.0111838696e-05  -0.00666989207042  0.0368585156199
+ 9000000000
+ 0.0372702880662
+ -0.00674441101458  0.0375001407396
+ -5.06736078959e-05  -0.00289862192751  0.0375001407396
+ -1.90653612934e-05  -5.06736078959e-05  -0.00674441101458  0.0372702880662
+ 9100000000
+ 0.0376820076891
+ -0.00681892045372  0.0379143908212
+ -5.12353266362e-05  -0.00293064682684  0.0379143908212
+ -1.92805193876e-05  -5.12353266362e-05  -0.00681892045372  0.0376820076891
+ 9200000000
+ 0.0380936744865
+ -0.00689342038689  0.0383285876566
+ -5.17969946791e-05  -0.00296266766399  0.0383285876566
+ -1.94957000994e-05  -5.17969946791e-05  -0.00689342038689  0.0380936744865
+ 9300000000
+ 0.0385052884565
+ -0.00696791081316  0.0387427312449
+ -5.23586117919e-05  -0.00299468443829  0.0387427312449
+ -1.97109028874e-05  -5.23586117919e-05  -0.00696791081316  0.0385052884565
+ 9400000000
+ 0.0389168495972
+ -0.00704239173162  0.0391568215852
+ -5.29201777469e-05  -0.00302669714911  0.0391568215852
+ -1.99261272216e-05  -5.29201777469e-05  -0.00704239173162  0.0389168495972
+ 9500000000
+ 0.0393283579068
+ -0.00711686314137  0.0395708586767
+ -5.34816923215e-05  -0.00305870579581  0.0395708586767
+ -2.01413725836e-05  -5.34816923215e-05  -0.00711686314137  0.0393283579068
+ 9600000000
+ 0.0397398133833
+ -0.00719132504155  0.0399848425185
+ -5.40431552973e-05  -0.0030907103778  0.0399848425185
+ -2.03566384656e-05  -5.40431552973e-05  -0.00719132504155  0.0397398133833
+ 9700000000
+ 0.0401512160252
+ -0.0072657774313  0.0403987731098
+ -5.4604566461e-05  -0.00312271089447  0.0403987731098
+ -2.05719243705e-05  -5.4604566461e-05  -0.0072657774313  0.0401512160252
+ 9800000000
+ 0.0405625658306
+ -0.00734022030979  0.0408126504498
+ -5.51659256033e-05  -0.00315470734523  0.0408126504498
+ -2.07872298115e-05  -5.51659256033e-05  -0.00734022030979  0.0405625658306
+ 9900000000
+ 0.040973862798
+ -0.00741465367621  0.0412264745376
+ -5.57272325193e-05  -0.00318669972951  0.0412264745376
+ -2.10025543117e-05  -5.57272325193e-05  -0.00741465367621  0.040973862798
+ 10000000000
+ 0.0413851069255
+ -0.00748907752976  0.0416402453726
+ -5.62884870084e-05  -0.00321868804675  0.0416402453726
+ -2.12178974038e-05  -5.62884870084e-05  -0.00748907752976  0.0413851069255
+ 10100000000
+ 0.0417962982118
+ -0.00756349186967  0.0420539629541
+ -5.68496888738e-05  -0.0032506722964  0.0420539629541
+ -2.14332586298e-05  -5.68496888738e-05  -0.00756349186967  0.0417962982118
+ 10200000000
+ 0.0422074366551
+ -0.00763789669516  0.0424676272812
+ -5.74108379227e-05  -0.00328265247793  0.0424676272812
+ -2.16486375409e-05  -5.74108379227e-05  -0.00763789669516  0.0422074366551
+ 10300000000
+ 0.042618522254
+ -0.00771229200549  0.0428812383534
+ -5.79719339662e-05  -0.00331462859079  0.0428812383534
+ -2.18640336971e-05  -5.79719339662e-05  -0.00771229200549  0.042618522254
+ 10400000000
+ 0.043029555007
+ -0.00778667779993  0.0432947961699
+ -5.85329768188e-05  -0.00334660063449  0.0432947961699
+ -2.20794466668e-05  -5.85329768188e-05  -0.00778667779993  0.043029555007
+ 10500000000
+ 0.0434405349127
+ -0.00786105407777  0.0437083007301
+ -5.90939662989e-05  -0.00337856860851  0.0437083007301
+ -2.22948760269e-05  -5.90939662989e-05  -0.00786105407777  0.0434405349127
+ 10600000000
+ 0.0438514619695
+ -0.0079354208383  0.0441217520334
+ -5.96549022281e-05  -0.00341053251235  0.0441217520334
+ -2.25103213621e-05  -5.96549022281e-05  -0.0079354208383  0.0438514619695
+ 10700000000
+ 0.0442623361763
+ -0.00800977808083  0.0445351500791
+ -6.02157844314e-05  -0.00344249234553  0.0445351500791
+ -2.27257822651e-05  -6.02157844314e-05  -0.00800977808083  0.0442623361763
+ 10800000000
+ 0.0446731575315
+ -0.0080841258047  0.0449484948667
+ -6.07766127374e-05  -0.00347444810758  0.0449484948667
+ -2.29412583363e-05  -6.07766127374e-05  -0.0080841258047  0.0446731575315
+ 10900000000
+ 0.0450839260338
+ -0.00815846400924  0.0453617863956
+ -6.13373869774e-05  -0.00350639979802  0.0453617863956
+ -2.31567491834e-05  -6.13373869774e-05  -0.00815846400924  0.0450839260338
+ 11000000000
+ 0.0454946416821
+ -0.00823279269381  0.0457750246651
+ -6.18981069862e-05  -0.0035383474164  0.0457750246651
+ -2.33722544212e-05  -6.18981069862e-05  -0.00823279269381  0.0454946416821
+ 11100000000
+ 0.045905304475
+ -0.00830711185777  0.0461882096749
+ -6.24587726014e-05  -0.00357029096227  0.0461882096749
+ -2.35877736717e-05  -6.24587726014e-05  -0.00830711185777  0.045905304475
+ 11200000000
+ 0.0463159144112
+ -0.0083814215005  0.0466013414242
+ -6.30193836635e-05  -0.00360223043518  0.0466013414242
+ -2.38033065635e-05  -6.30193836635e-05  -0.0083814215005  0.0463159144112
+ 11300000000
+ 0.0467264714897
+ -0.0084557216214  0.0470144199127
+ -6.35799400161e-05  -0.00363416583471  0.0470144199127
+ -2.40188527321e-05  -6.35799400161e-05  -0.0084557216214  0.0467264714897
+ 11400000000
+ 0.0471369757092
+ -0.00853001221986  0.0474274451398
+ -6.41404415053e-05  -0.00366609716044  0.0474274451398
+ -2.42344118192e-05  -6.41404415053e-05  -0.00853001221986  0.0471369757092
+ 11500000000
+ 0.0475474270685
+ -0.00860429329531  0.047840417105
+ -6.470088798e-05  -0.00369802441193  0.047840417105
+ -2.44499834729e-05  -6.470088798e-05  -0.00860429329531  0.0475474270685
+ 11600000000
+ 0.0479578255665
+ -0.00867856484717  0.0482533358079
+ -6.52612792919e-05  -0.0037299475888  0.0482533358079
+ -2.46655673474e-05  -6.52612792919e-05  -0.00867856484717  0.0479578255665
+ 11700000000
+ 0.0483681712023
+ -0.00875282687488  0.048666201248
+ -6.58216152951e-05  -0.00376186669062  0.048666201248
+ -2.4881163103e-05  -6.58216152951e-05  -0.00875282687488  0.0483681712023
+ 11800000000
+ 0.0487784639745
+ -0.00882707937787  0.0490790134249
+ -6.63818958461e-05  -0.00379378171702  0.0490790134249
+ -2.50967704055e-05  -6.63818958461e-05  -0.00882707937787  0.0487784639745
+ 11900000000
+ 0.0491887038823
+ -0.00890132235563  0.0494917723381
+ -6.69421208041e-05  -0.00382569266761  0.0494917723381
+ -2.53123889266e-05  -6.69421208041e-05  -0.00890132235563  0.0491887038823
+ 12000000000
+ 0.0495988909246
+ -0.0089755558076  0.0499044779873
+ -6.75022900304e-05  -0.003857599542  0.0499044779873
+ -2.55280183435e-05  -6.75022900304e-05  -0.0089755558076  0.0495988909246
+ 12100000000
+ 0.0500090251005
+ -0.00904977973327  0.050317130372
+ -6.80624033889e-05  -0.00388950233982  0.050317130372
+ -2.57436583387e-05  -6.80624033889e-05  -0.00904977973327  0.0500090251005
+ 12200000000
+ 0.0504191064088
+ -0.00912399413214  0.0507297294918
+ -6.86224607456e-05  -0.00392140106071  0.0507297294918
+ -2.59593086001e-05  -6.86224607456e-05  -0.00912399413214  0.0504191064088
+ 12300000000
+ 0.0508291348487
+ -0.00919819900369  0.0511422753465
+ -6.91824619687e-05  -0.0039532957043  0.0511422753465
+ -2.61749688205e-05  -6.91824619687e-05  -0.00919819900369  0.0508291348487
+ 12400000000
+ 0.0512391104193
+ -0.00927239434743  0.0515547679355
+ -6.97424069285e-05  -0.00398518627025  0.0515547679355
+ -2.63906386979e-05  -6.97424069285e-05  -0.00927239434743  0.0512391104193
+ 12500000000
+ 0.0516490331195
+ -0.00934658016289  0.0519672072586
+ -7.03022954976e-05  -0.00401707275821  0.0519672072586
+ -2.6606317935e-05  -7.03022954976e-05  -0.00934658016289  0.0516490331195
+ 12600000000
+ 0.0520589029486
+ -0.00942075644958  0.0523795933154
+ -7.08621275504e-05  -0.00404895516783  0.0523795933154
+ -2.68220062393e-05  -7.08621275504e-05  -0.00942075644958  0.0520589029486
+ 12700000000
+ 0.0524687199057
+ -0.00949492320705  0.0527919261056
+ -7.14219029635e-05  -0.00408083349878  0.0527919261056
+ -2.70377033232e-05  -7.14219029635e-05  -0.00949492320705  0.0524687199057
+ 12800000000
+ 0.0528784839899
+ -0.00956908043482  0.0532042056289
+ -7.19816216154e-05  -0.00411270775073  0.0532042056289
+ -2.72534089031e-05  -7.19816216154e-05  -0.00956908043482  0.0528784839899
+ 12900000000
+ 0.0532881952004
+ -0.00964322813246  0.0536164318849
+ -7.25412833863e-05  -0.00414457792336  0.0536164318849
+ -2.74691227004e-05  -7.25412833863e-05  -0.00964322813246  0.0532881952004
+ 13000000000
+ 0.0536978535364
+ -0.00971736629953  0.0540286048735
+ -7.31008881587e-05  -0.00417644401635  0.0540286048735
+ -2.76848444405e-05  -7.31008881587e-05  -0.00971736629953  0.0536978535364
+ 13100000000
+ 0.054107458997
+ -0.00979149493558  0.0544407245942
+ -7.36604358165e-05  -0.00420830602938  0.0544407245942
+ -2.79005738531e-05  -7.36604358165e-05  -0.00979149493558  0.054107458997
+ 13200000000
+ 0.0545170115815
+ -0.0098656140402  0.0548527910469
+ -7.42199262455e-05  -0.00424016396216  0.0548527910469
+ -2.81163106719e-05  -7.42199262455e-05  -0.0098656140402  0.0545170115815
+ 13300000000
+ 0.0549265112892
+ -0.00993972361296  0.0552648042313
+ -7.47793593334e-05  -0.00427201781436  0.0552648042313
+ -2.8332054635e-05  -7.47793593334e-05  -0.00993972361296  0.0549265112892
+ 13400000000
+ 0.0553359581193
+ -0.0100138236535  0.0556767641471
+ -7.53387349694e-05  -0.00430386758571  0.0556767641471
+ -2.85478054839e-05  -7.53387349694e-05  -0.0100138236535  0.0553359581193
+ 13500000000
+ 0.0557453520712
+ -0.0100879141613  0.056088670794
+ -7.58980530445e-05  -0.0043357132759  0.056088670794
+ -2.87635629645e-05  -7.58980530445e-05  -0.0100879141613  0.0557453520712
+ 13600000000
+ 0.0561546931439
+ -0.0101619951361  0.0565005241719
+ -7.64573134511e-05  -0.00436755488465  0.0565005241719
+ -2.89793268261e-05  -7.64573134511e-05  -0.0101619951361  0.0561546931439
+ 13700000000
+ 0.056563981337
+ -0.0102360665774  0.0569123242806
+ -7.70165160835e-05  -0.00439939241168  0.0569123242806
+ -2.91950968218e-05  -7.70165160835e-05  -0.0102360665774  0.056563981337
+ 13800000000
+ 0.0569732166498
+ -0.0103101284849  0.0573240711198
+ -7.75756608374e-05  -0.0044312258567  0.0573240711198
+ -2.94108727084e-05  -7.75756608374e-05  -0.0103101284849  0.0569732166498
+ 13900000000
+ 0.0573823990815
+ -0.0103841808581  0.0577357646893
+ -7.81347476099e-05  -0.00446305521945  0.0577357646893
+ -2.96266542461e-05  -7.81347476099e-05  -0.0103841808581  0.0573823990815
+ 14000000000
+ 0.0577915286315
+ -0.0104582236968  0.0581474049889
+ -7.86937762999e-05  -0.00449488049965  0.0581474049889
+ -2.98424411986e-05  -7.86937762999e-05  -0.0104582236968  0.0577915286315
+ 14100000000
+ 0.0582006052992
+ -0.0105322570006  0.0585589920185
+ -7.92527468073e-05  -0.00452670169704  0.0585589920185
+ -3.00582333329e-05  -7.92527468073e-05  -0.0105322570006  0.0582006052992
+ 14200000000
+ 0.0586096290841
+ -0.010606280769  0.0589705257778
+ -7.98116590339e-05  -0.00455851881136  0.0589705257778
+ -3.02740304195e-05  -7.98116590339e-05  -0.010606280769  0.0586096290841
+ 14300000000
+ 0.0590185999854
+ -0.0106802950018  0.0593820062668
+ -8.03705128826e-05  -0.00459033184235  0.0593820062668
+ -3.04898322319e-05  -8.03705128826e-05  -0.0106802950018  0.0590185999854
+ 14400000000
+ 0.0594275180027
+ -0.0107542996986  0.0597934334852
+ -8.09293082577e-05  -0.00462214078976  0.0597934334852
+ -3.07056385469e-05  -8.09293082577e-05  -0.0107542996986  0.0594275180027
+ 14500000000
+ 0.0598363831354
+ -0.0108282948591  0.0602048074329
+ -8.14880450649e-05  -0.00465394565333  0.0602048074329
+ -3.09214491445e-05  -8.14880450649e-05  -0.0108282948591  0.0598363831354
+ 14600000000
+ 0.0602451953828
+ -0.0109022804829  0.0606161281098
+ -8.20467232112e-05  -0.00468574643284  0.0606161281098
+ -3.11372638075e-05  -8.20467232112e-05  -0.0109022804829  0.0602451953828
+ 14700000000
+ 0.0606539547446
+ -0.0109762565697  0.0610273955157
+ -8.26053426049e-05  -0.00471754312803  0.0610273955157
+ -3.13530823218e-05  -8.26053426049e-05  -0.0109762565697  0.0606539547446
+ 14800000000
+ 0.0610626612201
+ -0.0110502231192  0.0614386096505
+ -8.31639031555e-05  -0.00474933573866  0.0614386096505
+ -3.15689044762e-05  -8.31639031555e-05  -0.0110502231192  0.0610626612201
+ 14900000000
+ 0.0614713148088
+ -0.0111241801311  0.0618497705141
+ -8.37224047738e-05  -0.00478112426452  0.0618497705141
+ -3.17847300625e-05  -8.37224047738e-05  -0.0111241801311  0.0614713148088
+ 15000000000
+ 0.0618799155103
+ -0.0111981276051  0.0622608781064
+ -8.42808473717e-05  -0.00481290870535  0.0622608781064
+ -3.2000558875e-05  -8.42808473717e-05  -0.0111981276051  0.0618799155103
+ 15100000000
+ 0.062288463324
+ -0.0112720655408  0.0626719324273
+ -8.48392308623e-05  -0.00484468906095  0.0626719324273
+ -3.22163907109e-05  -8.48392308623e-05  -0.0112720655408  0.062288463324
+ 15200000000
+ 0.0626969582496
+ -0.0113459939379  0.0630829334767
+ -8.539755516e-05  -0.00487646533108  0.0630829334767
+ -3.24322253702e-05  -8.539755516e-05  -0.0113459939379  0.0626969582496
+ 15300000000
+ 0.0631054002865
+ -0.0114199127962  0.0634938812544
+ -8.59558201802e-05  -0.00490823751553  0.0634938812544
+ -3.26480626554e-05  -8.59558201802e-05  -0.0114199127962  0.0631054002865
+ 15400000000
+ 0.0635137894342
+ -0.0114938221154  0.0639047757606
+ -8.65140258395e-05  -0.00494000561407  0.0639047757606
+ -3.28639023715e-05  -8.65140258395e-05  -0.0114938221154  0.0635137894342
+ 15500000000
+ 0.0639221256924
+ -0.0115677218952  0.0643156169949
+ -8.70721720554e-05  -0.00497176962651  0.0643156169949
+ -3.30797443263e-05  -8.70721720554e-05  -0.0115677218952  0.0639221256924
+ 15600000000
+ 0.0643304090607
+ -0.0116416121353  0.0647264049575
+ -8.76302587468e-05  -0.00500352955263  0.0647264049575
+ -3.32955883299e-05  -8.76302587468e-05  -0.0116416121353  0.0643304090607
+ 15700000000
+ 0.0647386395385
+ -0.0117154928354  0.0651371396482
+ -8.81882858333e-05  -0.00503528539221  0.0651371396482
+ -3.35114341947e-05  -8.81882858333e-05  -0.0117154928354  0.0647386395385
+ 15800000000
+ 0.0651468171256
+ -0.0117893639953  0.065547821067
+ -8.87462532358e-05  -0.00506703714507  0.065547821067
+ -3.37272817358e-05  -8.87462532358e-05  -0.0117893639953  0.0651468171256
+ 15900000000
+ 0.0655549418215
+ -0.0118632256147  0.0659584492139
+ -8.9304160876e-05  -0.005098784811  0.0659584492139
+ -3.39431307705e-05  -8.9304160876e-05  -0.0118632256147  0.0655549418215
+ 16000000000
+ 0.0659630136259
+ -0.0119370776933  0.0663690240888
+ -8.98620086768e-05  -0.0051305283898  0.0663690240888
+ -3.41589811183e-05  -8.98620086768e-05  -0.0119370776933  0.0659630136259
+ 16100000000
+ 0.0663710325383
+ -0.0120109202309  0.0667795456917
+ -9.04197965619e-05  -0.00516226788128  0.0667795456917
+ -3.43748326011e-05  -9.04197965619e-05  -0.0120109202309  0.0663710325383
+ 16200000000
+ 0.0667789985585
+ -0.0120847532272  0.0671900140226
+ -9.09775244561e-05  -0.00519400328524  0.0671900140226
+ -3.4590685043e-05  -9.09775244561e-05  -0.0120847532272  0.0667789985585
+ 16300000000
+ 0.0671869116861
+ -0.012158576682  0.0676004290814
+ -9.1535192285e-05  -0.00522573460151  0.0676004290814
+ -3.48065382702e-05  -9.1535192285e-05  -0.012158576682  0.0671869116861
+ 16400000000
+ 0.0675947719208
+ -0.0122323905951  0.0680107908682
+ -9.20927999751e-05  -0.00525746182988  0.0680107908682
+ -3.5022392111e-05  -9.20927999751e-05  -0.0122323905951  0.0675947719208
+ 16500000000
+ 0.0680025792621
+ -0.0123061949661  0.0684210993829
+ -9.2650347454e-05  -0.00528918497019  0.0684210993829
+ -3.5238246396e-05  -9.2650347454e-05  -0.0123061949661  0.0680025792621
+ 16600000000
+ 0.0684103337099
+ -0.0123799897948  0.0688313546256
+ -9.32078346501e-05  -0.00532090402225  0.0688313546256
+ -3.54541009577e-05  -9.32078346501e-05  -0.0123799897948  0.0684103337099
+ 16700000000
+ 0.0688180352639
+ -0.0124537750811  0.0692415565962
+ -9.37652614925e-05  -0.00535261898588  0.0692415565962
+ -3.56699556306e-05  -9.37652614925e-05  -0.0124537750811  0.0688180352639
+ 16800000000
+ 0.0692256839236
+ -0.0125275508247  0.0696517052949
+ -9.43226279114e-05  -0.00538432986091  0.0696517052949
+ -3.58858102512e-05  -9.43226279114e-05  -0.0125275508247  0.0692256839236
+ 16900000000
+ 0.0696332796889
+ -0.0126013170254  0.0700618007215
+ -9.48799338377e-05  -0.00541603664717  0.0700618007215
+ -3.6101664658e-05  -9.48799338377e-05  -0.0126013170254  0.0696332796889
+ 17000000000
+ 0.0700408225595
+ -0.0126750736829  0.0704718428762
+ -9.54371792032e-05  -0.00544773934448  0.0704718428762
+ -3.63175186914e-05  -9.54371792032e-05  -0.0126750736829  0.0700408225595
+ 17100000000
+ 0.070448312535
+ -0.012748820797  0.0708818317589
+ -9.59943639405e-05  -0.00547943795268  0.0708818317589
+ -3.65333721937e-05  -9.59943639405e-05  -0.012748820797  0.070448312535
+ 17200000000
+ 0.0708557496153
+ -0.0128225583676  0.0712917673698
+ -9.65514879828e-05  -0.00551113247161  0.0712917673698
+ -3.6749225009e-05  -9.65514879828e-05  -0.0128225583676  0.0708557496153
+ 17300000000
+ 0.0712631338002
+ -0.0128962863943  0.0717016497088
+ -9.71085512644e-05  -0.0055428229011  0.0717016497088
+ -3.69650769831e-05  -9.71085512644e-05  -0.0128962863943  0.0712631338002
+ 17400000000
+ 0.0716704650893
+ -0.0129700048771  0.0721114787761
+ -9.76655537202e-05  -0.00557450924099  0.0721114787761
+ -3.71809279639e-05  -9.76655537202e-05  -0.0129700048771  0.0716704650893
+ 17500000000
+ 0.0720777434824
+ -0.0130437138157  0.0725212545716
+ -9.82224952858e-05  -0.00560619149112  0.0725212545716
+ -3.73967778007e-05  -9.82224952859e-05  -0.0130437138157  0.0720777434824
+ 17600000000
+ 0.0724849689794
+ -0.0131174132098  0.0729309770955
+ -9.87793758978e-05  -0.00563786965134  0.0729309770955
+ -3.76126263449e-05  -9.87793758978e-05  -0.0131174132098  0.0724849689794
+ 17700000000
+ 0.07289214158
+ -0.0131911030594  0.0733406463478
+ -9.93361954931e-05  -0.0056695437215  0.0733406463478
+ -3.78284734491e-05  -9.93361954931e-05  -0.0131911030594  0.07289214158
+ 17800000000
+ 0.073299261284
+ -0.0132647833642  0.0737502623285
+ -9.98929540098e-05  -0.00570121370145  0.0737502623285
+ -3.8044318968e-05  -9.98929540098e-05  -0.0132647833642  0.073299261284
+ 17900000000
+ 0.0737063280912
+ -0.013338454124  0.0741598250379
+ -0.000100449651386  -0.00573287959103  0.0741598250379
+ -3.82601627578e-05  -0.000100449651386  -0.013338454124  0.0737063280912
+ 18000000000
+ 0.0741133420015
+ -0.0134121153387  0.0745693344759
+ -0.000101006287562  -0.0057645413901  0.0745693344759
+ -3.84760046762e-05  -0.000101006287562  -0.0134121153387  0.0741133420015
+ 18100000000
+ 0.0745203030146
+ -0.013485767008  0.0749787906426
+ -0.000101562862477  -0.00579619909851  0.0749787906426
+ -3.86918445827e-05  -0.000101562862477  -0.013485767008  0.0745203030146
+ 18200000000
+ 0.0749272111304
+ -0.0135594091318  0.0753881935382
+ -0.000102119376071  -0.00582785271613  0.0753881935382
+ -3.89076823381e-05  -0.000102119376071  -0.0135594091318  0.0749272111304
+ 18300000000
+ 0.0753340663488
+ -0.0136330417098  0.0757975431627
+ -0.000102675828287  -0.00585950224281  0.0757975431627
+ -3.91235178048e-05  -0.000102675828287  -0.0136330417098  0.0753340663488
+ 18400000000
+ 0.0757408686695
+ -0.013706664742  0.0762068395163
+ -0.000103232219065  -0.00589114767842  0.0762068395163
+ -3.93393508469e-05  -0.000103232219065  -0.013706664742  0.0757408686695
+ 18500000000
+ 0.0761476180925
+ -0.0137802782282  0.0766160825991
+ -0.000103788548349  -0.00592278902281  0.0766160825991
+ -3.95551813299e-05  -0.000103788548349  -0.0137802782282  0.0761476180925
+ 18600000000
+ 0.0765543146176
+ -0.0138538821682  0.0770252724111
+ -0.000104344816082  -0.00595442627586  0.0770252724111
+ -3.97710091204e-05  -0.000104344816082  -0.0138538821682  0.0765543146176
+ 18700000000
+ 0.0769609582447
+ -0.0139274765617  0.0774344089526
+ -0.000104901022207  -0.00598605943743  0.0774344089526
+ -3.99868340871e-05  -0.000104901022207  -0.0139274765617  0.0769609582447
+ 18800000000
+ 0.0773675489737
+ -0.0140010614088  0.0778434922236
+ -0.000105457166669  -0.00601768850739  0.0778434922236
+ -4.02026560994e-05  -0.000105457166669  -0.0140010614088  0.0773675489737
+ 18900000000
+ 0.0777740868044
+ -0.0140746367091  0.0782525222243
+ -0.000106013249413  -0.00604931348561  0.0782525222243
+ -4.04184750287e-05  -0.000106013249413  -0.0140746367091  0.0777740868044
+ 19000000000
+ 0.0781805717367
+ -0.0141482024626  0.0786614989548
+ -0.000106569270384  -0.00608093437196  0.0786614989548
+ -4.06342907473e-05  -0.000106569270384  -0.0141482024626  0.0781805717367
+ 19100000000
+ 0.0785870037706
+ -0.0142217586691  0.0790704224152
+ -0.00010712522953  -0.00611255116633  0.0790704224152
+ -4.08501031291e-05  -0.00010712522953  -0.0142217586691  0.0785870037706
+ 19200000000
+ 0.078993382906
+ -0.0142953053284  0.0794792926058
+ -0.000107681126796  -0.00614416386859  0.0794792926058
+ -4.10659120493e-05  -0.000107681126796  -0.0142953053284  0.078993382906
+ 19300000000
+ 0.0793997091428
+ -0.0143688424405  0.0798881095266
+ -0.00010823696213  -0.00617577247861  0.0798881095266
+ -4.12817173843e-05  -0.00010823696213  -0.0143688424405  0.0793997091428
+ 19400000000
+ 0.0798059824808
+ -0.014442370005  0.0802968731779
+ -0.000108792735479  -0.00620737699627  0.0802968731779
+ -4.14975190119e-05  -0.000108792735479  -0.014442370005  0.0798059824808
+ 19500000000
+ 0.0802122029201
+ -0.014515888022  0.0807055835597
+ -0.000109348446793  -0.00623897742147  0.0807055835597
+ -4.17133168111e-05  -0.000109348446793  -0.014515888022  0.0802122029201
+ 19600000000
+ 0.0806183704605
+ -0.0145893964913  0.0811142406722
+ -0.00010990409602  -0.00627057375408  0.0811142406722
+ -4.19291106621e-05  -0.00010990409602  -0.0145893964913  0.0806183704605
+ 19700000000
+ 0.0810244851021
+ -0.0146628954127  0.0815228445157
+ -0.00011045968311  -0.00630216599398  0.0815228445157
+ -4.21449004464e-05  -0.00011045968311  -0.0146628954127  0.0810244851021
+ 19800000000
+ 0.0814305468447
+ -0.0147363847861  0.0819313950903
+ -0.000111015208012  -0.00633375414107  0.0819313950903
+ -4.23606860466e-05  -0.000111015208012  -0.0147363847861  0.0814305468447
+ 19900000000
+ 0.0818365556884
+ -0.0148098646114  0.0823398923961
+ -0.000111570670678  -0.00636533819524  0.0823398923961
+ -4.25764673468e-05  -0.000111570670678  -0.0148098646114  0.0818365556884
+ 20000000000
+ 0.0822425116331
+ -0.0148833348884  0.0827483364334
+ -0.000112126071058  -0.00639691815637  0.0827483364334
+ -4.27922442318e-05  -0.000112126071058  -0.0148833348884  0.0822425116331
+ 20100000000
+ 0.0826484146787
+ -0.014956795617  0.0831567272024
+ -0.000112681409103  -0.00642849402435  0.0831567272024
+ -4.30080165878e-05  -0.000112681409103  -0.014956795617  0.0826484146787
+ 20200000000
+ 0.0830542648253
+ -0.0150302467971  0.0835650647032
+ -0.000113236684767  -0.00646006579908  0.0835650647032
+ -4.32237843023e-05  -0.000113236684767  -0.0150302467971  0.0830542648253
+ 20300000000
+ 0.0834600620728
+ -0.0151036884286  0.0839733489361
+ -0.000113791898001  -0.00649163348046  0.0839733489361
+ -4.34395472635e-05  -0.000113791898001  -0.0151036884286  0.0834600620728
+ 20400000000
+ 0.0838658064213
+ -0.0151771205113  0.0843815799012
+ -0.000114347048758  -0.00652319706838  0.0843815799012
+ -4.36553053611e-05  -0.000114347048758  -0.0151771205113  0.0838658064213
+ 20500000000
+ 0.0842714978706
+ -0.0152505430452  0.0847897575987
+ -0.000114902136992  -0.00655475656274  0.0847897575987
+ -4.38710584857e-05  -0.000114902136992  -0.0152505430452  0.0842714978706
+ 20600000000
+ 0.0846771364209
+ -0.01532395603  0.085197882029
+ -0.000115457162656  -0.00658631196344  0.085197882029
+ -4.4086806529e-05  -0.000115457162656  -0.01532395603  0.0846771364209
+ 20700000000
+ 0.0850827220722
+ -0.0153973594658  0.0856059531921
+ -0.000116012125706  -0.00661786327037  0.0856059531921
+ -4.43025493837e-05  -0.000116012125706  -0.0153973594658  0.0850827220722
+ 20800000000
+ 0.0854882548244
+ -0.0154707533523  0.0860139710883
+ -0.000116567026095  -0.00664941048345  0.0860139710883
+ -4.45182869436e-05  -0.000116567026095  -0.0154707533523  0.0854882548244
+ 20900000000
+ 0.0858937346776
+ -0.0155441376895  0.0864219357178
+ -0.000117121863779  -0.00668095360258  0.0864219357178
+ -4.47340191035e-05  -0.000117121863779  -0.0155441376895  0.0858937346776
+ 21000000000
+ 0.0862991616318
+ -0.0156175124773  0.086829847081
+ -0.000117676638715  -0.00671249262766  0.086829847081
+ -4.49497457592e-05  -0.000117676638715  -0.0156175124773  0.0862991616318
+ 21100000000
+ 0.086704535687
+ -0.0156908777156  0.0872377051779
+ -0.000118231350857  -0.00674402755859  0.0872377051779
+ -4.51654668076e-05  -0.000118231350857  -0.0156908777156  0.086704535687
+ 21200000000
+ 0.0871098568434
+ -0.0157642334042  0.0876455100088
+ -0.000118786000163  -0.00677555839529  0.0876455100088
+ -4.53811821463e-05  -0.000118786000163  -0.0157642334042  0.0871098568434
+ 21300000000
+ 0.0875151251009
+ -0.0158375795431  0.088053261574
+ -0.000119340586589  -0.00680708513767  0.088053261574
+ -4.55968916743e-05  -0.000119340586589  -0.0158375795431  0.0875151251009
+ 21400000000
+ 0.0879203404595
+ -0.0159109161321  0.0884609598737
+ -0.000119895110093  -0.00683860778564  0.0884609598737
+ -4.58125952912e-05  -0.000119895110093  -0.0159109161321  0.0879203404595
+ 21500000000
+ 0.0883255029194
+ -0.0159842431712  0.0888686049082
+ -0.000120449570632  -0.0068701263391  0.0888686049082
+ -4.60282928975e-05  -0.000120449570632  -0.0159842431712  0.0883255029194
+ 21600000000
+ 0.0887306124807
+ -0.0160575606603  0.0892761966778
+ -0.000121003968166  -0.00690164079797  0.0892761966778
+ -4.62439843951e-05  -0.000121003968166  -0.0160575606603  0.0887306124807
+ 21700000000
+ 0.0891356691433
+ -0.0161308685993  0.0896837351826
+ -0.000121558302651  -0.00693315116218  0.0896837351826
+ -4.64596696862e-05  -0.000121558302651  -0.0161308685993  0.0891356691433
+ 21800000000
+ 0.0895406729074
+ -0.0162041669881  0.0900912204229
+ -0.000122112574048  -0.00696465743162  0.0900912204229
+ -4.66753486742e-05  -0.000122112574048  -0.0162041669881  0.0895406729074
+ 21900000000
+ 0.089945623773
+ -0.0162774558266  0.090498652399
+ -0.000122666782316  -0.00699615960623  0.090498652399
+ -4.68910212636e-05  -0.000122666782316  -0.0162774558266  0.089945623773
+ 22000000000
+ 0.0903505217403
+ -0.0163507351147  0.0909060311113
+ -0.000123220927414  -0.00702765768591  0.0909060311113
+ -4.71066873594e-05  -0.000123220927414  -0.0163507351147  0.0903505217403
+ 22100000000
+ 0.0907553668093
+ -0.0164240048524  0.0913133565598
+ -0.000123775009303  -0.00705915167059  0.0913133565598
+ -4.73223468676e-05  -0.000123775009303  -0.0164240048524  0.0907553668093
+ 22200000000
+ 0.0911601589801
+ -0.0164972650395  0.091720628745
+ -0.000124329027943  -0.00709064156019  0.091720628745
+ -4.75379996951e-05  -0.000124329027943  -0.0164972650395  0.0911601589801
+ 22300000000
+ 0.0915648982528
+ -0.016570515676  0.0921278476671
+ -0.000124882983295  -0.00712212735464  0.0921278476671
+ -4.77536457496e-05  -0.000124882983295  -0.016570515676  0.0915648982528
+ 22400000000
+ 0.0919695846276
+ -0.0166437567617  0.0925350133265
+ -0.00012543687532  -0.00715360905384  0.0925350133265
+ -4.79692849397e-05  -0.00012543687532  -0.0166437567617  0.0919695846276
+ 22500000000
+ 0.0923742181046
+ -0.0167169882967  0.0929421257232
+ -0.000125990703979  -0.00718508665774  0.0929421257232
+ -4.81849171747e-05  -0.000125990703979  -0.0167169882967  0.0923742181046
+ 22600000000
+ 0.0927787986838
+ -0.0167902102809  0.0933491848578
+ -0.000126544469235  -0.00721656016625  0.0933491848578
+ -4.84005423648e-05  -0.000126544469235  -0.0167902102809  0.0927787986838
+ 22700000000
+ 0.0931833263654
+ -0.0168634227141  0.0937561907304
+ -0.00012709817105  -0.0072480295793  0.0937561907304
+ -4.86161604209e-05  -0.00012709817105  -0.0168634227141  0.0931833263654
+ 22800000000
+ 0.0935878011495
+ -0.0169366255963  0.0941631433414
+ -0.000127651809386  -0.00727949489683  0.0941631433414
+ -4.88317712549e-05  -0.000127651809386  -0.0169366255963  0.0935878011495
+ 22900000000
+ 0.0939922230363
+ -0.0170098189274  0.0945700426911
+ -0.000128205384207  -0.00731095611875  0.0945700426911
+ -4.90473747791e-05  -0.000128205384207  -0.0170098189274  0.0939922230363
+ 23000000000
+ 0.0943965920259
+ -0.0170830027075  0.0949768887798
+ -0.000128758895475  -0.007342413245  0.0949768887798
+ -4.9262970907e-05  -0.000128758895475  -0.0170830027075  0.0943965920259
+ 23100000000
+ 0.0948009081185
+ -0.0171561769363  0.0953836816078
+ -0.000129312343154  -0.00737386627551  0.0953836816078
+ -4.94785595525e-05  -0.000129312343154  -0.0171561769363  0.0948009081185
+ 23200000000
+ 0.0952051713142
+ -0.0172293416138  0.0957904211753
+ -0.000129865727208  -0.00740531521021  0.0957904211753
+ -4.96941406305e-05  -0.000129865727209  -0.0172293416138  0.0952051713142
+ 23300000000
+ 0.0956093816131
+ -0.01730249674  0.0961971074828
+ -0.000130419047602  -0.00743676004904  0.0961971074828
+ -4.99097140565e-05  -0.000130419047602  -0.01730249674  0.0956093816131
+ 23400000000
+ 0.0960135390154
+ -0.0173756423148  0.0966037405306
+ -0.0001309723043  -0.00746820079193  0.0966037405306
+ -5.01252797467e-05  -0.0001309723043  -0.0173756423148  0.0960135390154
+ 23500000000
+ 0.0964176435213
+ -0.0174487783382  0.0970103203189
+ -0.000131525497266  -0.00749963743882  0.0970103203189
+ -5.03408376182e-05  -0.000131525497266  -0.0174487783382  0.0964176435213
+ 23600000000
+ 0.096821695131
+ -0.0175219048101  0.0974168468481
+ -0.000132078626466  -0.00753106998964  0.0974168468481
+ -5.05563875886e-05  -0.000132078626466  -0.0175219048101  0.096821695131
+ 23700000000
+ 0.0972256938446
+ -0.0175950217304  0.0978233201186
+ -0.000132631691866  -0.00756249844432  0.0978233201186
+ -5.07719295762e-05  -0.000132631691866  -0.0175950217304  0.0972256938446
+ 23800000000
+ 0.0976296396624
+ -0.0176681290991  0.0982297401307
+ -0.00013318469343  -0.00759392280282  0.0982297401307
+ -5.09874635003e-05  -0.00013318469343  -0.0176681290991  0.0976296396624
+ 23900000000
+ 0.0980335325844
+ -0.0177412269161  0.0986361068846
+ -0.000133737631126  -0.00762534306507  0.0986361068846
+ -5.12029892805e-05  -0.000133737631126  -0.0177412269161  0.0980335325844
+ 24000000000
+ 0.0984373726109
+ -0.0178143151814  0.0990424203808
+ -0.000134290504919  -0.007656759231  0.0990424203808
+ -5.14185068372e-05  -0.000134290504919  -0.0178143151814  0.0984373726109
+ 24100000000
+ 0.0988411597421
+ -0.0178873938949  0.0994486806197
+ -0.000134843314777  -0.00768817130057  0.0994486806197
+ -5.16340160916e-05  -0.000134843314777  -0.0178873938949  0.0988411597421
+ 24200000000
+ 0.0992448939782
+ -0.0179604630566  0.0998548876015
+ -0.000135396060665  -0.00771957927371  0.0998548876015
+ -5.18495169654e-05  -0.000135396060665  -0.0179604630566  0.0992448939782
+ 24300000000
+ 0.0996485753193
+ -0.0180335226665  0.100261041327
+ -0.000135948742552  -0.00775098315036  0.100261041327
+ -5.2065009381e-05  -0.000135948742552  -0.0180335226665  0.0996485753193
+ 24400000000
+ 0.100052203766
+ -0.0181065727244  0.100667141795
+ -0.000136501360405  -0.00778238293048  0.100667141795
+ -5.22804932615e-05  -0.000136501360405  -0.0181065727244  0.100052203766
+ 24500000000
+ 0.100455779318
+ -0.0181796132304  0.101073189008
+ -0.000137053914191  -0.007813778614  0.101073189008
+ -5.24959685305e-05  -0.000137053914191  -0.0181796132304  0.100455779318
+ 24600000000
+ 0.100859301975
+ -0.0182526441844  0.101479182965
+ -0.000137606403879  -0.00784517020088  0.101479182965
+ -5.27114351124e-05  -0.000137606403879  -0.0182526441844  0.100859301975
+ 24700000000
+ 0.101262771739
+ -0.0183256655863  0.101885123667
+ -0.000138158829437  -0.00787655769106  0.101885123667
+ -5.2926892932e-05  -0.000138158829437  -0.0183256655863  0.101262771739
+ 24800000000
+ 0.101666188609
+ -0.0183986774362  0.102291011114
+ -0.000138711190833  -0.00790794108448  0.102291011114
+ -5.31423419148e-05  -0.000138711190833  -0.0183986774362  0.101666188609
+ 24900000000
+ 0.102069552585
+ -0.018471679734  0.102696845307
+ -0.000139263488036  -0.00793932038111  0.102696845307
+ -5.33577819871e-05  -0.000139263488036  -0.018471679734  0.102069552585
+ 25000000000
+ 0.102472863668
+ -0.0185446724796  0.103102626245
+ -0.000139815721016  -0.00797069558088  0.103102626245
+ -5.35732130756e-05  -0.000139815721016  -0.0185446724796  0.102472863668
+ 25100000000
+ 0.102876121858
+ -0.018617655673  0.10350835393
+ -0.000140367889742  -0.00800206668375  0.10350835393
+ -5.37886351075e-05  -0.000140367889742  -0.018617655673  0.102876121858
+ 25200000000
+ 0.103279327155
+ -0.0186906293142  0.103914028362
+ -0.000140919994183  -0.00803343368967  0.103914028362
+ -5.40040480107e-05  -0.000140919994183  -0.0186906293142  0.103279327155
+ 25300000000
+ 0.103682479559
+ -0.0187635934032  0.10431964954
+ -0.000141472034309  -0.0080647965986  0.10431964954
+ -5.42194517138e-05  -0.000141472034309  -0.0187635934032  0.103682479559
+ 25400000000
+ 0.104085579071
+ -0.0188365479399  0.104725217466
+ -0.00014202401009  -0.00809615541048  0.104725217466
+ -5.44348461458e-05  -0.00014202401009  -0.0188365479399  0.104085579071
+ 25500000000
+ 0.104488625691
+ -0.0189094929243  0.10513073214
+ -0.000142575921497  -0.00812751012527  0.10513073214
+ -5.46502312362e-05  -0.000142575921497  -0.0189094929243  0.104488625691
+ 25600000000
+ 0.104891619419
+ -0.0189824283563  0.105536193561
+ -0.0001431277685  -0.00815886074293  0.105536193561
+ -5.48656069152e-05  -0.0001431277685  -0.0189824283563  0.104891619419
+ 25700000000
+ 0.105294560255
+ -0.019055354236  0.105941601732
+ -0.00014367955107  -0.00819020726342  0.105941601732
+ -5.50809731136e-05  -0.00014367955107  -0.019055354236  0.105294560255
+ 25800000000
+ 0.1056974482
+ -0.0191282705633  0.106346956651
+ -0.000144231269179  -0.00822154968668  0.106346956651
+ -5.52963297625e-05  -0.000144231269179  -0.0191282705633  0.1056974482
+ 25900000000
+ 0.106100283254
+ -0.0192011773382  0.10675225832
+ -0.000144782922796  -0.00825288801268  0.10675225832
+ -5.55116767937e-05  -0.000144782922796  -0.0192011773382  0.106100283254
+ 26000000000
+ 0.106503065417
+ -0.0192740745607  0.107157506739
+ -0.000145334511894  -0.00828422224137  0.107157506739
+ -5.57270141396e-05  -0.000145334511894  -0.0192740745607  0.106503065417
+ 26100000000
+ 0.10690579469
+ -0.0193469622307  0.107562701908
+ -0.000145886036445  -0.00831555237272  0.107562701908
+ -5.5942341733e-05  -0.000145886036445  -0.0193469622307  0.10690579469
+ 26200000000
+ 0.107308471073
+ -0.0194198403482  0.107967843828
+ -0.00014643749642  -0.00834687840669  0.107967843828
+ -5.61576595073e-05  -0.00014643749642  -0.0194198403482  0.107308471073
+ 26300000000
+ 0.107711094565
+ -0.0194927089132  0.108372932499
+ -0.000146988891792  -0.00837820034323  0.108372932499
+ -5.63729673962e-05  -0.000146988891792  -0.0194927089132  0.107711094565
+ 26400000000
+ 0.108113665168
+ -0.0195655679258  0.108777967921
+ -0.000147540222533  -0.00840951818231  0.108777967921
+ -5.65882653341e-05  -0.000147540222533  -0.0195655679258  0.108113665168
+ 26500000000
+ 0.108516182882
+ -0.0196384173858  0.109182950096
+ -0.000148091488616  -0.00844083192389  0.109182950096
+ -5.6803553256e-05  -0.000148091488616  -0.0196384173858  0.108516182882
+ 26600000000
+ 0.108918647707
+ -0.0197112572932  0.109587879022
+ -0.000148642690014  -0.00847214156794  0.109587879022
+ -5.70188310971e-05  -0.000148642690014  -0.0197112572932  0.108918647707
+ 26700000000
+ 0.109321059643
+ -0.0197840876482  0.109992754702
+ -0.000149193826699  -0.00850344711441  0.109992754702
+ -5.72340987934e-05  -0.000149193826699  -0.0197840876482  0.109321059643
+ 26800000000
+ 0.109723418691
+ -0.0198569084505  0.110397577135
+ -0.000149744898644  -0.00853474856328  0.110397577135
+ -5.74493562811e-05  -0.000149744898644  -0.0198569084505  0.109723418691
+ 26900000000
+ 0.11012572485
+ -0.0199297197003  0.110802346321
+ -0.000150295905825  -0.0085660459145  0.110802346321
+ -5.76646034971e-05  -0.000150295905825  -0.0199297197003  0.11012572485
+ 27000000000
+ 0.110527978122
+ -0.0200025213975  0.111207062261
+ -0.000150846848213  -0.00859733916805  0.111207062261
+ -5.78798403785e-05  -0.000150846848213  -0.0200025213975  0.110527978122
+ 27100000000
+ 0.110930178507
+ -0.0200753135421  0.111611724957
+ -0.000151397725783  -0.00862862832389  0.111611724957
+ -5.80950668633e-05  -0.000151397725783  -0.0200753135421  0.110930178507
+ 27200000000
+ 0.111332326004
+ -0.0201480961341  0.112016334407
+ -0.000151948538509  -0.00865991338199  0.112016334407
+ -5.83102828895e-05  -0.000151948538509  -0.0201480961341  0.111332326004
+ 27300000000
+ 0.111734420615
+ -0.0202208691734  0.112420890612
+ -0.000152499286365  -0.00869119434232  0.112420890612
+ -5.85254883959e-05  -0.000152499286365  -0.0202208691734  0.111734420615
+ 27400000000
+ 0.112136462339
+ -0.0202936326602  0.112825393574
+ -0.000153049969326  -0.00872247120485  0.112825393574
+ -5.87406833215e-05  -0.000153049969326  -0.0202936326602  0.112136462339
+ 27500000000
+ 0.112538451177
+ -0.0203663865944  0.113229843292
+ -0.000153600587367  -0.00875374396954  0.113229843292
+ -5.8955867606e-05  -0.000153600587367  -0.0203663865944  0.112538451177
+ 27600000000
+ 0.11294038713
+ -0.0204391309759  0.113634239766
+ -0.000154151140461  -0.00878501263637  0.113634239766
+ -5.91710411892e-05  -0.000154151140461  -0.0204391309759  0.11294038713
+ 27700000000
+ 0.113342270197
+ -0.0205118658048  0.114038582998
+ -0.000154701628585  -0.00881627720531  0.114038582998
+ -5.93862040118e-05  -0.000154701628585  -0.0205118658048  0.113342270197
+ 27800000000
+ 0.113744100379
+ -0.0205845910811  0.114442872988
+ -0.000155252051714  -0.00884753767634  0.114442872988
+ -5.96013560144e-05  -0.000155252051714  -0.0205845910811  0.113744100379
+ 27900000000
+ 0.114145877676
+ -0.0206573068048  0.114847109736
+ -0.000155802409822  -0.00887879404941  0.114847109736
+ -5.98164971385e-05  -0.000155802409822  -0.0206573068048  0.114145877676
+ 28000000000
+ 0.114547602089
+ -0.0207300129759  0.115251293243
+ -0.000156352702886  -0.00891004632452  0.115251293243
+ -6.00316273257e-05  -0.000156352702886  -0.0207300129759  0.114547602089
+ 28100000000
+ 0.114949273618
+ -0.0208027095943  0.115655423509
+ -0.000156902930881  -0.00894129450163  0.115655423509
+ -6.02467465183e-05  -0.000156902930881  -0.0208027095943  0.114949273618
+ 28200000000
+ 0.115350892263
+ -0.0208753966602  0.116059500534
+ -0.000157453093784  -0.00897253858071  0.116059500534
+ -6.04618546587e-05  -0.000157453093784  -0.0208753966602  0.115350892263
+ 28300000000
+ 0.115752458025
+ -0.0209480741734  0.11646352432
+ -0.00015800319157  -0.00900377856174  0.11646352432
+ -6.06769516899e-05  -0.00015800319157  -0.0209480741734  0.115752458025
+ 28400000000
+ 0.116153970905
+ -0.0210207421341  0.116867494866
+ -0.000158553224216  -0.00903501444471  0.116867494866
+ -6.08920375553e-05  -0.000158553224216  -0.0210207421341  0.116153970905
+ 28500000000
+ 0.116555430901
+ -0.0210934005421  0.117271412174
+ -0.000159103191698  -0.00906624622958  0.117271412174
+ -6.11071121986e-05  -0.000159103191698  -0.0210934005421  0.116555430901
+ 28600000000
+ 0.116956838016
+ -0.0211660493976  0.117675276243
+ -0.000159653093993  -0.00909747391633  0.117675276243
+ -6.13221755641e-05  -0.000159653093993  -0.0211660493976  0.116956838016
+ 28700000000
+ 0.117358192249
+ -0.0212386887005  0.118079087074
+ -0.000160202931078  -0.00912869750494  0.118079087074
+ -6.15372275962e-05  -0.000160202931078  -0.0212386887005  0.117358192249
+ 28800000000
+ 0.117759493601
+ -0.0213113184508  0.118482844668
+ -0.00016075270293  -0.00915991699539  0.118482844668
+ -6.175226824e-05  -0.00016075270293  -0.0213113184508  0.117759493601
+ 28900000000
+ 0.118160742072
+ -0.0213839386486  0.118886549025
+ -0.000161302409526  -0.00919113238766  0.118886549025
+ -6.19672974408e-05  -0.000161302409526  -0.0213839386486  0.118160742072
+ 29000000000
+ 0.118561937662
+ -0.0214565492939  0.119290200145
+ -0.000161852050843  -0.00922234368173  0.119290200145
+ -6.21823151443e-05  -0.000161852050843  -0.0214565492939  0.118561937662
+ 29100000000
+ 0.118963080372
+ -0.0215291503866  0.11969379803
+ -0.000162401626859  -0.00925355087758  0.11969379803
+ -6.23973212965e-05  -0.000162401626859  -0.0215291503866  0.118963080372
+ 29200000000
+ 0.119364170202
+ -0.0216017419268  0.120097342679
+ -0.000162951137551  -0.00928475397518  0.120097342679
+ -6.2612315844e-05  -0.000162951137551  -0.0216017419268  0.119364170202
+ 29300000000
+ 0.119765207153
+ -0.0216743239146  0.120500834093
+ -0.000163500582898  -0.00931595297454  0.120500834093
+ -6.28272987335e-05  -0.000163500582898  -0.0216743239146  0.119765207153
+ 29400000000
+ 0.120166191225
+ -0.0217468963498  0.120904272273
+ -0.000164049962877  -0.00934714787561  0.120904272273
+ -6.30422699124e-05  -0.000164049962877  -0.0217468963498  0.120166191225
+ 29500000000
+ 0.120567122418
+ -0.0218194592326  0.121307657219
+ -0.000164599277467  -0.0093783386784  0.121307657219
+ -6.32572293281e-05  -0.000164599277467  -0.0218194592326  0.120567122418
+ 29600000000
+ 0.120968000734
+ -0.021892012563  0.121710988931
+ -0.000165148526646  -0.00940952538287  0.121710988931
+ -6.34721769285e-05  -0.000165148526646  -0.021892012563  0.120968000734
+ 29700000000
+ 0.121368826171
+ -0.021964556341  0.122114267411
+ -0.000165697710392  -0.00944070798902  0.122114267411
+ -6.36871126619e-05  -0.000165697710392  -0.021964556341  0.121368826171
+ 29800000000
+ 0.121769598732
+ -0.0220370905665  0.122517492659
+ -0.000166246828684  -0.00947188649684  0.122517492659
+ -6.3902036477e-05  -0.000166246828684  -0.0220370905665  0.121769598732
+ 29900000000
+ 0.122170318416
+ -0.0221096152397  0.122920664675
+ -0.000166795881501  -0.00950306090629  0.122920664675
+ -6.41169483228e-05  -0.000166795881501  -0.0221096152397  0.122170318416
+ 30000000000
+ 0.122570985223
+ -0.0221821303605  0.123323783459
+ -0.000167344868821  -0.00953423121739  0.123323783459
+ -6.43318481484e-05  -0.000167344868821  -0.0221821303605  0.122570985223
+ 30100000000
+ 0.122971599154
+ -0.0222546359291  0.123726849013
+ -0.000167893790624  -0.0095653974301  0.123726849013
+ -6.45467359037e-05  -0.000167893790624  -0.0222546359291  0.122971599154
+ 30200000000
+ 0.12337216021
+ -0.0223271319453  0.124129861337
+ -0.000168442646889  -0.00959655954441  0.124129861337
+ -6.47616115385e-05  -0.000168442646889  -0.0223271319453  0.12337216021
+ 30300000000
+ 0.12377266839
+ -0.0223996184092  0.124532820431
+ -0.000168991437595  -0.00962771756033  0.124532820431
+ -6.49764750032e-05  -0.000168991437595  -0.0223996184092  0.12377266839
+ 30400000000
+ 0.124173123696
+ -0.0224720953209  0.124935726296
+ -0.000169540162722  -0.00965887147782  0.124935726296
+ -6.51913262485e-05  -0.000169540162722  -0.0224720953209  0.124173123696
+ 30500000000
+ 0.124573526128
+ -0.0225445626804  0.125338578932
+ -0.000170088822249  -0.00969002129689  0.125338578932
+ -6.54061652254e-05  -0.000170088822249  -0.0225445626804  0.124573526128
+ 30600000000
+ 0.124973875686
+ -0.0226170204877  0.125741378341
+ -0.000170637416157  -0.00972116701751  0.125741378341
+ -6.5620991885e-05  -0.000170637416157  -0.0226170204877  0.124973875686
+ 30700000000
+ 0.125374172371
+ -0.0226894687428  0.126144124522
+ -0.000171185944424  -0.00975230863969  0.126144124522
+ -6.58358061792e-05  -0.000171185944424  -0.0226894687428  0.125374172371
+ 30800000000
+ 0.125774416183
+ -0.0227619074458  0.126546817476
+ -0.000171734407032  -0.00978344616341  0.126546817476
+ -6.60506080597e-05  -0.000171734407032  -0.0227619074458  0.125774416183
+ 30900000000
+ 0.126174607122
+ -0.0228343365967  0.126949457204
+ -0.000172282803961  -0.00981457958866  0.126949457204
+ -6.6265397479e-05  -0.000172282803961  -0.0228343365967  0.126174607122
+ 31000000000
+ 0.12657474519
+ -0.0229067561956  0.127352043706
+ -0.00017283113519  -0.00984570891544  0.127352043706
+ -6.64801743895e-05  -0.00017283113519  -0.0229067561956  0.12657474519
+ 31100000000
+ 0.126974830386
+ -0.0229791662424  0.127754576983
+ -0.0001733794007  -0.00987683414373  0.127754576983
+ -6.66949387441e-05  -0.0001733794007  -0.0229791662424  0.126974830386
+ 31200000000
+ 0.127374862711
+ -0.0230515667372  0.128157057035
+ -0.000173927600473  -0.00990795527354  0.128157057035
+ -6.6909690496e-05  -0.000173927600473  -0.0230515667372  0.127374862711
+ 31300000000
+ 0.127774842166
+ -0.0231239576801  0.128559483863
+ -0.000174475734487  -0.00993907230484  0.128559483863
+ -6.71244295987e-05  -0.000174475734487  -0.0231239576801  0.127774842166
+ 31400000000
+ 0.128174768751
+ -0.023196339071  0.128961857468
+ -0.000175023802726  -0.00997018523765  0.128961857468
+ -6.7339156006e-05  -0.000175023802726  -0.023196339071  0.128174768751
+ 31500000000
+ 0.128574642466
+ -0.02326871091  0.129364177849
+ -0.000175571805169  -0.0100012940719  0.129364177849
+ -6.75538696719e-05  -0.000175571805169  -0.02326871091  0.128574642466
+ 31600000000
+ 0.128974463312
+ -0.0233410731972  0.129766445008
+ -0.000176119741797  -0.0100323988077  0.129766445008
+ -6.77685705509e-05  -0.000176119741797  -0.0233410731972  0.128974463312
+ 31700000000
+ 0.12937423129
+ -0.0234134259326  0.130168658946
+ -0.000176667612593  -0.010063499445  0.130168658946
+ -6.79832585976e-05  -0.000176667612593  -0.0234134259326  0.12937423129
+ 31800000000
+ 0.129773946399
+ -0.0234857691163  0.130570819662
+ -0.000177215417536  -0.0100945959837  0.130570819662
+ -6.81979337669e-05  -0.000177215417536  -0.0234857691163  0.129773946399
+ 31900000000
+ 0.130173608641
+ -0.0235581027481  0.130972927158
+ -0.00017776315661  -0.0101256884239  0.130972927158
+ -6.84125960141e-05  -0.00017776315661  -0.0235581027481  0.130173608641
+ 32000000000
+ 0.130573218016
+ -0.0236304268284  0.131374981433
+ -0.000178310829795  -0.0101567767656  0.131374981433
+ -6.86272452948e-05  -0.000178310829795  -0.0236304268284  0.130573218016
+ 32100000000
+ 0.130972774524
+ -0.0237027413569  0.131776982489
+ -0.000178858437073  -0.0101878610088  0.131776982489
+ -6.88418815646e-05  -0.000178858437073  -0.0237027413569  0.130972774524
+ 32200000000
+ 0.131372278166
+ -0.0237750463339  0.132178930327
+ -0.000179405978426  -0.0102189411534  0.132178930327
+ -6.90565047798e-05  -0.000179405978426  -0.0237750463339  0.131372278166
+ 32300000000
+ 0.131771728943
+ -0.0238473417593  0.132580824946
+ -0.000179953453837  -0.0102500171995  0.132580824946
+ -6.92711148967e-05  -0.000179953453837  -0.0238473417593  0.131771728943
+ 32400000000
+ 0.132171126854
+ -0.0239196276332  0.132982666347
+ -0.000180500863286  -0.010281089147  0.132982666347
+ -6.94857118718e-05  -0.000180500863286  -0.0239196276332  0.132171126854
+ 32500000000
+ 0.132570471901
+ -0.0239919039557  0.133384454531
+ -0.000181048206758  -0.0103121569961  0.133384454531
+ -6.97002956622e-05  -0.000181048206758  -0.0239919039557  0.132570471901
+ 32600000000
+ 0.132969764084
+ -0.0240641707267  0.133786189499
+ -0.000181595484232  -0.0103432207465  0.133786189499
+ -6.99148662249e-05  -0.000181595484232  -0.0240641707267  0.132969764084
+ 32700000000
+ 0.133369003403
+ -0.0241364279463  0.134187871251
+ -0.000182142695694  -0.0103742803985  0.134187871251
+ -7.01294235174e-05  -0.000182142695694  -0.0241364279463  0.133369003403
+ 32800000000
+ 0.133768189859
+ -0.0242086756147  0.134589499787
+ -0.000182689841124  -0.0104053359519  0.134589499787
+ -7.03439674974e-05  -0.000182689841124  -0.0242086756147  0.133768189859
+ 32900000000
+ 0.134167323453
+ -0.0242809137318  0.134991075109
+ -0.000183236920506  -0.0104363874068  0.134991075109
+ -7.05584981228e-05  -0.000183236920506  -0.0242809137318  0.134167323453
+ 33000000000
+ 0.134566404185
+ -0.0243531422976  0.135392597217
+ -0.000183783933822  -0.0104674347631  0.135392597217
+ -7.0773015352e-05  -0.000183783933822  -0.0243531422976  0.134566404185
+ 33100000000
+ 0.134965432056
+ -0.0244253613123  0.135794066112
+ -0.000184330881055  -0.0104984780209  0.135794066112
+ -7.09875191432e-05  -0.000184330881055  -0.0244253613123  0.134965432056
+ 33200000000
+ 0.135364407065
+ -0.0244975707759  0.136195481793
+ -0.000184877762189  -0.0105295171802  0.136195481793
+ -7.12020094553e-05  -0.000184877762189  -0.0244975707759  0.135364407065
+ 33300000000
+ 0.135763329214
+ -0.0245697706884  0.136596844263
+ -0.000185424577207  -0.010560552241  0.136596844263
+ -7.14164862473e-05  -0.000185424577207  -0.0245697706884  0.135763329214
+ 33400000000
+ 0.136162198504
+ -0.0246419610498  0.136998153521
+ -0.000185971326091  -0.0105915832032  0.136998153521
+ -7.16309494783e-05  -0.000185971326091  -0.0246419610498  0.136162198504
+ 33500000000
+ 0.136561014934
+ -0.0247141418604  0.137399409567
+ -0.000186518008825  -0.010622610067  0.137399409567
+ -7.18453991078e-05  -0.000186518008825  -0.0247141418604  0.136561014934
+ 33600000000
+ 0.136959778506
+ -0.02478631312  0.137800612404
+ -0.000187064625394  -0.0106536328322  0.137800612404
+ -7.20598350956e-05  -0.000187064625394  -0.02478631312  0.136959778506
+ 33700000000
+ 0.137358489219
+ -0.0248584748288  0.138201762031
+ -0.000187611175779  -0.0106846514989  0.138201762031
+ -7.22742574015e-05  -0.000187611175779  -0.0248584748288  0.137358489219
+ 33800000000
+ 0.137757147075
+ -0.0249306269868  0.138602858449
+ -0.000188157659965  -0.0107156660671  0.138602858449
+ -7.24886659859e-05  -0.000188157659965  -0.0249306269868  0.137757147075
+ 33900000000
+ 0.138155752073
+ -0.0250027695941  0.139003901658
+ -0.000188704077937  -0.0107466765368  0.139003901658
+ -7.27030608091e-05  -0.000188704077937  -0.0250027695941  0.138155752073
+ 34000000000
+ 0.138554304215
+ -0.0250749026507  0.13940489166
+ -0.000189250429676  -0.0107776829081  0.13940489166
+ -7.29174418318e-05  -0.000189250429676  -0.0250749026507  0.138554304215
+ 34100000000
+ 0.138952803502
+ -0.0251470261567  0.139805828454
+ -0.000189796715169  -0.0108086851808  0.139805828454
+ -7.31318090149e-05  -0.000189796715169  -0.0251470261567  0.138952803502
+ 34200000000
+ 0.139351249933
+ -0.0252191401122  0.140206712043
+ -0.000190342934398  -0.0108396833551  0.140206712043
+ -7.33461623195e-05  -0.000190342934398  -0.0252191401122  0.139351249933
+ 34300000000
+ 0.139749643509
+ -0.0252912445172  0.140607542425
+ -0.000190889087348  -0.010870677431  0.140607542425
+ -7.3560501707e-05  -0.000190889087348  -0.0252912445172  0.139749643509
+ 34400000000
+ 0.14014798423
+ -0.0253633393717  0.141008319602
+ -0.000191435174004  -0.0109016674083  0.141008319602
+ -7.3774827139e-05  -0.000191435174004  -0.0253633393717  0.14014798423
+ 34500000000
+ 0.140546272099
+ -0.0254354246759  0.141409043574
+ -0.000191981194349  -0.0109326532873  0.141409043574
+ -7.39891385774e-05  -0.000191981194349  -0.0254354246759  0.140546272099
+ 34600000000
+ 0.140944507114
+ -0.0255075004297  0.141809714343
+ -0.000192527148368  -0.0109636350677  0.141809714343
+ -7.42034359841e-05  -0.000192527148368  -0.0255075004297  0.140944507114
+ 34700000000
+ 0.141342689276
+ -0.0255795666334  0.142210331908
+ -0.000193073036046  -0.0109946127498  0.142210331908
+ -7.44177193214e-05  -0.000193073036046  -0.0255795666334  0.141342689276
+ 34800000000
+ 0.141740818587
+ -0.0256516232868  0.142610896271
+ -0.000193618857368  -0.0110255863334  0.142610896271
+ -7.46319885518e-05  -0.000193618857368  -0.0256516232868  0.141740818587
+ 34900000000
+ 0.142138895046
+ -0.0257236703902  0.143011407431
+ -0.000194164612318  -0.0110565558187  0.143011407431
+ -7.48462436381e-05  -0.000194164612318  -0.0257236703902  0.142138895046
+ 35000000000
+ 0.142536918655
+ -0.0257957079435  0.143411865391
+ -0.000194710300881  -0.0110875212055  0.143411865391
+ -7.5060484543e-05  -0.000194710300881  -0.0257957079435  0.142536918655
+ 35100000000
+ 0.142934889413
+ -0.0258677359468  0.14381227015
+ -0.000195255923042  -0.011118482494  0.14381227015
+ -7.52747112299e-05  -0.000195255923042  -0.0258677359468  0.142934889413
+ 35200000000
+ 0.143332807322
+ -0.0259397544003  0.144212621709
+ -0.000195801478786  -0.0111494396841  0.144212621709
+ -7.54889236619e-05  -0.000195801478786  -0.0259397544003  0.143332807322
+ 35300000000
+ 0.143730672382
+ -0.0260117633039  0.144612920069
+ -0.000196346968099  -0.0111803927758  0.144612920069
+ -7.57031218027e-05  -0.000196346968099  -0.0260117633039  0.143730672382
+ 35400000000
+ 0.144128484594
+ -0.0260837626577  0.14501316523
+ -0.000196892390966  -0.0112113417692  0.14501316523
+ -7.59173056161e-05  -0.000196892390966  -0.0260837626577  0.144128484594
+ 35500000000
+ 0.144526243958
+ -0.0261557524619  0.145413357193
+ -0.000197437747371  -0.0112422866642  0.145413357193
+ -7.61314750659e-05  -0.000197437747371  -0.0261557524619  0.144526243958
+ 35600000000
+ 0.144923950474
+ -0.0262277327164  0.145813495959
+ -0.000197983037302  -0.0112732274609  0.145813495959
+ -7.63456301164e-05  -0.000197983037302  -0.0262277327164  0.144923950474
+ 35700000000
+ 0.145321604145
+ -0.0262997034213  0.146213581528
+ -0.000198528260742  -0.0113041641593  0.146213581528
+ -7.6559770732e-05  -0.000198528260742  -0.0262997034213  0.145321604145
+ 35800000000
+ 0.145719204969
+ -0.0263716645768  0.146613613902
+ -0.000199073417677  -0.0113350967594  0.146613613902
+ -7.67738968773e-05  -0.000199073417677  -0.0263716645768  0.145719204969
+ 35900000000
+ 0.146116752948
+ -0.0264436161829  0.147013593081
+ -0.000199618508095  -0.0113660252613  0.147013593081
+ -7.69880085169e-05  -0.000199618508095  -0.0264436161829  0.146116752948
+ 36000000000
+ 0.146514248082
+ -0.0265155582396  0.147413519065
+ -0.000200163531979  -0.0113969496649  0.147413519065
+ -7.7202105616e-05  -0.000200163531979  -0.0265155582396  0.146514248082
+ 36100000000
+ 0.146911690372
+ -0.0265874907471  0.147813391855
+ -0.000200708489316  -0.0114278699702  0.147813391855
+ -7.74161881397e-05  -0.000200708489316  -0.0265874907471  0.146911690372
+ 36200000000
+ 0.147309079819
+ -0.0266594137053  0.148213211452
+ -0.000201253380093  -0.0114587861773  0.148213211452
+ -7.76302560534e-05  -0.000201253380093  -0.0266594137053  0.147309079819
+ 36300000000
+ 0.147706416423
+ -0.0267313271145  0.148612977857
+ -0.000201798204294  -0.0114896982862  0.148612977857
+ -7.78443093226e-05  -0.000201798204294  -0.0267313271145  0.147706416423
+ 36400000000
+ 0.148103700184
+ -0.0268032309747  0.14901269107
+ -0.000202342961907  -0.0115206062969  0.14901269107
+ -7.8058347913e-05  -0.000202342961907  -0.0268032309747  0.148103700184
+ 36500000000
+ 0.148500931105
+ -0.0268751252859  0.149412351092
+ -0.000202887652917  -0.0115515102094  0.149412351092
+ -7.82723717908e-05  -0.000202887652917  -0.0268751252859  0.148500931105
+ 36600000000
+ 0.148898109184
+ -0.0269470100482  0.149811957923
+ -0.000203432277311  -0.0115824100237  0.149811957923
+ -7.84863809219e-05  -0.000203432277311  -0.0269470100482  0.148898109184
+ 36700000000
+ 0.149295234423
+ -0.0270188852617  0.150211511566
+ -0.000203976835076  -0.0116133057399  0.150211511566
+ -7.87003752728e-05  -0.000203976835076  -0.0270188852617  0.149295234423
+ 36800000000
+ 0.149692306822
+ -0.0270907509265  0.150611012019
+ -0.000204521326196  -0.011644197358  0.150611012019
+ -7.89143548099e-05  -0.000204521326196  -0.0270907509265  0.149692306822
+ 36900000000
+ 0.150089326382
+ -0.0271626070426  0.151010459284
+ -0.000205065750661  -0.011675084878  0.151010459284
+ -7.91283195e-05  -0.000205065750661  -0.0271626070426  0.150089326382
+ 37000000000
+ 0.150486293104
+ -0.0272344536102  0.151409853362
+ -0.000205610108455  -0.0117059682998  0.151409853362
+ -7.93422693098e-05  -0.000205610108455  -0.0272344536102  0.150486293104
+ 37100000000
+ 0.150883206988
+ -0.0273062906294  0.151809194253
+ -0.000206154399565  -0.0117368476236  0.151809194253
+ -7.95562042066e-05  -0.000206154399565  -0.0273062906294  0.150883206988
+ 37200000000
+ 0.151280068035
+ -0.0273781181001  0.152208481957
+ -0.000206698623979  -0.0117677228494  0.152208481957
+ -7.97701241574e-05  -0.000206698623979  -0.0273781181001  0.151280068035
+ 37300000000
+ 0.151676876246
+ -0.0274499360225  0.152607716477
+ -0.000207242781684  -0.0117985939771  0.152607716477
+ -7.99840291299e-05  -0.000207242781684  -0.0274499360225  0.151676876246
+ 37400000000
+ 0.152073631621
+ -0.0275217443967  0.153006897812
+ -0.000207786872665  -0.0118294610068  0.153006897812
+ -8.01979190914e-05  -0.000207786872665  -0.0275217443967  0.152073631621
+ 37500000000
+ 0.152470334161
+ -0.0275935432228  0.153406025963
+ -0.000208330896911  -0.0118603239386  0.153406025963
+ -8.04117940099e-05  -0.000208330896911  -0.0275935432228  0.152470334161
+ 37600000000
+ 0.152866983867
+ -0.0276653325008  0.153805100931
+ -0.000208874854409  -0.0118911827723  0.153805100931
+ -8.06256538533e-05  -0.000208874854409  -0.0276653325008  0.152866983867
+ 37700000000
+ 0.153263580738
+ -0.0277371122308  0.154204122717
+ -0.000209418745145  -0.0119220375081  0.154204122717
+ -8.08394985896e-05  -0.000209418745145  -0.0277371122308  0.153263580738
+ 37800000000
+ 0.153660124777
+ -0.027808882413  0.154603091321
+ -0.000209962569106  -0.011952888146  0.154603091321
+ -8.10533281873e-05  -0.000209962569106  -0.027808882413  0.153660124777
+ 37900000000
+ 0.154056615983
+ -0.0278806430473  0.155002006744
+ -0.000210506326281  -0.011983734686  0.155002006744
+ -8.12671426147e-05  -0.000210506326281  -0.0278806430473  0.154056615983
+ 38000000000
+ 0.154453054358
+ -0.027952394134  0.155400868987
+ -0.000211050016657  -0.0120145771282  0.155400868987
+ -8.14809418405e-05  -0.000211050016657  -0.027952394134  0.154453054358
+ 38100000000
+ 0.154849439901
+ -0.028024135673  0.155799678051
+ -0.000211593640221  -0.0120454154724  0.155799678051
+ -8.16947258335e-05  -0.000211593640221  -0.028024135673  0.154849439901
+ 38200000000
+ 0.155245772614
+ -0.0280958676645  0.156198433936
+ -0.00021213719696  -0.0120762497189  0.156198433936
+ -8.19084945626e-05  -0.00021213719696  -0.0280958676645  0.155245772614
+ 38300000000
+ 0.155642052497
+ -0.0281675901086  0.156597136643
+ -0.000212680686863  -0.0121070798675  0.156597136643
+ -8.2122247997e-05  -0.000212680686863  -0.0281675901086  0.155642052497
+ 38400000000
+ 0.156038279552
+ -0.0282393030053  0.156995786172
+ -0.000213224109917  -0.0121379059183  0.156995786172
+ -8.2335986106e-05  -0.000213224109917  -0.0282393030053  0.156038279552
+ 38500000000
+ 0.156434453778
+ -0.0283110063547  0.157394382526
+ -0.00021376746611  -0.0121687278714  0.157394382526
+ -8.25497088591e-05  -0.00021376746611  -0.0283110063547  0.156434453778
+ 38600000000
+ 0.156830575176
+ -0.028382700157  0.157792925703
+ -0.00021431075543  -0.0121995457268  0.157792925703
+ -8.27634162258e-05  -0.00021431075543  -0.028382700157  0.156830575176
+ 38700000000
+ 0.157226643747
+ -0.0284543844122  0.158191415706
+ -0.000214853977864  -0.0122303594844  0.158191415706
+ -8.29771081759e-05  -0.000214853977864  -0.0284543844122  0.157226643747
+ 38800000000
+ 0.157622659493
+ -0.0285260591205  0.158589852534
+ -0.000215397133401  -0.0122611691444  0.158589852534
+ -8.31907846795e-05  -0.000215397133401  -0.0285260591205  0.157622659493
+ 38900000000
+ 0.158018622412
+ -0.0285977242818  0.158988236189
+ -0.000215940222028  -0.0122919747067  0.158988236189
+ -8.34044457065e-05  -0.000215940222028  -0.0285977242818  0.158018622412
+ 39000000000
+ 0.158414532507
+ -0.0286693798963  0.159386566672
+ -0.000216483243735  -0.0123227761714  0.159386566672
+ -8.36180912272e-05  -0.000216483243735  -0.0286693798963  0.158414532507
+ 39100000000
+ 0.158810389777
+ -0.0287410259642  0.159784843982
+ -0.000217026198508  -0.0123535735385  0.159784843982
+ -8.38317212121e-05  -0.000217026198508  -0.0287410259642  0.158810389777
+ 39200000000
+ 0.159206194225
+ -0.0288126624855  0.160183068122
+ -0.000217569086337  -0.012384366808  0.160183068122
+ -8.40453356317e-05  -0.000217569086337  -0.0288126624855  0.159206194225
+ 39300000000
+ 0.159601945849
+ -0.0288842894602  0.160581239091
+ -0.00021811190721  -0.01241515598  0.160581239091
+ -8.42589344567e-05  -0.00021811190721  -0.0288842894602  0.159601945849
+ 39400000000
+ 0.159997644651
+ -0.0289559068885  0.16097935689
+ -0.000218654661114  -0.0124459410544  0.16097935689
+ -8.44725176579e-05  -0.000218654661114  -0.0289559068885  0.159997644651
+ 39500000000
+ 0.160393290633
+ -0.0290275147706  0.161377421521
+ -0.000219197348039  -0.0124767220314  0.161377421521
+ -8.46860852065e-05  -0.000219197348039  -0.0290275147706  0.160393290633
+ 39600000000
+ 0.160788883793
+ -0.0290991131064  0.161775432984
+ -0.000219739967974  -0.0125074989109  0.161775432984
+ -8.48996370735e-05  -0.000219739967974  -0.0290991131064  0.160788883793
+ 39700000000
+ 0.161184424134
+ -0.0291707018961  0.162173391279
+ -0.000220282520906  -0.012538271693  0.162173391279
+ -8.51131732303e-05  -0.000220282520906  -0.0291707018961  0.161184424134
+ 39800000000
+ 0.161579911655
+ -0.0292422811398  0.162571296408
+ -0.000220825006824  -0.0125690403776  0.162571296408
+ -8.53266936483e-05  -0.000220825006824  -0.0292422811398  0.161579911655
+ 39900000000
+ 0.161975346358
+ -0.0293138508376  0.162969148372
+ -0.000221367425718  -0.0125998049649  0.162969148372
+ -8.55401982992e-05  -0.000221367425718  -0.0293138508376  0.161975346358
+ 40000000000
+ 0.162370728244
+ -0.0293854109896  0.16336694717
+ -0.000221909777576  -0.0126305654549  0.16336694717
+ -8.57536871546e-05  -0.000221909777576  -0.0293854109896  0.162370728244
+ 40100000000
+ 0.162766057312
+ -0.0294569615958  0.163764692804
+ -0.000222452062387  -0.0126613218475  0.163764692804
+ -8.59671601866e-05  -0.000222452062387  -0.0294569615958  0.162766057312
+ 40200000000
+ 0.163161333564
+ -0.0295285026565  0.164162385275
+ -0.000222994280139  -0.0126920741428  0.164162385275
+ -8.6180617367e-05  -0.000222994280139  -0.0295285026565  0.163161333564
+ 40300000000
+ 0.163556557001
+ -0.0296000341716  0.164560024584
+ -0.000223536430822  -0.0127228223409  0.164560024584
+ -8.63940586682e-05  -0.000223536430822  -0.0296000341716  0.163556557001
+ 40400000000
+ 0.163951727623
+ -0.0296715561414  0.164957610731
+ -0.000224078514425  -0.0127535664418  0.164957610731
+ -8.66074840624e-05  -0.000224078514425  -0.0296715561414  0.163951727623
+ 40500000000
+ 0.164346845431
+ -0.0297430685659  0.165355143717
+ -0.000224620530937  -0.0127843064455  0.165355143717
+ -8.68208935221e-05  -0.000224620530937  -0.0297430685659  0.164346845431
+ 40600000000
+ 0.164741910426
+ -0.0298145714451  0.165752623542
+ -0.000225162480348  -0.012815042352  0.165752623542
+ -8.70342870198e-05  -0.000225162480348  -0.0298145714451  0.164741910426
+ 40700000000
+ 0.165136922608
+ -0.0298860647793  0.166150050209
+ -0.000225704362645  -0.0128457741615  0.166150050209
+ -8.72476645284e-05  -0.000225704362645  -0.0298860647793  0.165136922608
+ 40800000000
+ 0.165531881978
+ -0.0299575485685  0.166547423717
+ -0.00022624617782  -0.0128765018738  0.166547423717
+ -8.74610260206e-05  -0.00022624617782  -0.0299575485685  0.165531881978
+ 40900000000
+ 0.165926788538
+ -0.0300290228129  0.166944744067
+ -0.00022678792586  -0.012907225489  0.166944744067
+ -8.76743714696e-05  -0.00022678792586  -0.0300290228129  0.165926788538
+ 41000000000
+ 0.166321642287
+ -0.0301004875124  0.167342011261
+ -0.000227329606756  -0.0129379450073  0.167342011261
+ -8.78877008484e-05  -0.000227329606756  -0.0301004875124  0.166321642287
+ 41100000000
+ 0.166716443226
+ -0.0301719426673  0.167739225298
+ -0.000227871220498  -0.0129686604285  0.167739225298
+ -8.81010141303e-05  -0.000227871220498  -0.0301719426673  0.166716443226
+ 41200000000
+ 0.167111191357
+ -0.0302433882777  0.16813638618
+ -0.000228412767073  -0.0129993717528  0.16813638618
+ -8.83143112887e-05  -0.000228412767073  -0.0302433882777  0.167111191357
+ 41300000000
+ 0.16750588668
+ -0.0303148243436  0.168533493908
+ -0.000228954246473  -0.0130300789802  0.168533493908
+ -8.85275922972e-05  -0.000228954246473  -0.0303148243436  0.16750588668
+ 41400000000
+ 0.167900529196
+ -0.0303862508652  0.168930548482
+ -0.000229495658687  -0.0130607821106  0.168930548482
+ -8.87408571295e-05  -0.000229495658687  -0.0303862508652  0.167900529196
+ 41500000000
+ 0.168295118905
+ -0.0304576678426  0.169327549903
+ -0.000230037003704  -0.0130914811443  0.169327549903
+ -8.89541057593e-05  -0.000230037003704  -0.0304576678426  0.168295118905
+ 41600000000
+ 0.168689655809
+ -0.0305290752758  0.169724498172
+ -0.000230578281515  -0.0131221760811  0.169724498172
+ -8.91673381605e-05  -0.000230578281515  -0.0305290752758  0.168689655809
+ 41700000000
+ 0.169084139907
+ -0.0306004731651  0.170121393291
+ -0.000231119492109  -0.0131528669211  0.170121393291
+ -8.93805543073e-05  -0.000231119492109  -0.0306004731651  0.169084139907
+ 41800000000
+ 0.169478571202
+ -0.0306718615105  0.170518235259
+ -0.000231660635476  -0.0131835536644  0.170518235259
+ -8.95937541738e-05  -0.000231660635476  -0.0306718615105  0.169478571202
+ 41900000000
+ 0.169872949693
+ -0.0307432403121  0.170915024077
+ -0.000232201711606  -0.0132142363109  0.170915024077
+ -8.98069377343e-05  -0.000232201711606  -0.0307432403121  0.169872949693
+ 42000000000
+ 0.170267275381
+ -0.03081460957  0.171311759747
+ -0.00023274272049  -0.0132449148608  0.171311759747
+ -9.00201049633e-05  -0.00023274272049  -0.03081460957  0.170267275381
+ 42100000000
+ 0.170661548268
+ -0.0308859692844  0.171708442269
+ -0.000233283662116  -0.0132755893141  0.171708442269
+ -9.02332558352e-05  -0.000233283662116  -0.0308859692844  0.170661548268
+ 42200000000
+ 0.171055768354
+ -0.0309573194554  0.172105071644
+ -0.000233824536476  -0.0133062596707  0.172105071644
+ -9.04463903249e-05  -0.000233824536476  -0.0309573194554  0.171055768354
+ 42300000000
+ 0.17144993564
+ -0.031028660083  0.172501647873
+ -0.000234365343559  -0.0133369259308  0.172501647873
+ -9.06595084071e-05  -0.000234365343559  -0.031028660083  0.17144993564
+ 42400000000
+ 0.171844050126
+ -0.0310999911675  0.172898170956
+ -0.000234906083356  -0.0133675880944  0.172898170956
+ -9.08726100567e-05  -0.000234906083356  -0.0310999911675  0.171844050126
+ 42500000000
+ 0.172238111813
+ -0.0311713127088  0.173294640895
+ -0.000235446755856  -0.0133982461614  0.173294640895
+ -9.10856952489e-05  -0.000235446755856  -0.0311713127088  0.172238111813
+ 42600000000
+ 0.172632120703
+ -0.0312426247072  0.173691057691
+ -0.000235987361052  -0.0134289001321  0.173691057691
+ -9.12987639586e-05  -0.000235987361052  -0.0312426247072  0.172632120703
+ 42700000000
+ 0.173026076795
+ -0.0313139271628  0.174087421344
+ -0.000236527898931  -0.0134595500063  0.174087421344
+ -9.15118161613e-05  -0.000236527898931  -0.0313139271628  0.173026076795
+ 42800000000
+ 0.173419980092
+ -0.0313852200756  0.174483731855
+ -0.000237068369486  -0.0134901957841  0.174483731855
+ -9.17248518324e-05  -0.000237068369486  -0.0313852200756  0.173419980092
+ 42900000000
+ 0.173813830593
+ -0.0314565034458  0.174879989225
+ -0.000237608772707  -0.0135208374656  0.174879989225
+ -9.19378709473e-05  -0.000237608772707  -0.0314565034458  0.173813830593
+ 43000000000
+ 0.174207628299
+ -0.0315277772736  0.175276193455
+ -0.000238149108584  -0.0135514750509  0.175276193455
+ -9.21508734818e-05  -0.000238149108584  -0.0315277772736  0.174207628299
+ 43100000000
+ 0.174601373212
+ -0.0315990415589  0.175672344545
+ -0.000238689377108  -0.0135821085398  0.175672344545
+ -9.23638594115e-05  -0.000238689377108  -0.0315990415589  0.174601373212
+ 43200000000
+ 0.174995065331
+ -0.031670296302  0.176068442497
+ -0.000239229578269  -0.0136127379326  0.176068442497
+ -9.25768287124e-05  -0.000239229578269  -0.031670296302  0.174995065331
+ 43300000000
+ 0.175388704658
+ -0.0317415415029  0.176464487312
+ -0.000239769712058  -0.0136433632292  0.176464487312
+ -9.27897813604e-05  -0.000239769712058  -0.0317415415029  0.175388704658
+ 43400000000
+ 0.175782291194
+ -0.0318127771619  0.17686047899
+ -0.000240309778467  -0.0136739844296  0.17686047899
+ -9.30027173316e-05  -0.000240309778467  -0.0318127771619  0.175782291194
+ 43500000000
+ 0.176175824939
+ -0.031884003279  0.177256417532
+ -0.000240849777485  -0.013704601534  0.177256417532
+ -9.32156366022e-05  -0.000240849777485  -0.031884003279  0.176175824939
+ 43600000000
+ 0.176569305895
+ -0.0319552198542  0.177652302939
+ -0.000241389709103  -0.0137352145423  0.177652302939
+ -9.34285391486e-05  -0.000241389709103  -0.0319552198542  0.176569305895
+ 43700000000
+ 0.176962734062
+ -0.0320264268879  0.178048135212
+ -0.000241929573314  -0.0137658234546  0.178048135212
+ -9.36414249473e-05  -0.000241929573314  -0.0320264268879  0.176962734062
+ 43800000000
+ 0.17735610944
+ -0.03209762438  0.178443914351
+ -0.000242469370107  -0.013796428271  0.178443914351
+ -9.38542939746e-05  -0.000242469370107  -0.03209762438  0.17735610944
+ 43900000000
+ 0.177749432032
+ -0.0321688123308  0.178839640359
+ -0.000243009099473  -0.0138270289914  0.178839640359
+ -9.40671462074e-05  -0.000243009099473  -0.0321688123308  0.177749432032
+ 44000000000
+ 0.178142701837
+ -0.0322399907402  0.179235313235
+ -0.000243548761404  -0.013857625616  0.179235313235
+ -9.42799816223e-05  -0.000243548761404  -0.0322399907402  0.178142701837
+ 44100000000
+ 0.178535918856
+ -0.0323111596086  0.17963093298
+ -0.00024408835589  -0.0138882181447  0.17963093298
+ -9.44928001963e-05  -0.00024408835589  -0.0323111596086  0.178535918856
+ 44200000000
+ 0.17892908309
+ -0.0323823189359  0.180026499596
+ -0.000244627882924  -0.0139188065776  0.180026499596
+ -9.47056019063e-05  -0.000244627882924  -0.0323823189359  0.17892908309
+ 44300000000
+ 0.179322194541
+ -0.0324534687223  0.180422013083
+ -0.000245167342495  -0.0139493909148  0.180422013083
+ -9.49183867294e-05  -0.000245167342495  -0.0324534687223  0.179322194541
+ 44400000000
+ 0.179715253209
+ -0.032524608968  0.180817473442
+ -0.000245706734596  -0.0139799711563  0.180817473442
+ -9.51311546428e-05  -0.000245706734596  -0.032524608968  0.179715253209
+ 44500000000
+ 0.180108259094
+ -0.032595739673  0.181212880674
+ -0.000246246059217  -0.0140105473021  0.181212880674
+ -9.53439056238e-05  -0.000246246059217  -0.032595739673  0.180108259094
+ 44600000000
+ 0.180501212198
+ -0.0326668608375  0.18160823478
+ -0.00024678531635  -0.0140411193523  0.18160823478
+ -9.55566396498e-05  -0.00024678531635  -0.0326668608375  0.180501212198
+ 44700000000
+ 0.180894112521
+ -0.0327379724616  0.182003535761
+ -0.000247324505987  -0.0140716873069  0.182003535761
+ -9.57693566983e-05  -0.000247324505987  -0.0327379724616  0.180894112521
+ 44800000000
+ 0.181286960065
+ -0.0328090745455  0.182398783617
+ -0.000247863628118  -0.014102251166  0.182398783617
+ -9.5982056747e-05  -0.000247863628118  -0.0328090745455  0.181286960065
+ 44900000000
+ 0.18167975483
+ -0.0328801670893  0.18279397835
+ -0.000248402682736  -0.0141328109296  0.18279397835
+ -9.61947397734e-05  -0.000248402682736  -0.0328801670893  0.18167975483
+ 45000000000
+ 0.182072496816
+ -0.0329512500931  0.18318911996
+ -0.000248941669832  -0.0141633665978  0.18318911996
+ -9.64074057556e-05  -0.000248941669832  -0.0329512500931  0.182072496816
+ 45100000000
+ 0.182465186026
+ -0.033022323557  0.183584208449
+ -0.000249480589397  -0.0141939181705  0.183584208449
+ -9.66200546712e-05  -0.000249480589397  -0.033022323557  0.182465186026
+ 45200000000
+ 0.18285782246
+ -0.0330933874812  0.183979243818
+ -0.000250019441423  -0.014224465648  0.183979243818
+ -9.68326864985e-05  -0.000250019441423  -0.0330933874812  0.18285782246
+ 45300000000
+ 0.183250406118
+ -0.0331644418658  0.184374226066
+ -0.000250558225901  -0.0142550090301  0.184374226066
+ -9.70453012155e-05  -0.000250558225901  -0.0331644418658  0.183250406118
+ 45400000000
+ 0.183642937001
+ -0.033235486711  0.184769155196
+ -0.000251096942824  -0.014285548317  0.184769155196
+ -9.72578988003e-05  -0.000251096942824  -0.033235486711  0.183642937001
+ 45500000000
+ 0.184035415111
+ -0.0333065220168  0.185164031207
+ -0.000251635592184  -0.0143160835087  0.185164031207
+ -9.74704792314e-05  -0.000251635592184  -0.0333065220168  0.184035415111
+ 45600000000
+ 0.184427840448
+ -0.0333775477835  0.185558854102
+ -0.000252174173971  -0.0143466146052  0.185558854102
+ -9.76830424872e-05  -0.000252174173971  -0.0333775477835  0.184427840448
+ 45700000000
+ 0.184820213013
+ -0.033448564011  0.18595362388
+ -0.000252712688178  -0.0143771416066  0.18595362388
+ -9.78955885461e-05  -0.000252712688178  -0.033448564011  0.184820213013
+ 45800000000
+ 0.185212532808
+ -0.0335195706997  0.186348340544
+ -0.000253251134797  -0.014407664513  0.186348340544
+ -9.81081173867e-05  -0.000253251134797  -0.0335195706997  0.185212532808
+ 45900000000
+ 0.185604799832
+ -0.0335905678496  0.186743004093
+ -0.000253789513819  -0.0144381833243  0.186743004093
+ -9.83206289878e-05  -0.000253789513819  -0.0335905678496  0.185604799832
+ 46000000000
+ 0.185997014086
+ -0.0336615554608  0.187137614528
+ -0.000254327825238  -0.0144686980407  0.187137614528
+ -9.85331233282e-05  -0.000254327825238  -0.0336615554608  0.185997014086
+ 46100000000
+ 0.186389175573
+ -0.0337325335335  0.187532171852
+ -0.000254866069044  -0.0144992086621  0.187532171852
+ -9.87456003867e-05  -0.000254866069044  -0.0337325335335  0.186389175573
+ 46200000000
+ 0.186781284291
+ -0.0338035020678  0.187926676064
+ -0.000255404245229  -0.0145297151887  0.187926676064
+ -9.89580601424e-05  -0.000255404245229  -0.0338035020678  0.186781284291
+ 46300000000
+ 0.187173340244
+ -0.0338744610639  0.188321127165
+ -0.000255942353787  -0.0145602176205  0.188321127165
+ -9.91705025742e-05  -0.000255942353787  -0.0338744610639  0.187173340244
+ 46400000000
+ 0.18756534343
+ -0.0339454105219  0.188715525157
+ -0.000256480394708  -0.0145907159575  0.188715525157
+ -9.93829276615e-05  -0.000256480394708  -0.0339454105219  0.18756534343
+ 46500000000
+ 0.187957293851
+ -0.0340163504419  0.18910987004
+ -0.000257018367986  -0.0146212101998  0.18910987004
+ -9.95953353834e-05  -0.000257018367986  -0.0340163504419  0.187957293851
+ 46600000000
+ 0.188349191509
+ -0.0340872808241  0.189504161815
+ -0.000257556273612  -0.0146517003474  0.189504161815
+ -9.98077257194e-05  -0.000257556273612  -0.0340872808241  0.188349191509
+ 46700000000
+ 0.188741036404
+ -0.0341582016686  0.189898400484
+ -0.000258094111579  -0.0146821864004  0.189898400484
+ -0.000100020098649  -0.000258094111579  -0.0341582016686  0.188741036404
+ 46800000000
+ 0.189132828536
+ -0.0342291129756  0.190292586046
+ -0.000258631881879  -0.0147126683588  0.190292586046
+ -0.000100232454151  -0.000258631881879  -0.0342291129756  0.189132828536
+ 46900000000
+ 0.189524567907
+ -0.0343000147452  0.190686718504
+ -0.000259169584505  -0.0147431462227  0.190686718504
+ -0.000100444792206  -0.000259169584505  -0.0343000147452  0.189524567907
+ 47000000000
+ 0.189916254518
+ -0.0343709069775  0.191080797858
+ -0.000259707219448  -0.0147736199921  0.191080797858
+ -0.000100657112794  -0.000259707219448  -0.0343709069775  0.189916254518
+ 47100000000
+ 0.19030788837
+ -0.0344417896727  0.191474824109
+ -0.000260244786702  -0.0148040896672  0.191474824109
+ -0.000100869415893  -0.000260244786702  -0.0344417896727  0.19030788837
+ 47200000000
+ 0.190699469462
+ -0.0345126628309  0.191868797258
+ -0.000260782286258  -0.0148345552478  0.191868797258
+ -0.000101081701485  -0.000260782286258  -0.0345126628309  0.190699469462
+ 47300000000
+ 0.191090997798
+ -0.0345835264523  0.192262717306
+ -0.00026131971811  -0.0148650167342  0.192262717306
+ -0.000101293969548  -0.00026131971811  -0.0345835264523  0.191090997798
+ 47400000000
+ 0.191482473376
+ -0.034654380537  0.192656584254
+ -0.000261857082249  -0.0148954741263  0.192656584254
+ -0.000101506220064  -0.000261857082249  -0.034654380537  0.191482473376
+ 47500000000
+ 0.191873896199
+ -0.0347252250852  0.193050398102
+ -0.000262394378669  -0.0149259274241  0.193050398102
+ -0.000101718453012  -0.000262394378669  -0.0347252250852  0.191873896199
+ 47600000000
+ 0.192265266267
+ -0.034796060097  0.193444158853
+ -0.000262931607362  -0.0149563766279  0.193444158853
+ -0.000101930668373  -0.000262931607362  -0.034796060097  0.192265266267
+ 47700000000
+ 0.192656583581
+ -0.0348668855725  0.193837866506
+ -0.000263468768321  -0.0149868217375  0.193837866506
+ -0.000102142866126  -0.000263468768321  -0.0348668855725  0.192656583581
+ 47800000000
+ 0.193047848142
+ -0.0349377015119  0.194231521063
+ -0.000264005861538  -0.0150172627531  0.194231521063
+ -0.000102355046253  -0.000264005861538  -0.0349377015119  0.193047848142
+ 47900000000
+ 0.193439059951
+ -0.0350085079153  0.194625122525
+ -0.000264542887006  -0.0150476996746  0.194625122525
+ -0.000102567208733  -0.000264542887006  -0.0350085079153  0.193439059951
+ 48000000000
+ 0.193830219009
+ -0.035079304783  0.195018670892
+ -0.000265079844719  -0.0150781325023  0.195018670892
+ -0.000102779353548  -0.000265079844719  -0.035079304783  0.193830219009
+ 48100000000
+ 0.194221325316
+ -0.0351500921149  0.195412166167
+ -0.000265616734668  -0.015108561236  0.195412166167
+ -0.000102991480678  -0.000265616734668  -0.0351500921149  0.194221325316
+ 48200000000
+ 0.194612378875
+ -0.0352208699114  0.195805608348
+ -0.000266153556848  -0.0151389858759  0.195805608348
+ -0.000103203590104  -0.000266153556848  -0.0352208699114  0.194612378875
+ 48300000000
+ 0.195003379685
+ -0.0352916381724  0.196198997439
+ -0.000266690311249  -0.0151694064221  0.196198997439
+ -0.000103415681806  -0.000266690311249  -0.0352916381724  0.195003379685
+ 48400000000
+ 0.195394327747
+ -0.0353623968983  0.196592333439
+ -0.000267226997867  -0.0151998228745  0.196592333439
+ -0.000103627755766  -0.000267226997867  -0.0353623968983  0.195394327747
+ 48500000000
+ 0.195785223063
+ -0.035433146089  0.196985616349
+ -0.000267763616693  -0.0152302352332  0.196985616349
+ -0.000103839811964  -0.000267763616693  -0.035433146089  0.195785223063
+ 48600000000
+ 0.196176065634
+ -0.0355038857449  0.197378846172
+ -0.000268300167721  -0.0152606434984  0.197378846172
+ -0.000104051850382  -0.000268300167721  -0.0355038857449  0.196176065634
+ 48700000000
+ 0.19656685546
+ -0.035574615866  0.197772022907
+ -0.000268836650943  -0.0152910476699  0.197772022907
+ -0.000104263871  -0.000268836650943  -0.035574615866  0.19656685546
+ 48800000000
+ 0.196957592542
+ -0.0356453364524  0.198165146555
+ -0.000269373066353  -0.015321447748  0.198165146555
+ -0.000104475873801  -0.000269373066353  -0.0356453364524  0.196957592542
+ 48900000000
+ 0.197348276881
+ -0.0357160475044  0.198558217118
+ -0.000269909413945  -0.0153518437326  0.198558217118
+ -0.000104687858765  -0.000269909413945  -0.0357160475044  0.197348276881
+ 49000000000
+ 0.197738908479
+ -0.0357867490221  0.198951234596
+ -0.00027044569371  -0.0153822356239  0.198951234596
+ -0.000104899825873  -0.00027044569371  -0.0357867490221  0.197738908479
+ 49100000000
+ 0.198129487336
+ -0.0358574410056  0.199344198991
+ -0.000270981905642  -0.0154126234218  0.199344198991
+ -0.000105111775108  -0.000270981905642  -0.0358574410056  0.198129487336
+ 49200000000
+ 0.198520013454
+ -0.0359281234551  0.199737110304
+ -0.000271518049736  -0.0154430071264  0.199737110304
+ -0.000105323706451  -0.000271518049736  -0.0359281234551  0.198520013454
+ 49300000000
+ 0.198910486832
+ -0.0359987963707  0.200129968535
+ -0.000272054125983  -0.0154733867378  0.200129968535
+ -0.000105535619882  -0.000272054125983  -0.0359987963707  0.198910486832
+ 49400000000
+ 0.199300907473
+ -0.0360694597527  0.200522773686
+ -0.000272590134377  -0.0155037622561  0.200522773686
+ -0.000105747515385  -0.000272590134377  -0.0360694597527  0.199300907473
+ 49500000000
+ 0.199691275376
+ -0.036140113601  0.200915525757
+ -0.000273126074911  -0.0155341336812  0.200915525757
+ -0.000105959392941  -0.000273126074911  -0.036140113601  0.199691275376
+ 49600000000
+ 0.200081590544
+ -0.036210757916  0.20130822475
+ -0.00027366194758  -0.0155645010133  0.20130822475
+ -0.000106171252532  -0.00027366194758  -0.036210757916  0.200081590544
+ 49700000000
+ 0.200471852977
+ -0.0362813926978  0.201700870666
+ -0.000274197752376  -0.0155948642525  0.201700870666
+ -0.000106383094139  -0.000274197752376  -0.0362813926978  0.200471852977
+ 49800000000
+ 0.200862062675
+ -0.0363520179464  0.202093463505
+ -0.000274733489292  -0.0156252233986  0.202093463505
+ -0.000106594917745  -0.000274733489292  -0.0363520179464  0.200862062675
+ 49900000000
+ 0.201252219641
+ -0.0364226336622  0.202486003268
+ -0.000275269158323  -0.015655578452  0.202486003268
+ -0.000106806723331  -0.000275269158323  -0.0364226336622  0.201252219641
+ 50000000000
+ 0.201642323875
+ -0.0364932398451  0.202878489958
+ -0.000275804759462  -0.0156859294125  0.202878489958
+ -0.000107018510881  -0.000275804759462  -0.0364932398451  0.201642323875
+ 50100000000
+ 0.202032375377
+ -0.0365638364955  0.203270923574
+ -0.000276340292702  -0.0157162762802  0.203270923574
+ -0.000107230280376  -0.000276340292702  -0.0365638364955  0.202032375377
+ 50200000000
+ 0.202422374149
+ -0.0366344236134  0.203663304117
+ -0.000276875758037  -0.0157466190553  0.203663304117
+ -0.000107442031798  -0.000276875758037  -0.0366344236134  0.202422374149
+ 50300000000
+ 0.202812320193
+ -0.036705001199  0.20405563159
+ -0.00027741115546  -0.0157769577377  0.20405563159
+ -0.00010765376513  -0.00027741115546  -0.036705001199  0.202812320193
+ 50400000000
+ 0.203202213508
+ -0.0367755692525  0.204447905992
+ -0.000277946484966  -0.0158072923275  0.204447905992
+ -0.000107865480354  -0.000277946484966  -0.0367755692525  0.203202213508
+ 50500000000
+ 0.203592054096
+ -0.036846127774  0.204840127325
+ -0.000278481746548  -0.0158376228249  0.204840127325
+ -0.000108077177453  -0.000278481746548  -0.036846127774  0.203592054096
+ 50600000000
+ 0.203981841958
+ -0.0369166767636  0.20523229559
+ -0.000279016940199  -0.0158679492298  0.20523229559
+ -0.00010828885641  -0.000279016940199  -0.0369166767636  0.203981841958
+ 50700000000
+ 0.204371577094
+ -0.0369872162217  0.205624410787
+ -0.000279552065913  -0.0158982715423  0.205624410787
+ -0.000108500517207  -0.000279552065913  -0.0369872162217  0.204371577094
+ 50800000000
+ 0.204761259507
+ -0.0370577461482  0.206016472919
+ -0.000280087123685  -0.0159285897624  0.206016472919
+ -0.000108712159826  -0.000280087123685  -0.0370577461482  0.204761259507
+ 50900000000
+ 0.205150889196
+ -0.0371282665434  0.206408481985
+ -0.000280622113508  -0.0159589038903  0.206408481985
+ -0.000108923784252  -0.000280622113508  -0.0371282665434  0.205150889196
+ 51000000000
+ 0.205540466163
+ -0.0371987774074  0.206800437987
+ -0.000281157035376  -0.015989213926  0.206800437987
+ -0.000109135390465  -0.000281157035376  -0.0371987774074  0.205540466163
+ 51100000000
+ 0.205929990409
+ -0.0372692787404  0.207192340926
+ -0.000281691889283  -0.0160195198696  0.207192340926
+ -0.000109346978451  -0.000281691889283  -0.0372692787404  0.205929990409
+ 51200000000
+ 0.206319461935
+ -0.0373397705426  0.207584190804
+ -0.000282226675222  -0.016049821721  0.207584190804
+ -0.000109558548191  -0.000282226675222  -0.0373397705426  0.206319461935
+ 51300000000
+ 0.206708880742
+ -0.0374102528141  0.20797598762
+ -0.000282761393188  -0.0160801194804  0.20797598762
+ -0.000109770099668  -0.000282761393188  -0.0374102528141  0.206708880742
+ 51400000000
+ 0.207098246831
+ -0.0374807255551  0.208367731376
+ -0.000283296043174  -0.0161104131479  0.208367731376
+ -0.000109981632866  -0.000283296043174  -0.0374807255551  0.207098246831
+ 51500000000
+ 0.207487560202
+ -0.0375511887657  0.208759422074
+ -0.000283830625175  -0.0161407027235  0.208759422074
+ -0.000110193147769  -0.000283830625175  -0.0375511887657  0.207487560202
+ 51600000000
+ 0.207876820857
+ -0.0376216424461  0.209151059714
+ -0.000284365139185  -0.0161709882072  0.209151059714
+ -0.000110404644358  -0.000284365139185  -0.0376216424461  0.207876820857
+ 51700000000
+ 0.208266028798
+ -0.0376920865965  0.209542644297
+ -0.000284899585198  -0.0162012695992  0.209542644297
+ -0.000110616122618  -0.000284899585198  -0.0376920865965  0.208266028798
+ 51800000000
+ 0.208655184024
+ -0.0377625212171  0.209934175824
+ -0.000285433963207  -0.0162315468995  0.209934175824
+ -0.000110827582533  -0.000285433963207  -0.0377625212171  0.208655184024
+ 51900000000
+ 0.209044286537
+ -0.037832946308  0.210325654297
+ -0.000285968273208  -0.0162618201081  0.210325654297
+ -0.000111039024085  -0.000285968273208  -0.037832946308  0.209044286537
+ 52000000000
+ 0.209433336338
+ -0.0379033618693  0.210717079717
+ -0.000286502515194  -0.0162920892251  0.210717079717
+ -0.000111250447258  -0.000286502515194  -0.0379033618693  0.209433336338
+ 52100000000
+ 0.209822333428
+ -0.0379737679013  0.211108452084
+ -0.000287036689159  -0.0163223542506  0.211108452084
+ -0.000111461852036  -0.000287036689159  -0.0379737679013  0.209822333428
+ 52200000000
+ 0.210211277808
+ -0.0380441644041  0.211499771399
+ -0.000287570795098  -0.0163526151847  0.211499771399
+ -0.000111673238402  -0.000287570795098  -0.0380441644041  0.210211277808
+ 52300000000
+ 0.21060016948
+ -0.0381145513779  0.211891037664
+ -0.000288104833005  -0.0163828720274  0.211891037664
+ -0.000111884606341  -0.000288104833005  -0.0381145513779  0.21060016948
+ 52400000000
+ 0.210989008443
+ -0.0381849288228  0.21228225088
+ -0.000288638802874  -0.0164131247787  0.21228225088
+ -0.000112095955835  -0.000288638802874  -0.0381849288228  0.210989008443
+ 52500000000
+ 0.211377794699
+ -0.0382552967391  0.212673411048
+ -0.000289172704699  -0.0164433734388  0.212673411048
+ -0.00011230728687  -0.000289172704699  -0.0382552967391  0.211377794699
+ 52600000000
+ 0.21176652825
+ -0.0383256551269  0.213064518169
+ -0.000289706538476  -0.0164736180077  0.213064518169
+ -0.000112518599429  -0.000289706538476  -0.0383256551269  0.21176652825
+ 52700000000
+ 0.212155209096
+ -0.0383960039863  0.213455572243
+ -0.000290240304198  -0.0165038584855  0.213455572243
+ -0.000112729893495  -0.000290240304198  -0.0383960039863  0.212155209096
+ 52800000000
+ 0.212543837238
+ -0.0384663433175  0.213846573273
+ -0.000290774001859  -0.0165340948722  0.213846573273
+ -0.000112941169054  -0.000290774001859  -0.0384663433175  0.212543837238
+ 52900000000
+ 0.212932412677
+ -0.0385366731208  0.214237521259
+ -0.000291307631455  -0.0165643271679  0.214237521259
+ -0.000113152426088  -0.000291307631455  -0.0385366731208  0.212932412677
+ 53000000000
+ 0.213320935415
+ -0.0386069933962  0.214628416202
+ -0.000291841192979  -0.0165945553727  0.214628416202
+ -0.000113363664583  -0.000291841192979  -0.0386069933962  0.213320935415
+ 53100000000
+ 0.213709405452
+ -0.038677304144  0.215019258103
+ -0.000292374686426  -0.0166247794867  0.215019258103
+ -0.000113574884523  -0.000292374686426  -0.038677304144  0.213709405452
+ 53200000000
+ 0.214097822789
+ -0.0387476053643  0.215410046964
+ -0.000292908111791  -0.0166549995098  0.215410046964
+ -0.000113786085892  -0.000292908111791  -0.0387476053643  0.214097822789
+ 53300000000
+ 0.214486187428
+ -0.0388178970572  0.215800782785
+ -0.000293441469069  -0.0166852154422  0.215800782785
+ -0.000113997268674  -0.000293441469069  -0.0388178970572  0.214486187428
+ 53400000000
+ 0.21487449937
+ -0.0388881792231  0.216191465568
+ -0.000293974758253  -0.0167154272839  0.216191465568
+ -0.000114208432854  -0.000293974758253  -0.0388881792231  0.21487449937
+ 53500000000
+ 0.215262758615
+ -0.038958451862  0.216582095314
+ -0.000294507979338  -0.0167456350351  0.216582095314
+ -0.000114419578416  -0.000294507979338  -0.038958451862  0.215262758615
+ 53600000000
+ 0.215650965164
+ -0.0390287149741  0.216972672023
+ -0.00029504113232  -0.0167758386957  0.216972672023
+ -0.000114630705345  -0.00029504113232  -0.0390287149741  0.215650965164
+ 53700000000
+ 0.21603911902
+ -0.0390989685596  0.217363195697
+ -0.000295574217192  -0.0168060382659  0.217363195697
+ -0.000114841813625  -0.000295574217192  -0.0390989685596  0.21603911902
+ 53800000000
+ 0.216427220182
+ -0.0391692126187  0.217753666337
+ -0.00029610723395  -0.0168362337456  0.217753666337
+ -0.000115052903242  -0.00029610723395  -0.0391692126187  0.216427220182
+ 53900000000
+ 0.216815268653
+ -0.0392394471516  0.218144083944
+ -0.000296640182588  -0.0168664251351  0.218144083944
+ -0.00011526397418  -0.000296640182588  -0.0392394471516  0.216815268653
+ 54000000000
+ 0.217203264432
+ -0.0393096721583  0.21853444852
+ -0.000297173063101  -0.0168966124343  0.21853444852
+ -0.000115475026424  -0.000297173063101  -0.0393096721583  0.217203264432
+ 54100000000
+ 0.217591207521
+ -0.0393798876392  0.218924760064
+ -0.000297705875484  -0.0169267956433  0.218924760064
+ -0.000115686059958  -0.000297705875484  -0.0393798876392  0.217591207521
+ 54200000000
+ 0.217979097921
+ -0.0394500935943  0.21931501858
+ -0.000298238619731  -0.0169569747622  0.21931501858
+ -0.000115897074768  -0.000298238619731  -0.0394500935943  0.217979097921
+ 54300000000
+ 0.218366935634
+ -0.0395202900239  0.219705224066
+ -0.000298771295838  -0.016987149791  0.219705224066
+ -0.000116108070839  -0.000298771295838  -0.0395202900239  0.218366935634
+ 54400000000
+ 0.218754720659
+ -0.0395904769281  0.220095376525
+ -0.000299303903798  -0.0170173207299  0.220095376525
+ -0.000116319048155  -0.000299303903798  -0.0395904769281  0.218754720659
+ 54500000000
+ 0.219142452999
+ -0.0396606543071  0.220485475959
+ -0.000299836443609  -0.0170474875789  0.220485475959
+ -0.000116530006702  -0.000299836443609  -0.0396606543071  0.219142452999
+ 54600000000
+ 0.219530132654
+ -0.0397308221611  0.220875522366
+ -0.000300368915263  -0.017077650338  0.220875522366
+ -0.000116740946464  -0.000300368915263  -0.0397308221611  0.219530132654
+ 54700000000
+ 0.219917759626
+ -0.0398009804903  0.22126551575
+ -0.000300901318756  -0.0171078090073  0.22126551575
+ -0.000116951867428  -0.000300901318756  -0.0398009804903  0.219917759626
+ 54800000000
+ 0.220305333916
+ -0.0398711292949  0.221655456111
+ -0.000301433654083  -0.017137963587  0.221655456111
+ -0.000117162769579  -0.000301433654083  -0.0398711292949  0.220305333916
+ 54900000000
+ 0.220692855524
+ -0.0399412685749  0.222045343451
+ -0.000301965921239  -0.017168114077  0.222045343451
+ -0.000117373652901  -0.000301965921239  -0.0399412685749  0.220692855524
+ 55000000000
+ 0.221080324452
+ -0.0400113983307  0.222435177769
+ -0.00030249812022  -0.0171982604775  0.222435177769
+ -0.00011758451738  -0.00030249812022  -0.0400113983307  0.221080324452
+ 55100000000
+ 0.221467740701
+ -0.0400815185624  0.222824959068
+ -0.000303030251019  -0.0172284027885  0.222824959068
+ -0.000117795363002  -0.000303030251019  -0.0400815185624  0.221467740701
+ 55200000000
+ 0.221855104271
+ -0.0401516292702  0.223214687349
+ -0.000303562313633  -0.0172585410101  0.223214687349
+ -0.000118006189752  -0.000303562313633  -0.0401516292702  0.221855104271
+ 55300000000
+ 0.222242415165
+ -0.0402217304543  0.223604362613
+ -0.000304094308055  -0.0172886751423  0.223604362613
+ -0.000118216997616  -0.000304094308055  -0.0402217304543  0.222242415165
+ 55400000000
+ 0.222629673383
+ -0.0402918221147  0.22399398486
+ -0.000304626234283  -0.0173188051853  0.22399398486
+ -0.000118427786579  -0.000304626234283  -0.0402918221147  0.222629673383
+ 55500000000
+ 0.223016878926
+ -0.0403619042519  0.224383554093
+ -0.00030515809231  -0.0173489311391  0.224383554093
+ -0.000118638556626  -0.00030515809231  -0.0403619042519  0.223016878926
+ 55600000000
+ 0.223404031796
+ -0.0404319768658  0.224773070312
+ -0.000305689882131  -0.0173790530037  0.224773070312
+ -0.000118849307745  -0.000305689882131  -0.0404319768658  0.223404031796
+ 55700000000
+ 0.223791131993
+ -0.0405020399567  0.225162533518
+ -0.000306221603743  -0.0174091707793  0.225162533518
+ -0.00011906003992  -0.000306221603743  -0.0405020399567  0.223791131993
+ 55800000000
+ 0.224178179518
+ -0.0405720935248  0.225551943712
+ -0.00030675325714  -0.017439284466  0.225551943712
+ -0.000119270753137  -0.00030675325714  -0.0405720935248  0.224178179518
+ 55900000000
+ 0.224565174374
+ -0.0406421375703  0.225941300897
+ -0.000307284842317  -0.0174693940637  0.225941300897
+ -0.000119481447382  -0.000307284842317  -0.0406421375703  0.224565174374
+ 56000000000
+ 0.22495211656
+ -0.0407121720934  0.226330605072
+ -0.00030781635927  -0.0174994995726  0.226330605072
+ -0.000119692122641  -0.00030781635927  -0.0407121720934  0.22495211656
+ 56100000000
+ 0.225339006078
+ -0.0407821970941  0.226719856239
+ -0.000308347807995  -0.0175296009927  0.226719856239
+ -0.000119902778901  -0.000308347807995  -0.0407821970941  0.225339006078
+ 56200000000
+ 0.225725842929
+ -0.0408522125729  0.227109054399
+ -0.000308879188485  -0.0175596983241  0.227109054399
+ -0.000120113416146  -0.000308879188485  -0.0408522125729  0.225725842929
+ 56300000000
+ 0.226112627114
+ -0.0409222185297  0.227498199553
+ -0.000309410500738  -0.0175897915669  0.227498199553
+ -0.000120324034364  -0.000309410500738  -0.0409222185297  0.226112627114
+ 56400000000
+ 0.226499358635
+ -0.0409922149648  0.227887291703
+ -0.000309941744748  -0.0176198807212  0.227887291703
+ -0.00012053463354  -0.000309941744748  -0.0409922149648  0.226499358635
+ 56500000000
+ 0.226886037492
+ -0.0410622018785  0.228276330849
+ -0.00031047292051  -0.017649965787  0.228276330849
+ -0.00012074521366  -0.00031047292051  -0.0410622018785  0.226886037492
+ 56600000000
+ 0.227272663687
+ -0.0411321792708  0.228665316993
+ -0.00031100402802  -0.0176800467644  0.228665316993
+ -0.000120955774711  -0.00031100402802  -0.0411321792708  0.227272663687
+ 56700000000
+ 0.22765923722
+ -0.041202147142  0.229054250136
+ -0.000311535067274  -0.0177101236536  0.229054250136
+ -0.00012116631668  -0.000311535067274  -0.041202147142  0.22765923722
+ 56800000000
+ 0.228045758093
+ -0.0412721054923  0.229443130279
+ -0.000312066038267  -0.0177401964544  0.229443130279
+ -0.000121376839552  -0.000312066038267  -0.0412721054923  0.228045758093
+ 56900000000
+ 0.228432226308
+ -0.0413420543218  0.229831957423
+ -0.000312596940994  -0.0177702651671  0.229831957423
+ -0.000121587343313  -0.000312596940994  -0.0413420543218  0.228432226308
+ 57000000000
+ 0.228818641864
+ -0.0414119936307  0.23022073157
+ -0.000313127775452  -0.0178003297917  0.23022073157
+ -0.000121797827951  -0.000313127775452  -0.0414119936307  0.228818641864
+ 57100000000
+ 0.229205004763
+ -0.0414819234193  0.23060945272
+ -0.000313658541635  -0.0178303903283  0.23060945272
+ -0.000122008293452  -0.000313658541635  -0.0414819234193  0.229205004763
+ 57200000000
+ 0.229591315007
+ -0.0415518436877  0.230998120875
+ -0.000314189239539  -0.017860446777  0.230998120875
+ -0.000122218739802  -0.000314189239539  -0.0415518436877  0.229591315007
+ 57300000000
+ 0.229977572597
+ -0.0416217544362  0.231386736036
+ -0.00031471986916  -0.0178904991378  0.231386736036
+ -0.000122429166988  -0.00031471986916  -0.0416217544362  0.229977572597
+ 57400000000
+ 0.230363777533
+ -0.0416916556648  0.231775298204
+ -0.000315250430493  -0.0179205474108  0.231775298204
+ -0.000122639574996  -0.000315250430493  -0.0416916556648  0.230363777533
+ 57500000000
+ 0.230749929817
+ -0.0417615473739  0.232163807381
+ -0.000315780923535  -0.0179505915961  0.232163807381
+ -0.000122849963814  -0.000315780923535  -0.0417615473739  0.230749929817
+ 57600000000
+ 0.231136029449
+ -0.0418314295635  0.232552263567
+ -0.00031631134828  -0.0179806316938  0.232552263567
+ -0.000123060333428  -0.00031631134828  -0.0418314295635  0.231136029449
+ 57700000000
+ 0.231522076432
+ -0.041901302234  0.232940666763
+ -0.000316841704724  -0.0180106677039  0.232940666763
+ -0.000123270683825  -0.000316841704724  -0.041901302234  0.231522076432
+ 57800000000
+ 0.231908070767
+ -0.0419711653854  0.233329016972
+ -0.000317371992864  -0.0180406996265  0.233329016972
+ -0.000123481014991  -0.000317371992864  -0.0419711653854  0.231908070767
+ 57900000000
+ 0.232294012454
+ -0.042041019018  0.233717314193
+ -0.000317902212695  -0.0180707274618  0.233717314193
+ -0.000123691326914  -0.000317902212695  -0.042041019018  0.232294012454
+ 58000000000
+ 0.232679901494
+ -0.042110863132  0.234105558429
+ -0.000318432364212  -0.0181007512097  0.234105558429
+ -0.000123901619581  -0.000318432364212  -0.042110863132  0.232679901494
+ 58100000000
+ 0.233065737889
+ -0.0421806977276  0.23449374968
+ -0.000318962447412  -0.0181307708703  0.23449374968
+ -0.000124111892978  -0.000318962447412  -0.0421806977276  0.233065737889
+ 58200000000
+ 0.23345152164
+ -0.042250522805  0.234881887948
+ -0.00031949246229  -0.0181607864438  0.234881887948
+ -0.000124322147093  -0.00031949246229  -0.042250522805  0.23345152164
+ 58300000000
+ 0.233837252749
+ -0.0423203383643  0.235269973234
+ -0.000320022408842  -0.0181907979302  0.235269973234
+ -0.000124532381912  -0.000320022408842  -0.0423203383643  0.233837252749
+ 58400000000
+ 0.234222931215
+ -0.0423901444057  0.235658005538
+ -0.000320552287064  -0.0182208053296  0.235658005538
+ -0.000124742597423  -0.000320552287064  -0.0423901444057  0.234222931215
+ 58500000000
+ 0.234608557041
+ -0.0424599409296  0.236045984864
+ -0.000321082096953  -0.0182508086421  0.236045984864
+ -0.000124952793614  -0.000321082096953  -0.0424599409296  0.234608557041
+ 58600000000
+ 0.234994130228
+ -0.042529727936  0.23643391121
+ -0.000321611838502  -0.0182808078677  0.23643391121
+ -0.00012516297047  -0.000321611838502  -0.042529727936  0.234994130228
+ 58700000000
+ 0.235379650776
+ -0.0425995054251  0.236821784579
+ -0.00032214151171  -0.0183108030065  0.236821784579
+ -0.00012537312798  -0.00032214151171  -0.0425995054251  0.235379650776
+ 58800000000
+ 0.235765118687
+ -0.0426692733972  0.237209604972
+ -0.000322671116571  -0.0183407940587  0.237209604972
+ -0.00012558326613  -0.000322671116571  -0.0426692733972  0.235765118687
+ 58900000000
+ 0.236150533963
+ -0.0427390318525  0.237597372391
+ -0.000323200653082  -0.0183707810242  0.237597372391
+ -0.000125793384909  -0.000323200653082  -0.0427390318525  0.236150533963
+ 59000000000
+ 0.236535896604
+ -0.0428087807911  0.237985086835
+ -0.000323730121239  -0.0184007639032  0.237985086835
+ -0.000126003484303  -0.000323730121239  -0.0428087807911  0.236535896604
+ 59100000000
+ 0.236921206611
+ -0.0428785202133  0.238372748307
+ -0.000324259521037  -0.0184307426957  0.238372748307
+ -0.0001262135643  -0.000324259521037  -0.0428785202133  0.236921206611
+ 59200000000
+ 0.237306463986
+ -0.0429482501193  0.238760356808
+ -0.000324788852472  -0.0184607174019  0.238760356808
+ -0.000126423624888  -0.000324788852472  -0.0429482501193  0.237306463986
+ 59300000000
+ 0.23769166873
+ -0.0430179705092  0.239147912339
+ -0.000325318115542  -0.0184906880217  0.239147912339
+ -0.000126633666054  -0.000325318115542  -0.0430179705092  0.23769166873
+ 59400000000
+ 0.238076820844
+ -0.0430876813832  0.239535414901
+ -0.000325847310241  -0.0185206545554  0.239535414901
+ -0.000126843687786  -0.000325847310241  -0.0430876813832  0.238076820844
+ 59500000000
+ 0.23846192033
+ -0.0431573827417  0.239922864495
+ -0.000326376436567  -0.0185506170029  0.239922864495
+ -0.000127053690071  -0.000326376436567  -0.0431573827417  0.23846192033
+ 59600000000
+ 0.238846967188
+ -0.0432270745847  0.240310261123
+ -0.000326905494514  -0.0185805753643  0.240310261123
+ -0.000127263672897  -0.000326905494514  -0.0432270745847  0.238846967188
+ 59700000000
+ 0.239231961419
+ -0.0432967569124  0.240697604786
+ -0.000327434484079  -0.0186105296398  0.240697604786
+ -0.000127473636251  -0.000327434484079  -0.0432967569124  0.239231961419
+ 59800000000
+ 0.239616903026
+ -0.0433664297252  0.241084895485
+ -0.000327963405259  -0.0186404798294  0.241084895485
+ -0.000127683580122  -0.000327963405259  -0.0433664297252  0.239616903026
+ 59900000000
+ 0.240001792008
+ -0.0434360930231  0.241472133222
+ -0.000328492258049  -0.0186704259332  0.241472133222
+ -0.000127893504497  -0.000328492258049  -0.0434360930231  0.240001792008
+ 60000000000
+ 0.240386628368
+ -0.0435057468064  0.241859317997
+ -0.000329021042447  -0.0187003679513  0.241859317997
+ -0.000128103409365  -0.000329021042447  -0.0435057468064  0.240386628368
+ 60100000000
+ 0.240771412107
+ -0.0435753910753  0.242246449812
+ -0.000329549758447  -0.0187303058837  0.242246449812
+ -0.000128313294712  -0.000329549758447  -0.0435753910753  0.240771412107
+ 60200000000
+ 0.241156143225
+ -0.0436450258299  0.242633528668
+ -0.000330078406046  -0.0187602397305  0.242633528668
+ -0.000128523160528  -0.000330078406046  -0.0436450258299  0.241156143225
+ 60300000000
+ 0.241540821724
+ -0.0437146510706  0.243020554566
+ -0.000330606985241  -0.0187901694919  0.243020554566
+ -0.000128733006799  -0.000330606985241  -0.0437146510706  0.241540821724
+ 60400000000
+ 0.241925447605
+ -0.0437842667975  0.243407527508
+ -0.000331135496027  -0.0188200951679  0.243407527508
+ -0.000128942833515  -0.000331135496027  -0.0437842667975  0.241925447605
+ 60500000000
+ 0.242310020869
+ -0.0438538730108  0.243794447495
+ -0.000331663938402  -0.0188500167585  0.243794447495
+ -0.000129152640662  -0.000331663938402  -0.0438538730108  0.242310020869
+ 60600000000
+ 0.242694541518
+ -0.0439234697107  0.244181314527
+ -0.000332192312361  -0.0188799342639  0.244181314527
+ -0.00012936242823  -0.000332192312361  -0.0439234697107  0.242694541518
+ 60700000000
+ 0.243079009553
+ -0.0439930568974  0.244568128608
+ -0.000332720617901  -0.0189098476842  0.244568128608
+ -0.000129572196206  -0.000332720617901  -0.0439930568974  0.243079009553
+ 60800000000
+ 0.243463424975
+ -0.0440626345712  0.244954889736
+ -0.000333248855018  -0.0189397570194  0.244954889736
+ -0.000129781944578  -0.000333248855018  -0.0440626345712  0.243463424975
+ 60900000000
+ 0.243847787786
+ -0.0441322027322  0.245341597915
+ -0.000333777023708  -0.0189696622697  0.245341597915
+ -0.000129991673336  -0.000333777023708  -0.0441322027322  0.243847787786
+ 61000000000
+ 0.244232097985
+ -0.0442017613807  0.245728253144
+ -0.000334305123969  -0.018999563435  0.245728253144
+ -0.000130201382466  -0.000334305123969  -0.0442017613807  0.244232097985
+ 61100000000
+ 0.244616355576
+ -0.0442713105168  0.246114855426
+ -0.000334833155796  -0.0190294605155  0.246114855426
+ -0.000130411071958  -0.000334833155796  -0.0442713105168  0.244616355576
+ 61200000000
+ 0.245000560558
+ -0.0443408501408  0.246501404762
+ -0.000335361119186  -0.0190593535113  0.246501404762
+ -0.000130620741799  -0.000335361119186  -0.0443408501408  0.245000560558
+ 61300000000
+ 0.245384712933
+ -0.0444103802528  0.246887901152
+ -0.000335889014135  -0.0190892424225  0.246887901152
+ -0.000130830391979  -0.000335889014135  -0.0444103802528  0.245384712933
+ 61400000000
+ 0.245768812703
+ -0.0444799008532  0.247274344599
+ -0.00033641684064  -0.0191191272491  0.247274344599
+ -0.000131040022485  -0.00033641684064  -0.0444799008532  0.245768812703
+ 61500000000
+ 0.246152859869
+ -0.0445494119421  0.247660735103
+ -0.000336944598697  -0.0191490079912  0.247660735103
+ -0.000131249633306  -0.000336944598697  -0.0445494119421  0.246152859869
+ 61600000000
+ 0.246536854431
+ -0.0446189135196  0.248047072665
+ -0.000337472288303  -0.0191788846489  0.248047072665
+ -0.000131459224431  -0.000337472288303  -0.0446189135196  0.246536854431
+ 61700000000
+ 0.246920796392
+ -0.0446884055861  0.248433357288
+ -0.000337999909455  -0.0192087572224  0.248433357288
+ -0.000131668795847  -0.000337999909455  -0.0446884055861  0.246920796392
+ 61800000000
+ 0.247304685752
+ -0.0447578881418  0.248819588972
+ -0.000338527462148  -0.0192386257116  0.248819588972
+ -0.000131878347545  -0.000338527462148  -0.0447578881418  0.247304685752
+ 61900000000
+ 0.247688522512
+ -0.0448273611868  0.249205767718
+ -0.00033905494638  -0.0192684901167  0.249205767718
+ -0.000132087879512  -0.00033905494638  -0.0448273611868  0.247688522512
+ 62000000000
+ 0.248072306675
+ -0.0448968247213  0.249591893528
+ -0.000339582362148  -0.0192983504377  0.249591893528
+ -0.000132297391737  -0.000339582362148  -0.0448968247213  0.248072306675
+ 62100000000
+ 0.24845603824
+ -0.0449662787457  0.249977966403
+ -0.000340109709447  -0.0193282066748  0.249977966403
+ -0.000132506884209  -0.000340109709447  -0.0449662787457  0.24845603824
+ 62200000000
+ 0.24883971721
+ -0.04503572326  0.250363986345
+ -0.000340636988275  -0.019358058828  0.250363986345
+ -0.000132716356916  -0.000340636988275  -0.04503572326  0.24883971721
+ 62300000000
+ 0.249223343586
+ -0.0451051582645  0.250749953354
+ -0.000341164198627  -0.0193879068974  0.250749953354
+ -0.000132925809848  -0.000341164198627  -0.0451051582645  0.249223343586
+ 62400000000
+ 0.249606917369
+ -0.0451745837595  0.251135867432
+ -0.000341691340502  -0.0194177508832  0.251135867432
+ -0.000133135242993  -0.000341691340502  -0.0451745837595  0.249606917369
+ 62500000000
+ 0.249990438559
+ -0.0452439997451  0.251521728581
+ -0.000342218413895  -0.0194475907853  0.251521728581
+ -0.000133344656339  -0.000342218413895  -0.0452439997451  0.249990438559
+ 62600000000
+ 0.250373907159
+ -0.0453134062215  0.251907536801
+ -0.000342745418803  -0.0194774266039  0.251907536801
+ -0.000133554049877  -0.000342745418803  -0.0453134062215  0.250373907159
+ 62700000000
+ 0.25075732317
+ -0.045382803189  0.252293292094
+ -0.000343272355224  -0.019507258339  0.252293292094
+ -0.000133763423595  -0.000343272355224  -0.045382803189  0.25075732317
+ 62800000000
+ 0.251140686593
+ -0.0454521906478  0.25267899446
+ -0.000343799223153  -0.0195370859908  0.25267899446
+ -0.000133972777482  -0.000343799223153  -0.0454521906478  0.251140686593
+ 62900000000
+ 0.251523997429
+ -0.0455215685981  0.253064643903
+ -0.000344326022587  -0.0195669095593  0.253064643903
+ -0.000134182111526  -0.000344326022587  -0.0455215685981  0.251523997429
+ 63000000000
+ 0.251907255679
+ -0.0455909370401  0.253450240422
+ -0.000344852753524  -0.0195967290447  0.253450240422
+ -0.000134391425718  -0.000344852753524  -0.0455909370401  0.251907255679
+ 63100000000
+ 0.252290461345
+ -0.0456602959741  0.253835784019
+ -0.00034537941596  -0.019626544447  0.253835784019
+ -0.000134600720046  -0.00034537941596  -0.0456602959741  0.252290461345
+ 63200000000
+ 0.252673614429
+ -0.0457296454002  0.254221274695
+ -0.000345906009893  -0.0196563557663  0.254221274695
+ -0.000134809994499  -0.000345906009893  -0.0457296454002  0.252673614429
+ 63300000000
+ 0.25305671493
+ -0.0457989853187  0.254606712452
+ -0.000346432535318  -0.0196861630027  0.254606712452
+ -0.000135019249066  -0.000346432535318  -0.0457989853187  0.25305671493
+ 63400000000
+ 0.253439762851
+ -0.0458683157298  0.254992097291
+ -0.000346958992232  -0.0197159661562  0.254992097291
+ -0.000135228483737  -0.000346958992232  -0.0458683157298  0.253439762851
+ 63500000000
+ 0.253822758193
+ -0.0459376366337  0.255377429213
+ -0.000347485380634  -0.019745765227  0.255377429213
+ -0.000135437698501  -0.000347485380634  -0.0459376366337  0.253822758193
+ 63600000000
+ 0.254205700958
+ -0.0460069480307  0.25576270822
+ -0.000348011700518  -0.0197755602152  0.25576270822
+ -0.000135646893348  -0.000348011700518  -0.0460069480307  0.254205700958
+ 63700000000
+ 0.254588591145
+ -0.0460762499209  0.256147934313
+ -0.000348537951884  -0.0198053511209  0.256147934313
+ -0.000135856068265  -0.000348537951884  -0.0460762499209  0.254588591145
+ 63800000000
+ 0.254971428758
+ -0.0461455423046  0.256533107493
+ -0.000349064134726  -0.0198351379441  0.256533107493
+ -0.000136065223244  -0.000349064134726  -0.0461455423046  0.254971428758
+ 63900000000
+ 0.255354213796
+ -0.046214825182  0.256918227761
+ -0.000349590249043  -0.0198649206849  0.256918227761
+ -0.000136274358273  -0.000349590249043  -0.046214825182  0.255354213796
+ 64000000000
+ 0.255736946262
+ -0.0462840985533  0.257303295119
+ -0.000350116294832  -0.0198946993434  0.257303295119
+ -0.000136483473341  -0.000350116294832  -0.0462840985533  0.255736946262
+ 64100000000
+ 0.256119626157
+ -0.0463533624187  0.257688309569
+ -0.000350642272088  -0.0199244739197  0.257688309569
+ -0.000136692568439  -0.000350642272088  -0.0463533624187  0.256119626157
+ 64200000000
+ 0.256502253481
+ -0.0464226167785  0.25807327111
+ -0.000351168180811  -0.019954244414  0.25807327111
+ -0.000136901643556  -0.000351168180811  -0.0464226167785  0.256502253481
+ 64300000000
+ 0.256884828236
+ -0.046491861633  0.258458179746
+ -0.000351694020995  -0.0199840108262  0.258458179746
+ -0.00013711069868  -0.000351694020995  -0.046491861633  0.256884828236
+ 64400000000
+ 0.257267350425
+ -0.0465610969822  0.258843035477
+ -0.000352219792639  -0.0200137731565  0.258843035477
+ -0.000137319733803  -0.000352219792639  -0.0465610969822  0.257267350425
+ 64500000000
+ 0.257649820047
+ -0.0466303228265  0.259227838305
+ -0.000352745495739  -0.020043531405  0.259227838305
+ -0.000137528748913  -0.000352745495739  -0.0466303228265  0.257649820047
+ 64600000000
+ 0.258032237104
+ -0.046699539166  0.25961258823
+ -0.000353271130293  -0.0200732855717  0.25961258823
+ -0.000137737743999  -0.000353271130293  -0.046699539166  0.258032237104
+ 64700000000
+ 0.258414601597
+ -0.046768746001  0.259997285254
+ -0.000353796696298  -0.0201030356568  0.259997285254
+ -0.000137946719053  -0.000353796696298  -0.046768746001  0.258414601597
+ 64800000000
+ 0.258796913528
+ -0.0468379433317  0.260381929379
+ -0.00035432219375  -0.0201327816604  0.260381929379
+ -0.000138155674063  -0.00035432219375  -0.0468379433317  0.258796913528
+ 64900000000
+ 0.259179172899
+ -0.0469071311584  0.260766520606
+ -0.000354847622648  -0.0201625235825  0.260766520606
+ -0.00013836460902  -0.000354847622648  -0.0469071311584  0.259179172899
+ 65000000000
+ 0.25956137971
+ -0.0469763094812  0.261151058936
+ -0.000355372982987  -0.0201922614232  0.261151058936
+ -0.000138573523912  -0.000355372982987  -0.0469763094812  0.25956137971
+ 65100000000
+ 0.259943533962
+ -0.0470454783005  0.26153554437
+ -0.000355898274766  -0.0202219951826  0.26153554437
+ -0.00013878241873  -0.000355898274766  -0.0470454783005  0.259943533962
+ 65200000000
+ 0.260325635658
+ -0.0471146376163  0.261919976911
+ -0.000356423497981  -0.0202517248609  0.261919976911
+ -0.000138991293464  -0.000356423497981  -0.0471146376163  0.260325635658
+ 65300000000
+ 0.260707684797
+ -0.047183787429  0.262304356559
+ -0.00035694865263  -0.0202814504581  0.262304356559
+ -0.000139200148103  -0.00035694865263  -0.047183787429  0.260707684797
+ 65400000000
+ 0.261089681383
+ -0.0472529277388  0.262688683315
+ -0.00035747373871  -0.0203111719742  0.262688683315
+ -0.000139408982638  -0.00035747373871  -0.0472529277388  0.261089681383
+ 65500000000
+ 0.261471625415
+ -0.0473220585459  0.263072957181
+ -0.000357998756218  -0.0203408894095  0.263072957181
+ -0.000139617797058  -0.000357998756218  -0.0473220585459  0.261471625415
+ 65600000000
+ 0.261853516896
+ -0.0473911798505  0.263457178158
+ -0.000358523705151  -0.020370602764  0.263457178158
+ -0.000139826591354  -0.000358523705151  -0.0473911798505  0.261853516896
+ 65700000000
+ 0.262235355827
+ -0.0474602916528  0.263841346249
+ -0.000359048585507  -0.0204003120377  0.263841346249
+ -0.000140035365515  -0.000359048585507  -0.0474602916528  0.262235355827
+ 65800000000
+ 0.262617142208
+ -0.0475293939532  0.264225461453
+ -0.000359573397283  -0.0204300172308  0.264225461453
+ -0.000140244119531  -0.000359573397283  -0.0475293939532  0.262617142208
+ 65900000000
+ 0.262998876042
+ -0.0475984867518  0.264609523772
+ -0.000360098140476  -0.0204597183434  0.264609523772
+ -0.000140452853393  -0.000360098140476  -0.0475984867518  0.262998876042
+ 66000000000
+ 0.263380557329
+ -0.0476675700488  0.264993533209
+ -0.000360622815084  -0.0204894153756  0.264993533209
+ -0.000140661567091  -0.000360622815084  -0.0476675700488  0.263380557329
+ 66100000000
+ 0.263762186072
+ -0.0477366438446  0.265377489763
+ -0.000361147421104  -0.0205191083274  0.265377489763
+ -0.000140870260615  -0.000361147421104  -0.0477366438446  0.263762186072
+ 66200000000
+ 0.264143762271
+ -0.0478057081392  0.265761393437
+ -0.000361671958533  -0.020548797199  0.265761393437
+ -0.000141078933955  -0.000361671958533  -0.0478057081392  0.264143762271
+ 66300000000
+ 0.264525285927
+ -0.047874762933  0.266145244232
+ -0.000362196427368  -0.0205784819904  0.266145244232
+ -0.000141287587101  -0.000362196427368  -0.047874762933  0.264525285927
+ 66400000000
+ 0.264906757043
+ -0.0479438082262  0.266529042149
+ -0.000362720827608  -0.0206081627017  0.266529042149
+ -0.000141496220043  -0.000362720827608  -0.0479438082262  0.264906757043
+ 66500000000
+ 0.265288175618
+ -0.0480128440189  0.26691278719
+ -0.000363245159249  -0.0206378393331  0.26691278719
+ -0.000141704832772  -0.000363245159249  -0.0480128440189  0.265288175618
+ 66600000000
+ 0.265669541656
+ -0.0480818703116  0.267296479356
+ -0.000363769422289  -0.0206675118847  0.267296479356
+ -0.000141913425278  -0.000363769422289  -0.0480818703116  0.265669541656
+ 66700000000
+ 0.266050855157
+ -0.0481508871043  0.267680118648
+ -0.000364293616725  -0.0206971803564  0.267680118648
+ -0.000142121997552  -0.000364293616725  -0.0481508871043  0.266050855157
+ 66800000000
+ 0.266432116122
+ -0.0482198943973  0.268063705068
+ -0.000364817742555  -0.0207268447485  0.268063705068
+ -0.000142330549584  -0.000364817742555  -0.0482198943973  0.266432116122
+ 66900000000
+ 0.266813324553
+ -0.0482888921909  0.268447238617
+ -0.000365341799776  -0.020756505061  0.268447238617
+ -0.000142539081364  -0.000365341799776  -0.0482888921909  0.266813324553
+ 67000000000
+ 0.267194480451
+ -0.0483578804852  0.268830719296
+ -0.000365865788386  -0.020786161294  0.268830719296
+ -0.000142747592882  -0.000365865788386  -0.0483578804852  0.267194480451
+ 67100000000
+ 0.267575583817
+ -0.0484268592806  0.269214147108
+ -0.000366389708382  -0.0208158134477  0.269214147108
+ -0.00014295608413  -0.000366389708382  -0.0484268592806  0.267575583817
+ 67200000000
+ 0.267956634654
+ -0.0484958285772  0.269597522052
+ -0.000366913559762  -0.020845461522  0.269597522052
+ -0.000143164555097  -0.000366913559762  -0.0484958285772  0.267956634654
+ 67300000000
+ 0.268337632962
+ -0.0485647883753  0.269980844132
+ -0.000367437342523  -0.0208751055172  0.269980844132
+ -0.000143373005774  -0.000367437342523  -0.0485647883753  0.268337632962
+ 67400000000
+ 0.268718578742
+ -0.0486337386752  0.270364113347
+ -0.000367961056662  -0.0209047454332  0.270364113347
+ -0.000143581436152  -0.000367961056662  -0.0486337386752  0.268718578742
+ 67500000000
+ 0.269099471996
+ -0.048702679477  0.2707473297
+ -0.000368484702178  -0.0209343812703  0.2707473297
+ -0.000143789846222  -0.000368484702178  -0.048702679477  0.269099471996
+ 67600000000
+ 0.269480312726
+ -0.048771610781  0.271130493192
+ -0.000369008279068  -0.0209640130284  0.271130493192
+ -0.000143998235973  -0.000369008279068  -0.048771610781  0.269480312726
+ 67700000000
+ 0.269861100932
+ -0.0488405325874  0.271513603824
+ -0.00036953178733  -0.0209936407078  0.271513603824
+ -0.000144206605397  -0.00036953178733  -0.0488405325874  0.269861100932
+ 67800000000
+ 0.270241836617
+ -0.0489094448965  0.271896661598
+ -0.000370055226961  -0.0210232643084  0.271896661598
+ -0.000144414954485  -0.000370055226961  -0.0489094448965  0.270241836617
+ 67900000000
+ 0.27062251978
+ -0.0489783477085  0.272279666515
+ -0.000370578597958  -0.0210528838304  0.272279666515
+ -0.000144623283226  -0.000370578597958  -0.0489783477085  0.27062251978
+ 68000000000
+ 0.271003150425
+ -0.0490472410237  0.272662618577
+ -0.00037110190032  -0.021082499274  0.272662618577
+ -0.000144831591613  -0.00037110190032  -0.0490472410237  0.271003150425
+ 68100000000
+ 0.271383728552
+ -0.0491161248423  0.273045517784
+ -0.000371625134044  -0.0211121106391  0.273045517784
+ -0.000145039879634  -0.000371625134044  -0.0491161248423  0.271383728552
+ 68200000000
+ 0.271764254163
+ -0.0491849991645  0.273428364139
+ -0.000372148299127  -0.0211417179258  0.273428364139
+ -0.000145248147283  -0.000372148299127  -0.0491849991645  0.271764254163
+ 68300000000
+ 0.272144727258
+ -0.0492538639906  0.273811157643
+ -0.000372671395568  -0.0211713211344  0.273811157643
+ -0.000145456394548  -0.000372671395568  -0.0492538639906  0.272144727258
+ 68400000000
+ 0.27252514784
+ -0.0493227193208  0.274193898296
+ -0.000373194423364  -0.0212009202649  0.274193898296
+ -0.000145664621421  -0.000373194423364  -0.0493227193208  0.27252514784
+ 68500000000
+ 0.27290551591
+ -0.0493915651554  0.274576586102
+ -0.000373717382513  -0.0212305153173  0.274576586102
+ -0.000145872827894  -0.000373717382513  -0.0493915651554  0.27290551591
+ 68600000000
+ 0.273285831469
+ -0.0494604014945  0.27495922106
+ -0.000374240273012  -0.0212601062918  0.27495922106
+ -0.000146081013956  -0.000374240273012  -0.0494604014945  0.273285831469
+ 68700000000
+ 0.273666094519
+ -0.0495292283385  0.275341803172
+ -0.00037476309486  -0.0212896931886  0.275341803172
+ -0.000146289179599  -0.00037476309486  -0.0495292283385  0.273666094519
+ 68800000000
+ 0.27404630506
+ -0.0495980456876  0.275724332441
+ -0.000375285848053  -0.0213192760075  0.275724332441
+ -0.000146497324814  -0.000375285848054  -0.0495980456876  0.27404630506
+ 68900000000
+ 0.274426463095
+ -0.049666853542  0.276106808867
+ -0.000375808532591  -0.0213488547489  0.276106808867
+ -0.000146705449592  -0.000375808532591  -0.049666853542  0.274426463095
+ 69000000000
+ 0.274806568625
+ -0.049735651902  0.276489232451
+ -0.00037633114847  -0.0213784294127  0.276489232451
+ -0.000146913553924  -0.00037633114847  -0.049735651902  0.274806568625
+ 69100000000
+ 0.275186621651
+ -0.0498044407677  0.276871603196
+ -0.000376853695689  -0.0214079999992  0.276871603196
+ -0.0001471216378  -0.000376853695689  -0.0498044407677  0.275186621651
+ 69200000000
+ 0.275566622174
+ -0.0498732201396  0.277253921102
+ -0.000377376174244  -0.0214375665083  0.277253921102
+ -0.000147329701213  -0.000377376174244  -0.0498732201396  0.275566622174
+ 69300000000
+ 0.275946570197
+ -0.0499419900177  0.277636186172
+ -0.000377898584135  -0.0214671289402  0.277636186172
+ -0.000147537744153  -0.000377898584135  -0.0499419900177  0.275946570197
+ 69400000000
+ 0.27632646572
+ -0.0500107504024  0.278018398405
+ -0.000378420925359  -0.0214966872949  0.278018398405
+ -0.000147745766611  -0.000378420925359  -0.0500107504024  0.27632646572
+ 69500000000
+ 0.276706308744
+ -0.0500795012939  0.278400557805
+ -0.000378943197913  -0.0215262415727  0.278400557805
+ -0.000147953768579  -0.000378943197913  -0.0500795012939  0.276706308744
+ 69600000000
+ 0.277086099272
+ -0.0501482426924  0.278782664372
+ -0.000379465401796  -0.0215557917735  0.278782664372
+ -0.000148161750048  -0.000379465401796  -0.0501482426924  0.277086099272
+ 69700000000
+ 0.277465837305
+ -0.0502169745982  0.279164718107
+ -0.000379987537006  -0.0215853378975  0.279164718107
+ -0.000148369711008  -0.000379987537006  -0.0502169745982  0.277465837305
+ 69800000000
+ 0.277845522843
+ -0.0502856970115  0.279546719013
+ -0.00038050960354  -0.0216148799448  0.279546719013
+ -0.000148577651452  -0.00038050960354  -0.0502856970115  0.277845522843
+ 69900000000
+ 0.278225155889
+ -0.0503544099326  0.279928667091
+ -0.000381031601396  -0.0216444179155  0.279928667091
+ -0.000148785571371  -0.000381031601396  -0.0503544099326  0.278225155889
+ 70000000000
+ 0.278604736444
+ -0.0504231133617  0.280310562341
+ -0.000381553530573  -0.0216739518097  0.280310562341
+ -0.000148993470755  -0.000381553530573  -0.0504231133617  0.278604736444

.ends

* Example Usage
* X1 in1 in2 in3 in4 inref out1 out2 out3 out4 outref ckt_m4lines_ADS_W Length=0.5

* End of File
