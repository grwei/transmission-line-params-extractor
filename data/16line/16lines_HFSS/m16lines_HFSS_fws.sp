* BEGIN ANSOFT HEADER
* node 1    trace_p_0_T1
* node 2    trace_n_0_T1
* node 3    trace_p_1_T1
* node 4    trace_n_1_T1
* node 5    trace_p_2_T1
* node 6    trace_n_2_T1
* node 7    trace_p_3_T1
* node 8    trace_n_3_T1
* node 9    trace_p_4_T1
* node 10   trace_n_4_T1
* node 11   trace_p_5_T1
* node 12   trace_n_5_T1
* node 13   trace_p_6_T1
* node 14   trace_n_6_T1
* node 15   trace_p_7_T1
* node 16   trace_n_7_T1
* node 17   trace_p_0_T2
* node 18   trace_n_0_T2
* node 19   trace_p_1_T2
* node 20   trace_n_1_T2
* node 21   trace_p_2_T2
* node 22   trace_n_2_T2
* node 23   trace_p_3_T2
* node 24   trace_n_3_T2
* node 25   trace_p_4_T2
* node 26   trace_n_4_T2
* node 27   trace_p_5_T2
* node 28   trace_n_5_T2
* node 29   trace_p_6_T2
* node 30   trace_n_6_T2
* node 31   trace_p_7_T2
* node 32   trace_n_7_T2
*   Format: HSPICE
*   Topckt: m16lines_HFSS_fws
*     Date: Wed Jun 03 21:07:55 2020
*    Notes: Frequency range: 1e+08 to 7e+10 Hz, 700 points
*         : Maximum number of poles: 10000
*         : S-Matrix fitting error tolerance: 0.001
*         : Causality check tolerance: auto
*         : Passivity enforcement: on (by iterated fitting)
*         : Causality enforcement: off
*         : Fitting method: FastFit
*         : Matrix fitting: By entire matrix (required by FastFit)
*         : Ensure Z-parameter accuracy: on
*         : Relative error control: off
*         : Common ground option: on
*         : Final fitting error: 0.00848944
*         : Final model order: 1216
* END ANSOFT HEADER

.subckt m16lines_HFSS_fws 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32
Vam1 1 n2 dc 0
Rport1 n2 0 50 noise=0
Vam2 2 n4 dc 0
Rport2 n4 0 50 noise=0
Vam3 3 n6 dc 0
Rport3 n6 0 50 noise=0
Vam4 4 n8 dc 0
Rport4 n8 0 50 noise=0
Vam5 5 n10 dc 0
Rport5 n10 0 50 noise=0
Vam6 6 n12 dc 0
Rport6 n12 0 50 noise=0
Vam7 7 n14 dc 0
Rport7 n14 0 50 noise=0
Vam8 8 n16 dc 0
Rport8 n16 0 50 noise=0
Vam9 9 n18 dc 0
Rport9 n18 0 50 noise=0
Vam10 10 n20 dc 0
Rport10 n20 0 50 noise=0
Vam11 11 n22 dc 0
Rport11 n22 0 50 noise=0
Vam12 12 n24 dc 0
Rport12 n24 0 50 noise=0
Vam13 13 n26 dc 0
Rport13 n26 0 50 noise=0
Vam14 14 n28 dc 0
Rport14 n28 0 50 noise=0
Vam15 15 n30 dc 0
Rport15 n30 0 50 noise=0
Vam16 16 n32 dc 0
Rport16 n32 0 50 noise=0
Vam17 17 n34 dc 0
Rport17 n34 0 50 noise=0
Vam18 18 n36 dc 0
Rport18 n36 0 50 noise=0
Vam19 19 n38 dc 0
Rport19 n38 0 50 noise=0
Vam20 20 n40 dc 0
Rport20 n40 0 50 noise=0
Vam21 21 n42 dc 0
Rport21 n42 0 50 noise=0
Vam22 22 n44 dc 0
Rport22 n44 0 50 noise=0
Vam23 23 n46 dc 0
Rport23 n46 0 50 noise=0
Vam24 24 n48 dc 0
Rport24 n48 0 50 noise=0
Vam25 25 n50 dc 0
Rport25 n50 0 50 noise=0
Vam26 26 n52 dc 0
Rport26 n52 0 50 noise=0
Vam27 27 n54 dc 0
Rport27 n54 0 50 noise=0
Vam28 28 n56 dc 0
Rport28 n56 0 50 noise=0
Vam29 29 n58 dc 0
Rport29 n58 0 50 noise=0
Vam30 30 n60 dc 0
Rport30 n60 0 50 noise=0
Vam31 31 n62 dc 0
Rport31 n62 0 50 noise=0
Vam32 32 n64 dc 0
Rport32 n64 0 50 noise=0

Fi1 0 ni1 Vam1 50
Gi1 0 ni1 1 0 1
Rt1 ni1 0 1 noise=0
Fi2 0 ni2 Vam2 50
Gi2 0 ni2 2 0 1
Rt2 ni2 0 1 noise=0
Fi3 0 ni3 Vam3 50
Gi3 0 ni3 3 0 1
Rt3 ni3 0 1 noise=0
Fi4 0 ni4 Vam4 50
Gi4 0 ni4 4 0 1
Rt4 ni4 0 1 noise=0
Fi5 0 ni5 Vam5 50
Gi5 0 ni5 5 0 1
Rt5 ni5 0 1 noise=0
Fi6 0 ni6 Vam6 50
Gi6 0 ni6 6 0 1
Rt6 ni6 0 1 noise=0
Fi7 0 ni7 Vam7 50
Gi7 0 ni7 7 0 1
Rt7 ni7 0 1 noise=0
Fi8 0 ni8 Vam8 50
Gi8 0 ni8 8 0 1
Rt8 ni8 0 1 noise=0
Fi9 0 ni9 Vam9 50
Gi9 0 ni9 9 0 1
Rt9 ni9 0 1 noise=0
Fi10 0 ni10 Vam10 50
Gi10 0 ni10 10 0 1
Rt10 ni10 0 1 noise=0
Fi11 0 ni11 Vam11 50
Gi11 0 ni11 11 0 1
Rt11 ni11 0 1 noise=0
Fi12 0 ni12 Vam12 50
Gi12 0 ni12 12 0 1
Rt12 ni12 0 1 noise=0
Fi13 0 ni13 Vam13 50
Gi13 0 ni13 13 0 1
Rt13 ni13 0 1 noise=0
Fi14 0 ni14 Vam14 50
Gi14 0 ni14 14 0 1
Rt14 ni14 0 1 noise=0
Fi15 0 ni15 Vam15 50
Gi15 0 ni15 15 0 1
Rt15 ni15 0 1 noise=0
Fi16 0 ni16 Vam16 50
Gi16 0 ni16 16 0 1
Rt16 ni16 0 1 noise=0
Fi17 0 ni17 Vam17 50
Gi17 0 ni17 17 0 1
Rt17 ni17 0 1 noise=0
Fi18 0 ni18 Vam18 50
Gi18 0 ni18 18 0 1
Rt18 ni18 0 1 noise=0
Fi19 0 ni19 Vam19 50
Gi19 0 ni19 19 0 1
Rt19 ni19 0 1 noise=0
Fi20 0 ni20 Vam20 50
Gi20 0 ni20 20 0 1
Rt20 ni20 0 1 noise=0
Fi21 0 ni21 Vam21 50
Gi21 0 ni21 21 0 1
Rt21 ni21 0 1 noise=0
Fi22 0 ni22 Vam22 50
Gi22 0 ni22 22 0 1
Rt22 ni22 0 1 noise=0
Fi23 0 ni23 Vam23 50
Gi23 0 ni23 23 0 1
Rt23 ni23 0 1 noise=0
Fi24 0 ni24 Vam24 50
Gi24 0 ni24 24 0 1
Rt24 ni24 0 1 noise=0
Fi25 0 ni25 Vam25 50
Gi25 0 ni25 25 0 1
Rt25 ni25 0 1 noise=0
Fi26 0 ni26 Vam26 50
Gi26 0 ni26 26 0 1
Rt26 ni26 0 1 noise=0
Fi27 0 ni27 Vam27 50
Gi27 0 ni27 27 0 1
Rt27 ni27 0 1 noise=0
Fi28 0 ni28 Vam28 50
Gi28 0 ni28 28 0 1
Rt28 ni28 0 1 noise=0
Fi29 0 ni29 Vam29 50
Gi29 0 ni29 29 0 1
Rt29 ni29 0 1 noise=0
Fi30 0 ni30 Vam30 50
Gi30 0 ni30 30 0 1
Rt30 ni30 0 1 noise=0
Fi31 0 ni31 Vam31 50
Gi31 0 ni31 31 0 1
Rt31 ni31 0 1 noise=0
Fi32 0 ni32 Vam32 50
Gi32 0 ni32 32 0 1
Rt32 ni32 0 1 noise=0

Ca1 ns1 0 1e-12
Ra1 ns1 0 0.37257923819 noise=0
Ca2 ns2 0 1e-12
Ra2 ns2 0 0.636680753855 noise=0
Ca3 ns3 0 1e-12
Ca4 ns4 0 1e-12
Ra3 ns3 0 5.81195360108 noise=0
Ra4 ns4 0 5.81195360108 noise=0
Ga3 ns3 0 ns4 0 -0.440242930677
Ga4 ns4 0 ns3 0 0.440242930677
Ca5 ns5 0 1e-12
Ca6 ns6 0 1e-12
Ra5 ns5 0 25.0988766288 noise=0
Ra6 ns6 0 25.0988766288 noise=0
Ga5 ns5 0 ns6 0 -0.446182178947
Ga6 ns6 0 ns5 0 0.446182178947
Ca7 ns7 0 1e-12
Ca8 ns8 0 1e-12
Ra7 ns7 0 33.7291568883 noise=0
Ra8 ns8 0 33.7291568883 noise=0
Ga7 ns7 0 ns8 0 -0.437411009606
Ga8 ns8 0 ns7 0 0.437411009606
Ca9 ns9 0 1e-12
Ca10 ns10 0 1e-12
Ra9 ns9 0 30.2651538335 noise=0
Ra10 ns10 0 30.2651538335 noise=0
Ga9 ns9 0 ns10 0 -0.398051468393
Ga10 ns10 0 ns9 0 0.398051468393
Ca11 ns11 0 1e-12
Ca12 ns12 0 1e-12
Ra11 ns11 0 45.9593730353 noise=0
Ra12 ns12 0 45.9593730353 noise=0
Ga11 ns11 0 ns12 0 -0.376970230653
Ga12 ns12 0 ns11 0 0.376970230653
Ca13 ns13 0 1e-12
Ca14 ns14 0 1e-12
Ra13 ns13 0 22.8012326672 noise=0
Ra14 ns14 0 22.8012326672 noise=0
Ga13 ns13 0 ns14 0 -0.365000471119
Ga14 ns14 0 ns13 0 0.365000471119
Ca15 ns15 0 1e-12
Ca16 ns16 0 1e-12
Ra15 ns15 0 27.2711114272 noise=0
Ra16 ns16 0 27.2711114272 noise=0
Ga15 ns15 0 ns16 0 -0.30562060416
Ga16 ns16 0 ns15 0 0.30562060416
Ca17 ns17 0 1e-12
Ca18 ns18 0 1e-12
Ra17 ns17 0 36.1574626321 noise=0
Ra18 ns18 0 36.1574626321 noise=0
Ga17 ns17 0 ns18 0 -0.285967392433
Ga18 ns18 0 ns17 0 0.285967392433
Ca19 ns19 0 1e-12
Ca20 ns20 0 1e-12
Ra19 ns19 0 29.7569279687 noise=0
Ra20 ns20 0 29.7569279687 noise=0
Ga19 ns19 0 ns20 0 -0.276381759385
Ga20 ns20 0 ns19 0 0.276381759385
Ca21 ns21 0 1e-12
Ca22 ns22 0 1e-12
Ra21 ns21 0 20.4882528217 noise=0
Ra22 ns22 0 20.4882528217 noise=0
Ga21 ns21 0 ns22 0 -0.222396936817
Ga22 ns22 0 ns21 0 0.222396936817
Ca23 ns23 0 1e-12
Ca24 ns24 0 1e-12
Ra23 ns23 0 33.0904520292 noise=0
Ra24 ns24 0 33.0904520292 noise=0
Ga23 ns23 0 ns24 0 -0.193660507824
Ga24 ns24 0 ns23 0 0.193660507824
Ca25 ns25 0 1e-12
Ca26 ns26 0 1e-12
Ra25 ns25 0 34.81602158 noise=0
Ra26 ns26 0 34.81602158 noise=0
Ga25 ns25 0 ns26 0 -0.193389614476
Ga26 ns26 0 ns25 0 0.193389614476
Ca27 ns27 0 1e-12
Ca28 ns28 0 1e-12
Ra27 ns27 0 19.0488873153 noise=0
Ra28 ns28 0 19.0488873153 noise=0
Ga27 ns27 0 ns28 0 -0.118879593805
Ga28 ns28 0 ns27 0 0.118879593805
Ca29 ns29 0 1e-12
Ca30 ns30 0 1e-12
Ra29 ns29 0 38.9664963377 noise=0
Ra30 ns30 0 38.9664963377 noise=0
Ga29 ns29 0 ns30 0 -0.098928422879
Ga30 ns30 0 ns29 0 0.098928422879
Ca31 ns31 0 1e-12
Ca32 ns32 0 1e-12
Ra31 ns31 0 22.7620283637 noise=0
Ra32 ns32 0 22.7620283637 noise=0
Ga31 ns31 0 ns32 0 -0.0899282175659
Ga32 ns32 0 ns31 0 0.0899282175659
Ca33 ns33 0 1e-12
Ca34 ns34 0 1e-12
Ra33 ns33 0 21.1351530279 noise=0
Ra34 ns34 0 21.1351530279 noise=0
Ga33 ns33 0 ns34 0 -0.0231807799965
Ga34 ns34 0 ns33 0 0.0231807799965
Ca35 ns35 0 1e-12
Ra35 ns35 0 35.5013141349 noise=0
Ca36 ns36 0 1e-12
Ra36 ns36 0 1368.82509734 noise=0
Ca37 ns37 0 1e-12
Ra37 ns37 0 13570.4439484 noise=0
Ca38 ns38 0 1e-12
Ra38 ns38 0 4070.84562835 noise=0
Ca39 ns39 0 1e-12
Ra39 ns39 0 0.37257923819 noise=0
Ca40 ns40 0 1e-12
Ra40 ns40 0 0.636680753855 noise=0
Ca41 ns41 0 1e-12
Ca42 ns42 0 1e-12
Ra41 ns41 0 5.81195360108 noise=0
Ra42 ns42 0 5.81195360108 noise=0
Ga41 ns41 0 ns42 0 -0.440242930677
Ga42 ns42 0 ns41 0 0.440242930677
Ca43 ns43 0 1e-12
Ca44 ns44 0 1e-12
Ra43 ns43 0 25.0988766288 noise=0
Ra44 ns44 0 25.0988766288 noise=0
Ga43 ns43 0 ns44 0 -0.446182178947
Ga44 ns44 0 ns43 0 0.446182178947
Ca45 ns45 0 1e-12
Ca46 ns46 0 1e-12
Ra45 ns45 0 33.7291568883 noise=0
Ra46 ns46 0 33.7291568883 noise=0
Ga45 ns45 0 ns46 0 -0.437411009606
Ga46 ns46 0 ns45 0 0.437411009606
Ca47 ns47 0 1e-12
Ca48 ns48 0 1e-12
Ra47 ns47 0 30.2651538335 noise=0
Ra48 ns48 0 30.2651538335 noise=0
Ga47 ns47 0 ns48 0 -0.398051468393
Ga48 ns48 0 ns47 0 0.398051468393
Ca49 ns49 0 1e-12
Ca50 ns50 0 1e-12
Ra49 ns49 0 45.9593730353 noise=0
Ra50 ns50 0 45.9593730353 noise=0
Ga49 ns49 0 ns50 0 -0.376970230653
Ga50 ns50 0 ns49 0 0.376970230653
Ca51 ns51 0 1e-12
Ca52 ns52 0 1e-12
Ra51 ns51 0 22.8012326672 noise=0
Ra52 ns52 0 22.8012326672 noise=0
Ga51 ns51 0 ns52 0 -0.365000471119
Ga52 ns52 0 ns51 0 0.365000471119
Ca53 ns53 0 1e-12
Ca54 ns54 0 1e-12
Ra53 ns53 0 27.2711114272 noise=0
Ra54 ns54 0 27.2711114272 noise=0
Ga53 ns53 0 ns54 0 -0.30562060416
Ga54 ns54 0 ns53 0 0.30562060416
Ca55 ns55 0 1e-12
Ca56 ns56 0 1e-12
Ra55 ns55 0 36.1574626321 noise=0
Ra56 ns56 0 36.1574626321 noise=0
Ga55 ns55 0 ns56 0 -0.285967392433
Ga56 ns56 0 ns55 0 0.285967392433
Ca57 ns57 0 1e-12
Ca58 ns58 0 1e-12
Ra57 ns57 0 29.7569279687 noise=0
Ra58 ns58 0 29.7569279687 noise=0
Ga57 ns57 0 ns58 0 -0.276381759385
Ga58 ns58 0 ns57 0 0.276381759385
Ca59 ns59 0 1e-12
Ca60 ns60 0 1e-12
Ra59 ns59 0 20.4882528217 noise=0
Ra60 ns60 0 20.4882528217 noise=0
Ga59 ns59 0 ns60 0 -0.222396936817
Ga60 ns60 0 ns59 0 0.222396936817
Ca61 ns61 0 1e-12
Ca62 ns62 0 1e-12
Ra61 ns61 0 33.0904520292 noise=0
Ra62 ns62 0 33.0904520292 noise=0
Ga61 ns61 0 ns62 0 -0.193660507824
Ga62 ns62 0 ns61 0 0.193660507824
Ca63 ns63 0 1e-12
Ca64 ns64 0 1e-12
Ra63 ns63 0 34.81602158 noise=0
Ra64 ns64 0 34.81602158 noise=0
Ga63 ns63 0 ns64 0 -0.193389614476
Ga64 ns64 0 ns63 0 0.193389614476
Ca65 ns65 0 1e-12
Ca66 ns66 0 1e-12
Ra65 ns65 0 19.0488873153 noise=0
Ra66 ns66 0 19.0488873153 noise=0
Ga65 ns65 0 ns66 0 -0.118879593805
Ga66 ns66 0 ns65 0 0.118879593805
Ca67 ns67 0 1e-12
Ca68 ns68 0 1e-12
Ra67 ns67 0 38.9664963377 noise=0
Ra68 ns68 0 38.9664963377 noise=0
Ga67 ns67 0 ns68 0 -0.098928422879
Ga68 ns68 0 ns67 0 0.098928422879
Ca69 ns69 0 1e-12
Ca70 ns70 0 1e-12
Ra69 ns69 0 22.7620283637 noise=0
Ra70 ns70 0 22.7620283637 noise=0
Ga69 ns69 0 ns70 0 -0.0899282175659
Ga70 ns70 0 ns69 0 0.0899282175659
Ca71 ns71 0 1e-12
Ca72 ns72 0 1e-12
Ra71 ns71 0 21.1351530279 noise=0
Ra72 ns72 0 21.1351530279 noise=0
Ga71 ns71 0 ns72 0 -0.0231807799965
Ga72 ns72 0 ns71 0 0.0231807799965
Ca73 ns73 0 1e-12
Ra73 ns73 0 35.5013141349 noise=0
Ca74 ns74 0 1e-12
Ra74 ns74 0 1368.82509734 noise=0
Ca75 ns75 0 1e-12
Ra75 ns75 0 13570.4439484 noise=0
Ca76 ns76 0 1e-12
Ra76 ns76 0 4070.84562835 noise=0
Ca77 ns77 0 1e-12
Ra77 ns77 0 0.37257923819 noise=0
Ca78 ns78 0 1e-12
Ra78 ns78 0 0.636680753855 noise=0
Ca79 ns79 0 1e-12
Ca80 ns80 0 1e-12
Ra79 ns79 0 5.81195360108 noise=0
Ra80 ns80 0 5.81195360108 noise=0
Ga79 ns79 0 ns80 0 -0.440242930677
Ga80 ns80 0 ns79 0 0.440242930677
Ca81 ns81 0 1e-12
Ca82 ns82 0 1e-12
Ra81 ns81 0 25.0988766288 noise=0
Ra82 ns82 0 25.0988766288 noise=0
Ga81 ns81 0 ns82 0 -0.446182178947
Ga82 ns82 0 ns81 0 0.446182178947
Ca83 ns83 0 1e-12
Ca84 ns84 0 1e-12
Ra83 ns83 0 33.7291568883 noise=0
Ra84 ns84 0 33.7291568883 noise=0
Ga83 ns83 0 ns84 0 -0.437411009606
Ga84 ns84 0 ns83 0 0.437411009606
Ca85 ns85 0 1e-12
Ca86 ns86 0 1e-12
Ra85 ns85 0 30.2651538335 noise=0
Ra86 ns86 0 30.2651538335 noise=0
Ga85 ns85 0 ns86 0 -0.398051468393
Ga86 ns86 0 ns85 0 0.398051468393
Ca87 ns87 0 1e-12
Ca88 ns88 0 1e-12
Ra87 ns87 0 45.9593730353 noise=0
Ra88 ns88 0 45.9593730353 noise=0
Ga87 ns87 0 ns88 0 -0.376970230653
Ga88 ns88 0 ns87 0 0.376970230653
Ca89 ns89 0 1e-12
Ca90 ns90 0 1e-12
Ra89 ns89 0 22.8012326672 noise=0
Ra90 ns90 0 22.8012326672 noise=0
Ga89 ns89 0 ns90 0 -0.365000471119
Ga90 ns90 0 ns89 0 0.365000471119
Ca91 ns91 0 1e-12
Ca92 ns92 0 1e-12
Ra91 ns91 0 27.2711114272 noise=0
Ra92 ns92 0 27.2711114272 noise=0
Ga91 ns91 0 ns92 0 -0.30562060416
Ga92 ns92 0 ns91 0 0.30562060416
Ca93 ns93 0 1e-12
Ca94 ns94 0 1e-12
Ra93 ns93 0 36.1574626321 noise=0
Ra94 ns94 0 36.1574626321 noise=0
Ga93 ns93 0 ns94 0 -0.285967392433
Ga94 ns94 0 ns93 0 0.285967392433
Ca95 ns95 0 1e-12
Ca96 ns96 0 1e-12
Ra95 ns95 0 29.7569279687 noise=0
Ra96 ns96 0 29.7569279687 noise=0
Ga95 ns95 0 ns96 0 -0.276381759385
Ga96 ns96 0 ns95 0 0.276381759385
Ca97 ns97 0 1e-12
Ca98 ns98 0 1e-12
Ra97 ns97 0 20.4882528217 noise=0
Ra98 ns98 0 20.4882528217 noise=0
Ga97 ns97 0 ns98 0 -0.222396936817
Ga98 ns98 0 ns97 0 0.222396936817
Ca99 ns99 0 1e-12
Ca100 ns100 0 1e-12
Ra99 ns99 0 33.0904520292 noise=0
Ra100 ns100 0 33.0904520292 noise=0
Ga99 ns99 0 ns100 0 -0.193660507824
Ga100 ns100 0 ns99 0 0.193660507824
Ca101 ns101 0 1e-12
Ca102 ns102 0 1e-12
Ra101 ns101 0 34.81602158 noise=0
Ra102 ns102 0 34.81602158 noise=0
Ga101 ns101 0 ns102 0 -0.193389614476
Ga102 ns102 0 ns101 0 0.193389614476
Ca103 ns103 0 1e-12
Ca104 ns104 0 1e-12
Ra103 ns103 0 19.0488873153 noise=0
Ra104 ns104 0 19.0488873153 noise=0
Ga103 ns103 0 ns104 0 -0.118879593805
Ga104 ns104 0 ns103 0 0.118879593805
Ca105 ns105 0 1e-12
Ca106 ns106 0 1e-12
Ra105 ns105 0 38.9664963377 noise=0
Ra106 ns106 0 38.9664963377 noise=0
Ga105 ns105 0 ns106 0 -0.098928422879
Ga106 ns106 0 ns105 0 0.098928422879
Ca107 ns107 0 1e-12
Ca108 ns108 0 1e-12
Ra107 ns107 0 22.7620283637 noise=0
Ra108 ns108 0 22.7620283637 noise=0
Ga107 ns107 0 ns108 0 -0.0899282175659
Ga108 ns108 0 ns107 0 0.0899282175659
Ca109 ns109 0 1e-12
Ca110 ns110 0 1e-12
Ra109 ns109 0 21.1351530279 noise=0
Ra110 ns110 0 21.1351530279 noise=0
Ga109 ns109 0 ns110 0 -0.0231807799965
Ga110 ns110 0 ns109 0 0.0231807799965
Ca111 ns111 0 1e-12
Ra111 ns111 0 35.5013141349 noise=0
Ca112 ns112 0 1e-12
Ra112 ns112 0 1368.82509734 noise=0
Ca113 ns113 0 1e-12
Ra113 ns113 0 13570.4439484 noise=0
Ca114 ns114 0 1e-12
Ra114 ns114 0 4070.84562835 noise=0
Ca115 ns115 0 1e-12
Ra115 ns115 0 0.37257923819 noise=0
Ca116 ns116 0 1e-12
Ra116 ns116 0 0.636680753855 noise=0
Ca117 ns117 0 1e-12
Ca118 ns118 0 1e-12
Ra117 ns117 0 5.81195360108 noise=0
Ra118 ns118 0 5.81195360108 noise=0
Ga117 ns117 0 ns118 0 -0.440242930677
Ga118 ns118 0 ns117 0 0.440242930677
Ca119 ns119 0 1e-12
Ca120 ns120 0 1e-12
Ra119 ns119 0 25.0988766288 noise=0
Ra120 ns120 0 25.0988766288 noise=0
Ga119 ns119 0 ns120 0 -0.446182178947
Ga120 ns120 0 ns119 0 0.446182178947
Ca121 ns121 0 1e-12
Ca122 ns122 0 1e-12
Ra121 ns121 0 33.7291568883 noise=0
Ra122 ns122 0 33.7291568883 noise=0
Ga121 ns121 0 ns122 0 -0.437411009606
Ga122 ns122 0 ns121 0 0.437411009606
Ca123 ns123 0 1e-12
Ca124 ns124 0 1e-12
Ra123 ns123 0 30.2651538335 noise=0
Ra124 ns124 0 30.2651538335 noise=0
Ga123 ns123 0 ns124 0 -0.398051468393
Ga124 ns124 0 ns123 0 0.398051468393
Ca125 ns125 0 1e-12
Ca126 ns126 0 1e-12
Ra125 ns125 0 45.9593730353 noise=0
Ra126 ns126 0 45.9593730353 noise=0
Ga125 ns125 0 ns126 0 -0.376970230653
Ga126 ns126 0 ns125 0 0.376970230653
Ca127 ns127 0 1e-12
Ca128 ns128 0 1e-12
Ra127 ns127 0 22.8012326672 noise=0
Ra128 ns128 0 22.8012326672 noise=0
Ga127 ns127 0 ns128 0 -0.365000471119
Ga128 ns128 0 ns127 0 0.365000471119
Ca129 ns129 0 1e-12
Ca130 ns130 0 1e-12
Ra129 ns129 0 27.2711114272 noise=0
Ra130 ns130 0 27.2711114272 noise=0
Ga129 ns129 0 ns130 0 -0.30562060416
Ga130 ns130 0 ns129 0 0.30562060416
Ca131 ns131 0 1e-12
Ca132 ns132 0 1e-12
Ra131 ns131 0 36.1574626321 noise=0
Ra132 ns132 0 36.1574626321 noise=0
Ga131 ns131 0 ns132 0 -0.285967392433
Ga132 ns132 0 ns131 0 0.285967392433
Ca133 ns133 0 1e-12
Ca134 ns134 0 1e-12
Ra133 ns133 0 29.7569279687 noise=0
Ra134 ns134 0 29.7569279687 noise=0
Ga133 ns133 0 ns134 0 -0.276381759385
Ga134 ns134 0 ns133 0 0.276381759385
Ca135 ns135 0 1e-12
Ca136 ns136 0 1e-12
Ra135 ns135 0 20.4882528217 noise=0
Ra136 ns136 0 20.4882528217 noise=0
Ga135 ns135 0 ns136 0 -0.222396936817
Ga136 ns136 0 ns135 0 0.222396936817
Ca137 ns137 0 1e-12
Ca138 ns138 0 1e-12
Ra137 ns137 0 33.0904520292 noise=0
Ra138 ns138 0 33.0904520292 noise=0
Ga137 ns137 0 ns138 0 -0.193660507824
Ga138 ns138 0 ns137 0 0.193660507824
Ca139 ns139 0 1e-12
Ca140 ns140 0 1e-12
Ra139 ns139 0 34.81602158 noise=0
Ra140 ns140 0 34.81602158 noise=0
Ga139 ns139 0 ns140 0 -0.193389614476
Ga140 ns140 0 ns139 0 0.193389614476
Ca141 ns141 0 1e-12
Ca142 ns142 0 1e-12
Ra141 ns141 0 19.0488873153 noise=0
Ra142 ns142 0 19.0488873153 noise=0
Ga141 ns141 0 ns142 0 -0.118879593805
Ga142 ns142 0 ns141 0 0.118879593805
Ca143 ns143 0 1e-12
Ca144 ns144 0 1e-12
Ra143 ns143 0 38.9664963377 noise=0
Ra144 ns144 0 38.9664963377 noise=0
Ga143 ns143 0 ns144 0 -0.098928422879
Ga144 ns144 0 ns143 0 0.098928422879
Ca145 ns145 0 1e-12
Ca146 ns146 0 1e-12
Ra145 ns145 0 22.7620283637 noise=0
Ra146 ns146 0 22.7620283637 noise=0
Ga145 ns145 0 ns146 0 -0.0899282175659
Ga146 ns146 0 ns145 0 0.0899282175659
Ca147 ns147 0 1e-12
Ca148 ns148 0 1e-12
Ra147 ns147 0 21.1351530279 noise=0
Ra148 ns148 0 21.1351530279 noise=0
Ga147 ns147 0 ns148 0 -0.0231807799965
Ga148 ns148 0 ns147 0 0.0231807799965
Ca149 ns149 0 1e-12
Ra149 ns149 0 35.5013141349 noise=0
Ca150 ns150 0 1e-12
Ra150 ns150 0 1368.82509734 noise=0
Ca151 ns151 0 1e-12
Ra151 ns151 0 13570.4439484 noise=0
Ca152 ns152 0 1e-12
Ra152 ns152 0 4070.84562835 noise=0
Ca153 ns153 0 1e-12
Ra153 ns153 0 0.37257923819 noise=0
Ca154 ns154 0 1e-12
Ra154 ns154 0 0.636680753855 noise=0
Ca155 ns155 0 1e-12
Ca156 ns156 0 1e-12
Ra155 ns155 0 5.81195360108 noise=0
Ra156 ns156 0 5.81195360108 noise=0
Ga155 ns155 0 ns156 0 -0.440242930677
Ga156 ns156 0 ns155 0 0.440242930677
Ca157 ns157 0 1e-12
Ca158 ns158 0 1e-12
Ra157 ns157 0 25.0988766288 noise=0
Ra158 ns158 0 25.0988766288 noise=0
Ga157 ns157 0 ns158 0 -0.446182178947
Ga158 ns158 0 ns157 0 0.446182178947
Ca159 ns159 0 1e-12
Ca160 ns160 0 1e-12
Ra159 ns159 0 33.7291568883 noise=0
Ra160 ns160 0 33.7291568883 noise=0
Ga159 ns159 0 ns160 0 -0.437411009606
Ga160 ns160 0 ns159 0 0.437411009606
Ca161 ns161 0 1e-12
Ca162 ns162 0 1e-12
Ra161 ns161 0 30.2651538335 noise=0
Ra162 ns162 0 30.2651538335 noise=0
Ga161 ns161 0 ns162 0 -0.398051468393
Ga162 ns162 0 ns161 0 0.398051468393
Ca163 ns163 0 1e-12
Ca164 ns164 0 1e-12
Ra163 ns163 0 45.9593730353 noise=0
Ra164 ns164 0 45.9593730353 noise=0
Ga163 ns163 0 ns164 0 -0.376970230653
Ga164 ns164 0 ns163 0 0.376970230653
Ca165 ns165 0 1e-12
Ca166 ns166 0 1e-12
Ra165 ns165 0 22.8012326672 noise=0
Ra166 ns166 0 22.8012326672 noise=0
Ga165 ns165 0 ns166 0 -0.365000471119
Ga166 ns166 0 ns165 0 0.365000471119
Ca167 ns167 0 1e-12
Ca168 ns168 0 1e-12
Ra167 ns167 0 27.2711114272 noise=0
Ra168 ns168 0 27.2711114272 noise=0
Ga167 ns167 0 ns168 0 -0.30562060416
Ga168 ns168 0 ns167 0 0.30562060416
Ca169 ns169 0 1e-12
Ca170 ns170 0 1e-12
Ra169 ns169 0 36.1574626321 noise=0
Ra170 ns170 0 36.1574626321 noise=0
Ga169 ns169 0 ns170 0 -0.285967392433
Ga170 ns170 0 ns169 0 0.285967392433
Ca171 ns171 0 1e-12
Ca172 ns172 0 1e-12
Ra171 ns171 0 29.7569279687 noise=0
Ra172 ns172 0 29.7569279687 noise=0
Ga171 ns171 0 ns172 0 -0.276381759385
Ga172 ns172 0 ns171 0 0.276381759385
Ca173 ns173 0 1e-12
Ca174 ns174 0 1e-12
Ra173 ns173 0 20.4882528217 noise=0
Ra174 ns174 0 20.4882528217 noise=0
Ga173 ns173 0 ns174 0 -0.222396936817
Ga174 ns174 0 ns173 0 0.222396936817
Ca175 ns175 0 1e-12
Ca176 ns176 0 1e-12
Ra175 ns175 0 33.0904520292 noise=0
Ra176 ns176 0 33.0904520292 noise=0
Ga175 ns175 0 ns176 0 -0.193660507824
Ga176 ns176 0 ns175 0 0.193660507824
Ca177 ns177 0 1e-12
Ca178 ns178 0 1e-12
Ra177 ns177 0 34.81602158 noise=0
Ra178 ns178 0 34.81602158 noise=0
Ga177 ns177 0 ns178 0 -0.193389614476
Ga178 ns178 0 ns177 0 0.193389614476
Ca179 ns179 0 1e-12
Ca180 ns180 0 1e-12
Ra179 ns179 0 19.0488873153 noise=0
Ra180 ns180 0 19.0488873153 noise=0
Ga179 ns179 0 ns180 0 -0.118879593805
Ga180 ns180 0 ns179 0 0.118879593805
Ca181 ns181 0 1e-12
Ca182 ns182 0 1e-12
Ra181 ns181 0 38.9664963377 noise=0
Ra182 ns182 0 38.9664963377 noise=0
Ga181 ns181 0 ns182 0 -0.098928422879
Ga182 ns182 0 ns181 0 0.098928422879
Ca183 ns183 0 1e-12
Ca184 ns184 0 1e-12
Ra183 ns183 0 22.7620283637 noise=0
Ra184 ns184 0 22.7620283637 noise=0
Ga183 ns183 0 ns184 0 -0.0899282175659
Ga184 ns184 0 ns183 0 0.0899282175659
Ca185 ns185 0 1e-12
Ca186 ns186 0 1e-12
Ra185 ns185 0 21.1351530279 noise=0
Ra186 ns186 0 21.1351530279 noise=0
Ga185 ns185 0 ns186 0 -0.0231807799965
Ga186 ns186 0 ns185 0 0.0231807799965
Ca187 ns187 0 1e-12
Ra187 ns187 0 35.5013141349 noise=0
Ca188 ns188 0 1e-12
Ra188 ns188 0 1368.82509734 noise=0
Ca189 ns189 0 1e-12
Ra189 ns189 0 13570.4439484 noise=0
Ca190 ns190 0 1e-12
Ra190 ns190 0 4070.84562835 noise=0
Ca191 ns191 0 1e-12
Ra191 ns191 0 0.37257923819 noise=0
Ca192 ns192 0 1e-12
Ra192 ns192 0 0.636680753855 noise=0
Ca193 ns193 0 1e-12
Ca194 ns194 0 1e-12
Ra193 ns193 0 5.81195360108 noise=0
Ra194 ns194 0 5.81195360108 noise=0
Ga193 ns193 0 ns194 0 -0.440242930677
Ga194 ns194 0 ns193 0 0.440242930677
Ca195 ns195 0 1e-12
Ca196 ns196 0 1e-12
Ra195 ns195 0 25.0988766288 noise=0
Ra196 ns196 0 25.0988766288 noise=0
Ga195 ns195 0 ns196 0 -0.446182178947
Ga196 ns196 0 ns195 0 0.446182178947
Ca197 ns197 0 1e-12
Ca198 ns198 0 1e-12
Ra197 ns197 0 33.7291568883 noise=0
Ra198 ns198 0 33.7291568883 noise=0
Ga197 ns197 0 ns198 0 -0.437411009606
Ga198 ns198 0 ns197 0 0.437411009606
Ca199 ns199 0 1e-12
Ca200 ns200 0 1e-12
Ra199 ns199 0 30.2651538335 noise=0
Ra200 ns200 0 30.2651538335 noise=0
Ga199 ns199 0 ns200 0 -0.398051468393
Ga200 ns200 0 ns199 0 0.398051468393
Ca201 ns201 0 1e-12
Ca202 ns202 0 1e-12
Ra201 ns201 0 45.9593730353 noise=0
Ra202 ns202 0 45.9593730353 noise=0
Ga201 ns201 0 ns202 0 -0.376970230653
Ga202 ns202 0 ns201 0 0.376970230653
Ca203 ns203 0 1e-12
Ca204 ns204 0 1e-12
Ra203 ns203 0 22.8012326672 noise=0
Ra204 ns204 0 22.8012326672 noise=0
Ga203 ns203 0 ns204 0 -0.365000471119
Ga204 ns204 0 ns203 0 0.365000471119
Ca205 ns205 0 1e-12
Ca206 ns206 0 1e-12
Ra205 ns205 0 27.2711114272 noise=0
Ra206 ns206 0 27.2711114272 noise=0
Ga205 ns205 0 ns206 0 -0.30562060416
Ga206 ns206 0 ns205 0 0.30562060416
Ca207 ns207 0 1e-12
Ca208 ns208 0 1e-12
Ra207 ns207 0 36.1574626321 noise=0
Ra208 ns208 0 36.1574626321 noise=0
Ga207 ns207 0 ns208 0 -0.285967392433
Ga208 ns208 0 ns207 0 0.285967392433
Ca209 ns209 0 1e-12
Ca210 ns210 0 1e-12
Ra209 ns209 0 29.7569279687 noise=0
Ra210 ns210 0 29.7569279687 noise=0
Ga209 ns209 0 ns210 0 -0.276381759385
Ga210 ns210 0 ns209 0 0.276381759385
Ca211 ns211 0 1e-12
Ca212 ns212 0 1e-12
Ra211 ns211 0 20.4882528217 noise=0
Ra212 ns212 0 20.4882528217 noise=0
Ga211 ns211 0 ns212 0 -0.222396936817
Ga212 ns212 0 ns211 0 0.222396936817
Ca213 ns213 0 1e-12
Ca214 ns214 0 1e-12
Ra213 ns213 0 33.0904520292 noise=0
Ra214 ns214 0 33.0904520292 noise=0
Ga213 ns213 0 ns214 0 -0.193660507824
Ga214 ns214 0 ns213 0 0.193660507824
Ca215 ns215 0 1e-12
Ca216 ns216 0 1e-12
Ra215 ns215 0 34.81602158 noise=0
Ra216 ns216 0 34.81602158 noise=0
Ga215 ns215 0 ns216 0 -0.193389614476
Ga216 ns216 0 ns215 0 0.193389614476
Ca217 ns217 0 1e-12
Ca218 ns218 0 1e-12
Ra217 ns217 0 19.0488873153 noise=0
Ra218 ns218 0 19.0488873153 noise=0
Ga217 ns217 0 ns218 0 -0.118879593805
Ga218 ns218 0 ns217 0 0.118879593805
Ca219 ns219 0 1e-12
Ca220 ns220 0 1e-12
Ra219 ns219 0 38.9664963377 noise=0
Ra220 ns220 0 38.9664963377 noise=0
Ga219 ns219 0 ns220 0 -0.098928422879
Ga220 ns220 0 ns219 0 0.098928422879
Ca221 ns221 0 1e-12
Ca222 ns222 0 1e-12
Ra221 ns221 0 22.7620283637 noise=0
Ra222 ns222 0 22.7620283637 noise=0
Ga221 ns221 0 ns222 0 -0.0899282175659
Ga222 ns222 0 ns221 0 0.0899282175659
Ca223 ns223 0 1e-12
Ca224 ns224 0 1e-12
Ra223 ns223 0 21.1351530279 noise=0
Ra224 ns224 0 21.1351530279 noise=0
Ga223 ns223 0 ns224 0 -0.0231807799965
Ga224 ns224 0 ns223 0 0.0231807799965
Ca225 ns225 0 1e-12
Ra225 ns225 0 35.5013141349 noise=0
Ca226 ns226 0 1e-12
Ra226 ns226 0 1368.82509734 noise=0
Ca227 ns227 0 1e-12
Ra227 ns227 0 13570.4439484 noise=0
Ca228 ns228 0 1e-12
Ra228 ns228 0 4070.84562835 noise=0
Ca229 ns229 0 1e-12
Ra229 ns229 0 0.37257923819 noise=0
Ca230 ns230 0 1e-12
Ra230 ns230 0 0.636680753855 noise=0
Ca231 ns231 0 1e-12
Ca232 ns232 0 1e-12
Ra231 ns231 0 5.81195360108 noise=0
Ra232 ns232 0 5.81195360108 noise=0
Ga231 ns231 0 ns232 0 -0.440242930677
Ga232 ns232 0 ns231 0 0.440242930677
Ca233 ns233 0 1e-12
Ca234 ns234 0 1e-12
Ra233 ns233 0 25.0988766288 noise=0
Ra234 ns234 0 25.0988766288 noise=0
Ga233 ns233 0 ns234 0 -0.446182178947
Ga234 ns234 0 ns233 0 0.446182178947
Ca235 ns235 0 1e-12
Ca236 ns236 0 1e-12
Ra235 ns235 0 33.7291568883 noise=0
Ra236 ns236 0 33.7291568883 noise=0
Ga235 ns235 0 ns236 0 -0.437411009606
Ga236 ns236 0 ns235 0 0.437411009606
Ca237 ns237 0 1e-12
Ca238 ns238 0 1e-12
Ra237 ns237 0 30.2651538335 noise=0
Ra238 ns238 0 30.2651538335 noise=0
Ga237 ns237 0 ns238 0 -0.398051468393
Ga238 ns238 0 ns237 0 0.398051468393
Ca239 ns239 0 1e-12
Ca240 ns240 0 1e-12
Ra239 ns239 0 45.9593730353 noise=0
Ra240 ns240 0 45.9593730353 noise=0
Ga239 ns239 0 ns240 0 -0.376970230653
Ga240 ns240 0 ns239 0 0.376970230653
Ca241 ns241 0 1e-12
Ca242 ns242 0 1e-12
Ra241 ns241 0 22.8012326672 noise=0
Ra242 ns242 0 22.8012326672 noise=0
Ga241 ns241 0 ns242 0 -0.365000471119
Ga242 ns242 0 ns241 0 0.365000471119
Ca243 ns243 0 1e-12
Ca244 ns244 0 1e-12
Ra243 ns243 0 27.2711114272 noise=0
Ra244 ns244 0 27.2711114272 noise=0
Ga243 ns243 0 ns244 0 -0.30562060416
Ga244 ns244 0 ns243 0 0.30562060416
Ca245 ns245 0 1e-12
Ca246 ns246 0 1e-12
Ra245 ns245 0 36.1574626321 noise=0
Ra246 ns246 0 36.1574626321 noise=0
Ga245 ns245 0 ns246 0 -0.285967392433
Ga246 ns246 0 ns245 0 0.285967392433
Ca247 ns247 0 1e-12
Ca248 ns248 0 1e-12
Ra247 ns247 0 29.7569279687 noise=0
Ra248 ns248 0 29.7569279687 noise=0
Ga247 ns247 0 ns248 0 -0.276381759385
Ga248 ns248 0 ns247 0 0.276381759385
Ca249 ns249 0 1e-12
Ca250 ns250 0 1e-12
Ra249 ns249 0 20.4882528217 noise=0
Ra250 ns250 0 20.4882528217 noise=0
Ga249 ns249 0 ns250 0 -0.222396936817
Ga250 ns250 0 ns249 0 0.222396936817
Ca251 ns251 0 1e-12
Ca252 ns252 0 1e-12
Ra251 ns251 0 33.0904520292 noise=0
Ra252 ns252 0 33.0904520292 noise=0
Ga251 ns251 0 ns252 0 -0.193660507824
Ga252 ns252 0 ns251 0 0.193660507824
Ca253 ns253 0 1e-12
Ca254 ns254 0 1e-12
Ra253 ns253 0 34.81602158 noise=0
Ra254 ns254 0 34.81602158 noise=0
Ga253 ns253 0 ns254 0 -0.193389614476
Ga254 ns254 0 ns253 0 0.193389614476
Ca255 ns255 0 1e-12
Ca256 ns256 0 1e-12
Ra255 ns255 0 19.0488873153 noise=0
Ra256 ns256 0 19.0488873153 noise=0
Ga255 ns255 0 ns256 0 -0.118879593805
Ga256 ns256 0 ns255 0 0.118879593805
Ca257 ns257 0 1e-12
Ca258 ns258 0 1e-12
Ra257 ns257 0 38.9664963377 noise=0
Ra258 ns258 0 38.9664963377 noise=0
Ga257 ns257 0 ns258 0 -0.098928422879
Ga258 ns258 0 ns257 0 0.098928422879
Ca259 ns259 0 1e-12
Ca260 ns260 0 1e-12
Ra259 ns259 0 22.7620283637 noise=0
Ra260 ns260 0 22.7620283637 noise=0
Ga259 ns259 0 ns260 0 -0.0899282175659
Ga260 ns260 0 ns259 0 0.0899282175659
Ca261 ns261 0 1e-12
Ca262 ns262 0 1e-12
Ra261 ns261 0 21.1351530279 noise=0
Ra262 ns262 0 21.1351530279 noise=0
Ga261 ns261 0 ns262 0 -0.0231807799965
Ga262 ns262 0 ns261 0 0.0231807799965
Ca263 ns263 0 1e-12
Ra263 ns263 0 35.5013141349 noise=0
Ca264 ns264 0 1e-12
Ra264 ns264 0 1368.82509734 noise=0
Ca265 ns265 0 1e-12
Ra265 ns265 0 13570.4439484 noise=0
Ca266 ns266 0 1e-12
Ra266 ns266 0 4070.84562835 noise=0
Ca267 ns267 0 1e-12
Ra267 ns267 0 0.37257923819 noise=0
Ca268 ns268 0 1e-12
Ra268 ns268 0 0.636680753855 noise=0
Ca269 ns269 0 1e-12
Ca270 ns270 0 1e-12
Ra269 ns269 0 5.81195360108 noise=0
Ra270 ns270 0 5.81195360108 noise=0
Ga269 ns269 0 ns270 0 -0.440242930677
Ga270 ns270 0 ns269 0 0.440242930677
Ca271 ns271 0 1e-12
Ca272 ns272 0 1e-12
Ra271 ns271 0 25.0988766288 noise=0
Ra272 ns272 0 25.0988766288 noise=0
Ga271 ns271 0 ns272 0 -0.446182178947
Ga272 ns272 0 ns271 0 0.446182178947
Ca273 ns273 0 1e-12
Ca274 ns274 0 1e-12
Ra273 ns273 0 33.7291568883 noise=0
Ra274 ns274 0 33.7291568883 noise=0
Ga273 ns273 0 ns274 0 -0.437411009606
Ga274 ns274 0 ns273 0 0.437411009606
Ca275 ns275 0 1e-12
Ca276 ns276 0 1e-12
Ra275 ns275 0 30.2651538335 noise=0
Ra276 ns276 0 30.2651538335 noise=0
Ga275 ns275 0 ns276 0 -0.398051468393
Ga276 ns276 0 ns275 0 0.398051468393
Ca277 ns277 0 1e-12
Ca278 ns278 0 1e-12
Ra277 ns277 0 45.9593730353 noise=0
Ra278 ns278 0 45.9593730353 noise=0
Ga277 ns277 0 ns278 0 -0.376970230653
Ga278 ns278 0 ns277 0 0.376970230653
Ca279 ns279 0 1e-12
Ca280 ns280 0 1e-12
Ra279 ns279 0 22.8012326672 noise=0
Ra280 ns280 0 22.8012326672 noise=0
Ga279 ns279 0 ns280 0 -0.365000471119
Ga280 ns280 0 ns279 0 0.365000471119
Ca281 ns281 0 1e-12
Ca282 ns282 0 1e-12
Ra281 ns281 0 27.2711114272 noise=0
Ra282 ns282 0 27.2711114272 noise=0
Ga281 ns281 0 ns282 0 -0.30562060416
Ga282 ns282 0 ns281 0 0.30562060416
Ca283 ns283 0 1e-12
Ca284 ns284 0 1e-12
Ra283 ns283 0 36.1574626321 noise=0
Ra284 ns284 0 36.1574626321 noise=0
Ga283 ns283 0 ns284 0 -0.285967392433
Ga284 ns284 0 ns283 0 0.285967392433
Ca285 ns285 0 1e-12
Ca286 ns286 0 1e-12
Ra285 ns285 0 29.7569279687 noise=0
Ra286 ns286 0 29.7569279687 noise=0
Ga285 ns285 0 ns286 0 -0.276381759385
Ga286 ns286 0 ns285 0 0.276381759385
Ca287 ns287 0 1e-12
Ca288 ns288 0 1e-12
Ra287 ns287 0 20.4882528217 noise=0
Ra288 ns288 0 20.4882528217 noise=0
Ga287 ns287 0 ns288 0 -0.222396936817
Ga288 ns288 0 ns287 0 0.222396936817
Ca289 ns289 0 1e-12
Ca290 ns290 0 1e-12
Ra289 ns289 0 33.0904520292 noise=0
Ra290 ns290 0 33.0904520292 noise=0
Ga289 ns289 0 ns290 0 -0.193660507824
Ga290 ns290 0 ns289 0 0.193660507824
Ca291 ns291 0 1e-12
Ca292 ns292 0 1e-12
Ra291 ns291 0 34.81602158 noise=0
Ra292 ns292 0 34.81602158 noise=0
Ga291 ns291 0 ns292 0 -0.193389614476
Ga292 ns292 0 ns291 0 0.193389614476
Ca293 ns293 0 1e-12
Ca294 ns294 0 1e-12
Ra293 ns293 0 19.0488873153 noise=0
Ra294 ns294 0 19.0488873153 noise=0
Ga293 ns293 0 ns294 0 -0.118879593805
Ga294 ns294 0 ns293 0 0.118879593805
Ca295 ns295 0 1e-12
Ca296 ns296 0 1e-12
Ra295 ns295 0 38.9664963377 noise=0
Ra296 ns296 0 38.9664963377 noise=0
Ga295 ns295 0 ns296 0 -0.098928422879
Ga296 ns296 0 ns295 0 0.098928422879
Ca297 ns297 0 1e-12
Ca298 ns298 0 1e-12
Ra297 ns297 0 22.7620283637 noise=0
Ra298 ns298 0 22.7620283637 noise=0
Ga297 ns297 0 ns298 0 -0.0899282175659
Ga298 ns298 0 ns297 0 0.0899282175659
Ca299 ns299 0 1e-12
Ca300 ns300 0 1e-12
Ra299 ns299 0 21.1351530279 noise=0
Ra300 ns300 0 21.1351530279 noise=0
Ga299 ns299 0 ns300 0 -0.0231807799965
Ga300 ns300 0 ns299 0 0.0231807799965
Ca301 ns301 0 1e-12
Ra301 ns301 0 35.5013141349 noise=0
Ca302 ns302 0 1e-12
Ra302 ns302 0 1368.82509734 noise=0
Ca303 ns303 0 1e-12
Ra303 ns303 0 13570.4439484 noise=0
Ca304 ns304 0 1e-12
Ra304 ns304 0 4070.84562835 noise=0
Ca305 ns305 0 1e-12
Ra305 ns305 0 0.37257923819 noise=0
Ca306 ns306 0 1e-12
Ra306 ns306 0 0.636680753855 noise=0
Ca307 ns307 0 1e-12
Ca308 ns308 0 1e-12
Ra307 ns307 0 5.81195360108 noise=0
Ra308 ns308 0 5.81195360108 noise=0
Ga307 ns307 0 ns308 0 -0.440242930677
Ga308 ns308 0 ns307 0 0.440242930677
Ca309 ns309 0 1e-12
Ca310 ns310 0 1e-12
Ra309 ns309 0 25.0988766288 noise=0
Ra310 ns310 0 25.0988766288 noise=0
Ga309 ns309 0 ns310 0 -0.446182178947
Ga310 ns310 0 ns309 0 0.446182178947
Ca311 ns311 0 1e-12
Ca312 ns312 0 1e-12
Ra311 ns311 0 33.7291568883 noise=0
Ra312 ns312 0 33.7291568883 noise=0
Ga311 ns311 0 ns312 0 -0.437411009606
Ga312 ns312 0 ns311 0 0.437411009606
Ca313 ns313 0 1e-12
Ca314 ns314 0 1e-12
Ra313 ns313 0 30.2651538335 noise=0
Ra314 ns314 0 30.2651538335 noise=0
Ga313 ns313 0 ns314 0 -0.398051468393
Ga314 ns314 0 ns313 0 0.398051468393
Ca315 ns315 0 1e-12
Ca316 ns316 0 1e-12
Ra315 ns315 0 45.9593730353 noise=0
Ra316 ns316 0 45.9593730353 noise=0
Ga315 ns315 0 ns316 0 -0.376970230653
Ga316 ns316 0 ns315 0 0.376970230653
Ca317 ns317 0 1e-12
Ca318 ns318 0 1e-12
Ra317 ns317 0 22.8012326672 noise=0
Ra318 ns318 0 22.8012326672 noise=0
Ga317 ns317 0 ns318 0 -0.365000471119
Ga318 ns318 0 ns317 0 0.365000471119
Ca319 ns319 0 1e-12
Ca320 ns320 0 1e-12
Ra319 ns319 0 27.2711114272 noise=0
Ra320 ns320 0 27.2711114272 noise=0
Ga319 ns319 0 ns320 0 -0.30562060416
Ga320 ns320 0 ns319 0 0.30562060416
Ca321 ns321 0 1e-12
Ca322 ns322 0 1e-12
Ra321 ns321 0 36.1574626321 noise=0
Ra322 ns322 0 36.1574626321 noise=0
Ga321 ns321 0 ns322 0 -0.285967392433
Ga322 ns322 0 ns321 0 0.285967392433
Ca323 ns323 0 1e-12
Ca324 ns324 0 1e-12
Ra323 ns323 0 29.7569279687 noise=0
Ra324 ns324 0 29.7569279687 noise=0
Ga323 ns323 0 ns324 0 -0.276381759385
Ga324 ns324 0 ns323 0 0.276381759385
Ca325 ns325 0 1e-12
Ca326 ns326 0 1e-12
Ra325 ns325 0 20.4882528217 noise=0
Ra326 ns326 0 20.4882528217 noise=0
Ga325 ns325 0 ns326 0 -0.222396936817
Ga326 ns326 0 ns325 0 0.222396936817
Ca327 ns327 0 1e-12
Ca328 ns328 0 1e-12
Ra327 ns327 0 33.0904520292 noise=0
Ra328 ns328 0 33.0904520292 noise=0
Ga327 ns327 0 ns328 0 -0.193660507824
Ga328 ns328 0 ns327 0 0.193660507824
Ca329 ns329 0 1e-12
Ca330 ns330 0 1e-12
Ra329 ns329 0 34.81602158 noise=0
Ra330 ns330 0 34.81602158 noise=0
Ga329 ns329 0 ns330 0 -0.193389614476
Ga330 ns330 0 ns329 0 0.193389614476
Ca331 ns331 0 1e-12
Ca332 ns332 0 1e-12
Ra331 ns331 0 19.0488873153 noise=0
Ra332 ns332 0 19.0488873153 noise=0
Ga331 ns331 0 ns332 0 -0.118879593805
Ga332 ns332 0 ns331 0 0.118879593805
Ca333 ns333 0 1e-12
Ca334 ns334 0 1e-12
Ra333 ns333 0 38.9664963377 noise=0
Ra334 ns334 0 38.9664963377 noise=0
Ga333 ns333 0 ns334 0 -0.098928422879
Ga334 ns334 0 ns333 0 0.098928422879
Ca335 ns335 0 1e-12
Ca336 ns336 0 1e-12
Ra335 ns335 0 22.7620283637 noise=0
Ra336 ns336 0 22.7620283637 noise=0
Ga335 ns335 0 ns336 0 -0.0899282175659
Ga336 ns336 0 ns335 0 0.0899282175659
Ca337 ns337 0 1e-12
Ca338 ns338 0 1e-12
Ra337 ns337 0 21.1351530279 noise=0
Ra338 ns338 0 21.1351530279 noise=0
Ga337 ns337 0 ns338 0 -0.0231807799965
Ga338 ns338 0 ns337 0 0.0231807799965
Ca339 ns339 0 1e-12
Ra339 ns339 0 35.5013141349 noise=0
Ca340 ns340 0 1e-12
Ra340 ns340 0 1368.82509734 noise=0
Ca341 ns341 0 1e-12
Ra341 ns341 0 13570.4439484 noise=0
Ca342 ns342 0 1e-12
Ra342 ns342 0 4070.84562835 noise=0
Ca343 ns343 0 1e-12
Ra343 ns343 0 0.37257923819 noise=0
Ca344 ns344 0 1e-12
Ra344 ns344 0 0.636680753855 noise=0
Ca345 ns345 0 1e-12
Ca346 ns346 0 1e-12
Ra345 ns345 0 5.81195360108 noise=0
Ra346 ns346 0 5.81195360108 noise=0
Ga345 ns345 0 ns346 0 -0.440242930677
Ga346 ns346 0 ns345 0 0.440242930677
Ca347 ns347 0 1e-12
Ca348 ns348 0 1e-12
Ra347 ns347 0 25.0988766288 noise=0
Ra348 ns348 0 25.0988766288 noise=0
Ga347 ns347 0 ns348 0 -0.446182178947
Ga348 ns348 0 ns347 0 0.446182178947
Ca349 ns349 0 1e-12
Ca350 ns350 0 1e-12
Ra349 ns349 0 33.7291568883 noise=0
Ra350 ns350 0 33.7291568883 noise=0
Ga349 ns349 0 ns350 0 -0.437411009606
Ga350 ns350 0 ns349 0 0.437411009606
Ca351 ns351 0 1e-12
Ca352 ns352 0 1e-12
Ra351 ns351 0 30.2651538335 noise=0
Ra352 ns352 0 30.2651538335 noise=0
Ga351 ns351 0 ns352 0 -0.398051468393
Ga352 ns352 0 ns351 0 0.398051468393
Ca353 ns353 0 1e-12
Ca354 ns354 0 1e-12
Ra353 ns353 0 45.9593730353 noise=0
Ra354 ns354 0 45.9593730353 noise=0
Ga353 ns353 0 ns354 0 -0.376970230653
Ga354 ns354 0 ns353 0 0.376970230653
Ca355 ns355 0 1e-12
Ca356 ns356 0 1e-12
Ra355 ns355 0 22.8012326672 noise=0
Ra356 ns356 0 22.8012326672 noise=0
Ga355 ns355 0 ns356 0 -0.365000471119
Ga356 ns356 0 ns355 0 0.365000471119
Ca357 ns357 0 1e-12
Ca358 ns358 0 1e-12
Ra357 ns357 0 27.2711114272 noise=0
Ra358 ns358 0 27.2711114272 noise=0
Ga357 ns357 0 ns358 0 -0.30562060416
Ga358 ns358 0 ns357 0 0.30562060416
Ca359 ns359 0 1e-12
Ca360 ns360 0 1e-12
Ra359 ns359 0 36.1574626321 noise=0
Ra360 ns360 0 36.1574626321 noise=0
Ga359 ns359 0 ns360 0 -0.285967392433
Ga360 ns360 0 ns359 0 0.285967392433
Ca361 ns361 0 1e-12
Ca362 ns362 0 1e-12
Ra361 ns361 0 29.7569279687 noise=0
Ra362 ns362 0 29.7569279687 noise=0
Ga361 ns361 0 ns362 0 -0.276381759385
Ga362 ns362 0 ns361 0 0.276381759385
Ca363 ns363 0 1e-12
Ca364 ns364 0 1e-12
Ra363 ns363 0 20.4882528217 noise=0
Ra364 ns364 0 20.4882528217 noise=0
Ga363 ns363 0 ns364 0 -0.222396936817
Ga364 ns364 0 ns363 0 0.222396936817
Ca365 ns365 0 1e-12
Ca366 ns366 0 1e-12
Ra365 ns365 0 33.0904520292 noise=0
Ra366 ns366 0 33.0904520292 noise=0
Ga365 ns365 0 ns366 0 -0.193660507824
Ga366 ns366 0 ns365 0 0.193660507824
Ca367 ns367 0 1e-12
Ca368 ns368 0 1e-12
Ra367 ns367 0 34.81602158 noise=0
Ra368 ns368 0 34.81602158 noise=0
Ga367 ns367 0 ns368 0 -0.193389614476
Ga368 ns368 0 ns367 0 0.193389614476
Ca369 ns369 0 1e-12
Ca370 ns370 0 1e-12
Ra369 ns369 0 19.0488873153 noise=0
Ra370 ns370 0 19.0488873153 noise=0
Ga369 ns369 0 ns370 0 -0.118879593805
Ga370 ns370 0 ns369 0 0.118879593805
Ca371 ns371 0 1e-12
Ca372 ns372 0 1e-12
Ra371 ns371 0 38.9664963377 noise=0
Ra372 ns372 0 38.9664963377 noise=0
Ga371 ns371 0 ns372 0 -0.098928422879
Ga372 ns372 0 ns371 0 0.098928422879
Ca373 ns373 0 1e-12
Ca374 ns374 0 1e-12
Ra373 ns373 0 22.7620283637 noise=0
Ra374 ns374 0 22.7620283637 noise=0
Ga373 ns373 0 ns374 0 -0.0899282175659
Ga374 ns374 0 ns373 0 0.0899282175659
Ca375 ns375 0 1e-12
Ca376 ns376 0 1e-12
Ra375 ns375 0 21.1351530279 noise=0
Ra376 ns376 0 21.1351530279 noise=0
Ga375 ns375 0 ns376 0 -0.0231807799965
Ga376 ns376 0 ns375 0 0.0231807799965
Ca377 ns377 0 1e-12
Ra377 ns377 0 35.5013141349 noise=0
Ca378 ns378 0 1e-12
Ra378 ns378 0 1368.82509734 noise=0
Ca379 ns379 0 1e-12
Ra379 ns379 0 13570.4439484 noise=0
Ca380 ns380 0 1e-12
Ra380 ns380 0 4070.84562835 noise=0
Ca381 ns381 0 1e-12
Ra381 ns381 0 0.37257923819 noise=0
Ca382 ns382 0 1e-12
Ra382 ns382 0 0.636680753855 noise=0
Ca383 ns383 0 1e-12
Ca384 ns384 0 1e-12
Ra383 ns383 0 5.81195360108 noise=0
Ra384 ns384 0 5.81195360108 noise=0
Ga383 ns383 0 ns384 0 -0.440242930677
Ga384 ns384 0 ns383 0 0.440242930677
Ca385 ns385 0 1e-12
Ca386 ns386 0 1e-12
Ra385 ns385 0 25.0988766288 noise=0
Ra386 ns386 0 25.0988766288 noise=0
Ga385 ns385 0 ns386 0 -0.446182178947
Ga386 ns386 0 ns385 0 0.446182178947
Ca387 ns387 0 1e-12
Ca388 ns388 0 1e-12
Ra387 ns387 0 33.7291568883 noise=0
Ra388 ns388 0 33.7291568883 noise=0
Ga387 ns387 0 ns388 0 -0.437411009606
Ga388 ns388 0 ns387 0 0.437411009606
Ca389 ns389 0 1e-12
Ca390 ns390 0 1e-12
Ra389 ns389 0 30.2651538335 noise=0
Ra390 ns390 0 30.2651538335 noise=0
Ga389 ns389 0 ns390 0 -0.398051468393
Ga390 ns390 0 ns389 0 0.398051468393
Ca391 ns391 0 1e-12
Ca392 ns392 0 1e-12
Ra391 ns391 0 45.9593730353 noise=0
Ra392 ns392 0 45.9593730353 noise=0
Ga391 ns391 0 ns392 0 -0.376970230653
Ga392 ns392 0 ns391 0 0.376970230653
Ca393 ns393 0 1e-12
Ca394 ns394 0 1e-12
Ra393 ns393 0 22.8012326672 noise=0
Ra394 ns394 0 22.8012326672 noise=0
Ga393 ns393 0 ns394 0 -0.365000471119
Ga394 ns394 0 ns393 0 0.365000471119
Ca395 ns395 0 1e-12
Ca396 ns396 0 1e-12
Ra395 ns395 0 27.2711114272 noise=0
Ra396 ns396 0 27.2711114272 noise=0
Ga395 ns395 0 ns396 0 -0.30562060416
Ga396 ns396 0 ns395 0 0.30562060416
Ca397 ns397 0 1e-12
Ca398 ns398 0 1e-12
Ra397 ns397 0 36.1574626321 noise=0
Ra398 ns398 0 36.1574626321 noise=0
Ga397 ns397 0 ns398 0 -0.285967392433
Ga398 ns398 0 ns397 0 0.285967392433
Ca399 ns399 0 1e-12
Ca400 ns400 0 1e-12
Ra399 ns399 0 29.7569279687 noise=0
Ra400 ns400 0 29.7569279687 noise=0
Ga399 ns399 0 ns400 0 -0.276381759385
Ga400 ns400 0 ns399 0 0.276381759385
Ca401 ns401 0 1e-12
Ca402 ns402 0 1e-12
Ra401 ns401 0 20.4882528217 noise=0
Ra402 ns402 0 20.4882528217 noise=0
Ga401 ns401 0 ns402 0 -0.222396936817
Ga402 ns402 0 ns401 0 0.222396936817
Ca403 ns403 0 1e-12
Ca404 ns404 0 1e-12
Ra403 ns403 0 33.0904520292 noise=0
Ra404 ns404 0 33.0904520292 noise=0
Ga403 ns403 0 ns404 0 -0.193660507824
Ga404 ns404 0 ns403 0 0.193660507824
Ca405 ns405 0 1e-12
Ca406 ns406 0 1e-12
Ra405 ns405 0 34.81602158 noise=0
Ra406 ns406 0 34.81602158 noise=0
Ga405 ns405 0 ns406 0 -0.193389614476
Ga406 ns406 0 ns405 0 0.193389614476
Ca407 ns407 0 1e-12
Ca408 ns408 0 1e-12
Ra407 ns407 0 19.0488873153 noise=0
Ra408 ns408 0 19.0488873153 noise=0
Ga407 ns407 0 ns408 0 -0.118879593805
Ga408 ns408 0 ns407 0 0.118879593805
Ca409 ns409 0 1e-12
Ca410 ns410 0 1e-12
Ra409 ns409 0 38.9664963377 noise=0
Ra410 ns410 0 38.9664963377 noise=0
Ga409 ns409 0 ns410 0 -0.098928422879
Ga410 ns410 0 ns409 0 0.098928422879
Ca411 ns411 0 1e-12
Ca412 ns412 0 1e-12
Ra411 ns411 0 22.7620283637 noise=0
Ra412 ns412 0 22.7620283637 noise=0
Ga411 ns411 0 ns412 0 -0.0899282175659
Ga412 ns412 0 ns411 0 0.0899282175659
Ca413 ns413 0 1e-12
Ca414 ns414 0 1e-12
Ra413 ns413 0 21.1351530279 noise=0
Ra414 ns414 0 21.1351530279 noise=0
Ga413 ns413 0 ns414 0 -0.0231807799965
Ga414 ns414 0 ns413 0 0.0231807799965
Ca415 ns415 0 1e-12
Ra415 ns415 0 35.5013141349 noise=0
Ca416 ns416 0 1e-12
Ra416 ns416 0 1368.82509734 noise=0
Ca417 ns417 0 1e-12
Ra417 ns417 0 13570.4439484 noise=0
Ca418 ns418 0 1e-12
Ra418 ns418 0 4070.84562835 noise=0
Ca419 ns419 0 1e-12
Ra419 ns419 0 0.37257923819 noise=0
Ca420 ns420 0 1e-12
Ra420 ns420 0 0.636680753855 noise=0
Ca421 ns421 0 1e-12
Ca422 ns422 0 1e-12
Ra421 ns421 0 5.81195360108 noise=0
Ra422 ns422 0 5.81195360108 noise=0
Ga421 ns421 0 ns422 0 -0.440242930677
Ga422 ns422 0 ns421 0 0.440242930677
Ca423 ns423 0 1e-12
Ca424 ns424 0 1e-12
Ra423 ns423 0 25.0988766288 noise=0
Ra424 ns424 0 25.0988766288 noise=0
Ga423 ns423 0 ns424 0 -0.446182178947
Ga424 ns424 0 ns423 0 0.446182178947
Ca425 ns425 0 1e-12
Ca426 ns426 0 1e-12
Ra425 ns425 0 33.7291568883 noise=0
Ra426 ns426 0 33.7291568883 noise=0
Ga425 ns425 0 ns426 0 -0.437411009606
Ga426 ns426 0 ns425 0 0.437411009606
Ca427 ns427 0 1e-12
Ca428 ns428 0 1e-12
Ra427 ns427 0 30.2651538335 noise=0
Ra428 ns428 0 30.2651538335 noise=0
Ga427 ns427 0 ns428 0 -0.398051468393
Ga428 ns428 0 ns427 0 0.398051468393
Ca429 ns429 0 1e-12
Ca430 ns430 0 1e-12
Ra429 ns429 0 45.9593730353 noise=0
Ra430 ns430 0 45.9593730353 noise=0
Ga429 ns429 0 ns430 0 -0.376970230653
Ga430 ns430 0 ns429 0 0.376970230653
Ca431 ns431 0 1e-12
Ca432 ns432 0 1e-12
Ra431 ns431 0 22.8012326672 noise=0
Ra432 ns432 0 22.8012326672 noise=0
Ga431 ns431 0 ns432 0 -0.365000471119
Ga432 ns432 0 ns431 0 0.365000471119
Ca433 ns433 0 1e-12
Ca434 ns434 0 1e-12
Ra433 ns433 0 27.2711114272 noise=0
Ra434 ns434 0 27.2711114272 noise=0
Ga433 ns433 0 ns434 0 -0.30562060416
Ga434 ns434 0 ns433 0 0.30562060416
Ca435 ns435 0 1e-12
Ca436 ns436 0 1e-12
Ra435 ns435 0 36.1574626321 noise=0
Ra436 ns436 0 36.1574626321 noise=0
Ga435 ns435 0 ns436 0 -0.285967392433
Ga436 ns436 0 ns435 0 0.285967392433
Ca437 ns437 0 1e-12
Ca438 ns438 0 1e-12
Ra437 ns437 0 29.7569279687 noise=0
Ra438 ns438 0 29.7569279687 noise=0
Ga437 ns437 0 ns438 0 -0.276381759385
Ga438 ns438 0 ns437 0 0.276381759385
Ca439 ns439 0 1e-12
Ca440 ns440 0 1e-12
Ra439 ns439 0 20.4882528217 noise=0
Ra440 ns440 0 20.4882528217 noise=0
Ga439 ns439 0 ns440 0 -0.222396936817
Ga440 ns440 0 ns439 0 0.222396936817
Ca441 ns441 0 1e-12
Ca442 ns442 0 1e-12
Ra441 ns441 0 33.0904520292 noise=0
Ra442 ns442 0 33.0904520292 noise=0
Ga441 ns441 0 ns442 0 -0.193660507824
Ga442 ns442 0 ns441 0 0.193660507824
Ca443 ns443 0 1e-12
Ca444 ns444 0 1e-12
Ra443 ns443 0 34.81602158 noise=0
Ra444 ns444 0 34.81602158 noise=0
Ga443 ns443 0 ns444 0 -0.193389614476
Ga444 ns444 0 ns443 0 0.193389614476
Ca445 ns445 0 1e-12
Ca446 ns446 0 1e-12
Ra445 ns445 0 19.0488873153 noise=0
Ra446 ns446 0 19.0488873153 noise=0
Ga445 ns445 0 ns446 0 -0.118879593805
Ga446 ns446 0 ns445 0 0.118879593805
Ca447 ns447 0 1e-12
Ca448 ns448 0 1e-12
Ra447 ns447 0 38.9664963377 noise=0
Ra448 ns448 0 38.9664963377 noise=0
Ga447 ns447 0 ns448 0 -0.098928422879
Ga448 ns448 0 ns447 0 0.098928422879
Ca449 ns449 0 1e-12
Ca450 ns450 0 1e-12
Ra449 ns449 0 22.7620283637 noise=0
Ra450 ns450 0 22.7620283637 noise=0
Ga449 ns449 0 ns450 0 -0.0899282175659
Ga450 ns450 0 ns449 0 0.0899282175659
Ca451 ns451 0 1e-12
Ca452 ns452 0 1e-12
Ra451 ns451 0 21.1351530279 noise=0
Ra452 ns452 0 21.1351530279 noise=0
Ga451 ns451 0 ns452 0 -0.0231807799965
Ga452 ns452 0 ns451 0 0.0231807799965
Ca453 ns453 0 1e-12
Ra453 ns453 0 35.5013141349 noise=0
Ca454 ns454 0 1e-12
Ra454 ns454 0 1368.82509734 noise=0
Ca455 ns455 0 1e-12
Ra455 ns455 0 13570.4439484 noise=0
Ca456 ns456 0 1e-12
Ra456 ns456 0 4070.84562835 noise=0
Ca457 ns457 0 1e-12
Ra457 ns457 0 0.37257923819 noise=0
Ca458 ns458 0 1e-12
Ra458 ns458 0 0.636680753855 noise=0
Ca459 ns459 0 1e-12
Ca460 ns460 0 1e-12
Ra459 ns459 0 5.81195360108 noise=0
Ra460 ns460 0 5.81195360108 noise=0
Ga459 ns459 0 ns460 0 -0.440242930677
Ga460 ns460 0 ns459 0 0.440242930677
Ca461 ns461 0 1e-12
Ca462 ns462 0 1e-12
Ra461 ns461 0 25.0988766288 noise=0
Ra462 ns462 0 25.0988766288 noise=0
Ga461 ns461 0 ns462 0 -0.446182178947
Ga462 ns462 0 ns461 0 0.446182178947
Ca463 ns463 0 1e-12
Ca464 ns464 0 1e-12
Ra463 ns463 0 33.7291568883 noise=0
Ra464 ns464 0 33.7291568883 noise=0
Ga463 ns463 0 ns464 0 -0.437411009606
Ga464 ns464 0 ns463 0 0.437411009606
Ca465 ns465 0 1e-12
Ca466 ns466 0 1e-12
Ra465 ns465 0 30.2651538335 noise=0
Ra466 ns466 0 30.2651538335 noise=0
Ga465 ns465 0 ns466 0 -0.398051468393
Ga466 ns466 0 ns465 0 0.398051468393
Ca467 ns467 0 1e-12
Ca468 ns468 0 1e-12
Ra467 ns467 0 45.9593730353 noise=0
Ra468 ns468 0 45.9593730353 noise=0
Ga467 ns467 0 ns468 0 -0.376970230653
Ga468 ns468 0 ns467 0 0.376970230653
Ca469 ns469 0 1e-12
Ca470 ns470 0 1e-12
Ra469 ns469 0 22.8012326672 noise=0
Ra470 ns470 0 22.8012326672 noise=0
Ga469 ns469 0 ns470 0 -0.365000471119
Ga470 ns470 0 ns469 0 0.365000471119
Ca471 ns471 0 1e-12
Ca472 ns472 0 1e-12
Ra471 ns471 0 27.2711114272 noise=0
Ra472 ns472 0 27.2711114272 noise=0
Ga471 ns471 0 ns472 0 -0.30562060416
Ga472 ns472 0 ns471 0 0.30562060416
Ca473 ns473 0 1e-12
Ca474 ns474 0 1e-12
Ra473 ns473 0 36.1574626321 noise=0
Ra474 ns474 0 36.1574626321 noise=0
Ga473 ns473 0 ns474 0 -0.285967392433
Ga474 ns474 0 ns473 0 0.285967392433
Ca475 ns475 0 1e-12
Ca476 ns476 0 1e-12
Ra475 ns475 0 29.7569279687 noise=0
Ra476 ns476 0 29.7569279687 noise=0
Ga475 ns475 0 ns476 0 -0.276381759385
Ga476 ns476 0 ns475 0 0.276381759385
Ca477 ns477 0 1e-12
Ca478 ns478 0 1e-12
Ra477 ns477 0 20.4882528217 noise=0
Ra478 ns478 0 20.4882528217 noise=0
Ga477 ns477 0 ns478 0 -0.222396936817
Ga478 ns478 0 ns477 0 0.222396936817
Ca479 ns479 0 1e-12
Ca480 ns480 0 1e-12
Ra479 ns479 0 33.0904520292 noise=0
Ra480 ns480 0 33.0904520292 noise=0
Ga479 ns479 0 ns480 0 -0.193660507824
Ga480 ns480 0 ns479 0 0.193660507824
Ca481 ns481 0 1e-12
Ca482 ns482 0 1e-12
Ra481 ns481 0 34.81602158 noise=0
Ra482 ns482 0 34.81602158 noise=0
Ga481 ns481 0 ns482 0 -0.193389614476
Ga482 ns482 0 ns481 0 0.193389614476
Ca483 ns483 0 1e-12
Ca484 ns484 0 1e-12
Ra483 ns483 0 19.0488873153 noise=0
Ra484 ns484 0 19.0488873153 noise=0
Ga483 ns483 0 ns484 0 -0.118879593805
Ga484 ns484 0 ns483 0 0.118879593805
Ca485 ns485 0 1e-12
Ca486 ns486 0 1e-12
Ra485 ns485 0 38.9664963377 noise=0
Ra486 ns486 0 38.9664963377 noise=0
Ga485 ns485 0 ns486 0 -0.098928422879
Ga486 ns486 0 ns485 0 0.098928422879
Ca487 ns487 0 1e-12
Ca488 ns488 0 1e-12
Ra487 ns487 0 22.7620283637 noise=0
Ra488 ns488 0 22.7620283637 noise=0
Ga487 ns487 0 ns488 0 -0.0899282175659
Ga488 ns488 0 ns487 0 0.0899282175659
Ca489 ns489 0 1e-12
Ca490 ns490 0 1e-12
Ra489 ns489 0 21.1351530279 noise=0
Ra490 ns490 0 21.1351530279 noise=0
Ga489 ns489 0 ns490 0 -0.0231807799965
Ga490 ns490 0 ns489 0 0.0231807799965
Ca491 ns491 0 1e-12
Ra491 ns491 0 35.5013141349 noise=0
Ca492 ns492 0 1e-12
Ra492 ns492 0 1368.82509734 noise=0
Ca493 ns493 0 1e-12
Ra493 ns493 0 13570.4439484 noise=0
Ca494 ns494 0 1e-12
Ra494 ns494 0 4070.84562835 noise=0
Ca495 ns495 0 1e-12
Ra495 ns495 0 0.37257923819 noise=0
Ca496 ns496 0 1e-12
Ra496 ns496 0 0.636680753855 noise=0
Ca497 ns497 0 1e-12
Ca498 ns498 0 1e-12
Ra497 ns497 0 5.81195360108 noise=0
Ra498 ns498 0 5.81195360108 noise=0
Ga497 ns497 0 ns498 0 -0.440242930677
Ga498 ns498 0 ns497 0 0.440242930677
Ca499 ns499 0 1e-12
Ca500 ns500 0 1e-12
Ra499 ns499 0 25.0988766288 noise=0
Ra500 ns500 0 25.0988766288 noise=0
Ga499 ns499 0 ns500 0 -0.446182178947
Ga500 ns500 0 ns499 0 0.446182178947
Ca501 ns501 0 1e-12
Ca502 ns502 0 1e-12
Ra501 ns501 0 33.7291568883 noise=0
Ra502 ns502 0 33.7291568883 noise=0
Ga501 ns501 0 ns502 0 -0.437411009606
Ga502 ns502 0 ns501 0 0.437411009606
Ca503 ns503 0 1e-12
Ca504 ns504 0 1e-12
Ra503 ns503 0 30.2651538335 noise=0
Ra504 ns504 0 30.2651538335 noise=0
Ga503 ns503 0 ns504 0 -0.398051468393
Ga504 ns504 0 ns503 0 0.398051468393
Ca505 ns505 0 1e-12
Ca506 ns506 0 1e-12
Ra505 ns505 0 45.9593730353 noise=0
Ra506 ns506 0 45.9593730353 noise=0
Ga505 ns505 0 ns506 0 -0.376970230653
Ga506 ns506 0 ns505 0 0.376970230653
Ca507 ns507 0 1e-12
Ca508 ns508 0 1e-12
Ra507 ns507 0 22.8012326672 noise=0
Ra508 ns508 0 22.8012326672 noise=0
Ga507 ns507 0 ns508 0 -0.365000471119
Ga508 ns508 0 ns507 0 0.365000471119
Ca509 ns509 0 1e-12
Ca510 ns510 0 1e-12
Ra509 ns509 0 27.2711114272 noise=0
Ra510 ns510 0 27.2711114272 noise=0
Ga509 ns509 0 ns510 0 -0.30562060416
Ga510 ns510 0 ns509 0 0.30562060416
Ca511 ns511 0 1e-12
Ca512 ns512 0 1e-12
Ra511 ns511 0 36.1574626321 noise=0
Ra512 ns512 0 36.1574626321 noise=0
Ga511 ns511 0 ns512 0 -0.285967392433
Ga512 ns512 0 ns511 0 0.285967392433
Ca513 ns513 0 1e-12
Ca514 ns514 0 1e-12
Ra513 ns513 0 29.7569279687 noise=0
Ra514 ns514 0 29.7569279687 noise=0
Ga513 ns513 0 ns514 0 -0.276381759385
Ga514 ns514 0 ns513 0 0.276381759385
Ca515 ns515 0 1e-12
Ca516 ns516 0 1e-12
Ra515 ns515 0 20.4882528217 noise=0
Ra516 ns516 0 20.4882528217 noise=0
Ga515 ns515 0 ns516 0 -0.222396936817
Ga516 ns516 0 ns515 0 0.222396936817
Ca517 ns517 0 1e-12
Ca518 ns518 0 1e-12
Ra517 ns517 0 33.0904520292 noise=0
Ra518 ns518 0 33.0904520292 noise=0
Ga517 ns517 0 ns518 0 -0.193660507824
Ga518 ns518 0 ns517 0 0.193660507824
Ca519 ns519 0 1e-12
Ca520 ns520 0 1e-12
Ra519 ns519 0 34.81602158 noise=0
Ra520 ns520 0 34.81602158 noise=0
Ga519 ns519 0 ns520 0 -0.193389614476
Ga520 ns520 0 ns519 0 0.193389614476
Ca521 ns521 0 1e-12
Ca522 ns522 0 1e-12
Ra521 ns521 0 19.0488873153 noise=0
Ra522 ns522 0 19.0488873153 noise=0
Ga521 ns521 0 ns522 0 -0.118879593805
Ga522 ns522 0 ns521 0 0.118879593805
Ca523 ns523 0 1e-12
Ca524 ns524 0 1e-12
Ra523 ns523 0 38.9664963377 noise=0
Ra524 ns524 0 38.9664963377 noise=0
Ga523 ns523 0 ns524 0 -0.098928422879
Ga524 ns524 0 ns523 0 0.098928422879
Ca525 ns525 0 1e-12
Ca526 ns526 0 1e-12
Ra525 ns525 0 22.7620283637 noise=0
Ra526 ns526 0 22.7620283637 noise=0
Ga525 ns525 0 ns526 0 -0.0899282175659
Ga526 ns526 0 ns525 0 0.0899282175659
Ca527 ns527 0 1e-12
Ca528 ns528 0 1e-12
Ra527 ns527 0 21.1351530279 noise=0
Ra528 ns528 0 21.1351530279 noise=0
Ga527 ns527 0 ns528 0 -0.0231807799965
Ga528 ns528 0 ns527 0 0.0231807799965
Ca529 ns529 0 1e-12
Ra529 ns529 0 35.5013141349 noise=0
Ca530 ns530 0 1e-12
Ra530 ns530 0 1368.82509734 noise=0
Ca531 ns531 0 1e-12
Ra531 ns531 0 13570.4439484 noise=0
Ca532 ns532 0 1e-12
Ra532 ns532 0 4070.84562835 noise=0
Ca533 ns533 0 1e-12
Ra533 ns533 0 0.37257923819 noise=0
Ca534 ns534 0 1e-12
Ra534 ns534 0 0.636680753855 noise=0
Ca535 ns535 0 1e-12
Ca536 ns536 0 1e-12
Ra535 ns535 0 5.81195360108 noise=0
Ra536 ns536 0 5.81195360108 noise=0
Ga535 ns535 0 ns536 0 -0.440242930677
Ga536 ns536 0 ns535 0 0.440242930677
Ca537 ns537 0 1e-12
Ca538 ns538 0 1e-12
Ra537 ns537 0 25.0988766288 noise=0
Ra538 ns538 0 25.0988766288 noise=0
Ga537 ns537 0 ns538 0 -0.446182178947
Ga538 ns538 0 ns537 0 0.446182178947
Ca539 ns539 0 1e-12
Ca540 ns540 0 1e-12
Ra539 ns539 0 33.7291568883 noise=0
Ra540 ns540 0 33.7291568883 noise=0
Ga539 ns539 0 ns540 0 -0.437411009606
Ga540 ns540 0 ns539 0 0.437411009606
Ca541 ns541 0 1e-12
Ca542 ns542 0 1e-12
Ra541 ns541 0 30.2651538335 noise=0
Ra542 ns542 0 30.2651538335 noise=0
Ga541 ns541 0 ns542 0 -0.398051468393
Ga542 ns542 0 ns541 0 0.398051468393
Ca543 ns543 0 1e-12
Ca544 ns544 0 1e-12
Ra543 ns543 0 45.9593730353 noise=0
Ra544 ns544 0 45.9593730353 noise=0
Ga543 ns543 0 ns544 0 -0.376970230653
Ga544 ns544 0 ns543 0 0.376970230653
Ca545 ns545 0 1e-12
Ca546 ns546 0 1e-12
Ra545 ns545 0 22.8012326672 noise=0
Ra546 ns546 0 22.8012326672 noise=0
Ga545 ns545 0 ns546 0 -0.365000471119
Ga546 ns546 0 ns545 0 0.365000471119
Ca547 ns547 0 1e-12
Ca548 ns548 0 1e-12
Ra547 ns547 0 27.2711114272 noise=0
Ra548 ns548 0 27.2711114272 noise=0
Ga547 ns547 0 ns548 0 -0.30562060416
Ga548 ns548 0 ns547 0 0.30562060416
Ca549 ns549 0 1e-12
Ca550 ns550 0 1e-12
Ra549 ns549 0 36.1574626321 noise=0
Ra550 ns550 0 36.1574626321 noise=0
Ga549 ns549 0 ns550 0 -0.285967392433
Ga550 ns550 0 ns549 0 0.285967392433
Ca551 ns551 0 1e-12
Ca552 ns552 0 1e-12
Ra551 ns551 0 29.7569279687 noise=0
Ra552 ns552 0 29.7569279687 noise=0
Ga551 ns551 0 ns552 0 -0.276381759385
Ga552 ns552 0 ns551 0 0.276381759385
Ca553 ns553 0 1e-12
Ca554 ns554 0 1e-12
Ra553 ns553 0 20.4882528217 noise=0
Ra554 ns554 0 20.4882528217 noise=0
Ga553 ns553 0 ns554 0 -0.222396936817
Ga554 ns554 0 ns553 0 0.222396936817
Ca555 ns555 0 1e-12
Ca556 ns556 0 1e-12
Ra555 ns555 0 33.0904520292 noise=0
Ra556 ns556 0 33.0904520292 noise=0
Ga555 ns555 0 ns556 0 -0.193660507824
Ga556 ns556 0 ns555 0 0.193660507824
Ca557 ns557 0 1e-12
Ca558 ns558 0 1e-12
Ra557 ns557 0 34.81602158 noise=0
Ra558 ns558 0 34.81602158 noise=0
Ga557 ns557 0 ns558 0 -0.193389614476
Ga558 ns558 0 ns557 0 0.193389614476
Ca559 ns559 0 1e-12
Ca560 ns560 0 1e-12
Ra559 ns559 0 19.0488873153 noise=0
Ra560 ns560 0 19.0488873153 noise=0
Ga559 ns559 0 ns560 0 -0.118879593805
Ga560 ns560 0 ns559 0 0.118879593805
Ca561 ns561 0 1e-12
Ca562 ns562 0 1e-12
Ra561 ns561 0 38.9664963377 noise=0
Ra562 ns562 0 38.9664963377 noise=0
Ga561 ns561 0 ns562 0 -0.098928422879
Ga562 ns562 0 ns561 0 0.098928422879
Ca563 ns563 0 1e-12
Ca564 ns564 0 1e-12
Ra563 ns563 0 22.7620283637 noise=0
Ra564 ns564 0 22.7620283637 noise=0
Ga563 ns563 0 ns564 0 -0.0899282175659
Ga564 ns564 0 ns563 0 0.0899282175659
Ca565 ns565 0 1e-12
Ca566 ns566 0 1e-12
Ra565 ns565 0 21.1351530279 noise=0
Ra566 ns566 0 21.1351530279 noise=0
Ga565 ns565 0 ns566 0 -0.0231807799965
Ga566 ns566 0 ns565 0 0.0231807799965
Ca567 ns567 0 1e-12
Ra567 ns567 0 35.5013141349 noise=0
Ca568 ns568 0 1e-12
Ra568 ns568 0 1368.82509734 noise=0
Ca569 ns569 0 1e-12
Ra569 ns569 0 13570.4439484 noise=0
Ca570 ns570 0 1e-12
Ra570 ns570 0 4070.84562835 noise=0
Ca571 ns571 0 1e-12
Ra571 ns571 0 0.37257923819 noise=0
Ca572 ns572 0 1e-12
Ra572 ns572 0 0.636680753855 noise=0
Ca573 ns573 0 1e-12
Ca574 ns574 0 1e-12
Ra573 ns573 0 5.81195360108 noise=0
Ra574 ns574 0 5.81195360108 noise=0
Ga573 ns573 0 ns574 0 -0.440242930677
Ga574 ns574 0 ns573 0 0.440242930677
Ca575 ns575 0 1e-12
Ca576 ns576 0 1e-12
Ra575 ns575 0 25.0988766288 noise=0
Ra576 ns576 0 25.0988766288 noise=0
Ga575 ns575 0 ns576 0 -0.446182178947
Ga576 ns576 0 ns575 0 0.446182178947
Ca577 ns577 0 1e-12
Ca578 ns578 0 1e-12
Ra577 ns577 0 33.7291568883 noise=0
Ra578 ns578 0 33.7291568883 noise=0
Ga577 ns577 0 ns578 0 -0.437411009606
Ga578 ns578 0 ns577 0 0.437411009606
Ca579 ns579 0 1e-12
Ca580 ns580 0 1e-12
Ra579 ns579 0 30.2651538335 noise=0
Ra580 ns580 0 30.2651538335 noise=0
Ga579 ns579 0 ns580 0 -0.398051468393
Ga580 ns580 0 ns579 0 0.398051468393
Ca581 ns581 0 1e-12
Ca582 ns582 0 1e-12
Ra581 ns581 0 45.9593730353 noise=0
Ra582 ns582 0 45.9593730353 noise=0
Ga581 ns581 0 ns582 0 -0.376970230653
Ga582 ns582 0 ns581 0 0.376970230653
Ca583 ns583 0 1e-12
Ca584 ns584 0 1e-12
Ra583 ns583 0 22.8012326672 noise=0
Ra584 ns584 0 22.8012326672 noise=0
Ga583 ns583 0 ns584 0 -0.365000471119
Ga584 ns584 0 ns583 0 0.365000471119
Ca585 ns585 0 1e-12
Ca586 ns586 0 1e-12
Ra585 ns585 0 27.2711114272 noise=0
Ra586 ns586 0 27.2711114272 noise=0
Ga585 ns585 0 ns586 0 -0.30562060416
Ga586 ns586 0 ns585 0 0.30562060416
Ca587 ns587 0 1e-12
Ca588 ns588 0 1e-12
Ra587 ns587 0 36.1574626321 noise=0
Ra588 ns588 0 36.1574626321 noise=0
Ga587 ns587 0 ns588 0 -0.285967392433
Ga588 ns588 0 ns587 0 0.285967392433
Ca589 ns589 0 1e-12
Ca590 ns590 0 1e-12
Ra589 ns589 0 29.7569279687 noise=0
Ra590 ns590 0 29.7569279687 noise=0
Ga589 ns589 0 ns590 0 -0.276381759385
Ga590 ns590 0 ns589 0 0.276381759385
Ca591 ns591 0 1e-12
Ca592 ns592 0 1e-12
Ra591 ns591 0 20.4882528217 noise=0
Ra592 ns592 0 20.4882528217 noise=0
Ga591 ns591 0 ns592 0 -0.222396936817
Ga592 ns592 0 ns591 0 0.222396936817
Ca593 ns593 0 1e-12
Ca594 ns594 0 1e-12
Ra593 ns593 0 33.0904520292 noise=0
Ra594 ns594 0 33.0904520292 noise=0
Ga593 ns593 0 ns594 0 -0.193660507824
Ga594 ns594 0 ns593 0 0.193660507824
Ca595 ns595 0 1e-12
Ca596 ns596 0 1e-12
Ra595 ns595 0 34.81602158 noise=0
Ra596 ns596 0 34.81602158 noise=0
Ga595 ns595 0 ns596 0 -0.193389614476
Ga596 ns596 0 ns595 0 0.193389614476
Ca597 ns597 0 1e-12
Ca598 ns598 0 1e-12
Ra597 ns597 0 19.0488873153 noise=0
Ra598 ns598 0 19.0488873153 noise=0
Ga597 ns597 0 ns598 0 -0.118879593805
Ga598 ns598 0 ns597 0 0.118879593805
Ca599 ns599 0 1e-12
Ca600 ns600 0 1e-12
Ra599 ns599 0 38.9664963377 noise=0
Ra600 ns600 0 38.9664963377 noise=0
Ga599 ns599 0 ns600 0 -0.098928422879
Ga600 ns600 0 ns599 0 0.098928422879
Ca601 ns601 0 1e-12
Ca602 ns602 0 1e-12
Ra601 ns601 0 22.7620283637 noise=0
Ra602 ns602 0 22.7620283637 noise=0
Ga601 ns601 0 ns602 0 -0.0899282175659
Ga602 ns602 0 ns601 0 0.0899282175659
Ca603 ns603 0 1e-12
Ca604 ns604 0 1e-12
Ra603 ns603 0 21.1351530279 noise=0
Ra604 ns604 0 21.1351530279 noise=0
Ga603 ns603 0 ns604 0 -0.0231807799965
Ga604 ns604 0 ns603 0 0.0231807799965
Ca605 ns605 0 1e-12
Ra605 ns605 0 35.5013141349 noise=0
Ca606 ns606 0 1e-12
Ra606 ns606 0 1368.82509734 noise=0
Ca607 ns607 0 1e-12
Ra607 ns607 0 13570.4439484 noise=0
Ca608 ns608 0 1e-12
Ra608 ns608 0 4070.84562835 noise=0
Ca609 ns609 0 1e-12
Ra609 ns609 0 0.37257923819 noise=0
Ca610 ns610 0 1e-12
Ra610 ns610 0 0.636680753855 noise=0
Ca611 ns611 0 1e-12
Ca612 ns612 0 1e-12
Ra611 ns611 0 5.81195360108 noise=0
Ra612 ns612 0 5.81195360108 noise=0
Ga611 ns611 0 ns612 0 -0.440242930677
Ga612 ns612 0 ns611 0 0.440242930677
Ca613 ns613 0 1e-12
Ca614 ns614 0 1e-12
Ra613 ns613 0 25.0988766288 noise=0
Ra614 ns614 0 25.0988766288 noise=0
Ga613 ns613 0 ns614 0 -0.446182178947
Ga614 ns614 0 ns613 0 0.446182178947
Ca615 ns615 0 1e-12
Ca616 ns616 0 1e-12
Ra615 ns615 0 33.7291568883 noise=0
Ra616 ns616 0 33.7291568883 noise=0
Ga615 ns615 0 ns616 0 -0.437411009606
Ga616 ns616 0 ns615 0 0.437411009606
Ca617 ns617 0 1e-12
Ca618 ns618 0 1e-12
Ra617 ns617 0 30.2651538335 noise=0
Ra618 ns618 0 30.2651538335 noise=0
Ga617 ns617 0 ns618 0 -0.398051468393
Ga618 ns618 0 ns617 0 0.398051468393
Ca619 ns619 0 1e-12
Ca620 ns620 0 1e-12
Ra619 ns619 0 45.9593730353 noise=0
Ra620 ns620 0 45.9593730353 noise=0
Ga619 ns619 0 ns620 0 -0.376970230653
Ga620 ns620 0 ns619 0 0.376970230653
Ca621 ns621 0 1e-12
Ca622 ns622 0 1e-12
Ra621 ns621 0 22.8012326672 noise=0
Ra622 ns622 0 22.8012326672 noise=0
Ga621 ns621 0 ns622 0 -0.365000471119
Ga622 ns622 0 ns621 0 0.365000471119
Ca623 ns623 0 1e-12
Ca624 ns624 0 1e-12
Ra623 ns623 0 27.2711114272 noise=0
Ra624 ns624 0 27.2711114272 noise=0
Ga623 ns623 0 ns624 0 -0.30562060416
Ga624 ns624 0 ns623 0 0.30562060416
Ca625 ns625 0 1e-12
Ca626 ns626 0 1e-12
Ra625 ns625 0 36.1574626321 noise=0
Ra626 ns626 0 36.1574626321 noise=0
Ga625 ns625 0 ns626 0 -0.285967392433
Ga626 ns626 0 ns625 0 0.285967392433
Ca627 ns627 0 1e-12
Ca628 ns628 0 1e-12
Ra627 ns627 0 29.7569279687 noise=0
Ra628 ns628 0 29.7569279687 noise=0
Ga627 ns627 0 ns628 0 -0.276381759385
Ga628 ns628 0 ns627 0 0.276381759385
Ca629 ns629 0 1e-12
Ca630 ns630 0 1e-12
Ra629 ns629 0 20.4882528217 noise=0
Ra630 ns630 0 20.4882528217 noise=0
Ga629 ns629 0 ns630 0 -0.222396936817
Ga630 ns630 0 ns629 0 0.222396936817
Ca631 ns631 0 1e-12
Ca632 ns632 0 1e-12
Ra631 ns631 0 33.0904520292 noise=0
Ra632 ns632 0 33.0904520292 noise=0
Ga631 ns631 0 ns632 0 -0.193660507824
Ga632 ns632 0 ns631 0 0.193660507824
Ca633 ns633 0 1e-12
Ca634 ns634 0 1e-12
Ra633 ns633 0 34.81602158 noise=0
Ra634 ns634 0 34.81602158 noise=0
Ga633 ns633 0 ns634 0 -0.193389614476
Ga634 ns634 0 ns633 0 0.193389614476
Ca635 ns635 0 1e-12
Ca636 ns636 0 1e-12
Ra635 ns635 0 19.0488873153 noise=0
Ra636 ns636 0 19.0488873153 noise=0
Ga635 ns635 0 ns636 0 -0.118879593805
Ga636 ns636 0 ns635 0 0.118879593805
Ca637 ns637 0 1e-12
Ca638 ns638 0 1e-12
Ra637 ns637 0 38.9664963377 noise=0
Ra638 ns638 0 38.9664963377 noise=0
Ga637 ns637 0 ns638 0 -0.098928422879
Ga638 ns638 0 ns637 0 0.098928422879
Ca639 ns639 0 1e-12
Ca640 ns640 0 1e-12
Ra639 ns639 0 22.7620283637 noise=0
Ra640 ns640 0 22.7620283637 noise=0
Ga639 ns639 0 ns640 0 -0.0899282175659
Ga640 ns640 0 ns639 0 0.0899282175659
Ca641 ns641 0 1e-12
Ca642 ns642 0 1e-12
Ra641 ns641 0 21.1351530279 noise=0
Ra642 ns642 0 21.1351530279 noise=0
Ga641 ns641 0 ns642 0 -0.0231807799965
Ga642 ns642 0 ns641 0 0.0231807799965
Ca643 ns643 0 1e-12
Ra643 ns643 0 35.5013141349 noise=0
Ca644 ns644 0 1e-12
Ra644 ns644 0 1368.82509734 noise=0
Ca645 ns645 0 1e-12
Ra645 ns645 0 13570.4439484 noise=0
Ca646 ns646 0 1e-12
Ra646 ns646 0 4070.84562835 noise=0
Ca647 ns647 0 1e-12
Ra647 ns647 0 0.37257923819 noise=0
Ca648 ns648 0 1e-12
Ra648 ns648 0 0.636680753855 noise=0
Ca649 ns649 0 1e-12
Ca650 ns650 0 1e-12
Ra649 ns649 0 5.81195360108 noise=0
Ra650 ns650 0 5.81195360108 noise=0
Ga649 ns649 0 ns650 0 -0.440242930677
Ga650 ns650 0 ns649 0 0.440242930677
Ca651 ns651 0 1e-12
Ca652 ns652 0 1e-12
Ra651 ns651 0 25.0988766288 noise=0
Ra652 ns652 0 25.0988766288 noise=0
Ga651 ns651 0 ns652 0 -0.446182178947
Ga652 ns652 0 ns651 0 0.446182178947
Ca653 ns653 0 1e-12
Ca654 ns654 0 1e-12
Ra653 ns653 0 33.7291568883 noise=0
Ra654 ns654 0 33.7291568883 noise=0
Ga653 ns653 0 ns654 0 -0.437411009606
Ga654 ns654 0 ns653 0 0.437411009606
Ca655 ns655 0 1e-12
Ca656 ns656 0 1e-12
Ra655 ns655 0 30.2651538335 noise=0
Ra656 ns656 0 30.2651538335 noise=0
Ga655 ns655 0 ns656 0 -0.398051468393
Ga656 ns656 0 ns655 0 0.398051468393
Ca657 ns657 0 1e-12
Ca658 ns658 0 1e-12
Ra657 ns657 0 45.9593730353 noise=0
Ra658 ns658 0 45.9593730353 noise=0
Ga657 ns657 0 ns658 0 -0.376970230653
Ga658 ns658 0 ns657 0 0.376970230653
Ca659 ns659 0 1e-12
Ca660 ns660 0 1e-12
Ra659 ns659 0 22.8012326672 noise=0
Ra660 ns660 0 22.8012326672 noise=0
Ga659 ns659 0 ns660 0 -0.365000471119
Ga660 ns660 0 ns659 0 0.365000471119
Ca661 ns661 0 1e-12
Ca662 ns662 0 1e-12
Ra661 ns661 0 27.2711114272 noise=0
Ra662 ns662 0 27.2711114272 noise=0
Ga661 ns661 0 ns662 0 -0.30562060416
Ga662 ns662 0 ns661 0 0.30562060416
Ca663 ns663 0 1e-12
Ca664 ns664 0 1e-12
Ra663 ns663 0 36.1574626321 noise=0
Ra664 ns664 0 36.1574626321 noise=0
Ga663 ns663 0 ns664 0 -0.285967392433
Ga664 ns664 0 ns663 0 0.285967392433
Ca665 ns665 0 1e-12
Ca666 ns666 0 1e-12
Ra665 ns665 0 29.7569279687 noise=0
Ra666 ns666 0 29.7569279687 noise=0
Ga665 ns665 0 ns666 0 -0.276381759385
Ga666 ns666 0 ns665 0 0.276381759385
Ca667 ns667 0 1e-12
Ca668 ns668 0 1e-12
Ra667 ns667 0 20.4882528217 noise=0
Ra668 ns668 0 20.4882528217 noise=0
Ga667 ns667 0 ns668 0 -0.222396936817
Ga668 ns668 0 ns667 0 0.222396936817
Ca669 ns669 0 1e-12
Ca670 ns670 0 1e-12
Ra669 ns669 0 33.0904520292 noise=0
Ra670 ns670 0 33.0904520292 noise=0
Ga669 ns669 0 ns670 0 -0.193660507824
Ga670 ns670 0 ns669 0 0.193660507824
Ca671 ns671 0 1e-12
Ca672 ns672 0 1e-12
Ra671 ns671 0 34.81602158 noise=0
Ra672 ns672 0 34.81602158 noise=0
Ga671 ns671 0 ns672 0 -0.193389614476
Ga672 ns672 0 ns671 0 0.193389614476
Ca673 ns673 0 1e-12
Ca674 ns674 0 1e-12
Ra673 ns673 0 19.0488873153 noise=0
Ra674 ns674 0 19.0488873153 noise=0
Ga673 ns673 0 ns674 0 -0.118879593805
Ga674 ns674 0 ns673 0 0.118879593805
Ca675 ns675 0 1e-12
Ca676 ns676 0 1e-12
Ra675 ns675 0 38.9664963377 noise=0
Ra676 ns676 0 38.9664963377 noise=0
Ga675 ns675 0 ns676 0 -0.098928422879
Ga676 ns676 0 ns675 0 0.098928422879
Ca677 ns677 0 1e-12
Ca678 ns678 0 1e-12
Ra677 ns677 0 22.7620283637 noise=0
Ra678 ns678 0 22.7620283637 noise=0
Ga677 ns677 0 ns678 0 -0.0899282175659
Ga678 ns678 0 ns677 0 0.0899282175659
Ca679 ns679 0 1e-12
Ca680 ns680 0 1e-12
Ra679 ns679 0 21.1351530279 noise=0
Ra680 ns680 0 21.1351530279 noise=0
Ga679 ns679 0 ns680 0 -0.0231807799965
Ga680 ns680 0 ns679 0 0.0231807799965
Ca681 ns681 0 1e-12
Ra681 ns681 0 35.5013141349 noise=0
Ca682 ns682 0 1e-12
Ra682 ns682 0 1368.82509734 noise=0
Ca683 ns683 0 1e-12
Ra683 ns683 0 13570.4439484 noise=0
Ca684 ns684 0 1e-12
Ra684 ns684 0 4070.84562835 noise=0
Ca685 ns685 0 1e-12
Ra685 ns685 0 0.37257923819 noise=0
Ca686 ns686 0 1e-12
Ra686 ns686 0 0.636680753855 noise=0
Ca687 ns687 0 1e-12
Ca688 ns688 0 1e-12
Ra687 ns687 0 5.81195360108 noise=0
Ra688 ns688 0 5.81195360108 noise=0
Ga687 ns687 0 ns688 0 -0.440242930677
Ga688 ns688 0 ns687 0 0.440242930677
Ca689 ns689 0 1e-12
Ca690 ns690 0 1e-12
Ra689 ns689 0 25.0988766288 noise=0
Ra690 ns690 0 25.0988766288 noise=0
Ga689 ns689 0 ns690 0 -0.446182178947
Ga690 ns690 0 ns689 0 0.446182178947
Ca691 ns691 0 1e-12
Ca692 ns692 0 1e-12
Ra691 ns691 0 33.7291568883 noise=0
Ra692 ns692 0 33.7291568883 noise=0
Ga691 ns691 0 ns692 0 -0.437411009606
Ga692 ns692 0 ns691 0 0.437411009606
Ca693 ns693 0 1e-12
Ca694 ns694 0 1e-12
Ra693 ns693 0 30.2651538335 noise=0
Ra694 ns694 0 30.2651538335 noise=0
Ga693 ns693 0 ns694 0 -0.398051468393
Ga694 ns694 0 ns693 0 0.398051468393
Ca695 ns695 0 1e-12
Ca696 ns696 0 1e-12
Ra695 ns695 0 45.9593730353 noise=0
Ra696 ns696 0 45.9593730353 noise=0
Ga695 ns695 0 ns696 0 -0.376970230653
Ga696 ns696 0 ns695 0 0.376970230653
Ca697 ns697 0 1e-12
Ca698 ns698 0 1e-12
Ra697 ns697 0 22.8012326672 noise=0
Ra698 ns698 0 22.8012326672 noise=0
Ga697 ns697 0 ns698 0 -0.365000471119
Ga698 ns698 0 ns697 0 0.365000471119
Ca699 ns699 0 1e-12
Ca700 ns700 0 1e-12
Ra699 ns699 0 27.2711114272 noise=0
Ra700 ns700 0 27.2711114272 noise=0
Ga699 ns699 0 ns700 0 -0.30562060416
Ga700 ns700 0 ns699 0 0.30562060416
Ca701 ns701 0 1e-12
Ca702 ns702 0 1e-12
Ra701 ns701 0 36.1574626321 noise=0
Ra702 ns702 0 36.1574626321 noise=0
Ga701 ns701 0 ns702 0 -0.285967392433
Ga702 ns702 0 ns701 0 0.285967392433
Ca703 ns703 0 1e-12
Ca704 ns704 0 1e-12
Ra703 ns703 0 29.7569279687 noise=0
Ra704 ns704 0 29.7569279687 noise=0
Ga703 ns703 0 ns704 0 -0.276381759385
Ga704 ns704 0 ns703 0 0.276381759385
Ca705 ns705 0 1e-12
Ca706 ns706 0 1e-12
Ra705 ns705 0 20.4882528217 noise=0
Ra706 ns706 0 20.4882528217 noise=0
Ga705 ns705 0 ns706 0 -0.222396936817
Ga706 ns706 0 ns705 0 0.222396936817
Ca707 ns707 0 1e-12
Ca708 ns708 0 1e-12
Ra707 ns707 0 33.0904520292 noise=0
Ra708 ns708 0 33.0904520292 noise=0
Ga707 ns707 0 ns708 0 -0.193660507824
Ga708 ns708 0 ns707 0 0.193660507824
Ca709 ns709 0 1e-12
Ca710 ns710 0 1e-12
Ra709 ns709 0 34.81602158 noise=0
Ra710 ns710 0 34.81602158 noise=0
Ga709 ns709 0 ns710 0 -0.193389614476
Ga710 ns710 0 ns709 0 0.193389614476
Ca711 ns711 0 1e-12
Ca712 ns712 0 1e-12
Ra711 ns711 0 19.0488873153 noise=0
Ra712 ns712 0 19.0488873153 noise=0
Ga711 ns711 0 ns712 0 -0.118879593805
Ga712 ns712 0 ns711 0 0.118879593805
Ca713 ns713 0 1e-12
Ca714 ns714 0 1e-12
Ra713 ns713 0 38.9664963377 noise=0
Ra714 ns714 0 38.9664963377 noise=0
Ga713 ns713 0 ns714 0 -0.098928422879
Ga714 ns714 0 ns713 0 0.098928422879
Ca715 ns715 0 1e-12
Ca716 ns716 0 1e-12
Ra715 ns715 0 22.7620283637 noise=0
Ra716 ns716 0 22.7620283637 noise=0
Ga715 ns715 0 ns716 0 -0.0899282175659
Ga716 ns716 0 ns715 0 0.0899282175659
Ca717 ns717 0 1e-12
Ca718 ns718 0 1e-12
Ra717 ns717 0 21.1351530279 noise=0
Ra718 ns718 0 21.1351530279 noise=0
Ga717 ns717 0 ns718 0 -0.0231807799965
Ga718 ns718 0 ns717 0 0.0231807799965
Ca719 ns719 0 1e-12
Ra719 ns719 0 35.5013141349 noise=0
Ca720 ns720 0 1e-12
Ra720 ns720 0 1368.82509734 noise=0
Ca721 ns721 0 1e-12
Ra721 ns721 0 13570.4439484 noise=0
Ca722 ns722 0 1e-12
Ra722 ns722 0 4070.84562835 noise=0
Ca723 ns723 0 1e-12
Ra723 ns723 0 0.37257923819 noise=0
Ca724 ns724 0 1e-12
Ra724 ns724 0 0.636680753855 noise=0
Ca725 ns725 0 1e-12
Ca726 ns726 0 1e-12
Ra725 ns725 0 5.81195360108 noise=0
Ra726 ns726 0 5.81195360108 noise=0
Ga725 ns725 0 ns726 0 -0.440242930677
Ga726 ns726 0 ns725 0 0.440242930677
Ca727 ns727 0 1e-12
Ca728 ns728 0 1e-12
Ra727 ns727 0 25.0988766288 noise=0
Ra728 ns728 0 25.0988766288 noise=0
Ga727 ns727 0 ns728 0 -0.446182178947
Ga728 ns728 0 ns727 0 0.446182178947
Ca729 ns729 0 1e-12
Ca730 ns730 0 1e-12
Ra729 ns729 0 33.7291568883 noise=0
Ra730 ns730 0 33.7291568883 noise=0
Ga729 ns729 0 ns730 0 -0.437411009606
Ga730 ns730 0 ns729 0 0.437411009606
Ca731 ns731 0 1e-12
Ca732 ns732 0 1e-12
Ra731 ns731 0 30.2651538335 noise=0
Ra732 ns732 0 30.2651538335 noise=0
Ga731 ns731 0 ns732 0 -0.398051468393
Ga732 ns732 0 ns731 0 0.398051468393
Ca733 ns733 0 1e-12
Ca734 ns734 0 1e-12
Ra733 ns733 0 45.9593730353 noise=0
Ra734 ns734 0 45.9593730353 noise=0
Ga733 ns733 0 ns734 0 -0.376970230653
Ga734 ns734 0 ns733 0 0.376970230653
Ca735 ns735 0 1e-12
Ca736 ns736 0 1e-12
Ra735 ns735 0 22.8012326672 noise=0
Ra736 ns736 0 22.8012326672 noise=0
Ga735 ns735 0 ns736 0 -0.365000471119
Ga736 ns736 0 ns735 0 0.365000471119
Ca737 ns737 0 1e-12
Ca738 ns738 0 1e-12
Ra737 ns737 0 27.2711114272 noise=0
Ra738 ns738 0 27.2711114272 noise=0
Ga737 ns737 0 ns738 0 -0.30562060416
Ga738 ns738 0 ns737 0 0.30562060416
Ca739 ns739 0 1e-12
Ca740 ns740 0 1e-12
Ra739 ns739 0 36.1574626321 noise=0
Ra740 ns740 0 36.1574626321 noise=0
Ga739 ns739 0 ns740 0 -0.285967392433
Ga740 ns740 0 ns739 0 0.285967392433
Ca741 ns741 0 1e-12
Ca742 ns742 0 1e-12
Ra741 ns741 0 29.7569279687 noise=0
Ra742 ns742 0 29.7569279687 noise=0
Ga741 ns741 0 ns742 0 -0.276381759385
Ga742 ns742 0 ns741 0 0.276381759385
Ca743 ns743 0 1e-12
Ca744 ns744 0 1e-12
Ra743 ns743 0 20.4882528217 noise=0
Ra744 ns744 0 20.4882528217 noise=0
Ga743 ns743 0 ns744 0 -0.222396936817
Ga744 ns744 0 ns743 0 0.222396936817
Ca745 ns745 0 1e-12
Ca746 ns746 0 1e-12
Ra745 ns745 0 33.0904520292 noise=0
Ra746 ns746 0 33.0904520292 noise=0
Ga745 ns745 0 ns746 0 -0.193660507824
Ga746 ns746 0 ns745 0 0.193660507824
Ca747 ns747 0 1e-12
Ca748 ns748 0 1e-12
Ra747 ns747 0 34.81602158 noise=0
Ra748 ns748 0 34.81602158 noise=0
Ga747 ns747 0 ns748 0 -0.193389614476
Ga748 ns748 0 ns747 0 0.193389614476
Ca749 ns749 0 1e-12
Ca750 ns750 0 1e-12
Ra749 ns749 0 19.0488873153 noise=0
Ra750 ns750 0 19.0488873153 noise=0
Ga749 ns749 0 ns750 0 -0.118879593805
Ga750 ns750 0 ns749 0 0.118879593805
Ca751 ns751 0 1e-12
Ca752 ns752 0 1e-12
Ra751 ns751 0 38.9664963377 noise=0
Ra752 ns752 0 38.9664963377 noise=0
Ga751 ns751 0 ns752 0 -0.098928422879
Ga752 ns752 0 ns751 0 0.098928422879
Ca753 ns753 0 1e-12
Ca754 ns754 0 1e-12
Ra753 ns753 0 22.7620283637 noise=0
Ra754 ns754 0 22.7620283637 noise=0
Ga753 ns753 0 ns754 0 -0.0899282175659
Ga754 ns754 0 ns753 0 0.0899282175659
Ca755 ns755 0 1e-12
Ca756 ns756 0 1e-12
Ra755 ns755 0 21.1351530279 noise=0
Ra756 ns756 0 21.1351530279 noise=0
Ga755 ns755 0 ns756 0 -0.0231807799965
Ga756 ns756 0 ns755 0 0.0231807799965
Ca757 ns757 0 1e-12
Ra757 ns757 0 35.5013141349 noise=0
Ca758 ns758 0 1e-12
Ra758 ns758 0 1368.82509734 noise=0
Ca759 ns759 0 1e-12
Ra759 ns759 0 13570.4439484 noise=0
Ca760 ns760 0 1e-12
Ra760 ns760 0 4070.84562835 noise=0
Ca761 ns761 0 1e-12
Ra761 ns761 0 0.37257923819 noise=0
Ca762 ns762 0 1e-12
Ra762 ns762 0 0.636680753855 noise=0
Ca763 ns763 0 1e-12
Ca764 ns764 0 1e-12
Ra763 ns763 0 5.81195360108 noise=0
Ra764 ns764 0 5.81195360108 noise=0
Ga763 ns763 0 ns764 0 -0.440242930677
Ga764 ns764 0 ns763 0 0.440242930677
Ca765 ns765 0 1e-12
Ca766 ns766 0 1e-12
Ra765 ns765 0 25.0988766288 noise=0
Ra766 ns766 0 25.0988766288 noise=0
Ga765 ns765 0 ns766 0 -0.446182178947
Ga766 ns766 0 ns765 0 0.446182178947
Ca767 ns767 0 1e-12
Ca768 ns768 0 1e-12
Ra767 ns767 0 33.7291568883 noise=0
Ra768 ns768 0 33.7291568883 noise=0
Ga767 ns767 0 ns768 0 -0.437411009606
Ga768 ns768 0 ns767 0 0.437411009606
Ca769 ns769 0 1e-12
Ca770 ns770 0 1e-12
Ra769 ns769 0 30.2651538335 noise=0
Ra770 ns770 0 30.2651538335 noise=0
Ga769 ns769 0 ns770 0 -0.398051468393
Ga770 ns770 0 ns769 0 0.398051468393
Ca771 ns771 0 1e-12
Ca772 ns772 0 1e-12
Ra771 ns771 0 45.9593730353 noise=0
Ra772 ns772 0 45.9593730353 noise=0
Ga771 ns771 0 ns772 0 -0.376970230653
Ga772 ns772 0 ns771 0 0.376970230653
Ca773 ns773 0 1e-12
Ca774 ns774 0 1e-12
Ra773 ns773 0 22.8012326672 noise=0
Ra774 ns774 0 22.8012326672 noise=0
Ga773 ns773 0 ns774 0 -0.365000471119
Ga774 ns774 0 ns773 0 0.365000471119
Ca775 ns775 0 1e-12
Ca776 ns776 0 1e-12
Ra775 ns775 0 27.2711114272 noise=0
Ra776 ns776 0 27.2711114272 noise=0
Ga775 ns775 0 ns776 0 -0.30562060416
Ga776 ns776 0 ns775 0 0.30562060416
Ca777 ns777 0 1e-12
Ca778 ns778 0 1e-12
Ra777 ns777 0 36.1574626321 noise=0
Ra778 ns778 0 36.1574626321 noise=0
Ga777 ns777 0 ns778 0 -0.285967392433
Ga778 ns778 0 ns777 0 0.285967392433
Ca779 ns779 0 1e-12
Ca780 ns780 0 1e-12
Ra779 ns779 0 29.7569279687 noise=0
Ra780 ns780 0 29.7569279687 noise=0
Ga779 ns779 0 ns780 0 -0.276381759385
Ga780 ns780 0 ns779 0 0.276381759385
Ca781 ns781 0 1e-12
Ca782 ns782 0 1e-12
Ra781 ns781 0 20.4882528217 noise=0
Ra782 ns782 0 20.4882528217 noise=0
Ga781 ns781 0 ns782 0 -0.222396936817
Ga782 ns782 0 ns781 0 0.222396936817
Ca783 ns783 0 1e-12
Ca784 ns784 0 1e-12
Ra783 ns783 0 33.0904520292 noise=0
Ra784 ns784 0 33.0904520292 noise=0
Ga783 ns783 0 ns784 0 -0.193660507824
Ga784 ns784 0 ns783 0 0.193660507824
Ca785 ns785 0 1e-12
Ca786 ns786 0 1e-12
Ra785 ns785 0 34.81602158 noise=0
Ra786 ns786 0 34.81602158 noise=0
Ga785 ns785 0 ns786 0 -0.193389614476
Ga786 ns786 0 ns785 0 0.193389614476
Ca787 ns787 0 1e-12
Ca788 ns788 0 1e-12
Ra787 ns787 0 19.0488873153 noise=0
Ra788 ns788 0 19.0488873153 noise=0
Ga787 ns787 0 ns788 0 -0.118879593805
Ga788 ns788 0 ns787 0 0.118879593805
Ca789 ns789 0 1e-12
Ca790 ns790 0 1e-12
Ra789 ns789 0 38.9664963377 noise=0
Ra790 ns790 0 38.9664963377 noise=0
Ga789 ns789 0 ns790 0 -0.098928422879
Ga790 ns790 0 ns789 0 0.098928422879
Ca791 ns791 0 1e-12
Ca792 ns792 0 1e-12
Ra791 ns791 0 22.7620283637 noise=0
Ra792 ns792 0 22.7620283637 noise=0
Ga791 ns791 0 ns792 0 -0.0899282175659
Ga792 ns792 0 ns791 0 0.0899282175659
Ca793 ns793 0 1e-12
Ca794 ns794 0 1e-12
Ra793 ns793 0 21.1351530279 noise=0
Ra794 ns794 0 21.1351530279 noise=0
Ga793 ns793 0 ns794 0 -0.0231807799965
Ga794 ns794 0 ns793 0 0.0231807799965
Ca795 ns795 0 1e-12
Ra795 ns795 0 35.5013141349 noise=0
Ca796 ns796 0 1e-12
Ra796 ns796 0 1368.82509734 noise=0
Ca797 ns797 0 1e-12
Ra797 ns797 0 13570.4439484 noise=0
Ca798 ns798 0 1e-12
Ra798 ns798 0 4070.84562835 noise=0
Ca799 ns799 0 1e-12
Ra799 ns799 0 0.37257923819 noise=0
Ca800 ns800 0 1e-12
Ra800 ns800 0 0.636680753855 noise=0
Ca801 ns801 0 1e-12
Ca802 ns802 0 1e-12
Ra801 ns801 0 5.81195360108 noise=0
Ra802 ns802 0 5.81195360108 noise=0
Ga801 ns801 0 ns802 0 -0.440242930677
Ga802 ns802 0 ns801 0 0.440242930677
Ca803 ns803 0 1e-12
Ca804 ns804 0 1e-12
Ra803 ns803 0 25.0988766288 noise=0
Ra804 ns804 0 25.0988766288 noise=0
Ga803 ns803 0 ns804 0 -0.446182178947
Ga804 ns804 0 ns803 0 0.446182178947
Ca805 ns805 0 1e-12
Ca806 ns806 0 1e-12
Ra805 ns805 0 33.7291568883 noise=0
Ra806 ns806 0 33.7291568883 noise=0
Ga805 ns805 0 ns806 0 -0.437411009606
Ga806 ns806 0 ns805 0 0.437411009606
Ca807 ns807 0 1e-12
Ca808 ns808 0 1e-12
Ra807 ns807 0 30.2651538335 noise=0
Ra808 ns808 0 30.2651538335 noise=0
Ga807 ns807 0 ns808 0 -0.398051468393
Ga808 ns808 0 ns807 0 0.398051468393
Ca809 ns809 0 1e-12
Ca810 ns810 0 1e-12
Ra809 ns809 0 45.9593730353 noise=0
Ra810 ns810 0 45.9593730353 noise=0
Ga809 ns809 0 ns810 0 -0.376970230653
Ga810 ns810 0 ns809 0 0.376970230653
Ca811 ns811 0 1e-12
Ca812 ns812 0 1e-12
Ra811 ns811 0 22.8012326672 noise=0
Ra812 ns812 0 22.8012326672 noise=0
Ga811 ns811 0 ns812 0 -0.365000471119
Ga812 ns812 0 ns811 0 0.365000471119
Ca813 ns813 0 1e-12
Ca814 ns814 0 1e-12
Ra813 ns813 0 27.2711114272 noise=0
Ra814 ns814 0 27.2711114272 noise=0
Ga813 ns813 0 ns814 0 -0.30562060416
Ga814 ns814 0 ns813 0 0.30562060416
Ca815 ns815 0 1e-12
Ca816 ns816 0 1e-12
Ra815 ns815 0 36.1574626321 noise=0
Ra816 ns816 0 36.1574626321 noise=0
Ga815 ns815 0 ns816 0 -0.285967392433
Ga816 ns816 0 ns815 0 0.285967392433
Ca817 ns817 0 1e-12
Ca818 ns818 0 1e-12
Ra817 ns817 0 29.7569279687 noise=0
Ra818 ns818 0 29.7569279687 noise=0
Ga817 ns817 0 ns818 0 -0.276381759385
Ga818 ns818 0 ns817 0 0.276381759385
Ca819 ns819 0 1e-12
Ca820 ns820 0 1e-12
Ra819 ns819 0 20.4882528217 noise=0
Ra820 ns820 0 20.4882528217 noise=0
Ga819 ns819 0 ns820 0 -0.222396936817
Ga820 ns820 0 ns819 0 0.222396936817
Ca821 ns821 0 1e-12
Ca822 ns822 0 1e-12
Ra821 ns821 0 33.0904520292 noise=0
Ra822 ns822 0 33.0904520292 noise=0
Ga821 ns821 0 ns822 0 -0.193660507824
Ga822 ns822 0 ns821 0 0.193660507824
Ca823 ns823 0 1e-12
Ca824 ns824 0 1e-12
Ra823 ns823 0 34.81602158 noise=0
Ra824 ns824 0 34.81602158 noise=0
Ga823 ns823 0 ns824 0 -0.193389614476
Ga824 ns824 0 ns823 0 0.193389614476
Ca825 ns825 0 1e-12
Ca826 ns826 0 1e-12
Ra825 ns825 0 19.0488873153 noise=0
Ra826 ns826 0 19.0488873153 noise=0
Ga825 ns825 0 ns826 0 -0.118879593805
Ga826 ns826 0 ns825 0 0.118879593805
Ca827 ns827 0 1e-12
Ca828 ns828 0 1e-12
Ra827 ns827 0 38.9664963377 noise=0
Ra828 ns828 0 38.9664963377 noise=0
Ga827 ns827 0 ns828 0 -0.098928422879
Ga828 ns828 0 ns827 0 0.098928422879
Ca829 ns829 0 1e-12
Ca830 ns830 0 1e-12
Ra829 ns829 0 22.7620283637 noise=0
Ra830 ns830 0 22.7620283637 noise=0
Ga829 ns829 0 ns830 0 -0.0899282175659
Ga830 ns830 0 ns829 0 0.0899282175659
Ca831 ns831 0 1e-12
Ca832 ns832 0 1e-12
Ra831 ns831 0 21.1351530279 noise=0
Ra832 ns832 0 21.1351530279 noise=0
Ga831 ns831 0 ns832 0 -0.0231807799965
Ga832 ns832 0 ns831 0 0.0231807799965
Ca833 ns833 0 1e-12
Ra833 ns833 0 35.5013141349 noise=0
Ca834 ns834 0 1e-12
Ra834 ns834 0 1368.82509734 noise=0
Ca835 ns835 0 1e-12
Ra835 ns835 0 13570.4439484 noise=0
Ca836 ns836 0 1e-12
Ra836 ns836 0 4070.84562835 noise=0
Ca837 ns837 0 1e-12
Ra837 ns837 0 0.37257923819 noise=0
Ca838 ns838 0 1e-12
Ra838 ns838 0 0.636680753855 noise=0
Ca839 ns839 0 1e-12
Ca840 ns840 0 1e-12
Ra839 ns839 0 5.81195360108 noise=0
Ra840 ns840 0 5.81195360108 noise=0
Ga839 ns839 0 ns840 0 -0.440242930677
Ga840 ns840 0 ns839 0 0.440242930677
Ca841 ns841 0 1e-12
Ca842 ns842 0 1e-12
Ra841 ns841 0 25.0988766288 noise=0
Ra842 ns842 0 25.0988766288 noise=0
Ga841 ns841 0 ns842 0 -0.446182178947
Ga842 ns842 0 ns841 0 0.446182178947
Ca843 ns843 0 1e-12
Ca844 ns844 0 1e-12
Ra843 ns843 0 33.7291568883 noise=0
Ra844 ns844 0 33.7291568883 noise=0
Ga843 ns843 0 ns844 0 -0.437411009606
Ga844 ns844 0 ns843 0 0.437411009606
Ca845 ns845 0 1e-12
Ca846 ns846 0 1e-12
Ra845 ns845 0 30.2651538335 noise=0
Ra846 ns846 0 30.2651538335 noise=0
Ga845 ns845 0 ns846 0 -0.398051468393
Ga846 ns846 0 ns845 0 0.398051468393
Ca847 ns847 0 1e-12
Ca848 ns848 0 1e-12
Ra847 ns847 0 45.9593730353 noise=0
Ra848 ns848 0 45.9593730353 noise=0
Ga847 ns847 0 ns848 0 -0.376970230653
Ga848 ns848 0 ns847 0 0.376970230653
Ca849 ns849 0 1e-12
Ca850 ns850 0 1e-12
Ra849 ns849 0 22.8012326672 noise=0
Ra850 ns850 0 22.8012326672 noise=0
Ga849 ns849 0 ns850 0 -0.365000471119
Ga850 ns850 0 ns849 0 0.365000471119
Ca851 ns851 0 1e-12
Ca852 ns852 0 1e-12
Ra851 ns851 0 27.2711114272 noise=0
Ra852 ns852 0 27.2711114272 noise=0
Ga851 ns851 0 ns852 0 -0.30562060416
Ga852 ns852 0 ns851 0 0.30562060416
Ca853 ns853 0 1e-12
Ca854 ns854 0 1e-12
Ra853 ns853 0 36.1574626321 noise=0
Ra854 ns854 0 36.1574626321 noise=0
Ga853 ns853 0 ns854 0 -0.285967392433
Ga854 ns854 0 ns853 0 0.285967392433
Ca855 ns855 0 1e-12
Ca856 ns856 0 1e-12
Ra855 ns855 0 29.7569279687 noise=0
Ra856 ns856 0 29.7569279687 noise=0
Ga855 ns855 0 ns856 0 -0.276381759385
Ga856 ns856 0 ns855 0 0.276381759385
Ca857 ns857 0 1e-12
Ca858 ns858 0 1e-12
Ra857 ns857 0 20.4882528217 noise=0
Ra858 ns858 0 20.4882528217 noise=0
Ga857 ns857 0 ns858 0 -0.222396936817
Ga858 ns858 0 ns857 0 0.222396936817
Ca859 ns859 0 1e-12
Ca860 ns860 0 1e-12
Ra859 ns859 0 33.0904520292 noise=0
Ra860 ns860 0 33.0904520292 noise=0
Ga859 ns859 0 ns860 0 -0.193660507824
Ga860 ns860 0 ns859 0 0.193660507824
Ca861 ns861 0 1e-12
Ca862 ns862 0 1e-12
Ra861 ns861 0 34.81602158 noise=0
Ra862 ns862 0 34.81602158 noise=0
Ga861 ns861 0 ns862 0 -0.193389614476
Ga862 ns862 0 ns861 0 0.193389614476
Ca863 ns863 0 1e-12
Ca864 ns864 0 1e-12
Ra863 ns863 0 19.0488873153 noise=0
Ra864 ns864 0 19.0488873153 noise=0
Ga863 ns863 0 ns864 0 -0.118879593805
Ga864 ns864 0 ns863 0 0.118879593805
Ca865 ns865 0 1e-12
Ca866 ns866 0 1e-12
Ra865 ns865 0 38.9664963377 noise=0
Ra866 ns866 0 38.9664963377 noise=0
Ga865 ns865 0 ns866 0 -0.098928422879
Ga866 ns866 0 ns865 0 0.098928422879
Ca867 ns867 0 1e-12
Ca868 ns868 0 1e-12
Ra867 ns867 0 22.7620283637 noise=0
Ra868 ns868 0 22.7620283637 noise=0
Ga867 ns867 0 ns868 0 -0.0899282175659
Ga868 ns868 0 ns867 0 0.0899282175659
Ca869 ns869 0 1e-12
Ca870 ns870 0 1e-12
Ra869 ns869 0 21.1351530279 noise=0
Ra870 ns870 0 21.1351530279 noise=0
Ga869 ns869 0 ns870 0 -0.0231807799965
Ga870 ns870 0 ns869 0 0.0231807799965
Ca871 ns871 0 1e-12
Ra871 ns871 0 35.5013141349 noise=0
Ca872 ns872 0 1e-12
Ra872 ns872 0 1368.82509734 noise=0
Ca873 ns873 0 1e-12
Ra873 ns873 0 13570.4439484 noise=0
Ca874 ns874 0 1e-12
Ra874 ns874 0 4070.84562835 noise=0
Ca875 ns875 0 1e-12
Ra875 ns875 0 0.37257923819 noise=0
Ca876 ns876 0 1e-12
Ra876 ns876 0 0.636680753855 noise=0
Ca877 ns877 0 1e-12
Ca878 ns878 0 1e-12
Ra877 ns877 0 5.81195360108 noise=0
Ra878 ns878 0 5.81195360108 noise=0
Ga877 ns877 0 ns878 0 -0.440242930677
Ga878 ns878 0 ns877 0 0.440242930677
Ca879 ns879 0 1e-12
Ca880 ns880 0 1e-12
Ra879 ns879 0 25.0988766288 noise=0
Ra880 ns880 0 25.0988766288 noise=0
Ga879 ns879 0 ns880 0 -0.446182178947
Ga880 ns880 0 ns879 0 0.446182178947
Ca881 ns881 0 1e-12
Ca882 ns882 0 1e-12
Ra881 ns881 0 33.7291568883 noise=0
Ra882 ns882 0 33.7291568883 noise=0
Ga881 ns881 0 ns882 0 -0.437411009606
Ga882 ns882 0 ns881 0 0.437411009606
Ca883 ns883 0 1e-12
Ca884 ns884 0 1e-12
Ra883 ns883 0 30.2651538335 noise=0
Ra884 ns884 0 30.2651538335 noise=0
Ga883 ns883 0 ns884 0 -0.398051468393
Ga884 ns884 0 ns883 0 0.398051468393
Ca885 ns885 0 1e-12
Ca886 ns886 0 1e-12
Ra885 ns885 0 45.9593730353 noise=0
Ra886 ns886 0 45.9593730353 noise=0
Ga885 ns885 0 ns886 0 -0.376970230653
Ga886 ns886 0 ns885 0 0.376970230653
Ca887 ns887 0 1e-12
Ca888 ns888 0 1e-12
Ra887 ns887 0 22.8012326672 noise=0
Ra888 ns888 0 22.8012326672 noise=0
Ga887 ns887 0 ns888 0 -0.365000471119
Ga888 ns888 0 ns887 0 0.365000471119
Ca889 ns889 0 1e-12
Ca890 ns890 0 1e-12
Ra889 ns889 0 27.2711114272 noise=0
Ra890 ns890 0 27.2711114272 noise=0
Ga889 ns889 0 ns890 0 -0.30562060416
Ga890 ns890 0 ns889 0 0.30562060416
Ca891 ns891 0 1e-12
Ca892 ns892 0 1e-12
Ra891 ns891 0 36.1574626321 noise=0
Ra892 ns892 0 36.1574626321 noise=0
Ga891 ns891 0 ns892 0 -0.285967392433
Ga892 ns892 0 ns891 0 0.285967392433
Ca893 ns893 0 1e-12
Ca894 ns894 0 1e-12
Ra893 ns893 0 29.7569279687 noise=0
Ra894 ns894 0 29.7569279687 noise=0
Ga893 ns893 0 ns894 0 -0.276381759385
Ga894 ns894 0 ns893 0 0.276381759385
Ca895 ns895 0 1e-12
Ca896 ns896 0 1e-12
Ra895 ns895 0 20.4882528217 noise=0
Ra896 ns896 0 20.4882528217 noise=0
Ga895 ns895 0 ns896 0 -0.222396936817
Ga896 ns896 0 ns895 0 0.222396936817
Ca897 ns897 0 1e-12
Ca898 ns898 0 1e-12
Ra897 ns897 0 33.0904520292 noise=0
Ra898 ns898 0 33.0904520292 noise=0
Ga897 ns897 0 ns898 0 -0.193660507824
Ga898 ns898 0 ns897 0 0.193660507824
Ca899 ns899 0 1e-12
Ca900 ns900 0 1e-12
Ra899 ns899 0 34.81602158 noise=0
Ra900 ns900 0 34.81602158 noise=0
Ga899 ns899 0 ns900 0 -0.193389614476
Ga900 ns900 0 ns899 0 0.193389614476
Ca901 ns901 0 1e-12
Ca902 ns902 0 1e-12
Ra901 ns901 0 19.0488873153 noise=0
Ra902 ns902 0 19.0488873153 noise=0
Ga901 ns901 0 ns902 0 -0.118879593805
Ga902 ns902 0 ns901 0 0.118879593805
Ca903 ns903 0 1e-12
Ca904 ns904 0 1e-12
Ra903 ns903 0 38.9664963377 noise=0
Ra904 ns904 0 38.9664963377 noise=0
Ga903 ns903 0 ns904 0 -0.098928422879
Ga904 ns904 0 ns903 0 0.098928422879
Ca905 ns905 0 1e-12
Ca906 ns906 0 1e-12
Ra905 ns905 0 22.7620283637 noise=0
Ra906 ns906 0 22.7620283637 noise=0
Ga905 ns905 0 ns906 0 -0.0899282175659
Ga906 ns906 0 ns905 0 0.0899282175659
Ca907 ns907 0 1e-12
Ca908 ns908 0 1e-12
Ra907 ns907 0 21.1351530279 noise=0
Ra908 ns908 0 21.1351530279 noise=0
Ga907 ns907 0 ns908 0 -0.0231807799965
Ga908 ns908 0 ns907 0 0.0231807799965
Ca909 ns909 0 1e-12
Ra909 ns909 0 35.5013141349 noise=0
Ca910 ns910 0 1e-12
Ra910 ns910 0 1368.82509734 noise=0
Ca911 ns911 0 1e-12
Ra911 ns911 0 13570.4439484 noise=0
Ca912 ns912 0 1e-12
Ra912 ns912 0 4070.84562835 noise=0
Ca913 ns913 0 1e-12
Ra913 ns913 0 0.37257923819 noise=0
Ca914 ns914 0 1e-12
Ra914 ns914 0 0.636680753855 noise=0
Ca915 ns915 0 1e-12
Ca916 ns916 0 1e-12
Ra915 ns915 0 5.81195360108 noise=0
Ra916 ns916 0 5.81195360108 noise=0
Ga915 ns915 0 ns916 0 -0.440242930677
Ga916 ns916 0 ns915 0 0.440242930677
Ca917 ns917 0 1e-12
Ca918 ns918 0 1e-12
Ra917 ns917 0 25.0988766288 noise=0
Ra918 ns918 0 25.0988766288 noise=0
Ga917 ns917 0 ns918 0 -0.446182178947
Ga918 ns918 0 ns917 0 0.446182178947
Ca919 ns919 0 1e-12
Ca920 ns920 0 1e-12
Ra919 ns919 0 33.7291568883 noise=0
Ra920 ns920 0 33.7291568883 noise=0
Ga919 ns919 0 ns920 0 -0.437411009606
Ga920 ns920 0 ns919 0 0.437411009606
Ca921 ns921 0 1e-12
Ca922 ns922 0 1e-12
Ra921 ns921 0 30.2651538335 noise=0
Ra922 ns922 0 30.2651538335 noise=0
Ga921 ns921 0 ns922 0 -0.398051468393
Ga922 ns922 0 ns921 0 0.398051468393
Ca923 ns923 0 1e-12
Ca924 ns924 0 1e-12
Ra923 ns923 0 45.9593730353 noise=0
Ra924 ns924 0 45.9593730353 noise=0
Ga923 ns923 0 ns924 0 -0.376970230653
Ga924 ns924 0 ns923 0 0.376970230653
Ca925 ns925 0 1e-12
Ca926 ns926 0 1e-12
Ra925 ns925 0 22.8012326672 noise=0
Ra926 ns926 0 22.8012326672 noise=0
Ga925 ns925 0 ns926 0 -0.365000471119
Ga926 ns926 0 ns925 0 0.365000471119
Ca927 ns927 0 1e-12
Ca928 ns928 0 1e-12
Ra927 ns927 0 27.2711114272 noise=0
Ra928 ns928 0 27.2711114272 noise=0
Ga927 ns927 0 ns928 0 -0.30562060416
Ga928 ns928 0 ns927 0 0.30562060416
Ca929 ns929 0 1e-12
Ca930 ns930 0 1e-12
Ra929 ns929 0 36.1574626321 noise=0
Ra930 ns930 0 36.1574626321 noise=0
Ga929 ns929 0 ns930 0 -0.285967392433
Ga930 ns930 0 ns929 0 0.285967392433
Ca931 ns931 0 1e-12
Ca932 ns932 0 1e-12
Ra931 ns931 0 29.7569279687 noise=0
Ra932 ns932 0 29.7569279687 noise=0
Ga931 ns931 0 ns932 0 -0.276381759385
Ga932 ns932 0 ns931 0 0.276381759385
Ca933 ns933 0 1e-12
Ca934 ns934 0 1e-12
Ra933 ns933 0 20.4882528217 noise=0
Ra934 ns934 0 20.4882528217 noise=0
Ga933 ns933 0 ns934 0 -0.222396936817
Ga934 ns934 0 ns933 0 0.222396936817
Ca935 ns935 0 1e-12
Ca936 ns936 0 1e-12
Ra935 ns935 0 33.0904520292 noise=0
Ra936 ns936 0 33.0904520292 noise=0
Ga935 ns935 0 ns936 0 -0.193660507824
Ga936 ns936 0 ns935 0 0.193660507824
Ca937 ns937 0 1e-12
Ca938 ns938 0 1e-12
Ra937 ns937 0 34.81602158 noise=0
Ra938 ns938 0 34.81602158 noise=0
Ga937 ns937 0 ns938 0 -0.193389614476
Ga938 ns938 0 ns937 0 0.193389614476
Ca939 ns939 0 1e-12
Ca940 ns940 0 1e-12
Ra939 ns939 0 19.0488873153 noise=0
Ra940 ns940 0 19.0488873153 noise=0
Ga939 ns939 0 ns940 0 -0.118879593805
Ga940 ns940 0 ns939 0 0.118879593805
Ca941 ns941 0 1e-12
Ca942 ns942 0 1e-12
Ra941 ns941 0 38.9664963377 noise=0
Ra942 ns942 0 38.9664963377 noise=0
Ga941 ns941 0 ns942 0 -0.098928422879
Ga942 ns942 0 ns941 0 0.098928422879
Ca943 ns943 0 1e-12
Ca944 ns944 0 1e-12
Ra943 ns943 0 22.7620283637 noise=0
Ra944 ns944 0 22.7620283637 noise=0
Ga943 ns943 0 ns944 0 -0.0899282175659
Ga944 ns944 0 ns943 0 0.0899282175659
Ca945 ns945 0 1e-12
Ca946 ns946 0 1e-12
Ra945 ns945 0 21.1351530279 noise=0
Ra946 ns946 0 21.1351530279 noise=0
Ga945 ns945 0 ns946 0 -0.0231807799965
Ga946 ns946 0 ns945 0 0.0231807799965
Ca947 ns947 0 1e-12
Ra947 ns947 0 35.5013141349 noise=0
Ca948 ns948 0 1e-12
Ra948 ns948 0 1368.82509734 noise=0
Ca949 ns949 0 1e-12
Ra949 ns949 0 13570.4439484 noise=0
Ca950 ns950 0 1e-12
Ra950 ns950 0 4070.84562835 noise=0
Ca951 ns951 0 1e-12
Ra951 ns951 0 0.37257923819 noise=0
Ca952 ns952 0 1e-12
Ra952 ns952 0 0.636680753855 noise=0
Ca953 ns953 0 1e-12
Ca954 ns954 0 1e-12
Ra953 ns953 0 5.81195360108 noise=0
Ra954 ns954 0 5.81195360108 noise=0
Ga953 ns953 0 ns954 0 -0.440242930677
Ga954 ns954 0 ns953 0 0.440242930677
Ca955 ns955 0 1e-12
Ca956 ns956 0 1e-12
Ra955 ns955 0 25.0988766288 noise=0
Ra956 ns956 0 25.0988766288 noise=0
Ga955 ns955 0 ns956 0 -0.446182178947
Ga956 ns956 0 ns955 0 0.446182178947
Ca957 ns957 0 1e-12
Ca958 ns958 0 1e-12
Ra957 ns957 0 33.7291568883 noise=0
Ra958 ns958 0 33.7291568883 noise=0
Ga957 ns957 0 ns958 0 -0.437411009606
Ga958 ns958 0 ns957 0 0.437411009606
Ca959 ns959 0 1e-12
Ca960 ns960 0 1e-12
Ra959 ns959 0 30.2651538335 noise=0
Ra960 ns960 0 30.2651538335 noise=0
Ga959 ns959 0 ns960 0 -0.398051468393
Ga960 ns960 0 ns959 0 0.398051468393
Ca961 ns961 0 1e-12
Ca962 ns962 0 1e-12
Ra961 ns961 0 45.9593730353 noise=0
Ra962 ns962 0 45.9593730353 noise=0
Ga961 ns961 0 ns962 0 -0.376970230653
Ga962 ns962 0 ns961 0 0.376970230653
Ca963 ns963 0 1e-12
Ca964 ns964 0 1e-12
Ra963 ns963 0 22.8012326672 noise=0
Ra964 ns964 0 22.8012326672 noise=0
Ga963 ns963 0 ns964 0 -0.365000471119
Ga964 ns964 0 ns963 0 0.365000471119
Ca965 ns965 0 1e-12
Ca966 ns966 0 1e-12
Ra965 ns965 0 27.2711114272 noise=0
Ra966 ns966 0 27.2711114272 noise=0
Ga965 ns965 0 ns966 0 -0.30562060416
Ga966 ns966 0 ns965 0 0.30562060416
Ca967 ns967 0 1e-12
Ca968 ns968 0 1e-12
Ra967 ns967 0 36.1574626321 noise=0
Ra968 ns968 0 36.1574626321 noise=0
Ga967 ns967 0 ns968 0 -0.285967392433
Ga968 ns968 0 ns967 0 0.285967392433
Ca969 ns969 0 1e-12
Ca970 ns970 0 1e-12
Ra969 ns969 0 29.7569279687 noise=0
Ra970 ns970 0 29.7569279687 noise=0
Ga969 ns969 0 ns970 0 -0.276381759385
Ga970 ns970 0 ns969 0 0.276381759385
Ca971 ns971 0 1e-12
Ca972 ns972 0 1e-12
Ra971 ns971 0 20.4882528217 noise=0
Ra972 ns972 0 20.4882528217 noise=0
Ga971 ns971 0 ns972 0 -0.222396936817
Ga972 ns972 0 ns971 0 0.222396936817
Ca973 ns973 0 1e-12
Ca974 ns974 0 1e-12
Ra973 ns973 0 33.0904520292 noise=0
Ra974 ns974 0 33.0904520292 noise=0
Ga973 ns973 0 ns974 0 -0.193660507824
Ga974 ns974 0 ns973 0 0.193660507824
Ca975 ns975 0 1e-12
Ca976 ns976 0 1e-12
Ra975 ns975 0 34.81602158 noise=0
Ra976 ns976 0 34.81602158 noise=0
Ga975 ns975 0 ns976 0 -0.193389614476
Ga976 ns976 0 ns975 0 0.193389614476
Ca977 ns977 0 1e-12
Ca978 ns978 0 1e-12
Ra977 ns977 0 19.0488873153 noise=0
Ra978 ns978 0 19.0488873153 noise=0
Ga977 ns977 0 ns978 0 -0.118879593805
Ga978 ns978 0 ns977 0 0.118879593805
Ca979 ns979 0 1e-12
Ca980 ns980 0 1e-12
Ra979 ns979 0 38.9664963377 noise=0
Ra980 ns980 0 38.9664963377 noise=0
Ga979 ns979 0 ns980 0 -0.098928422879
Ga980 ns980 0 ns979 0 0.098928422879
Ca981 ns981 0 1e-12
Ca982 ns982 0 1e-12
Ra981 ns981 0 22.7620283637 noise=0
Ra982 ns982 0 22.7620283637 noise=0
Ga981 ns981 0 ns982 0 -0.0899282175659
Ga982 ns982 0 ns981 0 0.0899282175659
Ca983 ns983 0 1e-12
Ca984 ns984 0 1e-12
Ra983 ns983 0 21.1351530279 noise=0
Ra984 ns984 0 21.1351530279 noise=0
Ga983 ns983 0 ns984 0 -0.0231807799965
Ga984 ns984 0 ns983 0 0.0231807799965
Ca985 ns985 0 1e-12
Ra985 ns985 0 35.5013141349 noise=0
Ca986 ns986 0 1e-12
Ra986 ns986 0 1368.82509734 noise=0
Ca987 ns987 0 1e-12
Ra987 ns987 0 13570.4439484 noise=0
Ca988 ns988 0 1e-12
Ra988 ns988 0 4070.84562835 noise=0
Ca989 ns989 0 1e-12
Ra989 ns989 0 0.37257923819 noise=0
Ca990 ns990 0 1e-12
Ra990 ns990 0 0.636680753855 noise=0
Ca991 ns991 0 1e-12
Ca992 ns992 0 1e-12
Ra991 ns991 0 5.81195360108 noise=0
Ra992 ns992 0 5.81195360108 noise=0
Ga991 ns991 0 ns992 0 -0.440242930677
Ga992 ns992 0 ns991 0 0.440242930677
Ca993 ns993 0 1e-12
Ca994 ns994 0 1e-12
Ra993 ns993 0 25.0988766288 noise=0
Ra994 ns994 0 25.0988766288 noise=0
Ga993 ns993 0 ns994 0 -0.446182178947
Ga994 ns994 0 ns993 0 0.446182178947
Ca995 ns995 0 1e-12
Ca996 ns996 0 1e-12
Ra995 ns995 0 33.7291568883 noise=0
Ra996 ns996 0 33.7291568883 noise=0
Ga995 ns995 0 ns996 0 -0.437411009606
Ga996 ns996 0 ns995 0 0.437411009606
Ca997 ns997 0 1e-12
Ca998 ns998 0 1e-12
Ra997 ns997 0 30.2651538335 noise=0
Ra998 ns998 0 30.2651538335 noise=0
Ga997 ns997 0 ns998 0 -0.398051468393
Ga998 ns998 0 ns997 0 0.398051468393
Ca999 ns999 0 1e-12
Ca1000 ns1000 0 1e-12
Ra999 ns999 0 45.9593730353 noise=0
Ra1000 ns1000 0 45.9593730353 noise=0
Ga999 ns999 0 ns1000 0 -0.376970230653
Ga1000 ns1000 0 ns999 0 0.376970230653
Ca1001 ns1001 0 1e-12
Ca1002 ns1002 0 1e-12
Ra1001 ns1001 0 22.8012326672 noise=0
Ra1002 ns1002 0 22.8012326672 noise=0
Ga1001 ns1001 0 ns1002 0 -0.365000471119
Ga1002 ns1002 0 ns1001 0 0.365000471119
Ca1003 ns1003 0 1e-12
Ca1004 ns1004 0 1e-12
Ra1003 ns1003 0 27.2711114272 noise=0
Ra1004 ns1004 0 27.2711114272 noise=0
Ga1003 ns1003 0 ns1004 0 -0.30562060416
Ga1004 ns1004 0 ns1003 0 0.30562060416
Ca1005 ns1005 0 1e-12
Ca1006 ns1006 0 1e-12
Ra1005 ns1005 0 36.1574626321 noise=0
Ra1006 ns1006 0 36.1574626321 noise=0
Ga1005 ns1005 0 ns1006 0 -0.285967392433
Ga1006 ns1006 0 ns1005 0 0.285967392433
Ca1007 ns1007 0 1e-12
Ca1008 ns1008 0 1e-12
Ra1007 ns1007 0 29.7569279687 noise=0
Ra1008 ns1008 0 29.7569279687 noise=0
Ga1007 ns1007 0 ns1008 0 -0.276381759385
Ga1008 ns1008 0 ns1007 0 0.276381759385
Ca1009 ns1009 0 1e-12
Ca1010 ns1010 0 1e-12
Ra1009 ns1009 0 20.4882528217 noise=0
Ra1010 ns1010 0 20.4882528217 noise=0
Ga1009 ns1009 0 ns1010 0 -0.222396936817
Ga1010 ns1010 0 ns1009 0 0.222396936817
Ca1011 ns1011 0 1e-12
Ca1012 ns1012 0 1e-12
Ra1011 ns1011 0 33.0904520292 noise=0
Ra1012 ns1012 0 33.0904520292 noise=0
Ga1011 ns1011 0 ns1012 0 -0.193660507824
Ga1012 ns1012 0 ns1011 0 0.193660507824
Ca1013 ns1013 0 1e-12
Ca1014 ns1014 0 1e-12
Ra1013 ns1013 0 34.81602158 noise=0
Ra1014 ns1014 0 34.81602158 noise=0
Ga1013 ns1013 0 ns1014 0 -0.193389614476
Ga1014 ns1014 0 ns1013 0 0.193389614476
Ca1015 ns1015 0 1e-12
Ca1016 ns1016 0 1e-12
Ra1015 ns1015 0 19.0488873153 noise=0
Ra1016 ns1016 0 19.0488873153 noise=0
Ga1015 ns1015 0 ns1016 0 -0.118879593805
Ga1016 ns1016 0 ns1015 0 0.118879593805
Ca1017 ns1017 0 1e-12
Ca1018 ns1018 0 1e-12
Ra1017 ns1017 0 38.9664963377 noise=0
Ra1018 ns1018 0 38.9664963377 noise=0
Ga1017 ns1017 0 ns1018 0 -0.098928422879
Ga1018 ns1018 0 ns1017 0 0.098928422879
Ca1019 ns1019 0 1e-12
Ca1020 ns1020 0 1e-12
Ra1019 ns1019 0 22.7620283637 noise=0
Ra1020 ns1020 0 22.7620283637 noise=0
Ga1019 ns1019 0 ns1020 0 -0.0899282175659
Ga1020 ns1020 0 ns1019 0 0.0899282175659
Ca1021 ns1021 0 1e-12
Ca1022 ns1022 0 1e-12
Ra1021 ns1021 0 21.1351530279 noise=0
Ra1022 ns1022 0 21.1351530279 noise=0
Ga1021 ns1021 0 ns1022 0 -0.0231807799965
Ga1022 ns1022 0 ns1021 0 0.0231807799965
Ca1023 ns1023 0 1e-12
Ra1023 ns1023 0 35.5013141349 noise=0
Ca1024 ns1024 0 1e-12
Ra1024 ns1024 0 1368.82509734 noise=0
Ca1025 ns1025 0 1e-12
Ra1025 ns1025 0 13570.4439484 noise=0
Ca1026 ns1026 0 1e-12
Ra1026 ns1026 0 4070.84562835 noise=0
Ca1027 ns1027 0 1e-12
Ra1027 ns1027 0 0.37257923819 noise=0
Ca1028 ns1028 0 1e-12
Ra1028 ns1028 0 0.636680753855 noise=0
Ca1029 ns1029 0 1e-12
Ca1030 ns1030 0 1e-12
Ra1029 ns1029 0 5.81195360108 noise=0
Ra1030 ns1030 0 5.81195360108 noise=0
Ga1029 ns1029 0 ns1030 0 -0.440242930677
Ga1030 ns1030 0 ns1029 0 0.440242930677
Ca1031 ns1031 0 1e-12
Ca1032 ns1032 0 1e-12
Ra1031 ns1031 0 25.0988766288 noise=0
Ra1032 ns1032 0 25.0988766288 noise=0
Ga1031 ns1031 0 ns1032 0 -0.446182178947
Ga1032 ns1032 0 ns1031 0 0.446182178947
Ca1033 ns1033 0 1e-12
Ca1034 ns1034 0 1e-12
Ra1033 ns1033 0 33.7291568883 noise=0
Ra1034 ns1034 0 33.7291568883 noise=0
Ga1033 ns1033 0 ns1034 0 -0.437411009606
Ga1034 ns1034 0 ns1033 0 0.437411009606
Ca1035 ns1035 0 1e-12
Ca1036 ns1036 0 1e-12
Ra1035 ns1035 0 30.2651538335 noise=0
Ra1036 ns1036 0 30.2651538335 noise=0
Ga1035 ns1035 0 ns1036 0 -0.398051468393
Ga1036 ns1036 0 ns1035 0 0.398051468393
Ca1037 ns1037 0 1e-12
Ca1038 ns1038 0 1e-12
Ra1037 ns1037 0 45.9593730353 noise=0
Ra1038 ns1038 0 45.9593730353 noise=0
Ga1037 ns1037 0 ns1038 0 -0.376970230653
Ga1038 ns1038 0 ns1037 0 0.376970230653
Ca1039 ns1039 0 1e-12
Ca1040 ns1040 0 1e-12
Ra1039 ns1039 0 22.8012326672 noise=0
Ra1040 ns1040 0 22.8012326672 noise=0
Ga1039 ns1039 0 ns1040 0 -0.365000471119
Ga1040 ns1040 0 ns1039 0 0.365000471119
Ca1041 ns1041 0 1e-12
Ca1042 ns1042 0 1e-12
Ra1041 ns1041 0 27.2711114272 noise=0
Ra1042 ns1042 0 27.2711114272 noise=0
Ga1041 ns1041 0 ns1042 0 -0.30562060416
Ga1042 ns1042 0 ns1041 0 0.30562060416
Ca1043 ns1043 0 1e-12
Ca1044 ns1044 0 1e-12
Ra1043 ns1043 0 36.1574626321 noise=0
Ra1044 ns1044 0 36.1574626321 noise=0
Ga1043 ns1043 0 ns1044 0 -0.285967392433
Ga1044 ns1044 0 ns1043 0 0.285967392433
Ca1045 ns1045 0 1e-12
Ca1046 ns1046 0 1e-12
Ra1045 ns1045 0 29.7569279687 noise=0
Ra1046 ns1046 0 29.7569279687 noise=0
Ga1045 ns1045 0 ns1046 0 -0.276381759385
Ga1046 ns1046 0 ns1045 0 0.276381759385
Ca1047 ns1047 0 1e-12
Ca1048 ns1048 0 1e-12
Ra1047 ns1047 0 20.4882528217 noise=0
Ra1048 ns1048 0 20.4882528217 noise=0
Ga1047 ns1047 0 ns1048 0 -0.222396936817
Ga1048 ns1048 0 ns1047 0 0.222396936817
Ca1049 ns1049 0 1e-12
Ca1050 ns1050 0 1e-12
Ra1049 ns1049 0 33.0904520292 noise=0
Ra1050 ns1050 0 33.0904520292 noise=0
Ga1049 ns1049 0 ns1050 0 -0.193660507824
Ga1050 ns1050 0 ns1049 0 0.193660507824
Ca1051 ns1051 0 1e-12
Ca1052 ns1052 0 1e-12
Ra1051 ns1051 0 34.81602158 noise=0
Ra1052 ns1052 0 34.81602158 noise=0
Ga1051 ns1051 0 ns1052 0 -0.193389614476
Ga1052 ns1052 0 ns1051 0 0.193389614476
Ca1053 ns1053 0 1e-12
Ca1054 ns1054 0 1e-12
Ra1053 ns1053 0 19.0488873153 noise=0
Ra1054 ns1054 0 19.0488873153 noise=0
Ga1053 ns1053 0 ns1054 0 -0.118879593805
Ga1054 ns1054 0 ns1053 0 0.118879593805
Ca1055 ns1055 0 1e-12
Ca1056 ns1056 0 1e-12
Ra1055 ns1055 0 38.9664963377 noise=0
Ra1056 ns1056 0 38.9664963377 noise=0
Ga1055 ns1055 0 ns1056 0 -0.098928422879
Ga1056 ns1056 0 ns1055 0 0.098928422879
Ca1057 ns1057 0 1e-12
Ca1058 ns1058 0 1e-12
Ra1057 ns1057 0 22.7620283637 noise=0
Ra1058 ns1058 0 22.7620283637 noise=0
Ga1057 ns1057 0 ns1058 0 -0.0899282175659
Ga1058 ns1058 0 ns1057 0 0.0899282175659
Ca1059 ns1059 0 1e-12
Ca1060 ns1060 0 1e-12
Ra1059 ns1059 0 21.1351530279 noise=0
Ra1060 ns1060 0 21.1351530279 noise=0
Ga1059 ns1059 0 ns1060 0 -0.0231807799965
Ga1060 ns1060 0 ns1059 0 0.0231807799965
Ca1061 ns1061 0 1e-12
Ra1061 ns1061 0 35.5013141349 noise=0
Ca1062 ns1062 0 1e-12
Ra1062 ns1062 0 1368.82509734 noise=0
Ca1063 ns1063 0 1e-12
Ra1063 ns1063 0 13570.4439484 noise=0
Ca1064 ns1064 0 1e-12
Ra1064 ns1064 0 4070.84562835 noise=0
Ca1065 ns1065 0 1e-12
Ra1065 ns1065 0 0.37257923819 noise=0
Ca1066 ns1066 0 1e-12
Ra1066 ns1066 0 0.636680753855 noise=0
Ca1067 ns1067 0 1e-12
Ca1068 ns1068 0 1e-12
Ra1067 ns1067 0 5.81195360108 noise=0
Ra1068 ns1068 0 5.81195360108 noise=0
Ga1067 ns1067 0 ns1068 0 -0.440242930677
Ga1068 ns1068 0 ns1067 0 0.440242930677
Ca1069 ns1069 0 1e-12
Ca1070 ns1070 0 1e-12
Ra1069 ns1069 0 25.0988766288 noise=0
Ra1070 ns1070 0 25.0988766288 noise=0
Ga1069 ns1069 0 ns1070 0 -0.446182178947
Ga1070 ns1070 0 ns1069 0 0.446182178947
Ca1071 ns1071 0 1e-12
Ca1072 ns1072 0 1e-12
Ra1071 ns1071 0 33.7291568883 noise=0
Ra1072 ns1072 0 33.7291568883 noise=0
Ga1071 ns1071 0 ns1072 0 -0.437411009606
Ga1072 ns1072 0 ns1071 0 0.437411009606
Ca1073 ns1073 0 1e-12
Ca1074 ns1074 0 1e-12
Ra1073 ns1073 0 30.2651538335 noise=0
Ra1074 ns1074 0 30.2651538335 noise=0
Ga1073 ns1073 0 ns1074 0 -0.398051468393
Ga1074 ns1074 0 ns1073 0 0.398051468393
Ca1075 ns1075 0 1e-12
Ca1076 ns1076 0 1e-12
Ra1075 ns1075 0 45.9593730353 noise=0
Ra1076 ns1076 0 45.9593730353 noise=0
Ga1075 ns1075 0 ns1076 0 -0.376970230653
Ga1076 ns1076 0 ns1075 0 0.376970230653
Ca1077 ns1077 0 1e-12
Ca1078 ns1078 0 1e-12
Ra1077 ns1077 0 22.8012326672 noise=0
Ra1078 ns1078 0 22.8012326672 noise=0
Ga1077 ns1077 0 ns1078 0 -0.365000471119
Ga1078 ns1078 0 ns1077 0 0.365000471119
Ca1079 ns1079 0 1e-12
Ca1080 ns1080 0 1e-12
Ra1079 ns1079 0 27.2711114272 noise=0
Ra1080 ns1080 0 27.2711114272 noise=0
Ga1079 ns1079 0 ns1080 0 -0.30562060416
Ga1080 ns1080 0 ns1079 0 0.30562060416
Ca1081 ns1081 0 1e-12
Ca1082 ns1082 0 1e-12
Ra1081 ns1081 0 36.1574626321 noise=0
Ra1082 ns1082 0 36.1574626321 noise=0
Ga1081 ns1081 0 ns1082 0 -0.285967392433
Ga1082 ns1082 0 ns1081 0 0.285967392433
Ca1083 ns1083 0 1e-12
Ca1084 ns1084 0 1e-12
Ra1083 ns1083 0 29.7569279687 noise=0
Ra1084 ns1084 0 29.7569279687 noise=0
Ga1083 ns1083 0 ns1084 0 -0.276381759385
Ga1084 ns1084 0 ns1083 0 0.276381759385
Ca1085 ns1085 0 1e-12
Ca1086 ns1086 0 1e-12
Ra1085 ns1085 0 20.4882528217 noise=0
Ra1086 ns1086 0 20.4882528217 noise=0
Ga1085 ns1085 0 ns1086 0 -0.222396936817
Ga1086 ns1086 0 ns1085 0 0.222396936817
Ca1087 ns1087 0 1e-12
Ca1088 ns1088 0 1e-12
Ra1087 ns1087 0 33.0904520292 noise=0
Ra1088 ns1088 0 33.0904520292 noise=0
Ga1087 ns1087 0 ns1088 0 -0.193660507824
Ga1088 ns1088 0 ns1087 0 0.193660507824
Ca1089 ns1089 0 1e-12
Ca1090 ns1090 0 1e-12
Ra1089 ns1089 0 34.81602158 noise=0
Ra1090 ns1090 0 34.81602158 noise=0
Ga1089 ns1089 0 ns1090 0 -0.193389614476
Ga1090 ns1090 0 ns1089 0 0.193389614476
Ca1091 ns1091 0 1e-12
Ca1092 ns1092 0 1e-12
Ra1091 ns1091 0 19.0488873153 noise=0
Ra1092 ns1092 0 19.0488873153 noise=0
Ga1091 ns1091 0 ns1092 0 -0.118879593805
Ga1092 ns1092 0 ns1091 0 0.118879593805
Ca1093 ns1093 0 1e-12
Ca1094 ns1094 0 1e-12
Ra1093 ns1093 0 38.9664963377 noise=0
Ra1094 ns1094 0 38.9664963377 noise=0
Ga1093 ns1093 0 ns1094 0 -0.098928422879
Ga1094 ns1094 0 ns1093 0 0.098928422879
Ca1095 ns1095 0 1e-12
Ca1096 ns1096 0 1e-12
Ra1095 ns1095 0 22.7620283637 noise=0
Ra1096 ns1096 0 22.7620283637 noise=0
Ga1095 ns1095 0 ns1096 0 -0.0899282175659
Ga1096 ns1096 0 ns1095 0 0.0899282175659
Ca1097 ns1097 0 1e-12
Ca1098 ns1098 0 1e-12
Ra1097 ns1097 0 21.1351530279 noise=0
Ra1098 ns1098 0 21.1351530279 noise=0
Ga1097 ns1097 0 ns1098 0 -0.0231807799965
Ga1098 ns1098 0 ns1097 0 0.0231807799965
Ca1099 ns1099 0 1e-12
Ra1099 ns1099 0 35.5013141349 noise=0
Ca1100 ns1100 0 1e-12
Ra1100 ns1100 0 1368.82509734 noise=0
Ca1101 ns1101 0 1e-12
Ra1101 ns1101 0 13570.4439484 noise=0
Ca1102 ns1102 0 1e-12
Ra1102 ns1102 0 4070.84562835 noise=0
Ca1103 ns1103 0 1e-12
Ra1103 ns1103 0 0.37257923819 noise=0
Ca1104 ns1104 0 1e-12
Ra1104 ns1104 0 0.636680753855 noise=0
Ca1105 ns1105 0 1e-12
Ca1106 ns1106 0 1e-12
Ra1105 ns1105 0 5.81195360108 noise=0
Ra1106 ns1106 0 5.81195360108 noise=0
Ga1105 ns1105 0 ns1106 0 -0.440242930677
Ga1106 ns1106 0 ns1105 0 0.440242930677
Ca1107 ns1107 0 1e-12
Ca1108 ns1108 0 1e-12
Ra1107 ns1107 0 25.0988766288 noise=0
Ra1108 ns1108 0 25.0988766288 noise=0
Ga1107 ns1107 0 ns1108 0 -0.446182178947
Ga1108 ns1108 0 ns1107 0 0.446182178947
Ca1109 ns1109 0 1e-12
Ca1110 ns1110 0 1e-12
Ra1109 ns1109 0 33.7291568883 noise=0
Ra1110 ns1110 0 33.7291568883 noise=0
Ga1109 ns1109 0 ns1110 0 -0.437411009606
Ga1110 ns1110 0 ns1109 0 0.437411009606
Ca1111 ns1111 0 1e-12
Ca1112 ns1112 0 1e-12
Ra1111 ns1111 0 30.2651538335 noise=0
Ra1112 ns1112 0 30.2651538335 noise=0
Ga1111 ns1111 0 ns1112 0 -0.398051468393
Ga1112 ns1112 0 ns1111 0 0.398051468393
Ca1113 ns1113 0 1e-12
Ca1114 ns1114 0 1e-12
Ra1113 ns1113 0 45.9593730353 noise=0
Ra1114 ns1114 0 45.9593730353 noise=0
Ga1113 ns1113 0 ns1114 0 -0.376970230653
Ga1114 ns1114 0 ns1113 0 0.376970230653
Ca1115 ns1115 0 1e-12
Ca1116 ns1116 0 1e-12
Ra1115 ns1115 0 22.8012326672 noise=0
Ra1116 ns1116 0 22.8012326672 noise=0
Ga1115 ns1115 0 ns1116 0 -0.365000471119
Ga1116 ns1116 0 ns1115 0 0.365000471119
Ca1117 ns1117 0 1e-12
Ca1118 ns1118 0 1e-12
Ra1117 ns1117 0 27.2711114272 noise=0
Ra1118 ns1118 0 27.2711114272 noise=0
Ga1117 ns1117 0 ns1118 0 -0.30562060416
Ga1118 ns1118 0 ns1117 0 0.30562060416
Ca1119 ns1119 0 1e-12
Ca1120 ns1120 0 1e-12
Ra1119 ns1119 0 36.1574626321 noise=0
Ra1120 ns1120 0 36.1574626321 noise=0
Ga1119 ns1119 0 ns1120 0 -0.285967392433
Ga1120 ns1120 0 ns1119 0 0.285967392433
Ca1121 ns1121 0 1e-12
Ca1122 ns1122 0 1e-12
Ra1121 ns1121 0 29.7569279687 noise=0
Ra1122 ns1122 0 29.7569279687 noise=0
Ga1121 ns1121 0 ns1122 0 -0.276381759385
Ga1122 ns1122 0 ns1121 0 0.276381759385
Ca1123 ns1123 0 1e-12
Ca1124 ns1124 0 1e-12
Ra1123 ns1123 0 20.4882528217 noise=0
Ra1124 ns1124 0 20.4882528217 noise=0
Ga1123 ns1123 0 ns1124 0 -0.222396936817
Ga1124 ns1124 0 ns1123 0 0.222396936817
Ca1125 ns1125 0 1e-12
Ca1126 ns1126 0 1e-12
Ra1125 ns1125 0 33.0904520292 noise=0
Ra1126 ns1126 0 33.0904520292 noise=0
Ga1125 ns1125 0 ns1126 0 -0.193660507824
Ga1126 ns1126 0 ns1125 0 0.193660507824
Ca1127 ns1127 0 1e-12
Ca1128 ns1128 0 1e-12
Ra1127 ns1127 0 34.81602158 noise=0
Ra1128 ns1128 0 34.81602158 noise=0
Ga1127 ns1127 0 ns1128 0 -0.193389614476
Ga1128 ns1128 0 ns1127 0 0.193389614476
Ca1129 ns1129 0 1e-12
Ca1130 ns1130 0 1e-12
Ra1129 ns1129 0 19.0488873153 noise=0
Ra1130 ns1130 0 19.0488873153 noise=0
Ga1129 ns1129 0 ns1130 0 -0.118879593805
Ga1130 ns1130 0 ns1129 0 0.118879593805
Ca1131 ns1131 0 1e-12
Ca1132 ns1132 0 1e-12
Ra1131 ns1131 0 38.9664963377 noise=0
Ra1132 ns1132 0 38.9664963377 noise=0
Ga1131 ns1131 0 ns1132 0 -0.098928422879
Ga1132 ns1132 0 ns1131 0 0.098928422879
Ca1133 ns1133 0 1e-12
Ca1134 ns1134 0 1e-12
Ra1133 ns1133 0 22.7620283637 noise=0
Ra1134 ns1134 0 22.7620283637 noise=0
Ga1133 ns1133 0 ns1134 0 -0.0899282175659
Ga1134 ns1134 0 ns1133 0 0.0899282175659
Ca1135 ns1135 0 1e-12
Ca1136 ns1136 0 1e-12
Ra1135 ns1135 0 21.1351530279 noise=0
Ra1136 ns1136 0 21.1351530279 noise=0
Ga1135 ns1135 0 ns1136 0 -0.0231807799965
Ga1136 ns1136 0 ns1135 0 0.0231807799965
Ca1137 ns1137 0 1e-12
Ra1137 ns1137 0 35.5013141349 noise=0
Ca1138 ns1138 0 1e-12
Ra1138 ns1138 0 1368.82509734 noise=0
Ca1139 ns1139 0 1e-12
Ra1139 ns1139 0 13570.4439484 noise=0
Ca1140 ns1140 0 1e-12
Ra1140 ns1140 0 4070.84562835 noise=0
Ca1141 ns1141 0 1e-12
Ra1141 ns1141 0 0.37257923819 noise=0
Ca1142 ns1142 0 1e-12
Ra1142 ns1142 0 0.636680753855 noise=0
Ca1143 ns1143 0 1e-12
Ca1144 ns1144 0 1e-12
Ra1143 ns1143 0 5.81195360108 noise=0
Ra1144 ns1144 0 5.81195360108 noise=0
Ga1143 ns1143 0 ns1144 0 -0.440242930677
Ga1144 ns1144 0 ns1143 0 0.440242930677
Ca1145 ns1145 0 1e-12
Ca1146 ns1146 0 1e-12
Ra1145 ns1145 0 25.0988766288 noise=0
Ra1146 ns1146 0 25.0988766288 noise=0
Ga1145 ns1145 0 ns1146 0 -0.446182178947
Ga1146 ns1146 0 ns1145 0 0.446182178947
Ca1147 ns1147 0 1e-12
Ca1148 ns1148 0 1e-12
Ra1147 ns1147 0 33.7291568883 noise=0
Ra1148 ns1148 0 33.7291568883 noise=0
Ga1147 ns1147 0 ns1148 0 -0.437411009606
Ga1148 ns1148 0 ns1147 0 0.437411009606
Ca1149 ns1149 0 1e-12
Ca1150 ns1150 0 1e-12
Ra1149 ns1149 0 30.2651538335 noise=0
Ra1150 ns1150 0 30.2651538335 noise=0
Ga1149 ns1149 0 ns1150 0 -0.398051468393
Ga1150 ns1150 0 ns1149 0 0.398051468393
Ca1151 ns1151 0 1e-12
Ca1152 ns1152 0 1e-12
Ra1151 ns1151 0 45.9593730353 noise=0
Ra1152 ns1152 0 45.9593730353 noise=0
Ga1151 ns1151 0 ns1152 0 -0.376970230653
Ga1152 ns1152 0 ns1151 0 0.376970230653
Ca1153 ns1153 0 1e-12
Ca1154 ns1154 0 1e-12
Ra1153 ns1153 0 22.8012326672 noise=0
Ra1154 ns1154 0 22.8012326672 noise=0
Ga1153 ns1153 0 ns1154 0 -0.365000471119
Ga1154 ns1154 0 ns1153 0 0.365000471119
Ca1155 ns1155 0 1e-12
Ca1156 ns1156 0 1e-12
Ra1155 ns1155 0 27.2711114272 noise=0
Ra1156 ns1156 0 27.2711114272 noise=0
Ga1155 ns1155 0 ns1156 0 -0.30562060416
Ga1156 ns1156 0 ns1155 0 0.30562060416
Ca1157 ns1157 0 1e-12
Ca1158 ns1158 0 1e-12
Ra1157 ns1157 0 36.1574626321 noise=0
Ra1158 ns1158 0 36.1574626321 noise=0
Ga1157 ns1157 0 ns1158 0 -0.285967392433
Ga1158 ns1158 0 ns1157 0 0.285967392433
Ca1159 ns1159 0 1e-12
Ca1160 ns1160 0 1e-12
Ra1159 ns1159 0 29.7569279687 noise=0
Ra1160 ns1160 0 29.7569279687 noise=0
Ga1159 ns1159 0 ns1160 0 -0.276381759385
Ga1160 ns1160 0 ns1159 0 0.276381759385
Ca1161 ns1161 0 1e-12
Ca1162 ns1162 0 1e-12
Ra1161 ns1161 0 20.4882528217 noise=0
Ra1162 ns1162 0 20.4882528217 noise=0
Ga1161 ns1161 0 ns1162 0 -0.222396936817
Ga1162 ns1162 0 ns1161 0 0.222396936817
Ca1163 ns1163 0 1e-12
Ca1164 ns1164 0 1e-12
Ra1163 ns1163 0 33.0904520292 noise=0
Ra1164 ns1164 0 33.0904520292 noise=0
Ga1163 ns1163 0 ns1164 0 -0.193660507824
Ga1164 ns1164 0 ns1163 0 0.193660507824
Ca1165 ns1165 0 1e-12
Ca1166 ns1166 0 1e-12
Ra1165 ns1165 0 34.81602158 noise=0
Ra1166 ns1166 0 34.81602158 noise=0
Ga1165 ns1165 0 ns1166 0 -0.193389614476
Ga1166 ns1166 0 ns1165 0 0.193389614476
Ca1167 ns1167 0 1e-12
Ca1168 ns1168 0 1e-12
Ra1167 ns1167 0 19.0488873153 noise=0
Ra1168 ns1168 0 19.0488873153 noise=0
Ga1167 ns1167 0 ns1168 0 -0.118879593805
Ga1168 ns1168 0 ns1167 0 0.118879593805
Ca1169 ns1169 0 1e-12
Ca1170 ns1170 0 1e-12
Ra1169 ns1169 0 38.9664963377 noise=0
Ra1170 ns1170 0 38.9664963377 noise=0
Ga1169 ns1169 0 ns1170 0 -0.098928422879
Ga1170 ns1170 0 ns1169 0 0.098928422879
Ca1171 ns1171 0 1e-12
Ca1172 ns1172 0 1e-12
Ra1171 ns1171 0 22.7620283637 noise=0
Ra1172 ns1172 0 22.7620283637 noise=0
Ga1171 ns1171 0 ns1172 0 -0.0899282175659
Ga1172 ns1172 0 ns1171 0 0.0899282175659
Ca1173 ns1173 0 1e-12
Ca1174 ns1174 0 1e-12
Ra1173 ns1173 0 21.1351530279 noise=0
Ra1174 ns1174 0 21.1351530279 noise=0
Ga1173 ns1173 0 ns1174 0 -0.0231807799965
Ga1174 ns1174 0 ns1173 0 0.0231807799965
Ca1175 ns1175 0 1e-12
Ra1175 ns1175 0 35.5013141349 noise=0
Ca1176 ns1176 0 1e-12
Ra1176 ns1176 0 1368.82509734 noise=0
Ca1177 ns1177 0 1e-12
Ra1177 ns1177 0 13570.4439484 noise=0
Ca1178 ns1178 0 1e-12
Ra1178 ns1178 0 4070.84562835 noise=0
Ca1179 ns1179 0 1e-12
Ra1179 ns1179 0 0.37257923819 noise=0
Ca1180 ns1180 0 1e-12
Ra1180 ns1180 0 0.636680753855 noise=0
Ca1181 ns1181 0 1e-12
Ca1182 ns1182 0 1e-12
Ra1181 ns1181 0 5.81195360108 noise=0
Ra1182 ns1182 0 5.81195360108 noise=0
Ga1181 ns1181 0 ns1182 0 -0.440242930677
Ga1182 ns1182 0 ns1181 0 0.440242930677
Ca1183 ns1183 0 1e-12
Ca1184 ns1184 0 1e-12
Ra1183 ns1183 0 25.0988766288 noise=0
Ra1184 ns1184 0 25.0988766288 noise=0
Ga1183 ns1183 0 ns1184 0 -0.446182178947
Ga1184 ns1184 0 ns1183 0 0.446182178947
Ca1185 ns1185 0 1e-12
Ca1186 ns1186 0 1e-12
Ra1185 ns1185 0 33.7291568883 noise=0
Ra1186 ns1186 0 33.7291568883 noise=0
Ga1185 ns1185 0 ns1186 0 -0.437411009606
Ga1186 ns1186 0 ns1185 0 0.437411009606
Ca1187 ns1187 0 1e-12
Ca1188 ns1188 0 1e-12
Ra1187 ns1187 0 30.2651538335 noise=0
Ra1188 ns1188 0 30.2651538335 noise=0
Ga1187 ns1187 0 ns1188 0 -0.398051468393
Ga1188 ns1188 0 ns1187 0 0.398051468393
Ca1189 ns1189 0 1e-12
Ca1190 ns1190 0 1e-12
Ra1189 ns1189 0 45.9593730353 noise=0
Ra1190 ns1190 0 45.9593730353 noise=0
Ga1189 ns1189 0 ns1190 0 -0.376970230653
Ga1190 ns1190 0 ns1189 0 0.376970230653
Ca1191 ns1191 0 1e-12
Ca1192 ns1192 0 1e-12
Ra1191 ns1191 0 22.8012326672 noise=0
Ra1192 ns1192 0 22.8012326672 noise=0
Ga1191 ns1191 0 ns1192 0 -0.365000471119
Ga1192 ns1192 0 ns1191 0 0.365000471119
Ca1193 ns1193 0 1e-12
Ca1194 ns1194 0 1e-12
Ra1193 ns1193 0 27.2711114272 noise=0
Ra1194 ns1194 0 27.2711114272 noise=0
Ga1193 ns1193 0 ns1194 0 -0.30562060416
Ga1194 ns1194 0 ns1193 0 0.30562060416
Ca1195 ns1195 0 1e-12
Ca1196 ns1196 0 1e-12
Ra1195 ns1195 0 36.1574626321 noise=0
Ra1196 ns1196 0 36.1574626321 noise=0
Ga1195 ns1195 0 ns1196 0 -0.285967392433
Ga1196 ns1196 0 ns1195 0 0.285967392433
Ca1197 ns1197 0 1e-12
Ca1198 ns1198 0 1e-12
Ra1197 ns1197 0 29.7569279687 noise=0
Ra1198 ns1198 0 29.7569279687 noise=0
Ga1197 ns1197 0 ns1198 0 -0.276381759385
Ga1198 ns1198 0 ns1197 0 0.276381759385
Ca1199 ns1199 0 1e-12
Ca1200 ns1200 0 1e-12
Ra1199 ns1199 0 20.4882528217 noise=0
Ra1200 ns1200 0 20.4882528217 noise=0
Ga1199 ns1199 0 ns1200 0 -0.222396936817
Ga1200 ns1200 0 ns1199 0 0.222396936817
Ca1201 ns1201 0 1e-12
Ca1202 ns1202 0 1e-12
Ra1201 ns1201 0 33.0904520292 noise=0
Ra1202 ns1202 0 33.0904520292 noise=0
Ga1201 ns1201 0 ns1202 0 -0.193660507824
Ga1202 ns1202 0 ns1201 0 0.193660507824
Ca1203 ns1203 0 1e-12
Ca1204 ns1204 0 1e-12
Ra1203 ns1203 0 34.81602158 noise=0
Ra1204 ns1204 0 34.81602158 noise=0
Ga1203 ns1203 0 ns1204 0 -0.193389614476
Ga1204 ns1204 0 ns1203 0 0.193389614476
Ca1205 ns1205 0 1e-12
Ca1206 ns1206 0 1e-12
Ra1205 ns1205 0 19.0488873153 noise=0
Ra1206 ns1206 0 19.0488873153 noise=0
Ga1205 ns1205 0 ns1206 0 -0.118879593805
Ga1206 ns1206 0 ns1205 0 0.118879593805
Ca1207 ns1207 0 1e-12
Ca1208 ns1208 0 1e-12
Ra1207 ns1207 0 38.9664963377 noise=0
Ra1208 ns1208 0 38.9664963377 noise=0
Ga1207 ns1207 0 ns1208 0 -0.098928422879
Ga1208 ns1208 0 ns1207 0 0.098928422879
Ca1209 ns1209 0 1e-12
Ca1210 ns1210 0 1e-12
Ra1209 ns1209 0 22.7620283637 noise=0
Ra1210 ns1210 0 22.7620283637 noise=0
Ga1209 ns1209 0 ns1210 0 -0.0899282175659
Ga1210 ns1210 0 ns1209 0 0.0899282175659
Ca1211 ns1211 0 1e-12
Ca1212 ns1212 0 1e-12
Ra1211 ns1211 0 21.1351530279 noise=0
Ra1212 ns1212 0 21.1351530279 noise=0
Ga1211 ns1211 0 ns1212 0 -0.0231807799965
Ga1212 ns1212 0 ns1211 0 0.0231807799965
Ca1213 ns1213 0 1e-12
Ra1213 ns1213 0 35.5013141349 noise=0
Ca1214 ns1214 0 1e-12
Ra1214 ns1214 0 1368.82509734 noise=0
Ca1215 ns1215 0 1e-12
Ra1215 ns1215 0 13570.4439484 noise=0
Ca1216 ns1216 0 1e-12
Ra1216 ns1216 0 4070.84562835 noise=0

Gb1_1 ns1 0 ni1 0 -2.68399281951
Gb2_1 ns2 0 ni1 0 1.57064587542
Gb3_1 ns3 0 ni1 0 0.382436899313
Gb4_1 ns4 0 ni1 0 0.319965829211
Gb5_1 ns5 0 ni1 0 -0.393611813675
Gb6_1 ns6 0 ni1 0 0.414591878776
Gb7_1 ns7 0 ni1 0 -0.0288998953188
Gb8_1 ns8 0 ni1 0 0.437461712413
Gb9_1 ns9 0 ni1 0 -0.180810113414
Gb10_1 ns10 0 ni1 0 0.385785533009
Gb11_1 ns11 0 ni1 0 0.369549265187
Gb12_1 ns12 0 ni1 0 0.150328914964
Gb13_1 ns13 0 ni1 0 0.337732020689
Gb14_1 ns14 0 ni1 0 0.270797884127
Gb15_1 ns15 0 ni1 0 0.309492476244
Gb16_1 ns16 0 ni1 0 -0.00439828167297
Gb17_1 ns17 0 ni1 0 0.268378258407
Gb18_1 ns18 0 ni1 0 0.209525908734
Gb19_1 ns19 0 ni1 0 -0.262416526624
Gb20_1 ns20 0 ni1 0 0.148459493783
Gb21_1 ns21 0 ni1 0 -0.202854772461
Gb22_1 ns22 0 ni1 0 -0.137852810629
Gb23_1 ns23 0 ni1 0 0.151709094532
Gb24_1 ns24 0 ni1 0 -0.17470249457
Gb25_1 ns25 0 ni1 0 -0.150930199769
Gb26_1 ns26 0 ni1 0 0.17523919762
Gb27_1 ns27 0 ni1 0 -0.123939719155
Gb28_1 ns28 0 ni1 0 0.0410377293386
Gb29_1 ns29 0 ni1 0 0.101603024312
Gb30_1 ns30 0 ni1 0 -0.0153527668791
Gb31_1 ns31 0 ni1 0 -0.0166299065128
Gb32_1 ns32 0 ni1 0 0.103266563627
Gb33_1 ns33 0 ni1 0 0.0392458406069
Gb34_1 ns34 0 ni1 0 0.0394437935273
Gb35_1 ns35 0 ni1 0 0.0281679713658
Gb36_1 ns36 0 ni1 0 0.00073055352502
Gb37_1 ns37 0 ni1 0 7.36895567902e-05
Gb38_1 ns38 0 ni1 0 0.000245649206896
Gb39_2 ns39 0 ni2 0 -2.68399281951
Gb40_2 ns40 0 ni2 0 1.57064587542
Gb41_2 ns41 0 ni2 0 0.382436899313
Gb42_2 ns42 0 ni2 0 0.319965829211
Gb43_2 ns43 0 ni2 0 -0.393611813675
Gb44_2 ns44 0 ni2 0 0.414591878776
Gb45_2 ns45 0 ni2 0 -0.0288998953188
Gb46_2 ns46 0 ni2 0 0.437461712413
Gb47_2 ns47 0 ni2 0 -0.180810113414
Gb48_2 ns48 0 ni2 0 0.385785533009
Gb49_2 ns49 0 ni2 0 0.369549265187
Gb50_2 ns50 0 ni2 0 0.150328914964
Gb51_2 ns51 0 ni2 0 0.337732020689
Gb52_2 ns52 0 ni2 0 0.270797884127
Gb53_2 ns53 0 ni2 0 0.309492476244
Gb54_2 ns54 0 ni2 0 -0.00439828167297
Gb55_2 ns55 0 ni2 0 0.268378258407
Gb56_2 ns56 0 ni2 0 0.209525908734
Gb57_2 ns57 0 ni2 0 -0.262416526624
Gb58_2 ns58 0 ni2 0 0.148459493783
Gb59_2 ns59 0 ni2 0 -0.202854772461
Gb60_2 ns60 0 ni2 0 -0.137852810629
Gb61_2 ns61 0 ni2 0 0.151709094532
Gb62_2 ns62 0 ni2 0 -0.17470249457
Gb63_2 ns63 0 ni2 0 -0.150930199769
Gb64_2 ns64 0 ni2 0 0.17523919762
Gb65_2 ns65 0 ni2 0 -0.123939719155
Gb66_2 ns66 0 ni2 0 0.0410377293386
Gb67_2 ns67 0 ni2 0 0.101603024312
Gb68_2 ns68 0 ni2 0 -0.0153527668791
Gb69_2 ns69 0 ni2 0 -0.0166299065128
Gb70_2 ns70 0 ni2 0 0.103266563627
Gb71_2 ns71 0 ni2 0 0.0392458406069
Gb72_2 ns72 0 ni2 0 0.0394437935273
Gb73_2 ns73 0 ni2 0 0.0281679713658
Gb74_2 ns74 0 ni2 0 0.00073055352502
Gb75_2 ns75 0 ni2 0 7.36895567902e-05
Gb76_2 ns76 0 ni2 0 0.000245649206896
Gb77_3 ns77 0 ni3 0 -2.68399281951
Gb78_3 ns78 0 ni3 0 1.57064587542
Gb79_3 ns79 0 ni3 0 0.382436899313
Gb80_3 ns80 0 ni3 0 0.319965829211
Gb81_3 ns81 0 ni3 0 -0.393611813675
Gb82_3 ns82 0 ni3 0 0.414591878776
Gb83_3 ns83 0 ni3 0 -0.0288998953188
Gb84_3 ns84 0 ni3 0 0.437461712413
Gb85_3 ns85 0 ni3 0 -0.180810113414
Gb86_3 ns86 0 ni3 0 0.385785533009
Gb87_3 ns87 0 ni3 0 0.369549265187
Gb88_3 ns88 0 ni3 0 0.150328914964
Gb89_3 ns89 0 ni3 0 0.337732020689
Gb90_3 ns90 0 ni3 0 0.270797884127
Gb91_3 ns91 0 ni3 0 0.309492476244
Gb92_3 ns92 0 ni3 0 -0.00439828167297
Gb93_3 ns93 0 ni3 0 0.268378258407
Gb94_3 ns94 0 ni3 0 0.209525908734
Gb95_3 ns95 0 ni3 0 -0.262416526624
Gb96_3 ns96 0 ni3 0 0.148459493783
Gb97_3 ns97 0 ni3 0 -0.202854772461
Gb98_3 ns98 0 ni3 0 -0.137852810629
Gb99_3 ns99 0 ni3 0 0.151709094532
Gb100_3 ns100 0 ni3 0 -0.17470249457
Gb101_3 ns101 0 ni3 0 -0.150930199769
Gb102_3 ns102 0 ni3 0 0.17523919762
Gb103_3 ns103 0 ni3 0 -0.123939719155
Gb104_3 ns104 0 ni3 0 0.0410377293386
Gb105_3 ns105 0 ni3 0 0.101603024312
Gb106_3 ns106 0 ni3 0 -0.0153527668791
Gb107_3 ns107 0 ni3 0 -0.0166299065128
Gb108_3 ns108 0 ni3 0 0.103266563627
Gb109_3 ns109 0 ni3 0 0.0392458406069
Gb110_3 ns110 0 ni3 0 0.0394437935273
Gb111_3 ns111 0 ni3 0 0.0281679713658
Gb112_3 ns112 0 ni3 0 0.00073055352502
Gb113_3 ns113 0 ni3 0 7.36895567902e-05
Gb114_3 ns114 0 ni3 0 0.000245649206896
Gb115_4 ns115 0 ni4 0 -2.68399281951
Gb116_4 ns116 0 ni4 0 1.57064587542
Gb117_4 ns117 0 ni4 0 0.382436899313
Gb118_4 ns118 0 ni4 0 0.319965829211
Gb119_4 ns119 0 ni4 0 -0.393611813675
Gb120_4 ns120 0 ni4 0 0.414591878776
Gb121_4 ns121 0 ni4 0 -0.0288998953188
Gb122_4 ns122 0 ni4 0 0.437461712413
Gb123_4 ns123 0 ni4 0 -0.180810113414
Gb124_4 ns124 0 ni4 0 0.385785533009
Gb125_4 ns125 0 ni4 0 0.369549265187
Gb126_4 ns126 0 ni4 0 0.150328914964
Gb127_4 ns127 0 ni4 0 0.337732020689
Gb128_4 ns128 0 ni4 0 0.270797884127
Gb129_4 ns129 0 ni4 0 0.309492476244
Gb130_4 ns130 0 ni4 0 -0.00439828167297
Gb131_4 ns131 0 ni4 0 0.268378258407
Gb132_4 ns132 0 ni4 0 0.209525908734
Gb133_4 ns133 0 ni4 0 -0.262416526624
Gb134_4 ns134 0 ni4 0 0.148459493783
Gb135_4 ns135 0 ni4 0 -0.202854772461
Gb136_4 ns136 0 ni4 0 -0.137852810629
Gb137_4 ns137 0 ni4 0 0.151709094532
Gb138_4 ns138 0 ni4 0 -0.17470249457
Gb139_4 ns139 0 ni4 0 -0.150930199769
Gb140_4 ns140 0 ni4 0 0.17523919762
Gb141_4 ns141 0 ni4 0 -0.123939719155
Gb142_4 ns142 0 ni4 0 0.0410377293386
Gb143_4 ns143 0 ni4 0 0.101603024312
Gb144_4 ns144 0 ni4 0 -0.0153527668791
Gb145_4 ns145 0 ni4 0 -0.0166299065128
Gb146_4 ns146 0 ni4 0 0.103266563627
Gb147_4 ns147 0 ni4 0 0.0392458406069
Gb148_4 ns148 0 ni4 0 0.0394437935273
Gb149_4 ns149 0 ni4 0 0.0281679713658
Gb150_4 ns150 0 ni4 0 0.00073055352502
Gb151_4 ns151 0 ni4 0 7.36895567902e-05
Gb152_4 ns152 0 ni4 0 0.000245649206896
Gb153_5 ns153 0 ni5 0 -2.68399281951
Gb154_5 ns154 0 ni5 0 1.57064587542
Gb155_5 ns155 0 ni5 0 0.382436899313
Gb156_5 ns156 0 ni5 0 0.319965829211
Gb157_5 ns157 0 ni5 0 -0.393611813675
Gb158_5 ns158 0 ni5 0 0.414591878776
Gb159_5 ns159 0 ni5 0 -0.0288998953188
Gb160_5 ns160 0 ni5 0 0.437461712413
Gb161_5 ns161 0 ni5 0 -0.180810113414
Gb162_5 ns162 0 ni5 0 0.385785533009
Gb163_5 ns163 0 ni5 0 0.369549265187
Gb164_5 ns164 0 ni5 0 0.150328914964
Gb165_5 ns165 0 ni5 0 0.337732020689
Gb166_5 ns166 0 ni5 0 0.270797884127
Gb167_5 ns167 0 ni5 0 0.309492476244
Gb168_5 ns168 0 ni5 0 -0.00439828167297
Gb169_5 ns169 0 ni5 0 0.268378258407
Gb170_5 ns170 0 ni5 0 0.209525908734
Gb171_5 ns171 0 ni5 0 -0.262416526624
Gb172_5 ns172 0 ni5 0 0.148459493783
Gb173_5 ns173 0 ni5 0 -0.202854772461
Gb174_5 ns174 0 ni5 0 -0.137852810629
Gb175_5 ns175 0 ni5 0 0.151709094532
Gb176_5 ns176 0 ni5 0 -0.17470249457
Gb177_5 ns177 0 ni5 0 -0.150930199769
Gb178_5 ns178 0 ni5 0 0.17523919762
Gb179_5 ns179 0 ni5 0 -0.123939719155
Gb180_5 ns180 0 ni5 0 0.0410377293386
Gb181_5 ns181 0 ni5 0 0.101603024312
Gb182_5 ns182 0 ni5 0 -0.0153527668791
Gb183_5 ns183 0 ni5 0 -0.0166299065128
Gb184_5 ns184 0 ni5 0 0.103266563627
Gb185_5 ns185 0 ni5 0 0.0392458406069
Gb186_5 ns186 0 ni5 0 0.0394437935273
Gb187_5 ns187 0 ni5 0 0.0281679713658
Gb188_5 ns188 0 ni5 0 0.00073055352502
Gb189_5 ns189 0 ni5 0 7.36895567902e-05
Gb190_5 ns190 0 ni5 0 0.000245649206896
Gb191_6 ns191 0 ni6 0 -2.68399281951
Gb192_6 ns192 0 ni6 0 1.57064587542
Gb193_6 ns193 0 ni6 0 0.382436899313
Gb194_6 ns194 0 ni6 0 0.319965829211
Gb195_6 ns195 0 ni6 0 -0.393611813675
Gb196_6 ns196 0 ni6 0 0.414591878776
Gb197_6 ns197 0 ni6 0 -0.0288998953188
Gb198_6 ns198 0 ni6 0 0.437461712413
Gb199_6 ns199 0 ni6 0 -0.180810113414
Gb200_6 ns200 0 ni6 0 0.385785533009
Gb201_6 ns201 0 ni6 0 0.369549265187
Gb202_6 ns202 0 ni6 0 0.150328914964
Gb203_6 ns203 0 ni6 0 0.337732020689
Gb204_6 ns204 0 ni6 0 0.270797884127
Gb205_6 ns205 0 ni6 0 0.309492476244
Gb206_6 ns206 0 ni6 0 -0.00439828167297
Gb207_6 ns207 0 ni6 0 0.268378258407
Gb208_6 ns208 0 ni6 0 0.209525908734
Gb209_6 ns209 0 ni6 0 -0.262416526624
Gb210_6 ns210 0 ni6 0 0.148459493783
Gb211_6 ns211 0 ni6 0 -0.202854772461
Gb212_6 ns212 0 ni6 0 -0.137852810629
Gb213_6 ns213 0 ni6 0 0.151709094532
Gb214_6 ns214 0 ni6 0 -0.17470249457
Gb215_6 ns215 0 ni6 0 -0.150930199769
Gb216_6 ns216 0 ni6 0 0.17523919762
Gb217_6 ns217 0 ni6 0 -0.123939719155
Gb218_6 ns218 0 ni6 0 0.0410377293386
Gb219_6 ns219 0 ni6 0 0.101603024312
Gb220_6 ns220 0 ni6 0 -0.0153527668791
Gb221_6 ns221 0 ni6 0 -0.0166299065128
Gb222_6 ns222 0 ni6 0 0.103266563627
Gb223_6 ns223 0 ni6 0 0.0392458406069
Gb224_6 ns224 0 ni6 0 0.0394437935273
Gb225_6 ns225 0 ni6 0 0.0281679713658
Gb226_6 ns226 0 ni6 0 0.00073055352502
Gb227_6 ns227 0 ni6 0 7.36895567902e-05
Gb228_6 ns228 0 ni6 0 0.000245649206896
Gb229_7 ns229 0 ni7 0 -2.68399281951
Gb230_7 ns230 0 ni7 0 1.57064587542
Gb231_7 ns231 0 ni7 0 0.382436899313
Gb232_7 ns232 0 ni7 0 0.319965829211
Gb233_7 ns233 0 ni7 0 -0.393611813675
Gb234_7 ns234 0 ni7 0 0.414591878776
Gb235_7 ns235 0 ni7 0 -0.0288998953188
Gb236_7 ns236 0 ni7 0 0.437461712413
Gb237_7 ns237 0 ni7 0 -0.180810113414
Gb238_7 ns238 0 ni7 0 0.385785533009
Gb239_7 ns239 0 ni7 0 0.369549265187
Gb240_7 ns240 0 ni7 0 0.150328914964
Gb241_7 ns241 0 ni7 0 0.337732020689
Gb242_7 ns242 0 ni7 0 0.270797884127
Gb243_7 ns243 0 ni7 0 0.309492476244
Gb244_7 ns244 0 ni7 0 -0.00439828167297
Gb245_7 ns245 0 ni7 0 0.268378258407
Gb246_7 ns246 0 ni7 0 0.209525908734
Gb247_7 ns247 0 ni7 0 -0.262416526624
Gb248_7 ns248 0 ni7 0 0.148459493783
Gb249_7 ns249 0 ni7 0 -0.202854772461
Gb250_7 ns250 0 ni7 0 -0.137852810629
Gb251_7 ns251 0 ni7 0 0.151709094532
Gb252_7 ns252 0 ni7 0 -0.17470249457
Gb253_7 ns253 0 ni7 0 -0.150930199769
Gb254_7 ns254 0 ni7 0 0.17523919762
Gb255_7 ns255 0 ni7 0 -0.123939719155
Gb256_7 ns256 0 ni7 0 0.0410377293386
Gb257_7 ns257 0 ni7 0 0.101603024312
Gb258_7 ns258 0 ni7 0 -0.0153527668791
Gb259_7 ns259 0 ni7 0 -0.0166299065128
Gb260_7 ns260 0 ni7 0 0.103266563627
Gb261_7 ns261 0 ni7 0 0.0392458406069
Gb262_7 ns262 0 ni7 0 0.0394437935273
Gb263_7 ns263 0 ni7 0 0.0281679713658
Gb264_7 ns264 0 ni7 0 0.00073055352502
Gb265_7 ns265 0 ni7 0 7.36895567902e-05
Gb266_7 ns266 0 ni7 0 0.000245649206896
Gb267_8 ns267 0 ni8 0 -2.68399281951
Gb268_8 ns268 0 ni8 0 1.57064587542
Gb269_8 ns269 0 ni8 0 0.382436899313
Gb270_8 ns270 0 ni8 0 0.319965829211
Gb271_8 ns271 0 ni8 0 -0.393611813675
Gb272_8 ns272 0 ni8 0 0.414591878776
Gb273_8 ns273 0 ni8 0 -0.0288998953188
Gb274_8 ns274 0 ni8 0 0.437461712413
Gb275_8 ns275 0 ni8 0 -0.180810113414
Gb276_8 ns276 0 ni8 0 0.385785533009
Gb277_8 ns277 0 ni8 0 0.369549265187
Gb278_8 ns278 0 ni8 0 0.150328914964
Gb279_8 ns279 0 ni8 0 0.337732020689
Gb280_8 ns280 0 ni8 0 0.270797884127
Gb281_8 ns281 0 ni8 0 0.309492476244
Gb282_8 ns282 0 ni8 0 -0.00439828167297
Gb283_8 ns283 0 ni8 0 0.268378258407
Gb284_8 ns284 0 ni8 0 0.209525908734
Gb285_8 ns285 0 ni8 0 -0.262416526624
Gb286_8 ns286 0 ni8 0 0.148459493783
Gb287_8 ns287 0 ni8 0 -0.202854772461
Gb288_8 ns288 0 ni8 0 -0.137852810629
Gb289_8 ns289 0 ni8 0 0.151709094532
Gb290_8 ns290 0 ni8 0 -0.17470249457
Gb291_8 ns291 0 ni8 0 -0.150930199769
Gb292_8 ns292 0 ni8 0 0.17523919762
Gb293_8 ns293 0 ni8 0 -0.123939719155
Gb294_8 ns294 0 ni8 0 0.0410377293386
Gb295_8 ns295 0 ni8 0 0.101603024312
Gb296_8 ns296 0 ni8 0 -0.0153527668791
Gb297_8 ns297 0 ni8 0 -0.0166299065128
Gb298_8 ns298 0 ni8 0 0.103266563627
Gb299_8 ns299 0 ni8 0 0.0392458406069
Gb300_8 ns300 0 ni8 0 0.0394437935273
Gb301_8 ns301 0 ni8 0 0.0281679713658
Gb302_8 ns302 0 ni8 0 0.00073055352502
Gb303_8 ns303 0 ni8 0 7.36895567902e-05
Gb304_8 ns304 0 ni8 0 0.000245649206896
Gb305_9 ns305 0 ni9 0 -2.68399281951
Gb306_9 ns306 0 ni9 0 1.57064587542
Gb307_9 ns307 0 ni9 0 0.382436899313
Gb308_9 ns308 0 ni9 0 0.319965829211
Gb309_9 ns309 0 ni9 0 -0.393611813675
Gb310_9 ns310 0 ni9 0 0.414591878776
Gb311_9 ns311 0 ni9 0 -0.0288998953188
Gb312_9 ns312 0 ni9 0 0.437461712413
Gb313_9 ns313 0 ni9 0 -0.180810113414
Gb314_9 ns314 0 ni9 0 0.385785533009
Gb315_9 ns315 0 ni9 0 0.369549265187
Gb316_9 ns316 0 ni9 0 0.150328914964
Gb317_9 ns317 0 ni9 0 0.337732020689
Gb318_9 ns318 0 ni9 0 0.270797884127
Gb319_9 ns319 0 ni9 0 0.309492476244
Gb320_9 ns320 0 ni9 0 -0.00439828167297
Gb321_9 ns321 0 ni9 0 0.268378258407
Gb322_9 ns322 0 ni9 0 0.209525908734
Gb323_9 ns323 0 ni9 0 -0.262416526624
Gb324_9 ns324 0 ni9 0 0.148459493783
Gb325_9 ns325 0 ni9 0 -0.202854772461
Gb326_9 ns326 0 ni9 0 -0.137852810629
Gb327_9 ns327 0 ni9 0 0.151709094532
Gb328_9 ns328 0 ni9 0 -0.17470249457
Gb329_9 ns329 0 ni9 0 -0.150930199769
Gb330_9 ns330 0 ni9 0 0.17523919762
Gb331_9 ns331 0 ni9 0 -0.123939719155
Gb332_9 ns332 0 ni9 0 0.0410377293386
Gb333_9 ns333 0 ni9 0 0.101603024312
Gb334_9 ns334 0 ni9 0 -0.0153527668791
Gb335_9 ns335 0 ni9 0 -0.0166299065128
Gb336_9 ns336 0 ni9 0 0.103266563627
Gb337_9 ns337 0 ni9 0 0.0392458406069
Gb338_9 ns338 0 ni9 0 0.0394437935273
Gb339_9 ns339 0 ni9 0 0.0281679713658
Gb340_9 ns340 0 ni9 0 0.00073055352502
Gb341_9 ns341 0 ni9 0 7.36895567902e-05
Gb342_9 ns342 0 ni9 0 0.000245649206896
Gb343_10 ns343 0 ni10 0 -2.68399281951
Gb344_10 ns344 0 ni10 0 1.57064587542
Gb345_10 ns345 0 ni10 0 0.382436899313
Gb346_10 ns346 0 ni10 0 0.319965829211
Gb347_10 ns347 0 ni10 0 -0.393611813675
Gb348_10 ns348 0 ni10 0 0.414591878776
Gb349_10 ns349 0 ni10 0 -0.0288998953188
Gb350_10 ns350 0 ni10 0 0.437461712413
Gb351_10 ns351 0 ni10 0 -0.180810113414
Gb352_10 ns352 0 ni10 0 0.385785533009
Gb353_10 ns353 0 ni10 0 0.369549265187
Gb354_10 ns354 0 ni10 0 0.150328914964
Gb355_10 ns355 0 ni10 0 0.337732020689
Gb356_10 ns356 0 ni10 0 0.270797884127
Gb357_10 ns357 0 ni10 0 0.309492476244
Gb358_10 ns358 0 ni10 0 -0.00439828167297
Gb359_10 ns359 0 ni10 0 0.268378258407
Gb360_10 ns360 0 ni10 0 0.209525908734
Gb361_10 ns361 0 ni10 0 -0.262416526624
Gb362_10 ns362 0 ni10 0 0.148459493783
Gb363_10 ns363 0 ni10 0 -0.202854772461
Gb364_10 ns364 0 ni10 0 -0.137852810629
Gb365_10 ns365 0 ni10 0 0.151709094532
Gb366_10 ns366 0 ni10 0 -0.17470249457
Gb367_10 ns367 0 ni10 0 -0.150930199769
Gb368_10 ns368 0 ni10 0 0.17523919762
Gb369_10 ns369 0 ni10 0 -0.123939719155
Gb370_10 ns370 0 ni10 0 0.0410377293386
Gb371_10 ns371 0 ni10 0 0.101603024312
Gb372_10 ns372 0 ni10 0 -0.0153527668791
Gb373_10 ns373 0 ni10 0 -0.0166299065128
Gb374_10 ns374 0 ni10 0 0.103266563627
Gb375_10 ns375 0 ni10 0 0.0392458406069
Gb376_10 ns376 0 ni10 0 0.0394437935273
Gb377_10 ns377 0 ni10 0 0.0281679713658
Gb378_10 ns378 0 ni10 0 0.00073055352502
Gb379_10 ns379 0 ni10 0 7.36895567902e-05
Gb380_10 ns380 0 ni10 0 0.000245649206896
Gb381_11 ns381 0 ni11 0 -2.68399281951
Gb382_11 ns382 0 ni11 0 1.57064587542
Gb383_11 ns383 0 ni11 0 0.382436899313
Gb384_11 ns384 0 ni11 0 0.319965829211
Gb385_11 ns385 0 ni11 0 -0.393611813675
Gb386_11 ns386 0 ni11 0 0.414591878776
Gb387_11 ns387 0 ni11 0 -0.0288998953188
Gb388_11 ns388 0 ni11 0 0.437461712413
Gb389_11 ns389 0 ni11 0 -0.180810113414
Gb390_11 ns390 0 ni11 0 0.385785533009
Gb391_11 ns391 0 ni11 0 0.369549265187
Gb392_11 ns392 0 ni11 0 0.150328914964
Gb393_11 ns393 0 ni11 0 0.337732020689
Gb394_11 ns394 0 ni11 0 0.270797884127
Gb395_11 ns395 0 ni11 0 0.309492476244
Gb396_11 ns396 0 ni11 0 -0.00439828167297
Gb397_11 ns397 0 ni11 0 0.268378258407
Gb398_11 ns398 0 ni11 0 0.209525908734
Gb399_11 ns399 0 ni11 0 -0.262416526624
Gb400_11 ns400 0 ni11 0 0.148459493783
Gb401_11 ns401 0 ni11 0 -0.202854772461
Gb402_11 ns402 0 ni11 0 -0.137852810629
Gb403_11 ns403 0 ni11 0 0.151709094532
Gb404_11 ns404 0 ni11 0 -0.17470249457
Gb405_11 ns405 0 ni11 0 -0.150930199769
Gb406_11 ns406 0 ni11 0 0.17523919762
Gb407_11 ns407 0 ni11 0 -0.123939719155
Gb408_11 ns408 0 ni11 0 0.0410377293386
Gb409_11 ns409 0 ni11 0 0.101603024312
Gb410_11 ns410 0 ni11 0 -0.0153527668791
Gb411_11 ns411 0 ni11 0 -0.0166299065128
Gb412_11 ns412 0 ni11 0 0.103266563627
Gb413_11 ns413 0 ni11 0 0.0392458406069
Gb414_11 ns414 0 ni11 0 0.0394437935273
Gb415_11 ns415 0 ni11 0 0.0281679713658
Gb416_11 ns416 0 ni11 0 0.00073055352502
Gb417_11 ns417 0 ni11 0 7.36895567902e-05
Gb418_11 ns418 0 ni11 0 0.000245649206896
Gb419_12 ns419 0 ni12 0 -2.68399281951
Gb420_12 ns420 0 ni12 0 1.57064587542
Gb421_12 ns421 0 ni12 0 0.382436899313
Gb422_12 ns422 0 ni12 0 0.319965829211
Gb423_12 ns423 0 ni12 0 -0.393611813675
Gb424_12 ns424 0 ni12 0 0.414591878776
Gb425_12 ns425 0 ni12 0 -0.0288998953188
Gb426_12 ns426 0 ni12 0 0.437461712413
Gb427_12 ns427 0 ni12 0 -0.180810113414
Gb428_12 ns428 0 ni12 0 0.385785533009
Gb429_12 ns429 0 ni12 0 0.369549265187
Gb430_12 ns430 0 ni12 0 0.150328914964
Gb431_12 ns431 0 ni12 0 0.337732020689
Gb432_12 ns432 0 ni12 0 0.270797884127
Gb433_12 ns433 0 ni12 0 0.309492476244
Gb434_12 ns434 0 ni12 0 -0.00439828167297
Gb435_12 ns435 0 ni12 0 0.268378258407
Gb436_12 ns436 0 ni12 0 0.209525908734
Gb437_12 ns437 0 ni12 0 -0.262416526624
Gb438_12 ns438 0 ni12 0 0.148459493783
Gb439_12 ns439 0 ni12 0 -0.202854772461
Gb440_12 ns440 0 ni12 0 -0.137852810629
Gb441_12 ns441 0 ni12 0 0.151709094532
Gb442_12 ns442 0 ni12 0 -0.17470249457
Gb443_12 ns443 0 ni12 0 -0.150930199769
Gb444_12 ns444 0 ni12 0 0.17523919762
Gb445_12 ns445 0 ni12 0 -0.123939719155
Gb446_12 ns446 0 ni12 0 0.0410377293386
Gb447_12 ns447 0 ni12 0 0.101603024312
Gb448_12 ns448 0 ni12 0 -0.0153527668791
Gb449_12 ns449 0 ni12 0 -0.0166299065128
Gb450_12 ns450 0 ni12 0 0.103266563627
Gb451_12 ns451 0 ni12 0 0.0392458406069
Gb452_12 ns452 0 ni12 0 0.0394437935273
Gb453_12 ns453 0 ni12 0 0.0281679713658
Gb454_12 ns454 0 ni12 0 0.00073055352502
Gb455_12 ns455 0 ni12 0 7.36895567902e-05
Gb456_12 ns456 0 ni12 0 0.000245649206896
Gb457_13 ns457 0 ni13 0 -2.68399281951
Gb458_13 ns458 0 ni13 0 1.57064587542
Gb459_13 ns459 0 ni13 0 0.382436899313
Gb460_13 ns460 0 ni13 0 0.319965829211
Gb461_13 ns461 0 ni13 0 -0.393611813675
Gb462_13 ns462 0 ni13 0 0.414591878776
Gb463_13 ns463 0 ni13 0 -0.0288998953188
Gb464_13 ns464 0 ni13 0 0.437461712413
Gb465_13 ns465 0 ni13 0 -0.180810113414
Gb466_13 ns466 0 ni13 0 0.385785533009
Gb467_13 ns467 0 ni13 0 0.369549265187
Gb468_13 ns468 0 ni13 0 0.150328914964
Gb469_13 ns469 0 ni13 0 0.337732020689
Gb470_13 ns470 0 ni13 0 0.270797884127
Gb471_13 ns471 0 ni13 0 0.309492476244
Gb472_13 ns472 0 ni13 0 -0.00439828167297
Gb473_13 ns473 0 ni13 0 0.268378258407
Gb474_13 ns474 0 ni13 0 0.209525908734
Gb475_13 ns475 0 ni13 0 -0.262416526624
Gb476_13 ns476 0 ni13 0 0.148459493783
Gb477_13 ns477 0 ni13 0 -0.202854772461
Gb478_13 ns478 0 ni13 0 -0.137852810629
Gb479_13 ns479 0 ni13 0 0.151709094532
Gb480_13 ns480 0 ni13 0 -0.17470249457
Gb481_13 ns481 0 ni13 0 -0.150930199769
Gb482_13 ns482 0 ni13 0 0.17523919762
Gb483_13 ns483 0 ni13 0 -0.123939719155
Gb484_13 ns484 0 ni13 0 0.0410377293386
Gb485_13 ns485 0 ni13 0 0.101603024312
Gb486_13 ns486 0 ni13 0 -0.0153527668791
Gb487_13 ns487 0 ni13 0 -0.0166299065128
Gb488_13 ns488 0 ni13 0 0.103266563627
Gb489_13 ns489 0 ni13 0 0.0392458406069
Gb490_13 ns490 0 ni13 0 0.0394437935273
Gb491_13 ns491 0 ni13 0 0.0281679713658
Gb492_13 ns492 0 ni13 0 0.00073055352502
Gb493_13 ns493 0 ni13 0 7.36895567902e-05
Gb494_13 ns494 0 ni13 0 0.000245649206896
Gb495_14 ns495 0 ni14 0 -2.68399281951
Gb496_14 ns496 0 ni14 0 1.57064587542
Gb497_14 ns497 0 ni14 0 0.382436899313
Gb498_14 ns498 0 ni14 0 0.319965829211
Gb499_14 ns499 0 ni14 0 -0.393611813675
Gb500_14 ns500 0 ni14 0 0.414591878776
Gb501_14 ns501 0 ni14 0 -0.0288998953188
Gb502_14 ns502 0 ni14 0 0.437461712413
Gb503_14 ns503 0 ni14 0 -0.180810113414
Gb504_14 ns504 0 ni14 0 0.385785533009
Gb505_14 ns505 0 ni14 0 0.369549265187
Gb506_14 ns506 0 ni14 0 0.150328914964
Gb507_14 ns507 0 ni14 0 0.337732020689
Gb508_14 ns508 0 ni14 0 0.270797884127
Gb509_14 ns509 0 ni14 0 0.309492476244
Gb510_14 ns510 0 ni14 0 -0.00439828167297
Gb511_14 ns511 0 ni14 0 0.268378258407
Gb512_14 ns512 0 ni14 0 0.209525908734
Gb513_14 ns513 0 ni14 0 -0.262416526624
Gb514_14 ns514 0 ni14 0 0.148459493783
Gb515_14 ns515 0 ni14 0 -0.202854772461
Gb516_14 ns516 0 ni14 0 -0.137852810629
Gb517_14 ns517 0 ni14 0 0.151709094532
Gb518_14 ns518 0 ni14 0 -0.17470249457
Gb519_14 ns519 0 ni14 0 -0.150930199769
Gb520_14 ns520 0 ni14 0 0.17523919762
Gb521_14 ns521 0 ni14 0 -0.123939719155
Gb522_14 ns522 0 ni14 0 0.0410377293386
Gb523_14 ns523 0 ni14 0 0.101603024312
Gb524_14 ns524 0 ni14 0 -0.0153527668791
Gb525_14 ns525 0 ni14 0 -0.0166299065128
Gb526_14 ns526 0 ni14 0 0.103266563627
Gb527_14 ns527 0 ni14 0 0.0392458406069
Gb528_14 ns528 0 ni14 0 0.0394437935273
Gb529_14 ns529 0 ni14 0 0.0281679713658
Gb530_14 ns530 0 ni14 0 0.00073055352502
Gb531_14 ns531 0 ni14 0 7.36895567902e-05
Gb532_14 ns532 0 ni14 0 0.000245649206896
Gb533_15 ns533 0 ni15 0 -2.68399281951
Gb534_15 ns534 0 ni15 0 1.57064587542
Gb535_15 ns535 0 ni15 0 0.382436899313
Gb536_15 ns536 0 ni15 0 0.319965829211
Gb537_15 ns537 0 ni15 0 -0.393611813675
Gb538_15 ns538 0 ni15 0 0.414591878776
Gb539_15 ns539 0 ni15 0 -0.0288998953188
Gb540_15 ns540 0 ni15 0 0.437461712413
Gb541_15 ns541 0 ni15 0 -0.180810113414
Gb542_15 ns542 0 ni15 0 0.385785533009
Gb543_15 ns543 0 ni15 0 0.369549265187
Gb544_15 ns544 0 ni15 0 0.150328914964
Gb545_15 ns545 0 ni15 0 0.337732020689
Gb546_15 ns546 0 ni15 0 0.270797884127
Gb547_15 ns547 0 ni15 0 0.309492476244
Gb548_15 ns548 0 ni15 0 -0.00439828167297
Gb549_15 ns549 0 ni15 0 0.268378258407
Gb550_15 ns550 0 ni15 0 0.209525908734
Gb551_15 ns551 0 ni15 0 -0.262416526624
Gb552_15 ns552 0 ni15 0 0.148459493783
Gb553_15 ns553 0 ni15 0 -0.202854772461
Gb554_15 ns554 0 ni15 0 -0.137852810629
Gb555_15 ns555 0 ni15 0 0.151709094532
Gb556_15 ns556 0 ni15 0 -0.17470249457
Gb557_15 ns557 0 ni15 0 -0.150930199769
Gb558_15 ns558 0 ni15 0 0.17523919762
Gb559_15 ns559 0 ni15 0 -0.123939719155
Gb560_15 ns560 0 ni15 0 0.0410377293386
Gb561_15 ns561 0 ni15 0 0.101603024312
Gb562_15 ns562 0 ni15 0 -0.0153527668791
Gb563_15 ns563 0 ni15 0 -0.0166299065128
Gb564_15 ns564 0 ni15 0 0.103266563627
Gb565_15 ns565 0 ni15 0 0.0392458406069
Gb566_15 ns566 0 ni15 0 0.0394437935273
Gb567_15 ns567 0 ni15 0 0.0281679713658
Gb568_15 ns568 0 ni15 0 0.00073055352502
Gb569_15 ns569 0 ni15 0 7.36895567902e-05
Gb570_15 ns570 0 ni15 0 0.000245649206896
Gb571_16 ns571 0 ni16 0 -2.68399281951
Gb572_16 ns572 0 ni16 0 1.57064587542
Gb573_16 ns573 0 ni16 0 0.382436899313
Gb574_16 ns574 0 ni16 0 0.319965829211
Gb575_16 ns575 0 ni16 0 -0.393611813675
Gb576_16 ns576 0 ni16 0 0.414591878776
Gb577_16 ns577 0 ni16 0 -0.0288998953188
Gb578_16 ns578 0 ni16 0 0.437461712413
Gb579_16 ns579 0 ni16 0 -0.180810113414
Gb580_16 ns580 0 ni16 0 0.385785533009
Gb581_16 ns581 0 ni16 0 0.369549265187
Gb582_16 ns582 0 ni16 0 0.150328914964
Gb583_16 ns583 0 ni16 0 0.337732020689
Gb584_16 ns584 0 ni16 0 0.270797884127
Gb585_16 ns585 0 ni16 0 0.309492476244
Gb586_16 ns586 0 ni16 0 -0.00439828167297
Gb587_16 ns587 0 ni16 0 0.268378258407
Gb588_16 ns588 0 ni16 0 0.209525908734
Gb589_16 ns589 0 ni16 0 -0.262416526624
Gb590_16 ns590 0 ni16 0 0.148459493783
Gb591_16 ns591 0 ni16 0 -0.202854772461
Gb592_16 ns592 0 ni16 0 -0.137852810629
Gb593_16 ns593 0 ni16 0 0.151709094532
Gb594_16 ns594 0 ni16 0 -0.17470249457
Gb595_16 ns595 0 ni16 0 -0.150930199769
Gb596_16 ns596 0 ni16 0 0.17523919762
Gb597_16 ns597 0 ni16 0 -0.123939719155
Gb598_16 ns598 0 ni16 0 0.0410377293386
Gb599_16 ns599 0 ni16 0 0.101603024312
Gb600_16 ns600 0 ni16 0 -0.0153527668791
Gb601_16 ns601 0 ni16 0 -0.0166299065128
Gb602_16 ns602 0 ni16 0 0.103266563627
Gb603_16 ns603 0 ni16 0 0.0392458406069
Gb604_16 ns604 0 ni16 0 0.0394437935273
Gb605_16 ns605 0 ni16 0 0.0281679713658
Gb606_16 ns606 0 ni16 0 0.00073055352502
Gb607_16 ns607 0 ni16 0 7.36895567902e-05
Gb608_16 ns608 0 ni16 0 0.000245649206896
Gb609_17 ns609 0 ni17 0 -2.68399281951
Gb610_17 ns610 0 ni17 0 1.57064587542
Gb611_17 ns611 0 ni17 0 0.382436899313
Gb612_17 ns612 0 ni17 0 0.319965829211
Gb613_17 ns613 0 ni17 0 -0.393611813675
Gb614_17 ns614 0 ni17 0 0.414591878776
Gb615_17 ns615 0 ni17 0 -0.0288998953188
Gb616_17 ns616 0 ni17 0 0.437461712413
Gb617_17 ns617 0 ni17 0 -0.180810113414
Gb618_17 ns618 0 ni17 0 0.385785533009
Gb619_17 ns619 0 ni17 0 0.369549265187
Gb620_17 ns620 0 ni17 0 0.150328914964
Gb621_17 ns621 0 ni17 0 0.337732020689
Gb622_17 ns622 0 ni17 0 0.270797884127
Gb623_17 ns623 0 ni17 0 0.309492476244
Gb624_17 ns624 0 ni17 0 -0.00439828167297
Gb625_17 ns625 0 ni17 0 0.268378258407
Gb626_17 ns626 0 ni17 0 0.209525908734
Gb627_17 ns627 0 ni17 0 -0.262416526624
Gb628_17 ns628 0 ni17 0 0.148459493783
Gb629_17 ns629 0 ni17 0 -0.202854772461
Gb630_17 ns630 0 ni17 0 -0.137852810629
Gb631_17 ns631 0 ni17 0 0.151709094532
Gb632_17 ns632 0 ni17 0 -0.17470249457
Gb633_17 ns633 0 ni17 0 -0.150930199769
Gb634_17 ns634 0 ni17 0 0.17523919762
Gb635_17 ns635 0 ni17 0 -0.123939719155
Gb636_17 ns636 0 ni17 0 0.0410377293386
Gb637_17 ns637 0 ni17 0 0.101603024312
Gb638_17 ns638 0 ni17 0 -0.0153527668791
Gb639_17 ns639 0 ni17 0 -0.0166299065128
Gb640_17 ns640 0 ni17 0 0.103266563627
Gb641_17 ns641 0 ni17 0 0.0392458406069
Gb642_17 ns642 0 ni17 0 0.0394437935273
Gb643_17 ns643 0 ni17 0 0.0281679713658
Gb644_17 ns644 0 ni17 0 0.00073055352502
Gb645_17 ns645 0 ni17 0 7.36895567902e-05
Gb646_17 ns646 0 ni17 0 0.000245649206896
Gb647_18 ns647 0 ni18 0 -2.68399281951
Gb648_18 ns648 0 ni18 0 1.57064587542
Gb649_18 ns649 0 ni18 0 0.382436899313
Gb650_18 ns650 0 ni18 0 0.319965829211
Gb651_18 ns651 0 ni18 0 -0.393611813675
Gb652_18 ns652 0 ni18 0 0.414591878776
Gb653_18 ns653 0 ni18 0 -0.0288998953188
Gb654_18 ns654 0 ni18 0 0.437461712413
Gb655_18 ns655 0 ni18 0 -0.180810113414
Gb656_18 ns656 0 ni18 0 0.385785533009
Gb657_18 ns657 0 ni18 0 0.369549265187
Gb658_18 ns658 0 ni18 0 0.150328914964
Gb659_18 ns659 0 ni18 0 0.337732020689
Gb660_18 ns660 0 ni18 0 0.270797884127
Gb661_18 ns661 0 ni18 0 0.309492476244
Gb662_18 ns662 0 ni18 0 -0.00439828167297
Gb663_18 ns663 0 ni18 0 0.268378258407
Gb664_18 ns664 0 ni18 0 0.209525908734
Gb665_18 ns665 0 ni18 0 -0.262416526624
Gb666_18 ns666 0 ni18 0 0.148459493783
Gb667_18 ns667 0 ni18 0 -0.202854772461
Gb668_18 ns668 0 ni18 0 -0.137852810629
Gb669_18 ns669 0 ni18 0 0.151709094532
Gb670_18 ns670 0 ni18 0 -0.17470249457
Gb671_18 ns671 0 ni18 0 -0.150930199769
Gb672_18 ns672 0 ni18 0 0.17523919762
Gb673_18 ns673 0 ni18 0 -0.123939719155
Gb674_18 ns674 0 ni18 0 0.0410377293386
Gb675_18 ns675 0 ni18 0 0.101603024312
Gb676_18 ns676 0 ni18 0 -0.0153527668791
Gb677_18 ns677 0 ni18 0 -0.0166299065128
Gb678_18 ns678 0 ni18 0 0.103266563627
Gb679_18 ns679 0 ni18 0 0.0392458406069
Gb680_18 ns680 0 ni18 0 0.0394437935273
Gb681_18 ns681 0 ni18 0 0.0281679713658
Gb682_18 ns682 0 ni18 0 0.00073055352502
Gb683_18 ns683 0 ni18 0 7.36895567902e-05
Gb684_18 ns684 0 ni18 0 0.000245649206896
Gb685_19 ns685 0 ni19 0 -2.68399281951
Gb686_19 ns686 0 ni19 0 1.57064587542
Gb687_19 ns687 0 ni19 0 0.382436899313
Gb688_19 ns688 0 ni19 0 0.319965829211
Gb689_19 ns689 0 ni19 0 -0.393611813675
Gb690_19 ns690 0 ni19 0 0.414591878776
Gb691_19 ns691 0 ni19 0 -0.0288998953188
Gb692_19 ns692 0 ni19 0 0.437461712413
Gb693_19 ns693 0 ni19 0 -0.180810113414
Gb694_19 ns694 0 ni19 0 0.385785533009
Gb695_19 ns695 0 ni19 0 0.369549265187
Gb696_19 ns696 0 ni19 0 0.150328914964
Gb697_19 ns697 0 ni19 0 0.337732020689
Gb698_19 ns698 0 ni19 0 0.270797884127
Gb699_19 ns699 0 ni19 0 0.309492476244
Gb700_19 ns700 0 ni19 0 -0.00439828167297
Gb701_19 ns701 0 ni19 0 0.268378258407
Gb702_19 ns702 0 ni19 0 0.209525908734
Gb703_19 ns703 0 ni19 0 -0.262416526624
Gb704_19 ns704 0 ni19 0 0.148459493783
Gb705_19 ns705 0 ni19 0 -0.202854772461
Gb706_19 ns706 0 ni19 0 -0.137852810629
Gb707_19 ns707 0 ni19 0 0.151709094532
Gb708_19 ns708 0 ni19 0 -0.17470249457
Gb709_19 ns709 0 ni19 0 -0.150930199769
Gb710_19 ns710 0 ni19 0 0.17523919762
Gb711_19 ns711 0 ni19 0 -0.123939719155
Gb712_19 ns712 0 ni19 0 0.0410377293386
Gb713_19 ns713 0 ni19 0 0.101603024312
Gb714_19 ns714 0 ni19 0 -0.0153527668791
Gb715_19 ns715 0 ni19 0 -0.0166299065128
Gb716_19 ns716 0 ni19 0 0.103266563627
Gb717_19 ns717 0 ni19 0 0.0392458406069
Gb718_19 ns718 0 ni19 0 0.0394437935273
Gb719_19 ns719 0 ni19 0 0.0281679713658
Gb720_19 ns720 0 ni19 0 0.00073055352502
Gb721_19 ns721 0 ni19 0 7.36895567902e-05
Gb722_19 ns722 0 ni19 0 0.000245649206896
Gb723_20 ns723 0 ni20 0 -2.68399281951
Gb724_20 ns724 0 ni20 0 1.57064587542
Gb725_20 ns725 0 ni20 0 0.382436899313
Gb726_20 ns726 0 ni20 0 0.319965829211
Gb727_20 ns727 0 ni20 0 -0.393611813675
Gb728_20 ns728 0 ni20 0 0.414591878776
Gb729_20 ns729 0 ni20 0 -0.0288998953188
Gb730_20 ns730 0 ni20 0 0.437461712413
Gb731_20 ns731 0 ni20 0 -0.180810113414
Gb732_20 ns732 0 ni20 0 0.385785533009
Gb733_20 ns733 0 ni20 0 0.369549265187
Gb734_20 ns734 0 ni20 0 0.150328914964
Gb735_20 ns735 0 ni20 0 0.337732020689
Gb736_20 ns736 0 ni20 0 0.270797884127
Gb737_20 ns737 0 ni20 0 0.309492476244
Gb738_20 ns738 0 ni20 0 -0.00439828167297
Gb739_20 ns739 0 ni20 0 0.268378258407
Gb740_20 ns740 0 ni20 0 0.209525908734
Gb741_20 ns741 0 ni20 0 -0.262416526624
Gb742_20 ns742 0 ni20 0 0.148459493783
Gb743_20 ns743 0 ni20 0 -0.202854772461
Gb744_20 ns744 0 ni20 0 -0.137852810629
Gb745_20 ns745 0 ni20 0 0.151709094532
Gb746_20 ns746 0 ni20 0 -0.17470249457
Gb747_20 ns747 0 ni20 0 -0.150930199769
Gb748_20 ns748 0 ni20 0 0.17523919762
Gb749_20 ns749 0 ni20 0 -0.123939719155
Gb750_20 ns750 0 ni20 0 0.0410377293386
Gb751_20 ns751 0 ni20 0 0.101603024312
Gb752_20 ns752 0 ni20 0 -0.0153527668791
Gb753_20 ns753 0 ni20 0 -0.0166299065128
Gb754_20 ns754 0 ni20 0 0.103266563627
Gb755_20 ns755 0 ni20 0 0.0392458406069
Gb756_20 ns756 0 ni20 0 0.0394437935273
Gb757_20 ns757 0 ni20 0 0.0281679713658
Gb758_20 ns758 0 ni20 0 0.00073055352502
Gb759_20 ns759 0 ni20 0 7.36895567902e-05
Gb760_20 ns760 0 ni20 0 0.000245649206896
Gb761_21 ns761 0 ni21 0 -2.68399281951
Gb762_21 ns762 0 ni21 0 1.57064587542
Gb763_21 ns763 0 ni21 0 0.382436899313
Gb764_21 ns764 0 ni21 0 0.319965829211
Gb765_21 ns765 0 ni21 0 -0.393611813675
Gb766_21 ns766 0 ni21 0 0.414591878776
Gb767_21 ns767 0 ni21 0 -0.0288998953188
Gb768_21 ns768 0 ni21 0 0.437461712413
Gb769_21 ns769 0 ni21 0 -0.180810113414
Gb770_21 ns770 0 ni21 0 0.385785533009
Gb771_21 ns771 0 ni21 0 0.369549265187
Gb772_21 ns772 0 ni21 0 0.150328914964
Gb773_21 ns773 0 ni21 0 0.337732020689
Gb774_21 ns774 0 ni21 0 0.270797884127
Gb775_21 ns775 0 ni21 0 0.309492476244
Gb776_21 ns776 0 ni21 0 -0.00439828167297
Gb777_21 ns777 0 ni21 0 0.268378258407
Gb778_21 ns778 0 ni21 0 0.209525908734
Gb779_21 ns779 0 ni21 0 -0.262416526624
Gb780_21 ns780 0 ni21 0 0.148459493783
Gb781_21 ns781 0 ni21 0 -0.202854772461
Gb782_21 ns782 0 ni21 0 -0.137852810629
Gb783_21 ns783 0 ni21 0 0.151709094532
Gb784_21 ns784 0 ni21 0 -0.17470249457
Gb785_21 ns785 0 ni21 0 -0.150930199769
Gb786_21 ns786 0 ni21 0 0.17523919762
Gb787_21 ns787 0 ni21 0 -0.123939719155
Gb788_21 ns788 0 ni21 0 0.0410377293386
Gb789_21 ns789 0 ni21 0 0.101603024312
Gb790_21 ns790 0 ni21 0 -0.0153527668791
Gb791_21 ns791 0 ni21 0 -0.0166299065128
Gb792_21 ns792 0 ni21 0 0.103266563627
Gb793_21 ns793 0 ni21 0 0.0392458406069
Gb794_21 ns794 0 ni21 0 0.0394437935273
Gb795_21 ns795 0 ni21 0 0.0281679713658
Gb796_21 ns796 0 ni21 0 0.00073055352502
Gb797_21 ns797 0 ni21 0 7.36895567902e-05
Gb798_21 ns798 0 ni21 0 0.000245649206896
Gb799_22 ns799 0 ni22 0 -2.68399281951
Gb800_22 ns800 0 ni22 0 1.57064587542
Gb801_22 ns801 0 ni22 0 0.382436899313
Gb802_22 ns802 0 ni22 0 0.319965829211
Gb803_22 ns803 0 ni22 0 -0.393611813675
Gb804_22 ns804 0 ni22 0 0.414591878776
Gb805_22 ns805 0 ni22 0 -0.0288998953188
Gb806_22 ns806 0 ni22 0 0.437461712413
Gb807_22 ns807 0 ni22 0 -0.180810113414
Gb808_22 ns808 0 ni22 0 0.385785533009
Gb809_22 ns809 0 ni22 0 0.369549265187
Gb810_22 ns810 0 ni22 0 0.150328914964
Gb811_22 ns811 0 ni22 0 0.337732020689
Gb812_22 ns812 0 ni22 0 0.270797884127
Gb813_22 ns813 0 ni22 0 0.309492476244
Gb814_22 ns814 0 ni22 0 -0.00439828167297
Gb815_22 ns815 0 ni22 0 0.268378258407
Gb816_22 ns816 0 ni22 0 0.209525908734
Gb817_22 ns817 0 ni22 0 -0.262416526624
Gb818_22 ns818 0 ni22 0 0.148459493783
Gb819_22 ns819 0 ni22 0 -0.202854772461
Gb820_22 ns820 0 ni22 0 -0.137852810629
Gb821_22 ns821 0 ni22 0 0.151709094532
Gb822_22 ns822 0 ni22 0 -0.17470249457
Gb823_22 ns823 0 ni22 0 -0.150930199769
Gb824_22 ns824 0 ni22 0 0.17523919762
Gb825_22 ns825 0 ni22 0 -0.123939719155
Gb826_22 ns826 0 ni22 0 0.0410377293386
Gb827_22 ns827 0 ni22 0 0.101603024312
Gb828_22 ns828 0 ni22 0 -0.0153527668791
Gb829_22 ns829 0 ni22 0 -0.0166299065128
Gb830_22 ns830 0 ni22 0 0.103266563627
Gb831_22 ns831 0 ni22 0 0.0392458406069
Gb832_22 ns832 0 ni22 0 0.0394437935273
Gb833_22 ns833 0 ni22 0 0.0281679713658
Gb834_22 ns834 0 ni22 0 0.00073055352502
Gb835_22 ns835 0 ni22 0 7.36895567902e-05
Gb836_22 ns836 0 ni22 0 0.000245649206896
Gb837_23 ns837 0 ni23 0 -2.68399281951
Gb838_23 ns838 0 ni23 0 1.57064587542
Gb839_23 ns839 0 ni23 0 0.382436899313
Gb840_23 ns840 0 ni23 0 0.319965829211
Gb841_23 ns841 0 ni23 0 -0.393611813675
Gb842_23 ns842 0 ni23 0 0.414591878776
Gb843_23 ns843 0 ni23 0 -0.0288998953188
Gb844_23 ns844 0 ni23 0 0.437461712413
Gb845_23 ns845 0 ni23 0 -0.180810113414
Gb846_23 ns846 0 ni23 0 0.385785533009
Gb847_23 ns847 0 ni23 0 0.369549265187
Gb848_23 ns848 0 ni23 0 0.150328914964
Gb849_23 ns849 0 ni23 0 0.337732020689
Gb850_23 ns850 0 ni23 0 0.270797884127
Gb851_23 ns851 0 ni23 0 0.309492476244
Gb852_23 ns852 0 ni23 0 -0.00439828167297
Gb853_23 ns853 0 ni23 0 0.268378258407
Gb854_23 ns854 0 ni23 0 0.209525908734
Gb855_23 ns855 0 ni23 0 -0.262416526624
Gb856_23 ns856 0 ni23 0 0.148459493783
Gb857_23 ns857 0 ni23 0 -0.202854772461
Gb858_23 ns858 0 ni23 0 -0.137852810629
Gb859_23 ns859 0 ni23 0 0.151709094532
Gb860_23 ns860 0 ni23 0 -0.17470249457
Gb861_23 ns861 0 ni23 0 -0.150930199769
Gb862_23 ns862 0 ni23 0 0.17523919762
Gb863_23 ns863 0 ni23 0 -0.123939719155
Gb864_23 ns864 0 ni23 0 0.0410377293386
Gb865_23 ns865 0 ni23 0 0.101603024312
Gb866_23 ns866 0 ni23 0 -0.0153527668791
Gb867_23 ns867 0 ni23 0 -0.0166299065128
Gb868_23 ns868 0 ni23 0 0.103266563627
Gb869_23 ns869 0 ni23 0 0.0392458406069
Gb870_23 ns870 0 ni23 0 0.0394437935273
Gb871_23 ns871 0 ni23 0 0.0281679713658
Gb872_23 ns872 0 ni23 0 0.00073055352502
Gb873_23 ns873 0 ni23 0 7.36895567902e-05
Gb874_23 ns874 0 ni23 0 0.000245649206896
Gb875_24 ns875 0 ni24 0 -2.68399281951
Gb876_24 ns876 0 ni24 0 1.57064587542
Gb877_24 ns877 0 ni24 0 0.382436899313
Gb878_24 ns878 0 ni24 0 0.319965829211
Gb879_24 ns879 0 ni24 0 -0.393611813675
Gb880_24 ns880 0 ni24 0 0.414591878776
Gb881_24 ns881 0 ni24 0 -0.0288998953188
Gb882_24 ns882 0 ni24 0 0.437461712413
Gb883_24 ns883 0 ni24 0 -0.180810113414
Gb884_24 ns884 0 ni24 0 0.385785533009
Gb885_24 ns885 0 ni24 0 0.369549265187
Gb886_24 ns886 0 ni24 0 0.150328914964
Gb887_24 ns887 0 ni24 0 0.337732020689
Gb888_24 ns888 0 ni24 0 0.270797884127
Gb889_24 ns889 0 ni24 0 0.309492476244
Gb890_24 ns890 0 ni24 0 -0.00439828167297
Gb891_24 ns891 0 ni24 0 0.268378258407
Gb892_24 ns892 0 ni24 0 0.209525908734
Gb893_24 ns893 0 ni24 0 -0.262416526624
Gb894_24 ns894 0 ni24 0 0.148459493783
Gb895_24 ns895 0 ni24 0 -0.202854772461
Gb896_24 ns896 0 ni24 0 -0.137852810629
Gb897_24 ns897 0 ni24 0 0.151709094532
Gb898_24 ns898 0 ni24 0 -0.17470249457
Gb899_24 ns899 0 ni24 0 -0.150930199769
Gb900_24 ns900 0 ni24 0 0.17523919762
Gb901_24 ns901 0 ni24 0 -0.123939719155
Gb902_24 ns902 0 ni24 0 0.0410377293386
Gb903_24 ns903 0 ni24 0 0.101603024312
Gb904_24 ns904 0 ni24 0 -0.0153527668791
Gb905_24 ns905 0 ni24 0 -0.0166299065128
Gb906_24 ns906 0 ni24 0 0.103266563627
Gb907_24 ns907 0 ni24 0 0.0392458406069
Gb908_24 ns908 0 ni24 0 0.0394437935273
Gb909_24 ns909 0 ni24 0 0.0281679713658
Gb910_24 ns910 0 ni24 0 0.00073055352502
Gb911_24 ns911 0 ni24 0 7.36895567902e-05
Gb912_24 ns912 0 ni24 0 0.000245649206896
Gb913_25 ns913 0 ni25 0 -2.68399281951
Gb914_25 ns914 0 ni25 0 1.57064587542
Gb915_25 ns915 0 ni25 0 0.382436899313
Gb916_25 ns916 0 ni25 0 0.319965829211
Gb917_25 ns917 0 ni25 0 -0.393611813675
Gb918_25 ns918 0 ni25 0 0.414591878776
Gb919_25 ns919 0 ni25 0 -0.0288998953188
Gb920_25 ns920 0 ni25 0 0.437461712413
Gb921_25 ns921 0 ni25 0 -0.180810113414
Gb922_25 ns922 0 ni25 0 0.385785533009
Gb923_25 ns923 0 ni25 0 0.369549265187
Gb924_25 ns924 0 ni25 0 0.150328914964
Gb925_25 ns925 0 ni25 0 0.337732020689
Gb926_25 ns926 0 ni25 0 0.270797884127
Gb927_25 ns927 0 ni25 0 0.309492476244
Gb928_25 ns928 0 ni25 0 -0.00439828167297
Gb929_25 ns929 0 ni25 0 0.268378258407
Gb930_25 ns930 0 ni25 0 0.209525908734
Gb931_25 ns931 0 ni25 0 -0.262416526624
Gb932_25 ns932 0 ni25 0 0.148459493783
Gb933_25 ns933 0 ni25 0 -0.202854772461
Gb934_25 ns934 0 ni25 0 -0.137852810629
Gb935_25 ns935 0 ni25 0 0.151709094532
Gb936_25 ns936 0 ni25 0 -0.17470249457
Gb937_25 ns937 0 ni25 0 -0.150930199769
Gb938_25 ns938 0 ni25 0 0.17523919762
Gb939_25 ns939 0 ni25 0 -0.123939719155
Gb940_25 ns940 0 ni25 0 0.0410377293386
Gb941_25 ns941 0 ni25 0 0.101603024312
Gb942_25 ns942 0 ni25 0 -0.0153527668791
Gb943_25 ns943 0 ni25 0 -0.0166299065128
Gb944_25 ns944 0 ni25 0 0.103266563627
Gb945_25 ns945 0 ni25 0 0.0392458406069
Gb946_25 ns946 0 ni25 0 0.0394437935273
Gb947_25 ns947 0 ni25 0 0.0281679713658
Gb948_25 ns948 0 ni25 0 0.00073055352502
Gb949_25 ns949 0 ni25 0 7.36895567902e-05
Gb950_25 ns950 0 ni25 0 0.000245649206896
Gb951_26 ns951 0 ni26 0 -2.68399281951
Gb952_26 ns952 0 ni26 0 1.57064587542
Gb953_26 ns953 0 ni26 0 0.382436899313
Gb954_26 ns954 0 ni26 0 0.319965829211
Gb955_26 ns955 0 ni26 0 -0.393611813675
Gb956_26 ns956 0 ni26 0 0.414591878776
Gb957_26 ns957 0 ni26 0 -0.0288998953188
Gb958_26 ns958 0 ni26 0 0.437461712413
Gb959_26 ns959 0 ni26 0 -0.180810113414
Gb960_26 ns960 0 ni26 0 0.385785533009
Gb961_26 ns961 0 ni26 0 0.369549265187
Gb962_26 ns962 0 ni26 0 0.150328914964
Gb963_26 ns963 0 ni26 0 0.337732020689
Gb964_26 ns964 0 ni26 0 0.270797884127
Gb965_26 ns965 0 ni26 0 0.309492476244
Gb966_26 ns966 0 ni26 0 -0.00439828167297
Gb967_26 ns967 0 ni26 0 0.268378258407
Gb968_26 ns968 0 ni26 0 0.209525908734
Gb969_26 ns969 0 ni26 0 -0.262416526624
Gb970_26 ns970 0 ni26 0 0.148459493783
Gb971_26 ns971 0 ni26 0 -0.202854772461
Gb972_26 ns972 0 ni26 0 -0.137852810629
Gb973_26 ns973 0 ni26 0 0.151709094532
Gb974_26 ns974 0 ni26 0 -0.17470249457
Gb975_26 ns975 0 ni26 0 -0.150930199769
Gb976_26 ns976 0 ni26 0 0.17523919762
Gb977_26 ns977 0 ni26 0 -0.123939719155
Gb978_26 ns978 0 ni26 0 0.0410377293386
Gb979_26 ns979 0 ni26 0 0.101603024312
Gb980_26 ns980 0 ni26 0 -0.0153527668791
Gb981_26 ns981 0 ni26 0 -0.0166299065128
Gb982_26 ns982 0 ni26 0 0.103266563627
Gb983_26 ns983 0 ni26 0 0.0392458406069
Gb984_26 ns984 0 ni26 0 0.0394437935273
Gb985_26 ns985 0 ni26 0 0.0281679713658
Gb986_26 ns986 0 ni26 0 0.00073055352502
Gb987_26 ns987 0 ni26 0 7.36895567902e-05
Gb988_26 ns988 0 ni26 0 0.000245649206896
Gb989_27 ns989 0 ni27 0 -2.68399281951
Gb990_27 ns990 0 ni27 0 1.57064587542
Gb991_27 ns991 0 ni27 0 0.382436899313
Gb992_27 ns992 0 ni27 0 0.319965829211
Gb993_27 ns993 0 ni27 0 -0.393611813675
Gb994_27 ns994 0 ni27 0 0.414591878776
Gb995_27 ns995 0 ni27 0 -0.0288998953188
Gb996_27 ns996 0 ni27 0 0.437461712413
Gb997_27 ns997 0 ni27 0 -0.180810113414
Gb998_27 ns998 0 ni27 0 0.385785533009
Gb999_27 ns999 0 ni27 0 0.369549265187
Gb1000_27 ns1000 0 ni27 0 0.150328914964
Gb1001_27 ns1001 0 ni27 0 0.337732020689
Gb1002_27 ns1002 0 ni27 0 0.270797884127
Gb1003_27 ns1003 0 ni27 0 0.309492476244
Gb1004_27 ns1004 0 ni27 0 -0.00439828167297
Gb1005_27 ns1005 0 ni27 0 0.268378258407
Gb1006_27 ns1006 0 ni27 0 0.209525908734
Gb1007_27 ns1007 0 ni27 0 -0.262416526624
Gb1008_27 ns1008 0 ni27 0 0.148459493783
Gb1009_27 ns1009 0 ni27 0 -0.202854772461
Gb1010_27 ns1010 0 ni27 0 -0.137852810629
Gb1011_27 ns1011 0 ni27 0 0.151709094532
Gb1012_27 ns1012 0 ni27 0 -0.17470249457
Gb1013_27 ns1013 0 ni27 0 -0.150930199769
Gb1014_27 ns1014 0 ni27 0 0.17523919762
Gb1015_27 ns1015 0 ni27 0 -0.123939719155
Gb1016_27 ns1016 0 ni27 0 0.0410377293386
Gb1017_27 ns1017 0 ni27 0 0.101603024312
Gb1018_27 ns1018 0 ni27 0 -0.0153527668791
Gb1019_27 ns1019 0 ni27 0 -0.0166299065128
Gb1020_27 ns1020 0 ni27 0 0.103266563627
Gb1021_27 ns1021 0 ni27 0 0.0392458406069
Gb1022_27 ns1022 0 ni27 0 0.0394437935273
Gb1023_27 ns1023 0 ni27 0 0.0281679713658
Gb1024_27 ns1024 0 ni27 0 0.00073055352502
Gb1025_27 ns1025 0 ni27 0 7.36895567902e-05
Gb1026_27 ns1026 0 ni27 0 0.000245649206896
Gb1027_28 ns1027 0 ni28 0 -2.68399281951
Gb1028_28 ns1028 0 ni28 0 1.57064587542
Gb1029_28 ns1029 0 ni28 0 0.382436899313
Gb1030_28 ns1030 0 ni28 0 0.319965829211
Gb1031_28 ns1031 0 ni28 0 -0.393611813675
Gb1032_28 ns1032 0 ni28 0 0.414591878776
Gb1033_28 ns1033 0 ni28 0 -0.0288998953188
Gb1034_28 ns1034 0 ni28 0 0.437461712413
Gb1035_28 ns1035 0 ni28 0 -0.180810113414
Gb1036_28 ns1036 0 ni28 0 0.385785533009
Gb1037_28 ns1037 0 ni28 0 0.369549265187
Gb1038_28 ns1038 0 ni28 0 0.150328914964
Gb1039_28 ns1039 0 ni28 0 0.337732020689
Gb1040_28 ns1040 0 ni28 0 0.270797884127
Gb1041_28 ns1041 0 ni28 0 0.309492476244
Gb1042_28 ns1042 0 ni28 0 -0.00439828167297
Gb1043_28 ns1043 0 ni28 0 0.268378258407
Gb1044_28 ns1044 0 ni28 0 0.209525908734
Gb1045_28 ns1045 0 ni28 0 -0.262416526624
Gb1046_28 ns1046 0 ni28 0 0.148459493783
Gb1047_28 ns1047 0 ni28 0 -0.202854772461
Gb1048_28 ns1048 0 ni28 0 -0.137852810629
Gb1049_28 ns1049 0 ni28 0 0.151709094532
Gb1050_28 ns1050 0 ni28 0 -0.17470249457
Gb1051_28 ns1051 0 ni28 0 -0.150930199769
Gb1052_28 ns1052 0 ni28 0 0.17523919762
Gb1053_28 ns1053 0 ni28 0 -0.123939719155
Gb1054_28 ns1054 0 ni28 0 0.0410377293386
Gb1055_28 ns1055 0 ni28 0 0.101603024312
Gb1056_28 ns1056 0 ni28 0 -0.0153527668791
Gb1057_28 ns1057 0 ni28 0 -0.0166299065128
Gb1058_28 ns1058 0 ni28 0 0.103266563627
Gb1059_28 ns1059 0 ni28 0 0.0392458406069
Gb1060_28 ns1060 0 ni28 0 0.0394437935273
Gb1061_28 ns1061 0 ni28 0 0.0281679713658
Gb1062_28 ns1062 0 ni28 0 0.00073055352502
Gb1063_28 ns1063 0 ni28 0 7.36895567902e-05
Gb1064_28 ns1064 0 ni28 0 0.000245649206896
Gb1065_29 ns1065 0 ni29 0 -2.68399281951
Gb1066_29 ns1066 0 ni29 0 1.57064587542
Gb1067_29 ns1067 0 ni29 0 0.382436899313
Gb1068_29 ns1068 0 ni29 0 0.319965829211
Gb1069_29 ns1069 0 ni29 0 -0.393611813675
Gb1070_29 ns1070 0 ni29 0 0.414591878776
Gb1071_29 ns1071 0 ni29 0 -0.0288998953188
Gb1072_29 ns1072 0 ni29 0 0.437461712413
Gb1073_29 ns1073 0 ni29 0 -0.180810113414
Gb1074_29 ns1074 0 ni29 0 0.385785533009
Gb1075_29 ns1075 0 ni29 0 0.369549265187
Gb1076_29 ns1076 0 ni29 0 0.150328914964
Gb1077_29 ns1077 0 ni29 0 0.337732020689
Gb1078_29 ns1078 0 ni29 0 0.270797884127
Gb1079_29 ns1079 0 ni29 0 0.309492476244
Gb1080_29 ns1080 0 ni29 0 -0.00439828167297
Gb1081_29 ns1081 0 ni29 0 0.268378258407
Gb1082_29 ns1082 0 ni29 0 0.209525908734
Gb1083_29 ns1083 0 ni29 0 -0.262416526624
Gb1084_29 ns1084 0 ni29 0 0.148459493783
Gb1085_29 ns1085 0 ni29 0 -0.202854772461
Gb1086_29 ns1086 0 ni29 0 -0.137852810629
Gb1087_29 ns1087 0 ni29 0 0.151709094532
Gb1088_29 ns1088 0 ni29 0 -0.17470249457
Gb1089_29 ns1089 0 ni29 0 -0.150930199769
Gb1090_29 ns1090 0 ni29 0 0.17523919762
Gb1091_29 ns1091 0 ni29 0 -0.123939719155
Gb1092_29 ns1092 0 ni29 0 0.0410377293386
Gb1093_29 ns1093 0 ni29 0 0.101603024312
Gb1094_29 ns1094 0 ni29 0 -0.0153527668791
Gb1095_29 ns1095 0 ni29 0 -0.0166299065128
Gb1096_29 ns1096 0 ni29 0 0.103266563627
Gb1097_29 ns1097 0 ni29 0 0.0392458406069
Gb1098_29 ns1098 0 ni29 0 0.0394437935273
Gb1099_29 ns1099 0 ni29 0 0.0281679713658
Gb1100_29 ns1100 0 ni29 0 0.00073055352502
Gb1101_29 ns1101 0 ni29 0 7.36895567902e-05
Gb1102_29 ns1102 0 ni29 0 0.000245649206896
Gb1103_30 ns1103 0 ni30 0 -2.68399281951
Gb1104_30 ns1104 0 ni30 0 1.57064587542
Gb1105_30 ns1105 0 ni30 0 0.382436899313
Gb1106_30 ns1106 0 ni30 0 0.319965829211
Gb1107_30 ns1107 0 ni30 0 -0.393611813675
Gb1108_30 ns1108 0 ni30 0 0.414591878776
Gb1109_30 ns1109 0 ni30 0 -0.0288998953188
Gb1110_30 ns1110 0 ni30 0 0.437461712413
Gb1111_30 ns1111 0 ni30 0 -0.180810113414
Gb1112_30 ns1112 0 ni30 0 0.385785533009
Gb1113_30 ns1113 0 ni30 0 0.369549265187
Gb1114_30 ns1114 0 ni30 0 0.150328914964
Gb1115_30 ns1115 0 ni30 0 0.337732020689
Gb1116_30 ns1116 0 ni30 0 0.270797884127
Gb1117_30 ns1117 0 ni30 0 0.309492476244
Gb1118_30 ns1118 0 ni30 0 -0.00439828167297
Gb1119_30 ns1119 0 ni30 0 0.268378258407
Gb1120_30 ns1120 0 ni30 0 0.209525908734
Gb1121_30 ns1121 0 ni30 0 -0.262416526624
Gb1122_30 ns1122 0 ni30 0 0.148459493783
Gb1123_30 ns1123 0 ni30 0 -0.202854772461
Gb1124_30 ns1124 0 ni30 0 -0.137852810629
Gb1125_30 ns1125 0 ni30 0 0.151709094532
Gb1126_30 ns1126 0 ni30 0 -0.17470249457
Gb1127_30 ns1127 0 ni30 0 -0.150930199769
Gb1128_30 ns1128 0 ni30 0 0.17523919762
Gb1129_30 ns1129 0 ni30 0 -0.123939719155
Gb1130_30 ns1130 0 ni30 0 0.0410377293386
Gb1131_30 ns1131 0 ni30 0 0.101603024312
Gb1132_30 ns1132 0 ni30 0 -0.0153527668791
Gb1133_30 ns1133 0 ni30 0 -0.0166299065128
Gb1134_30 ns1134 0 ni30 0 0.103266563627
Gb1135_30 ns1135 0 ni30 0 0.0392458406069
Gb1136_30 ns1136 0 ni30 0 0.0394437935273
Gb1137_30 ns1137 0 ni30 0 0.0281679713658
Gb1138_30 ns1138 0 ni30 0 0.00073055352502
Gb1139_30 ns1139 0 ni30 0 7.36895567902e-05
Gb1140_30 ns1140 0 ni30 0 0.000245649206896
Gb1141_31 ns1141 0 ni31 0 -2.68399281951
Gb1142_31 ns1142 0 ni31 0 1.57064587542
Gb1143_31 ns1143 0 ni31 0 0.382436899313
Gb1144_31 ns1144 0 ni31 0 0.319965829211
Gb1145_31 ns1145 0 ni31 0 -0.393611813675
Gb1146_31 ns1146 0 ni31 0 0.414591878776
Gb1147_31 ns1147 0 ni31 0 -0.0288998953188
Gb1148_31 ns1148 0 ni31 0 0.437461712413
Gb1149_31 ns1149 0 ni31 0 -0.180810113414
Gb1150_31 ns1150 0 ni31 0 0.385785533009
Gb1151_31 ns1151 0 ni31 0 0.369549265187
Gb1152_31 ns1152 0 ni31 0 0.150328914964
Gb1153_31 ns1153 0 ni31 0 0.337732020689
Gb1154_31 ns1154 0 ni31 0 0.270797884127
Gb1155_31 ns1155 0 ni31 0 0.309492476244
Gb1156_31 ns1156 0 ni31 0 -0.00439828167297
Gb1157_31 ns1157 0 ni31 0 0.268378258407
Gb1158_31 ns1158 0 ni31 0 0.209525908734
Gb1159_31 ns1159 0 ni31 0 -0.262416526624
Gb1160_31 ns1160 0 ni31 0 0.148459493783
Gb1161_31 ns1161 0 ni31 0 -0.202854772461
Gb1162_31 ns1162 0 ni31 0 -0.137852810629
Gb1163_31 ns1163 0 ni31 0 0.151709094532
Gb1164_31 ns1164 0 ni31 0 -0.17470249457
Gb1165_31 ns1165 0 ni31 0 -0.150930199769
Gb1166_31 ns1166 0 ni31 0 0.17523919762
Gb1167_31 ns1167 0 ni31 0 -0.123939719155
Gb1168_31 ns1168 0 ni31 0 0.0410377293386
Gb1169_31 ns1169 0 ni31 0 0.101603024312
Gb1170_31 ns1170 0 ni31 0 -0.0153527668791
Gb1171_31 ns1171 0 ni31 0 -0.0166299065128
Gb1172_31 ns1172 0 ni31 0 0.103266563627
Gb1173_31 ns1173 0 ni31 0 0.0392458406069
Gb1174_31 ns1174 0 ni31 0 0.0394437935273
Gb1175_31 ns1175 0 ni31 0 0.0281679713658
Gb1176_31 ns1176 0 ni31 0 0.00073055352502
Gb1177_31 ns1177 0 ni31 0 7.36895567902e-05
Gb1178_31 ns1178 0 ni31 0 0.000245649206896
Gb1179_32 ns1179 0 ni32 0 -2.68399281951
Gb1180_32 ns1180 0 ni32 0 1.57064587542
Gb1181_32 ns1181 0 ni32 0 0.382436899313
Gb1182_32 ns1182 0 ni32 0 0.319965829211
Gb1183_32 ns1183 0 ni32 0 -0.393611813675
Gb1184_32 ns1184 0 ni32 0 0.414591878776
Gb1185_32 ns1185 0 ni32 0 -0.0288998953188
Gb1186_32 ns1186 0 ni32 0 0.437461712413
Gb1187_32 ns1187 0 ni32 0 -0.180810113414
Gb1188_32 ns1188 0 ni32 0 0.385785533009
Gb1189_32 ns1189 0 ni32 0 0.369549265187
Gb1190_32 ns1190 0 ni32 0 0.150328914964
Gb1191_32 ns1191 0 ni32 0 0.337732020689
Gb1192_32 ns1192 0 ni32 0 0.270797884127
Gb1193_32 ns1193 0 ni32 0 0.309492476244
Gb1194_32 ns1194 0 ni32 0 -0.00439828167297
Gb1195_32 ns1195 0 ni32 0 0.268378258407
Gb1196_32 ns1196 0 ni32 0 0.209525908734
Gb1197_32 ns1197 0 ni32 0 -0.262416526624
Gb1198_32 ns1198 0 ni32 0 0.148459493783
Gb1199_32 ns1199 0 ni32 0 -0.202854772461
Gb1200_32 ns1200 0 ni32 0 -0.137852810629
Gb1201_32 ns1201 0 ni32 0 0.151709094532
Gb1202_32 ns1202 0 ni32 0 -0.17470249457
Gb1203_32 ns1203 0 ni32 0 -0.150930199769
Gb1204_32 ns1204 0 ni32 0 0.17523919762
Gb1205_32 ns1205 0 ni32 0 -0.123939719155
Gb1206_32 ns1206 0 ni32 0 0.0410377293386
Gb1207_32 ns1207 0 ni32 0 0.101603024312
Gb1208_32 ns1208 0 ni32 0 -0.0153527668791
Gb1209_32 ns1209 0 ni32 0 -0.0166299065128
Gb1210_32 ns1210 0 ni32 0 0.103266563627
Gb1211_32 ns1211 0 ni32 0 0.0392458406069
Gb1212_32 ns1212 0 ni32 0 0.0394437935273
Gb1213_32 ns1213 0 ni32 0 0.0281679713658
Gb1214_32 ns1214 0 ni32 0 0.00073055352502
Gb1215_32 ns1215 0 ni32 0 7.36895567902e-05
Gb1216_32 ns1216 0 ni32 0 0.000245649206896

Gc1_1 0 n2 ns1 0 0.0015464240527
Gc1_2 0 n2 ns2 0 -0.00508123899399
Gc1_3 0 n2 ns3 0 0.000691055776228
Gc1_4 0 n2 ns4 0 -0.0039493433983
Gc1_5 0 n2 ns5 0 -0.000375402678927
Gc1_6 0 n2 ns6 0 -0.000498117257188
Gc1_7 0 n2 ns7 0 0.000470145980312
Gc1_8 0 n2 ns8 0 -2.24265574076e-05
Gc1_9 0 n2 ns9 0 -0.000182556250521
Gc1_10 0 n2 ns10 0 0.000265095760249
Gc1_11 0 n2 ns11 0 1.13922534505e-05
Gc1_12 0 n2 ns12 0 3.75768765972e-05
Gc1_13 0 n2 ns13 0 -0.00127518112899
Gc1_14 0 n2 ns14 0 7.0593960132e-05
Gc1_15 0 n2 ns15 0 0.000455086091306
Gc1_16 0 n2 ns16 0 0.000405140619709
Gc1_17 0 n2 ns17 0 -0.000262884118717
Gc1_18 0 n2 ns18 0 0.000166075287384
Gc1_19 0 n2 ns19 0 -0.000779813327921
Gc1_20 0 n2 ns20 0 -0.000669865719488
Gc1_21 0 n2 ns21 0 -0.000871705277868
Gc1_22 0 n2 ns22 0 0.000822546070103
Gc1_23 0 n2 ns23 0 0.00780693413008
Gc1_24 0 n2 ns24 0 0.00331644272162
Gc1_25 0 n2 ns25 0 0.00561343542656
Gc1_26 0 n2 ns26 0 0.0030444143207
Gc1_27 0 n2 ns27 0 0.0032124161212
Gc1_28 0 n2 ns28 0 0.00670454036181
Gc1_29 0 n2 ns29 0 0.000482262633662
Gc1_30 0 n2 ns30 0 6.20132333877e-06
Gc1_31 0 n2 ns31 0 -0.00805198448163
Gc1_32 0 n2 ns32 0 -0.000459219819995
Gc1_33 0 n2 ns33 0 0.00466108128129
Gc1_34 0 n2 ns34 0 -0.00741685643178
Gc1_35 0 n2 ns35 0 0.00366115289669
Gc1_36 0 n2 ns36 0 -2.88631490053e-05
Gc1_37 0 n2 ns37 0 -9.49924174122e-05
Gc1_38 0 n2 ns38 0 1.04200096088e-05
Gc1_39 0 n2 ns39 0 0.00202298915697
Gc1_40 0 n2 ns40 0 -0.00557715150992
Gc1_41 0 n2 ns41 0 0.00172274630479
Gc1_42 0 n2 ns42 0 -0.00415045499861
Gc1_43 0 n2 ns43 0 -0.00080537093807
Gc1_44 0 n2 ns44 0 -0.000934829005073
Gc1_45 0 n2 ns45 0 0.000595409021626
Gc1_46 0 n2 ns46 0 0.000117237717435
Gc1_47 0 n2 ns47 0 -0.000112191149923
Gc1_48 0 n2 ns48 0 0.000421081858404
Gc1_49 0 n2 ns49 0 4.25211730199e-05
Gc1_50 0 n2 ns50 0 7.85972099598e-05
Gc1_51 0 n2 ns51 0 -0.000906965249321
Gc1_52 0 n2 ns52 0 0.000278486034738
Gc1_53 0 n2 ns53 0 0.000464858107967
Gc1_54 0 n2 ns54 0 -3.45906717387e-05
Gc1_55 0 n2 ns55 0 -4.79420596473e-05
Gc1_56 0 n2 ns56 0 0.000166977883512
Gc1_57 0 n2 ns57 0 -0.000457004685562
Gc1_58 0 n2 ns58 0 -0.000647169452593
Gc1_59 0 n2 ns59 0 -0.000521419408793
Gc1_60 0 n2 ns60 0 0.00114439767408
Gc1_61 0 n2 ns61 0 0.00599132507064
Gc1_62 0 n2 ns62 0 0.00370608362725
Gc1_63 0 n2 ns63 0 0.00404434732238
Gc1_64 0 n2 ns64 0 0.00347242888947
Gc1_65 0 n2 ns65 0 0.00341315284212
Gc1_66 0 n2 ns66 0 0.00626780503617
Gc1_67 0 n2 ns67 0 0.000731543436911
Gc1_68 0 n2 ns68 0 -0.000159822270828
Gc1_69 0 n2 ns69 0 -0.00747649617793
Gc1_70 0 n2 ns70 0 -0.000996730545594
Gc1_71 0 n2 ns71 0 0.00384113289606
Gc1_72 0 n2 ns72 0 -0.00795995224065
Gc1_73 0 n2 ns73 0 0.00388304047863
Gc1_74 0 n2 ns74 0 7.88027469156e-06
Gc1_75 0 n2 ns75 0 -0.000137401285718
Gc1_76 0 n2 ns76 0 2.60407426135e-05
Gc1_77 0 n2 ns77 0 0.000663706917914
Gc1_78 0 n2 ns78 0 -0.00182045744314
Gc1_79 0 n2 ns79 0 0.00132640187593
Gc1_80 0 n2 ns80 0 -0.00156607085298
Gc1_81 0 n2 ns81 0 -0.000983195487717
Gc1_82 0 n2 ns82 0 -0.000179506682393
Gc1_83 0 n2 ns83 0 0.000145493490874
Gc1_84 0 n2 ns84 0 -0.000147271204855
Gc1_85 0 n2 ns85 0 0.00052661213355
Gc1_86 0 n2 ns86 0 0.000332731385137
Gc1_87 0 n2 ns87 0 0.000136517304199
Gc1_88 0 n2 ns88 0 0.000103701679077
Gc1_89 0 n2 ns89 0 0.000367852655131
Gc1_90 0 n2 ns90 0 0.000386652662116
Gc1_91 0 n2 ns91 0 -0.000238761812157
Gc1_92 0 n2 ns92 0 -0.00152977425549
Gc1_93 0 n2 ns93 0 0.000582889759626
Gc1_94 0 n2 ns94 0 -0.000127012790384
Gc1_95 0 n2 ns95 0 0.000578388466606
Gc1_96 0 n2 ns96 0 -0.000651944491692
Gc1_97 0 n2 ns97 0 0.00229369991084
Gc1_98 0 n2 ns98 0 0.00126625313557
Gc1_99 0 n2 ns99 0 -0.000602526547858
Gc1_100 0 n2 ns100 0 0.00185765892842
Gc1_101 0 n2 ns101 0 -0.00101281356783
Gc1_102 0 n2 ns102 0 0.00234353658159
Gc1_103 0 n2 ns103 0 0.00234286620969
Gc1_104 0 n2 ns104 0 -0.00296957365007
Gc1_105 0 n2 ns105 0 0.00116648267558
Gc1_106 0 n2 ns106 0 -0.000575876009387
Gc1_107 0 n2 ns107 0 9.75172274275e-05
Gc1_108 0 n2 ns108 0 0.000587782686096
Gc1_109 0 n2 ns109 0 -0.00311655379119
Gc1_110 0 n2 ns110 0 0.00207749033169
Gc1_111 0 n2 ns111 0 0.00260543492279
Gc1_112 0 n2 ns112 0 1.74832548016e-05
Gc1_113 0 n2 ns113 0 -0.000197670239907
Gc1_114 0 n2 ns114 0 4.63923235074e-05
Gc1_115 0 n2 ns115 0 0.000118183477848
Gc1_116 0 n2 ns116 0 -0.000371130442993
Gc1_117 0 n2 ns117 0 0.000415133555007
Gc1_118 0 n2 ns118 0 0.000402930610014
Gc1_119 0 n2 ns119 0 0.000153813036842
Gc1_120 0 n2 ns120 0 0.000233920050144
Gc1_121 0 n2 ns121 0 -5.40864838611e-07
Gc1_122 0 n2 ns122 0 0.000112693291888
Gc1_123 0 n2 ns123 0 0.000251050003434
Gc1_124 0 n2 ns124 0 -0.000596579220398
Gc1_125 0 n2 ns125 0 0.000157181944928
Gc1_126 0 n2 ns126 0 3.44499731975e-05
Gc1_127 0 n2 ns127 0 -0.000115691542947
Gc1_128 0 n2 ns128 0 -0.000277013175101
Gc1_129 0 n2 ns129 0 -0.00122698175879
Gc1_130 0 n2 ns130 0 0.000778034269179
Gc1_131 0 n2 ns131 0 0.000247678491545
Gc1_132 0 n2 ns132 0 0.000127571592903
Gc1_133 0 n2 ns133 0 -0.000371130284034
Gc1_134 0 n2 ns134 0 -0.000187541557919
Gc1_135 0 n2 ns135 0 0.000157419591021
Gc1_136 0 n2 ns136 0 -0.00178992393218
Gc1_137 0 n2 ns137 0 -0.00173733633133
Gc1_138 0 n2 ns138 0 0.00227709086663
Gc1_139 0 n2 ns139 0 -0.00134564015866
Gc1_140 0 n2 ns140 0 0.00271945490881
Gc1_141 0 n2 ns141 0 -0.00258665947344
Gc1_142 0 n2 ns142 0 -0.00123937567451
Gc1_143 0 n2 ns143 0 0.000510603037176
Gc1_144 0 n2 ns144 0 -0.00093956217504
Gc1_145 0 n2 ns145 0 0.0013197759613
Gc1_146 0 n2 ns146 0 -0.000765537046125
Gc1_147 0 n2 ns147 0 -0.00066533299444
Gc1_148 0 n2 ns148 0 0.00226452012117
Gc1_149 0 n2 ns149 0 0.00110436372275
Gc1_150 0 n2 ns150 0 2.89640690667e-05
Gc1_151 0 n2 ns151 0 -0.000339738634311
Gc1_152 0 n2 ns152 0 0.000138853496742
Gc1_153 0 n2 ns153 0 -1.43767932201e-05
Gc1_154 0 n2 ns154 0 -0.000491981050461
Gc1_155 0 n2 ns155 0 -0.00012944422174
Gc1_156 0 n2 ns156 0 3.86652235392e-05
Gc1_157 0 n2 ns157 0 0.000173705413809
Gc1_158 0 n2 ns158 0 -0.00013806136911
Gc1_159 0 n2 ns159 0 -9.6777757043e-06
Gc1_160 0 n2 ns160 0 -8.16783587031e-05
Gc1_161 0 n2 ns161 0 -0.000544493199633
Gc1_162 0 n2 ns162 0 -0.00029260104843
Gc1_163 0 n2 ns163 0 0.00012870122548
Gc1_164 0 n2 ns164 0 -6.21624429532e-05
Gc1_165 0 n2 ns165 0 -3.21053802582e-05
Gc1_166 0 n2 ns166 0 0.000271121607241
Gc1_167 0 n2 ns167 0 0.00076361521237
Gc1_168 0 n2 ns168 0 0.0010312190372
Gc1_169 0 n2 ns169 0 0.000590064118661
Gc1_170 0 n2 ns170 0 -0.00014635174093
Gc1_171 0 n2 ns171 0 0.000278666435315
Gc1_172 0 n2 ns172 0 0.000139107070155
Gc1_173 0 n2 ns173 0 -0.00115165619887
Gc1_174 0 n2 ns174 0 -2.24923838986e-06
Gc1_175 0 n2 ns175 0 0.000856471426969
Gc1_176 0 n2 ns176 0 0.00422259212418
Gc1_177 0 n2 ns177 0 0.00114326929452
Gc1_178 0 n2 ns178 0 0.00385105908381
Gc1_179 0 n2 ns179 0 -0.00108045232484
Gc1_180 0 n2 ns180 0 0.000975458977577
Gc1_181 0 n2 ns181 0 -0.000106912289012
Gc1_182 0 n2 ns182 0 -0.000672011752309
Gc1_183 0 n2 ns183 0 -0.000247548970509
Gc1_184 0 n2 ns184 0 -0.0014233511698
Gc1_185 0 n2 ns185 0 -0.000408326613939
Gc1_186 0 n2 ns186 0 0.000420393761016
Gc1_187 0 n2 ns187 0 0.000337907643579
Gc1_188 0 n2 ns188 0 -2.10452089132e-05
Gc1_189 0 n2 ns189 0 -0.000102154462916
Gc1_190 0 n2 ns190 0 -7.81806691467e-06
Gc1_191 0 n2 ns191 0 7.35760144945e-05
Gc1_192 0 n2 ns192 0 0.000262329502158
Gc1_193 0 n2 ns193 0 0.000208065380679
Gc1_194 0 n2 ns194 0 0.00101994570083
Gc1_195 0 n2 ns195 0 0.000107247380468
Gc1_196 0 n2 ns196 0 1.12173391613e-05
Gc1_197 0 n2 ns197 0 -0.000188887458032
Gc1_198 0 n2 ns198 0 7.65902981285e-06
Gc1_199 0 n2 ns199 0 -0.000267663645591
Gc1_200 0 n2 ns200 0 0.000442551780794
Gc1_201 0 n2 ns201 0 5.81545964846e-05
Gc1_202 0 n2 ns202 0 -0.000124301256581
Gc1_203 0 n2 ns203 0 0.000220450083066
Gc1_204 0 n2 ns204 0 -0.000351834155123
Gc1_205 0 n2 ns205 0 0.000904265395454
Gc1_206 0 n2 ns206 0 -0.000738892464672
Gc1_207 0 n2 ns207 0 0.000237028286748
Gc1_208 0 n2 ns208 0 -0.000794122142168
Gc1_209 0 n2 ns209 0 0.000434938931579
Gc1_210 0 n2 ns210 0 -0.00079901086026
Gc1_211 0 n2 ns211 0 0.000189320758635
Gc1_212 0 n2 ns212 0 0.0012022149596
Gc1_213 0 n2 ns213 0 0.00376388092376
Gc1_214 0 n2 ns214 0 0.00299990504761
Gc1_215 0 n2 ns215 0 0.00343237356892
Gc1_216 0 n2 ns216 0 0.00244847065738
Gc1_217 0 n2 ns217 0 0.000785092119811
Gc1_218 0 n2 ns218 0 0.00105357550516
Gc1_219 0 n2 ns219 0 -0.000334368703086
Gc1_220 0 n2 ns220 0 -0.000366642189306
Gc1_221 0 n2 ns221 0 -0.00144416335649
Gc1_222 0 n2 ns222 0 -0.00109209020993
Gc1_223 0 n2 ns223 0 -0.000568869830543
Gc1_224 0 n2 ns224 0 -0.000485399405678
Gc1_225 0 n2 ns225 0 3.82516108256e-05
Gc1_226 0 n2 ns226 0 1.15146636659e-05
Gc1_227 0 n2 ns227 0 -0.00010024365326
Gc1_228 0 n2 ns228 0 3.37256527668e-06
Gc1_229 0 n2 ns229 0 0.000436149043902
Gc1_230 0 n2 ns230 0 1.73120242687e-05
Gc1_231 0 n2 ns231 0 0.00139803704155
Gc1_232 0 n2 ns232 0 -0.00014458710004
Gc1_233 0 n2 ns233 0 9.6478982752e-05
Gc1_234 0 n2 ns234 0 -8.73360993821e-05
Gc1_235 0 n2 ns235 0 -2.6009439477e-05
Gc1_236 0 n2 ns236 0 0.000116762469672
Gc1_237 0 n2 ns237 0 0.00025426392545
Gc1_238 0 n2 ns238 0 0.000161760288057
Gc1_239 0 n2 ns239 0 -6.11883868096e-05
Gc1_240 0 n2 ns240 0 -6.4327975171e-05
Gc1_241 0 n2 ns241 0 -0.000298168958571
Gc1_242 0 n2 ns242 0 -0.00020261888081
Gc1_243 0 n2 ns243 0 -0.000289597993894
Gc1_244 0 n2 ns244 0 -0.000656533875359
Gc1_245 0 n2 ns245 0 -0.000386772963143
Gc1_246 0 n2 ns246 0 -0.000366159836079
Gc1_247 0 n2 ns247 0 -0.000390504672598
Gc1_248 0 n2 ns248 0 -0.000521899236226
Gc1_249 0 n2 ns249 0 0.000709586158247
Gc1_250 0 n2 ns250 0 0.000223507993921
Gc1_251 0 n2 ns251 0 0.00275041967091
Gc1_252 0 n2 ns252 0 -0.000657384012889
Gc1_253 0 n2 ns253 0 0.0023704105835
Gc1_254 0 n2 ns254 0 -0.000664273952414
Gc1_255 0 n2 ns255 0 0.000505420872328
Gc1_256 0 n2 ns256 0 0.000273127743753
Gc1_257 0 n2 ns257 0 -0.000187006346021
Gc1_258 0 n2 ns258 0 -0.000119141305705
Gc1_259 0 n2 ns259 0 -0.000810595039424
Gc1_260 0 n2 ns260 0 -0.000297388683342
Gc1_261 0 n2 ns261 0 -0.000337863268155
Gc1_262 0 n2 ns262 0 -0.000165610323071
Gc1_263 0 n2 ns263 0 5.226800196e-05
Gc1_264 0 n2 ns264 0 1.62152542549e-05
Gc1_265 0 n2 ns265 0 -5.60723727158e-05
Gc1_266 0 n2 ns266 0 1.59207723198e-05
Gc1_267 0 n2 ns267 0 -6.80737783911e-09
Gc1_268 0 n2 ns268 0 0.000114514797522
Gc1_269 0 n2 ns269 0 -1.09307725155e-05
Gc1_270 0 n2 ns270 0 -0.0008394130829
Gc1_271 0 n2 ns271 0 -0.000107340970056
Gc1_272 0 n2 ns272 0 -9.37160030576e-05
Gc1_273 0 n2 ns273 0 9.79019728935e-05
Gc1_274 0 n2 ns274 0 2.58687386009e-05
Gc1_275 0 n2 ns275 0 7.94091246247e-05
Gc1_276 0 n2 ns276 0 -0.000125087203565
Gc1_277 0 n2 ns277 0 -4.54225444344e-05
Gc1_278 0 n2 ns278 0 3.43438587832e-05
Gc1_279 0 n2 ns279 0 -6.84320387425e-05
Gc1_280 0 n2 ns280 0 0.000191801242447
Gc1_281 0 n2 ns281 0 -0.000324116274204
Gc1_282 0 n2 ns282 0 0.000136673035429
Gc1_283 0 n2 ns283 0 -0.000243988071197
Gc1_284 0 n2 ns284 0 0.000206359882096
Gc1_285 0 n2 ns285 0 -0.000332785306297
Gc1_286 0 n2 ns286 0 0.000270628418316
Gc1_287 0 n2 ns287 0 3.57583304005e-05
Gc1_288 0 n2 ns288 0 -0.000351167701346
Gc1_289 0 n2 ns289 0 5.11023455645e-05
Gc1_290 0 n2 ns290 0 -0.00169241674737
Gc1_291 0 n2 ns291 0 3.84009406969e-05
Gc1_292 0 n2 ns292 0 -0.00146476156604
Gc1_293 0 n2 ns293 0 -0.000123300225305
Gc1_294 0 n2 ns294 0 8.99422592935e-05
Gc1_295 0 n2 ns295 0 -6.52485875097e-05
Gc1_296 0 n2 ns296 0 -3.85156868475e-05
Gc1_297 0 n2 ns297 0 -0.000146317930601
Gc1_298 0 n2 ns298 0 4.27578304183e-05
Gc1_299 0 n2 ns299 0 -5.91059044495e-05
Gc1_300 0 n2 ns300 0 0.000385858340663
Gc1_301 0 n2 ns301 0 0.000139382676309
Gc1_302 0 n2 ns302 0 -1.68047167489e-06
Gc1_303 0 n2 ns303 0 4.99858416133e-05
Gc1_304 0 n2 ns304 0 -4.4364743751e-05
Gc1_305 0 n2 ns305 0 0.000355758695295
Gc1_306 0 n2 ns306 0 -0.000159187487609
Gc1_307 0 n2 ns307 0 0.00102162295719
Gc1_308 0 n2 ns308 0 -0.000260041370976
Gc1_309 0 n2 ns309 0 0.00019012092145
Gc1_310 0 n2 ns310 0 -7.68814767242e-05
Gc1_311 0 n2 ns311 0 -8.50911199737e-05
Gc1_312 0 n2 ns312 0 -2.89954187382e-06
Gc1_313 0 n2 ns313 0 2.47108558961e-05
Gc1_314 0 n2 ns314 0 -0.000168243708985
Gc1_315 0 n2 ns315 0 -2.03959961805e-05
Gc1_316 0 n2 ns316 0 1.80769118963e-05
Gc1_317 0 n2 ns317 0 -0.000129875114158
Gc1_318 0 n2 ns318 0 0.000126205483387
Gc1_319 0 n2 ns319 0 -0.000108265036579
Gc1_320 0 n2 ns320 0 4.52845700311e-05
Gc1_321 0 n2 ns321 0 -1.44583306111e-05
Gc1_322 0 n2 ns322 0 4.81741250078e-05
Gc1_323 0 n2 ns323 0 -2.06105494435e-06
Gc1_324 0 n2 ns324 0 1.08658828419e-05
Gc1_325 0 n2 ns325 0 9.1168870248e-05
Gc1_326 0 n2 ns326 0 9.08106452606e-06
Gc1_327 0 n2 ns327 0 -0.000128892961653
Gc1_328 0 n2 ns328 0 -0.000359888665824
Gc1_329 0 n2 ns329 0 -0.000121440176412
Gc1_330 0 n2 ns330 0 -0.000332894367583
Gc1_331 0 n2 ns331 0 0.00024279953166
Gc1_332 0 n2 ns332 0 0.000420318717554
Gc1_333 0 n2 ns333 0 -7.03769871489e-05
Gc1_334 0 n2 ns334 0 -8.93904965384e-05
Gc1_335 0 n2 ns335 0 -0.000343343940324
Gc1_336 0 n2 ns336 0 -0.000429597275965
Gc1_337 0 n2 ns337 0 -0.000169624908175
Gc1_338 0 n2 ns338 0 -0.000468137745986
Gc1_339 0 n2 ns339 0 -5.34790781247e-05
Gc1_340 0 n2 ns340 0 3.02186595867e-05
Gc1_341 0 n2 ns341 0 -6.73404450232e-05
Gc1_342 0 n2 ns342 0 3.55885677917e-05
Gc1_343 0 n2 ns343 0 0.000739158496384
Gc1_344 0 n2 ns344 0 -0.00251819443726
Gc1_345 0 n2 ns345 0 0.00115754606684
Gc1_346 0 n2 ns346 0 -0.0018150218358
Gc1_347 0 n2 ns347 0 -0.00107593182787
Gc1_348 0 n2 ns348 0 -0.000208709890775
Gc1_349 0 n2 ns349 0 0.000343483368982
Gc1_350 0 n2 ns350 0 -0.000316861577447
Gc1_351 0 n2 ns351 0 0.000355496012572
Gc1_352 0 n2 ns352 0 0.000670979069714
Gc1_353 0 n2 ns353 0 0.000114174975704
Gc1_354 0 n2 ns354 0 9.43075445907e-05
Gc1_355 0 n2 ns355 0 -0.000111185276148
Gc1_356 0 n2 ns356 0 0.000383772776264
Gc1_357 0 n2 ns357 0 0.000673383911874
Gc1_358 0 n2 ns358 0 -0.00158876403196
Gc1_359 0 n2 ns359 0 0.00064196560405
Gc1_360 0 n2 ns360 0 -3.86136093537e-05
Gc1_361 0 n2 ns361 0 0.000651854871061
Gc1_362 0 n2 ns362 0 -0.000591772765657
Gc1_363 0 n2 ns363 0 0.0015314141993
Gc1_364 0 n2 ns364 0 0.0026715288413
Gc1_365 0 n2 ns365 0 0.000647851423642
Gc1_366 0 n2 ns366 0 0.00181646012287
Gc1_367 0 n2 ns367 0 -0.000142931415259
Gc1_368 0 n2 ns368 0 0.00221984291591
Gc1_369 0 n2 ns369 0 0.00502618945047
Gc1_370 0 n2 ns370 0 -0.00042306154776
Gc1_371 0 n2 ns371 0 0.00116474678612
Gc1_372 0 n2 ns372 0 -0.00044920629978
Gc1_373 0 n2 ns373 0 -0.00164609597325
Gc1_374 0 n2 ns374 0 -0.000120404679593
Gc1_375 0 n2 ns375 0 -0.00372765398309
Gc1_376 0 n2 ns376 0 -0.0010676703405
Gc1_377 0 n2 ns377 0 0.00295501785614
Gc1_378 0 n2 ns378 0 2.60722060909e-05
Gc1_379 0 n2 ns379 0 -0.000178170450457
Gc1_380 0 n2 ns380 0 3.55321717934e-05
Gc1_381 0 n2 ns381 0 0.000351800880098
Gc1_382 0 n2 ns382 0 -0.000550422846372
Gc1_383 0 n2 ns383 0 0.00101932018054
Gc1_384 0 n2 ns384 0 0.000364087366445
Gc1_385 0 n2 ns385 0 -0.000165725945717
Gc1_386 0 n2 ns386 0 0.000377062619124
Gc1_387 0 n2 ns387 0 -5.86284606007e-05
Gc1_388 0 n2 ns388 0 3.52333894042e-05
Gc1_389 0 n2 ns389 0 0.000649508736497
Gc1_390 0 n2 ns390 0 -0.000269963326731
Gc1_391 0 n2 ns391 0 0.000170450982515
Gc1_392 0 n2 ns392 0 4.16155841861e-05
Gc1_393 0 n2 ns393 0 6.78343356559e-06
Gc1_394 0 n2 ns394 0 -0.000460134871958
Gc1_395 0 n2 ns395 0 -0.00155754100817
Gc1_396 0 n2 ns396 0 -0.000290233881007
Gc1_397 0 n2 ns397 0 0.000215928377746
Gc1_398 0 n2 ns398 0 -9.66662153849e-05
Gc1_399 0 n2 ns399 0 -0.000244156313197
Gc1_400 0 n2 ns400 0 -0.000740385029289
Gc1_401 0 n2 ns401 0 0.00142360649571
Gc1_402 0 n2 ns402 0 -0.00131701561935
Gc1_403 0 n2 ns403 0 -0.00130701855967
Gc1_404 0 n2 ns404 0 0.00204444311747
Gc1_405 0 n2 ns405 0 -0.00120936795245
Gc1_406 0 n2 ns406 0 0.00261497056518
Gc1_407 0 n2 ns407 0 -0.00157897966205
Gc1_408 0 n2 ns408 0 -0.00230449550014
Gc1_409 0 n2 ns409 0 0.000749030039763
Gc1_410 0 n2 ns410 0 -0.000915576329113
Gc1_411 0 n2 ns411 0 0.00117682293259
Gc1_412 0 n2 ns412 0 -0.000273488321738
Gc1_413 0 n2 ns413 0 -0.00122800695013
Gc1_414 0 n2 ns414 0 0.00248133624724
Gc1_415 0 n2 ns415 0 0.00148784771352
Gc1_416 0 n2 ns416 0 3.98129582567e-05
Gc1_417 0 n2 ns417 0 -0.000338617562981
Gc1_418 0 n2 ns418 0 0.000135054871858
Gc1_419 0 n2 ns419 0 2.37188154812e-05
Gc1_420 0 n2 ns420 0 -0.000627662021346
Gc1_421 0 n2 ns421 0 2.6726975869e-05
Gc1_422 0 n2 ns422 0 -0.000255257247657
Gc1_423 0 n2 ns423 0 0.000136127571337
Gc1_424 0 n2 ns424 0 -0.000213028655728
Gc1_425 0 n2 ns425 0 0.00013872145145
Gc1_426 0 n2 ns426 0 7.51771913062e-05
Gc1_427 0 n2 ns427 0 -0.000379738483425
Gc1_428 0 n2 ns428 0 -0.000549682597707
Gc1_429 0 n2 ns429 0 0.000162193291389
Gc1_430 0 n2 ns430 0 -1.82133548285e-05
Gc1_431 0 n2 ns431 0 -0.000157108072108
Gc1_432 0 n2 ns432 0 0.0002002850301
Gc1_433 0 n2 ns433 0 0.000108732527588
Gc1_434 0 n2 ns434 0 0.00146592695202
Gc1_435 0 n2 ns435 0 0.000549560479115
Gc1_436 0 n2 ns436 0 0.000108010941931
Gc1_437 0 n2 ns437 0 -2.52161722165e-06
Gc1_438 0 n2 ns438 0 0.000299580937708
Gc1_439 0 n2 ns439 0 -0.00117766137543
Gc1_440 0 n2 ns440 0 -0.000823620885074
Gc1_441 0 n2 ns441 0 -0.00046762452747
Gc1_442 0 n2 ns442 0 0.00392056773426
Gc1_443 0 n2 ns443 0 4.20440051588e-06
Gc1_444 0 n2 ns444 0 0.00380824248726
Gc1_445 0 n2 ns445 0 -0.00189013798698
Gc1_446 0 n2 ns446 0 0.000500088587257
Gc1_447 0 n2 ns447 0 6.48016959733e-05
Gc1_448 0 n2 ns448 0 -0.000803711919196
Gc1_449 0 n2 ns449 0 0.000358658002779
Gc1_450 0 n2 ns450 0 -0.00135741497702
Gc1_451 0 n2 ns451 0 -0.000387850873989
Gc1_452 0 n2 ns452 0 0.00101625501131
Gc1_453 0 n2 ns453 0 0.000551760361473
Gc1_454 0 n2 ns454 0 -7.89543469632e-06
Gc1_455 0 n2 ns455 0 -0.000151974371082
Gc1_456 0 n2 ns456 0 1.09708529746e-05
Gc1_457 0 n2 ns457 0 -1.16567934285e-05
Gc1_458 0 n2 ns458 0 -1.90774784011e-05
Gc1_459 0 n2 ns459 0 -8.83581793105e-05
Gc1_460 0 n2 ns460 0 0.000975000937988
Gc1_461 0 n2 ns461 0 0.000107558405005
Gc1_462 0 n2 ns462 0 0.000119975342722
Gc1_463 0 n2 ns463 0 -0.000169926062704
Gc1_464 0 n2 ns464 0 -0.00017848053589
Gc1_465 0 n2 ns465 0 -0.000445893331791
Gc1_466 0 n2 ns466 0 0.000233978528324
Gc1_467 0 n2 ns467 0 9.59680692242e-05
Gc1_468 0 n2 ns468 0 -0.000121236391214
Gc1_469 0 n2 ns469 0 0.000212616793055
Gc1_470 0 n2 ns470 0 -0.000138825498468
Gc1_471 0 n2 ns471 0 0.00118312795302
Gc1_472 0 n2 ns472 0 -0.000231378552626
Gc1_473 0 n2 ns473 0 0.000489519731816
Gc1_474 0 n2 ns474 0 -0.000707905989109
Gc1_475 0 n2 ns475 0 0.000594896030764
Gc1_476 0 n2 ns476 0 -0.000581016508731
Gc1_477 0 n2 ns477 0 -0.000311481020323
Gc1_478 0 n2 ns478 0 0.00111900057493
Gc1_479 0 n2 ns479 0 0.00320602626672
Gc1_480 0 n2 ns480 0 0.00403142684926
Gc1_481 0 n2 ns481 0 0.00305272347827
Gc1_482 0 n2 ns482 0 0.00340765058243
Gc1_483 0 n2 ns483 0 0.000322711728831
Gc1_484 0 n2 ns484 0 0.00123104102366
Gc1_485 0 n2 ns485 0 -0.000282026682573
Gc1_486 0 n2 ns486 0 -0.000470823519075
Gc1_487 0 n2 ns487 0 -0.00112003743841
Gc1_488 0 n2 ns488 0 -0.00138159700489
Gc1_489 0 n2 ns489 0 -0.000542725730242
Gc1_490 0 n2 ns490 0 -0.000583113716746
Gc1_491 0 n2 ns491 0 4.12809261068e-05
Gc1_492 0 n2 ns492 0 -8.63214974149e-07
Gc1_493 0 n2 ns493 0 -9.15722641107e-05
Gc1_494 0 n2 ns494 0 3.56568899004e-06
Gc1_495 0 n2 ns495 0 0.000564498291159
Gc1_496 0 n2 ns496 0 -4.05238551256e-05
Gc1_497 0 n2 ns497 0 0.00176812965775
Gc1_498 0 n2 ns498 0 0.000366154081396
Gc1_499 0 n2 ns499 0 0.000258657791237
Gc1_500 0 n2 ns500 0 -4.42150777512e-06
Gc1_501 0 n2 ns501 0 -0.000186911269592
Gc1_502 0 n2 ns502 0 6.40601484806e-05
Gc1_503 0 n2 ns503 0 0.000174165382714
Gc1_504 0 n2 ns504 0 0.000258740459815
Gc1_505 0 n2 ns505 0 -4.54139617668e-05
Gc1_506 0 n2 ns506 0 -0.000103662413088
Gc1_507 0 n2 ns507 0 -0.000261943758835
Gc1_508 0 n2 ns508 0 -0.000306224191024
Gc1_509 0 n2 ns509 0 7.76102776238e-06
Gc1_510 0 n2 ns510 0 -0.000931486615202
Gc1_511 0 n2 ns511 0 -0.000281355665938
Gc1_512 0 n2 ns512 0 -0.000656430575074
Gc1_513 0 n2 ns513 0 -0.000209140335911
Gc1_514 0 n2 ns514 0 -0.000856171275648
Gc1_515 0 n2 ns515 0 0.000820030207236
Gc1_516 0 n2 ns516 0 0.000628999730063
Gc1_517 0 n2 ns517 0 0.0037590907279
Gc1_518 0 n2 ns518 0 0.000476935962481
Gc1_519 0 n2 ns519 0 0.00327716867718
Gc1_520 0 n2 ns520 0 0.000273114788977
Gc1_521 0 n2 ns521 0 0.00078375630641
Gc1_522 0 n2 ns522 0 0.000496394234894
Gc1_523 0 n2 ns523 0 -0.000248146348079
Gc1_524 0 n2 ns524 0 -0.000186774707781
Gc1_525 0 n2 ns525 0 -0.00112608175458
Gc1_526 0 n2 ns526 0 -0.000582380159554
Gc1_527 0 n2 ns527 0 -0.00048197408957
Gc1_528 0 n2 ns528 0 -0.000482263137858
Gc1_529 0 n2 ns529 0 8.82562155575e-06
Gc1_530 0 n2 ns530 0 3.1191381873e-05
Gc1_531 0 n2 ns531 0 -0.000120247545244
Gc1_532 0 n2 ns532 0 4.74668636476e-05
Gc1_533 0 n2 ns533 0 5.33180954291e-05
Gc1_534 0 n2 ns534 0 0.000205461261124
Gc1_535 0 n2 ns535 0 0.000218847981676
Gc1_536 0 n2 ns536 0 -0.000588633630649
Gc1_537 0 n2 ns537 0 -0.000100412923316
Gc1_538 0 n2 ns538 0 -4.47092582858e-05
Gc1_539 0 n2 ns539 0 0.000104844829504
Gc1_540 0 n2 ns540 0 3.68077043413e-05
Gc1_541 0 n2 ns541 0 0.000189753849975
Gc1_542 0 n2 ns542 0 -2.12066015155e-05
Gc1_543 0 n2 ns543 0 -5.70133032589e-05
Gc1_544 0 n2 ns544 0 8.73745632543e-07
Gc1_545 0 n2 ns545 0 -0.000177787006717
Gc1_546 0 n2 ns546 0 4.65309543659e-05
Gc1_547 0 n2 ns547 0 -0.000408517290358
Gc1_548 0 n2 ns548 0 -9.38792491046e-05
Gc1_549 0 n2 ns549 0 -0.000357095947709
Gc1_550 0 n2 ns550 0 7.45546054581e-05
Gc1_551 0 n2 ns551 0 -0.000445365743055
Gc1_552 0 n2 ns552 0 8.37498305906e-05
Gc1_553 0 n2 ns553 0 0.000235218761248
Gc1_554 0 n2 ns554 0 -0.000273782528208
Gc1_555 0 n2 ns555 0 0.000796939463358
Gc1_556 0 n2 ns556 0 -0.00171643101123
Gc1_557 0 n2 ns557 0 0.000678009219278
Gc1_558 0 n2 ns558 0 -0.00150822910127
Gc1_559 0 n2 ns559 0 1.00843042271e-05
Gc1_560 0 n2 ns560 0 6.67935396476e-05
Gc1_561 0 n2 ns561 0 -9.91802772258e-05
Gc1_562 0 n2 ns562 0 -4.34680107788e-05
Gc1_563 0 n2 ns563 0 -0.00030755560092
Gc1_564 0 n2 ns564 0 5.90720148434e-05
Gc1_565 0 n2 ns565 0 -0.000112211802174
Gc1_566 0 n2 ns566 0 0.00040003211285
Gc1_567 0 n2 ns567 0 0.000150524114648
Gc1_568 0 n2 ns568 0 -6.57727708223e-06
Gc1_569 0 n2 ns569 0 1.56348230712e-05
Gc1_570 0 n2 ns570 0 -3.06496448694e-05
Gc1_571 0 n2 ns571 0 0.00018134278557
Gc1_572 0 n2 ns572 0 6.20621654047e-05
Gc1_573 0 n2 ns573 0 0.000607722660687
Gc1_574 0 n2 ns574 0 -0.00018108884619
Gc1_575 0 n2 ns575 0 6.97361930184e-05
Gc1_576 0 n2 ns576 0 1.28503552179e-05
Gc1_577 0 n2 ns577 0 -5.36861170725e-06
Gc1_578 0 n2 ns578 0 -5.20584560058e-05
Gc1_579 0 n2 ns579 0 7.15002615957e-05
Gc1_580 0 n2 ns580 0 -0.000133842430832
Gc1_581 0 n2 ns581 0 -1.9936844362e-05
Gc1_582 0 n2 ns582 0 1.76337641179e-05
Gc1_583 0 n2 ns583 0 -0.000123196537643
Gc1_584 0 n2 ns584 0 7.22879940525e-05
Gc1_585 0 n2 ns585 0 -0.000152047565116
Gc1_586 0 n2 ns586 0 4.09946660129e-05
Gc1_587 0 n2 ns587 0 -5.45603613915e-05
Gc1_588 0 n2 ns588 0 7.80101225671e-05
Gc1_589 0 n2 ns589 0 -4.85914723213e-05
Gc1_590 0 n2 ns590 0 5.80005428246e-05
Gc1_591 0 n2 ns591 0 6.65329697621e-05
Gc1_592 0 n2 ns592 0 -4.29565486505e-05
Gc1_593 0 n2 ns593 0 -0.000196517833887
Gc1_594 0 n2 ns594 0 -0.000640346218558
Gc1_595 0 n2 ns595 0 -0.000177674567069
Gc1_596 0 n2 ns596 0 -0.000575868729352
Gc1_597 0 n2 ns597 0 0.000201722541113
Gc1_598 0 n2 ns598 0 0.000443218632128
Gc1_599 0 n2 ns599 0 -7.76760112656e-05
Gc1_600 0 n2 ns600 0 -9.30429875557e-05
Gc1_601 0 n2 ns601 0 -0.000342957178161
Gc1_602 0 n2 ns602 0 -0.000421624548758
Gc1_603 0 n2 ns603 0 -0.000172164528444
Gc1_604 0 n2 ns604 0 -0.000374797908035
Gc1_605 0 n2 ns605 0 -3.10728413946e-05
Gc1_606 0 n2 ns606 0 1.9070594667e-05
Gc1_607 0 n2 ns607 0 -3.82894112747e-05
Gc1_608 0 n2 ns608 0 1.25208571416e-05
Gc1_609 0 n2 ns609 0 0.000109421691722
Gc1_610 0 n2 ns610 0 0.00021437320932
Gc1_611 0 n2 ns611 0 0.00235040373479
Gc1_612 0 n2 ns612 0 0.00220022246031
Gc1_613 0 n2 ns613 0 0.000951679340931
Gc1_614 0 n2 ns614 0 -0.00206475814383
Gc1_615 0 n2 ns615 0 -0.000245656140458
Gc1_616 0 n2 ns616 0 0.000527442227307
Gc1_617 0 n2 ns617 0 0.000575703132372
Gc1_618 0 n2 ns618 0 -9.07376260362e-05
Gc1_619 0 n2 ns619 0 4.32116689149e-05
Gc1_620 0 n2 ns620 0 -0.000116309579985
Gc1_621 0 n2 ns621 0 0.00109924310834
Gc1_622 0 n2 ns622 0 -0.00104544792918
Gc1_623 0 n2 ns623 0 0.00025832775602
Gc1_624 0 n2 ns624 0 0.00160916179593
Gc1_625 0 n2 ns625 0 -0.000710313524086
Gc1_626 0 n2 ns626 0 0.000569948009185
Gc1_627 0 n2 ns627 0 -0.00190392664879
Gc1_628 0 n2 ns628 0 -0.000390404677954
Gc1_629 0 n2 ns629 0 0.00407587504951
Gc1_630 0 n2 ns630 0 0.00260386534161
Gc1_631 0 n2 ns631 0 -0.00837376263938
Gc1_632 0 n2 ns632 0 0.0031117708622
Gc1_633 0 n2 ns633 0 -0.00601335354337
Gc1_634 0 n2 ns634 0 0.00202465661783
Gc1_635 0 n2 ns635 0 -0.0103284952835
Gc1_636 0 n2 ns636 0 4.6138803701e-05
Gc1_637 0 n2 ns637 0 0.00129072939335
Gc1_638 0 n2 ns638 0 0.000988447930497
Gc1_639 0 n2 ns639 0 -0.00359564721474
Gc1_640 0 n2 ns640 0 0.0108530548685
Gc1_641 0 n2 ns641 0 -0.0155895004427
Gc1_642 0 n2 ns642 0 -0.000688444681858
Gc1_643 0 n2 ns643 0 -0.00490744281567
Gc1_644 0 n2 ns644 0 -4.74781492439e-05
Gc1_645 0 n2 ns645 0 -0.00036953821406
Gc1_646 0 n2 ns646 0 0.000561745844696
Gc1_647 0 n2 ns647 0 0.00248867135808
Gc1_648 0 n2 ns648 0 -0.00367715438299
Gc1_649 0 n2 ns649 0 0.0049618855348
Gc1_650 0 n2 ns650 0 -0.00869819417812
Gc1_651 0 n2 ns651 0 -0.00376048038548
Gc1_652 0 n2 ns652 0 -0.00259665490122
Gc1_653 0 n2 ns653 0 0.00126667615095
Gc1_654 0 n2 ns654 0 0.000975318163674
Gc1_655 0 n2 ns655 0 -0.00035575057948
Gc1_656 0 n2 ns656 0 -0.000880487410406
Gc1_657 0 n2 ns657 0 -0.000114510066427
Gc1_658 0 n2 ns658 0 -0.000106853576913
Gc1_659 0 n2 ns659 0 -0.000999142987961
Gc1_660 0 n2 ns660 0 6.30509958481e-05
Gc1_661 0 n2 ns661 0 0.00167024975606
Gc1_662 0 n2 ns662 0 -4.42584884763e-05
Gc1_663 0 n2 ns663 0 0.000567640358053
Gc1_664 0 n2 ns664 0 0.000807480503251
Gc1_665 0 n2 ns665 0 0.000419967585874
Gc1_666 0 n2 ns666 0 0.0011481031269
Gc1_667 0 n2 ns667 0 0.000986247366272
Gc1_668 0 n2 ns668 0 -0.00412998026149
Gc1_669 0 n2 ns669 0 -0.000415854402808
Gc1_670 0 n2 ns670 0 -0.00481775951601
Gc1_671 0 n2 ns671 0 0.000368648985737
Gc1_672 0 n2 ns672 0 -0.00427094028853
Gc1_673 0 n2 ns673 0 0.00673777607928
Gc1_674 0 n2 ns674 0 0.00739638673101
Gc1_675 0 n2 ns675 0 0.000887514292193
Gc1_676 0 n2 ns676 0 -0.000280256417607
Gc1_677 0 n2 ns677 0 -0.00549690860118
Gc1_678 0 n2 ns678 0 -0.00358561925511
Gc1_679 0 n2 ns679 0 0.00102672592809
Gc1_680 0 n2 ns680 0 0.00887880049981
Gc1_681 0 n2 ns681 0 -0.00349457089037
Gc1_682 0 n2 ns682 0 4.41478850184e-06
Gc1_683 0 n2 ns683 0 0.000466787953116
Gc1_684 0 n2 ns684 0 -0.000305687924711
Gc1_685 0 n2 ns685 0 -0.000986303410038
Gc1_686 0 n2 ns686 0 0.000236742725507
Gc1_687 0 n2 ns687 0 -0.00302196069844
Gc1_688 0 n2 ns688 0 0.00113026728667
Gc1_689 0 n2 ns689 0 -0.000124122617746
Gc1_690 0 n2 ns690 0 0.000963955722332
Gc1_691 0 n2 ns691 0 0.00023923098012
Gc1_692 0 n2 ns692 0 -0.000408814090562
Gc1_693 0 n2 ns693 0 -0.000734805259372
Gc1_694 0 n2 ns694 0 -9.72071842848e-06
Gc1_695 0 n2 ns695 0 -0.00010393149277
Gc1_696 0 n2 ns696 0 -2.47896574731e-05
Gc1_697 0 n2 ns697 0 0.00104730464981
Gc1_698 0 n2 ns698 0 0.000340371144221
Gc1_699 0 n2 ns699 0 -0.000317650575191
Gc1_700 0 n2 ns700 0 -0.00114258032411
Gc1_701 0 n2 ns701 0 0.000456901670982
Gc1_702 0 n2 ns702 0 2.78921395393e-05
Gc1_703 0 n2 ns703 0 0.000292295254662
Gc1_704 0 n2 ns704 0 -0.000533796797251
Gc1_705 0 n2 ns705 0 -0.00252110867596
Gc1_706 0 n2 ns706 0 0.000152629816689
Gc1_707 0 n2 ns707 0 -0.00160987057581
Gc1_708 0 n2 ns708 0 0.00107444546668
Gc1_709 0 n2 ns709 0 -0.000780214106418
Gc1_710 0 n2 ns710 0 3.98076392976e-05
Gc1_711 0 n2 ns711 0 0.00194847359436
Gc1_712 0 n2 ns712 0 -0.00198883271033
Gc1_713 0 n2 ns713 0 0.00120781292723
Gc1_714 0 n2 ns714 0 -0.000683184763531
Gc1_715 0 n2 ns715 0 0.000488544229455
Gc1_716 0 n2 ns716 0 4.38385714037e-05
Gc1_717 0 n2 ns717 0 0.00271679554242
Gc1_718 0 n2 ns718 0 -0.00104649322898
Gc1_719 0 n2 ns719 0 -0.00226393272563
Gc1_720 0 n2 ns720 0 -1.00475698063e-05
Gc1_721 0 n2 ns721 0 0.000219611420411
Gc1_722 0 n2 ns722 0 -7.29103292785e-05
Gc1_723 0 n2 ns723 0 -0.000310436763529
Gc1_724 0 n2 ns724 0 -0.000209320317503
Gc1_725 0 n2 ns725 0 -0.000986572029601
Gc1_726 0 n2 ns726 0 0.000803319019864
Gc1_727 0 n2 ns727 0 -0.000339581533047
Gc1_728 0 n2 ns728 0 -0.000149735354272
Gc1_729 0 n2 ns729 0 7.35558888256e-05
Gc1_730 0 n2 ns730 0 -7.79627994268e-05
Gc1_731 0 n2 ns731 0 -0.000352949195597
Gc1_732 0 n2 ns732 0 0.000857201325773
Gc1_733 0 n2 ns733 0 -5.34773953214e-05
Gc1_734 0 n2 ns734 0 -3.18686196057e-06
Gc1_735 0 n2 ns735 0 0.000547814197008
Gc1_736 0 n2 ns736 0 -0.000859543561459
Gc1_737 0 n2 ns737 0 -0.000648606748867
Gc1_738 0 n2 ns738 0 0.000857006346593
Gc1_739 0 n2 ns739 0 0.000589421952626
Gc1_740 0 n2 ns740 0 0.00035784511929
Gc1_741 0 n2 ns741 0 0.000173610115006
Gc1_742 0 n2 ns742 0 0.000437274733708
Gc1_743 0 n2 ns743 0 -0.000291501545461
Gc1_744 0 n2 ns744 0 0.00108051179481
Gc1_745 0 n2 ns745 0 0.00187063744626
Gc1_746 0 n2 ns746 0 -0.00389890331477
Gc1_747 0 n2 ns747 0 0.0014328368126
Gc1_748 0 n2 ns748 0 -0.0040387467032
Gc1_749 0 n2 ns749 0 -0.00177404999393
Gc1_750 0 n2 ns750 0 -0.000119883415437
Gc1_751 0 n2 ns751 0 0.000460690484541
Gc1_752 0 n2 ns752 0 -0.0010801578478
Gc1_753 0 n2 ns753 0 0.00105402491393
Gc1_754 0 n2 ns754 0 -0.00199571533841
Gc1_755 0 n2 ns755 0 0.000933946907668
Gc1_756 0 n2 ns756 0 -0.00178115402821
Gc1_757 0 n2 ns757 0 -0.000976896640671
Gc1_758 0 n2 ns758 0 -3.65515248921e-05
Gc1_759 0 n2 ns759 0 0.000150139951447
Gc1_760 0 n2 ns760 0 -2.91398984426e-05
Gc1_761 0 n2 ns761 0 8.30379658039e-05
Gc1_762 0 n2 ns762 0 -0.000580407562894
Gc1_763 0 n2 ns763 0 0.000211087084265
Gc1_764 0 n2 ns764 0 -8.72689910761e-06
Gc1_765 0 n2 ns765 0 -3.80676191317e-06
Gc1_766 0 n2 ns766 0 -0.000104481697589
Gc1_767 0 n2 ns767 0 -7.62372622728e-05
Gc1_768 0 n2 ns768 0 0.000224238033636
Gc1_769 0 n2 ns769 0 0.000564594088168
Gc1_770 0 n2 ns770 0 0.000191327882151
Gc1_771 0 n2 ns771 0 -0.000160858877843
Gc1_772 0 n2 ns772 0 2.73475543942e-05
Gc1_773 0 n2 ns773 0 -0.000499523614199
Gc1_774 0 n2 ns774 0 0.000232551389063
Gc1_775 0 n2 ns775 0 0.000732433461953
Gc1_776 0 n2 ns776 0 0.00082445994358
Gc1_777 0 n2 ns777 0 0.000678653775929
Gc1_778 0 n2 ns778 0 -0.000300693148397
Gc1_779 0 n2 ns779 0 0.000536357520461
Gc1_780 0 n2 ns780 0 -0.000179730546393
Gc1_781 0 n2 ns781 0 0.000471016516159
Gc1_782 0 n2 ns782 0 -0.000297813971101
Gc1_783 0 n2 ns783 0 -0.00239929804226
Gc1_784 0 n2 ns784 0 -0.00586402795593
Gc1_785 0 n2 ns785 0 -0.00240669586346
Gc1_786 0 n2 ns786 0 -0.00521087088248
Gc1_787 0 n2 ns787 0 -0.000963794363127
Gc1_788 0 n2 ns788 0 0.00127234155187
Gc1_789 0 n2 ns789 0 -0.000119483538882
Gc1_790 0 n2 ns790 0 -0.000715044368461
Gc1_791 0 n2 ns791 0 -0.000280431502322
Gc1_792 0 n2 ns792 0 -0.00176051104284
Gc1_793 0 n2 ns793 0 0.000163271768342
Gc1_794 0 n2 ns794 0 -0.000851322994628
Gc1_795 0 n2 ns795 0 -0.000372265663422
Gc1_796 0 n2 ns796 0 -1.0097746094e-06
Gc1_797 0 n2 ns797 0 4.05674899331e-05
Gc1_798 0 n2 ns798 0 2.0933817897e-05
Gc1_799 0 n2 ns799 0 -0.000267678110786
Gc1_800 0 n2 ns800 0 0.000533711323738
Gc1_801 0 n2 ns801 0 -0.000530986978161
Gc1_802 0 n2 ns802 0 0.000782943447788
Gc1_803 0 n2 ns803 0 -7.45356976456e-05
Gc1_804 0 n2 ns804 0 0.000349587143246
Gc1_805 0 n2 ns805 0 0.000159876515704
Gc1_806 0 n2 ns806 0 -0.000194839828751
Gc1_807 0 n2 ns807 0 0.000274917101289
Gc1_808 0 n2 ns808 0 -0.000416354092643
Gc1_809 0 n2 ns809 0 -6.53802701835e-05
Gc1_810 0 n2 ns810 0 0.00014757001073
Gc1_811 0 n2 ns811 0 0.000256276850582
Gc1_812 0 n2 ns812 0 0.00034785586074
Gc1_813 0 n2 ns813 0 0.000738667078524
Gc1_814 0 n2 ns814 0 -0.000500229122405
Gc1_815 0 n2 ns815 0 5.85782897151e-05
Gc1_816 0 n2 ns816 0 -0.000713527051705
Gc1_817 0 n2 ns817 0 1.5700291361e-05
Gc1_818 0 n2 ns818 0 -0.00072977654086
Gc1_819 0 n2 ns819 0 -0.000115806121565
Gc1_820 0 n2 ns820 0 -0.000478169598455
Gc1_821 0 n2 ns821 0 -0.00445191884233
Gc1_822 0 n2 ns822 0 -0.00180856101421
Gc1_823 0 n2 ns823 0 -0.00399445350221
Gc1_824 0 n2 ns824 0 -0.00150274796219
Gc1_825 0 n2 ns825 0 0.000225056247446
Gc1_826 0 n2 ns826 0 0.00146127335615
Gc1_827 0 n2 ns827 0 -0.000284627429069
Gc1_828 0 n2 ns828 0 -0.000409832463934
Gc1_829 0 n2 ns829 0 -0.000982009605831
Gc1_830 0 n2 ns830 0 -0.00130316926696
Gc1_831 0 n2 ns831 0 -0.000114415490872
Gc1_832 0 n2 ns832 0 -0.000715260938258
Gc1_833 0 n2 ns833 0 -0.000239690679243
Gc1_834 0 n2 ns834 0 -2.76974372288e-06
Gc1_835 0 n2 ns835 0 4.57548691528e-05
Gc1_836 0 n2 ns836 0 1.94662733556e-05
Gc1_837 0 n2 ns837 0 -0.000490477836869
Gc1_838 0 n2 ns838 0 0.000967576938282
Gc1_839 0 n2 ns839 0 -0.00133661854519
Gc1_840 0 n2 ns840 0 0.00135239944732
Gc1_841 0 n2 ns841 0 -0.000127723354789
Gc1_842 0 n2 ns842 0 0.000461644421743
Gc1_843 0 n2 ns843 0 4.7129898364e-05
Gc1_844 0 n2 ns844 0 -0.000305200963428
Gc1_845 0 n2 ns845 0 -0.000217127613553
Gc1_846 0 n2 ns846 0 1.19755911713e-05
Gc1_847 0 n2 ns847 0 0.000129032470628
Gc1_848 0 n2 ns848 0 7.08397632676e-05
Gc1_849 0 n2 ns849 0 0.000500851929845
Gc1_850 0 n2 ns850 0 -0.000454436247335
Gc1_851 0 n2 ns851 0 4.82769060942e-05
Gc1_852 0 n2 ns852 0 -0.000569531266815
Gc1_853 0 n2 ns853 0 -0.000280002019022
Gc1_854 0 n2 ns854 0 -0.000246469948639
Gc1_855 0 n2 ns855 0 -0.00028867870754
Gc1_856 0 n2 ns856 0 -0.000171038818754
Gc1_857 0 n2 ns857 0 -0.000566502851463
Gc1_858 0 n2 ns858 0 -7.63422537161e-05
Gc1_859 0 n2 ns859 0 -0.0032249025622
Gc1_860 0 n2 ns860 0 0.00104616692536
Gc1_861 0 n2 ns861 0 -0.00277939305454
Gc1_862 0 n2 ns862 0 0.000967052065667
Gc1_863 0 n2 ns863 0 0.000409857615589
Gc1_864 0 n2 ns864 0 0.000942677543702
Gc1_865 0 n2 ns865 0 -0.000206105622097
Gc1_866 0 n2 ns866 0 -0.000187955291062
Gc1_867 0 n2 ns867 0 -0.000718946108254
Gc1_868 0 n2 ns868 0 -0.000701886431834
Gc1_869 0 n2 ns869 0 -8.43718209325e-05
Gc1_870 0 n2 ns870 0 -0.000422748520617
Gc1_871 0 n2 ns871 0 -0.000141073510912
Gc1_872 0 n2 ns872 0 -1.51349083457e-05
Gc1_873 0 n2 ns873 0 4.74826691617e-05
Gc1_874 0 n2 ns874 0 1.99974249754e-06
Gc1_875 0 n2 ns875 0 0.000342403019042
Gc1_876 0 n2 ns876 0 -0.000226179811425
Gc1_877 0 n2 ns877 0 0.000895312762182
Gc1_878 0 n2 ns878 0 -0.000468782195936
Gc1_879 0 n2 ns879 0 0.000165225171515
Gc1_880 0 n2 ns880 0 -0.000233593491831
Gc1_881 0 n2 ns881 0 -0.000129669164789
Gc1_882 0 n2 ns882 0 0.000150715549106
Gc1_883 0 n2 ns883 0 -0.000135647038578
Gc1_884 0 n2 ns884 0 0.000101362301909
Gc1_885 0 n2 ns885 0 6.11025372037e-05
Gc1_886 0 n2 ns886 0 -4.34109649276e-05
Gc1_887 0 n2 ns887 0 -0.000140294116683
Gc1_888 0 n2 ns888 0 -0.000186479028781
Gc1_889 0 n2 ns889 0 -0.000360930894768
Gc1_890 0 n2 ns890 0 -2.97880875621e-05
Gc1_891 0 n2 ns891 0 -0.00026212220051
Gc1_892 0 n2 ns892 0 0.000127006009366
Gc1_893 0 n2 ns893 0 -0.000306559726452
Gc1_894 0 n2 ns894 0 0.000174631257715
Gc1_895 0 n2 ns895 0 -0.000181439884569
Gc1_896 0 n2 ns896 0 0.000122712576931
Gc1_897 0 n2 ns897 0 -0.000651885611484
Gc1_898 0 n2 ns898 0 0.00150089387329
Gc1_899 0 n2 ns899 0 -0.000549706161383
Gc1_900 0 n2 ns900 0 0.00131444097086
Gc1_901 0 n2 ns901 0 0.000495672949814
Gc1_902 0 n2 ns902 0 0.000218941129611
Gc1_903 0 n2 ns903 0 -0.000127646344255
Gc1_904 0 n2 ns904 0 -4.897617056e-05
Gc1_905 0 n2 ns905 0 -0.000549798478433
Gc1_906 0 n2 ns906 0 -0.000165851505163
Gc1_907 0 n2 ns907 0 -7.69279881389e-05
Gc1_908 0 n2 ns908 0 -0.000242846259246
Gc1_909 0 n2 ns909 0 -9.33809620696e-05
Gc1_910 0 n2 ns910 0 -1.01189556446e-05
Gc1_911 0 n2 ns911 0 4.21402497298e-06
Gc1_912 0 n2 ns912 0 7.71130290237e-06
Gc1_913 0 n2 ns913 0 -0.00022782854606
Gc1_914 0 n2 ns914 0 0.000878498517967
Gc1_915 0 n2 ns915 0 -0.000311282913216
Gc1_916 0 n2 ns916 0 0.000699625481899
Gc1_917 0 n2 ns917 0 -0.000192682452894
Gc1_918 0 n2 ns918 0 0.000302698536633
Gc1_919 0 n2 ns919 0 0.000140473791181
Gc1_920 0 n2 ns920 0 -0.000129746715859
Gc1_921 0 n2 ns921 0 0.000213843297905
Gc1_922 0 n2 ns922 0 0.000284302269592
Gc1_923 0 n2 ns923 0 2.71543033203e-05
Gc1_924 0 n2 ns924 0 -0.000100053708602
Gc1_925 0 n2 ns925 0 -0.000267910040384
Gc1_926 0 n2 ns926 0 -0.000413400179184
Gc1_927 0 n2 ns927 0 -5.72627717885e-05
Gc1_928 0 n2 ns928 0 -0.000130883690513
Gc1_929 0 n2 ns929 0 2.92350415031e-05
Gc1_930 0 n2 ns930 0 -2.11500682096e-05
Gc1_931 0 n2 ns931 0 0.000129250968218
Gc1_932 0 n2 ns932 0 -5.74985103606e-05
Gc1_933 0 n2 ns933 0 -6.75371342886e-06
Gc1_934 0 n2 ns934 0 0.000452821212792
Gc1_935 0 n2 ns935 0 4.16611245694e-05
Gc1_936 0 n2 ns936 0 0.0017045556802
Gc1_937 0 n2 ns937 0 5.12843723097e-05
Gc1_938 0 n2 ns938 0 0.00143842436127
Gc1_939 0 n2 ns939 0 0.000620004262279
Gc1_940 0 n2 ns940 0 0.00041782456104
Gc1_941 0 n2 ns941 0 -0.000112048845881
Gc1_942 0 n2 ns942 0 -7.47738406365e-05
Gc1_943 0 n2 ns943 0 -0.000571472191611
Gc1_944 0 n2 ns944 0 -0.000455800681826
Gc1_945 0 n2 ns945 0 -0.000125996259121
Gc1_946 0 n2 ns946 0 -0.000788385639435
Gc1_947 0 n2 ns947 0 -0.000223937238189
Gc1_948 0 n2 ns948 0 -7.98679522821e-06
Gc1_949 0 n2 ns949 0 4.93048116223e-05
Gc1_950 0 n2 ns950 0 -3.43406416159e-05
Gc1_951 0 n2 ns951 0 -0.00104679061872
Gc1_952 0 n2 ns952 0 -0.000306121880932
Gc1_953 0 n2 ns953 0 -0.00423506938536
Gc1_954 0 n2 ns954 0 -0.00174973905696
Gc1_955 0 n2 ns955 0 -0.00182026788881
Gc1_956 0 n2 ns956 0 0.00120205675784
Gc1_957 0 n2 ns957 0 0.000901668502894
Gc1_958 0 n2 ns958 0 -0.00041394821937
Gc1_959 0 n2 ns959 0 -0.000669534279319
Gc1_960 0 n2 ns960 0 -0.000245599883713
Gc1_961 0 n2 ns961 0 -8.62704503078e-05
Gc1_962 0 n2 ns962 0 -5.35135044326e-05
Gc1_963 0 n2 ns963 0 0.00074736798906
Gc1_964 0 n2 ns964 0 0.000526355044377
Gc1_965 0 n2 ns965 0 0.000661539514441
Gc1_966 0 n2 ns966 0 -0.00145740266256
Gc1_967 0 n2 ns967 0 0.000694279401105
Gc1_968 0 n2 ns968 0 9.47575524759e-05
Gc1_969 0 n2 ns969 0 0.0007999672447
Gc1_970 0 n2 ns970 0 -0.000333763879494
Gc1_971 0 n2 ns971 0 -0.00250145795956
Gc1_972 0 n2 ns972 0 -0.00106455281806
Gc1_973 0 n2 ns973 0 -0.00286882737134
Gc1_974 0 n2 ns974 0 0.000761033613475
Gc1_975 0 n2 ns975 0 -0.00163705288161
Gc1_976 0 n2 ns976 0 -6.52298445326e-05
Gc1_977 0 n2 ns977 0 0.00414927443631
Gc1_978 0 n2 ns978 0 0.000136936713609
Gc1_979 0 n2 ns979 0 0.0012288786983
Gc1_980 0 n2 ns980 0 -0.000540527720962
Gc1_981 0 n2 ns981 0 -0.00135322407771
Gc1_982 0 n2 ns982 0 -0.000714354868401
Gc1_983 0 n2 ns983 0 0.00270246358169
Gc1_984 0 n2 ns984 0 0.00138439884703
Gc1_985 0 n2 ns985 0 -0.00284919496865
Gc1_986 0 n2 ns986 0 -3.9585655615e-05
Gc1_987 0 n2 ns987 0 0.000368401904493
Gc1_988 0 n2 ns988 0 -0.000189174698766
Gc1_989 0 n2 ns989 0 -0.000403133773773
Gc1_990 0 n2 ns990 0 0.000114879900273
Gc1_991 0 n2 ns991 0 -0.0011607008999
Gc1_992 0 n2 ns992 0 0.00152411361179
Gc1_993 0 n2 ns993 0 -8.07027231347e-05
Gc1_994 0 n2 ns994 0 0.000132947600647
Gc1_995 0 n2 ns995 0 8.3628696831e-05
Gc1_996 0 n2 ns996 0 -0.000269217272482
Gc1_997 0 n2 ns997 0 -0.000692988536315
Gc1_998 0 n2 ns998 0 0.000666738072121
Gc1_999 0 n2 ns999 0 -3.99233983056e-05
Gc1_1000 0 n2 ns1000 0 -1.44136694724e-05
Gc1_1001 0 n2 ns1001 0 0.000975119445667
Gc1_1002 0 n2 ns1002 0 -0.00079119807439
Gc1_1003 0 n2 ns1003 0 -0.00101943946297
Gc1_1004 0 n2 ns1004 0 8.2134194688e-05
Gc1_1005 0 n2 ns1005 0 0.00044810036687
Gc1_1006 0 n2 ns1006 0 0.000289561194596
Gc1_1007 0 n2 ns1007 0 6.35295009922e-06
Gc1_1008 0 n2 ns1008 0 8.6247184883e-05
Gc1_1009 0 n2 ns1009 0 -0.000970886307911
Gc1_1010 0 n2 ns1010 0 0.00136296174678
Gc1_1011 0 n2 ns1011 0 0.00215934053072
Gc1_1012 0 n2 ns1012 0 -0.00149436889311
Gc1_1013 0 n2 ns1013 0 0.00189220106562
Gc1_1014 0 n2 ns1014 0 -0.00217081047726
Gc1_1015 0 n2 ns1015 0 -0.000907645166317
Gc1_1016 0 n2 ns1016 0 -0.000874090535322
Gc1_1017 0 n2 ns1017 0 0.000706251865294
Gc1_1018 0 n2 ns1018 0 -0.00107547987883
Gc1_1019 0 n2 ns1019 0 0.00107607524198
Gc1_1020 0 n2 ns1020 0 -0.00161641088134
Gc1_1021 0 n2 ns1021 0 0.00137836045048
Gc1_1022 0 n2 ns1022 0 -0.00213664056568
Gc1_1023 0 n2 ns1023 0 -0.00139435978716
Gc1_1024 0 n2 ns1024 0 -3.09036168441e-05
Gc1_1025 0 n2 ns1025 0 0.000131718810197
Gc1_1026 0 n2 ns1026 0 -1.28004951029e-05
Gc1_1027 0 n2 ns1027 0 -0.000164830318468
Gc1_1028 0 n2 ns1028 0 -0.000384909225639
Gc1_1029 0 n2 ns1029 0 -0.0005312427577
Gc1_1030 0 n2 ns1030 0 0.000595651775421
Gc1_1031 0 n2 ns1031 0 -0.000201449562958
Gc1_1032 0 n2 ns1032 0 -2.55271942155e-05
Gc1_1033 0 n2 ns1033 0 -7.01256820789e-05
Gc1_1034 0 n2 ns1034 0 0.000113987464706
Gc1_1035 0 n2 ns1035 0 0.000368699864787
Gc1_1036 0 n2 ns1036 0 0.000687243646371
Gc1_1037 0 n2 ns1037 0 -0.00011727741795
Gc1_1038 0 n2 ns1038 0 -2.77419954266e-05
Gc1_1039 0 n2 ns1039 0 -0.00035618110521
Gc1_1040 0 n2 ns1040 0 -0.000375496395181
Gc1_1041 0 n2 ns1041 0 0.000386185329801
Gc1_1042 0 n2 ns1042 0 0.00116078282488
Gc1_1043 0 n2 ns1043 0 0.000852757651411
Gc1_1044 0 n2 ns1044 0 -1.49105619302e-05
Gc1_1045 0 n2 ns1045 0 0.000655506795716
Gc1_1046 0 n2 ns1046 0 0.000156345517826
Gc1_1047 0 n2 ns1047 0 0.000398494757664
Gc1_1048 0 n2 ns1048 0 0.000197021074084
Gc1_1049 0 n2 ns1049 0 -0.0009338439843
Gc1_1050 0 n2 ns1050 0 -0.00618632115167
Gc1_1051 0 n2 ns1051 0 -0.00115372409297
Gc1_1052 0 n2 ns1052 0 -0.00566537387928
Gc1_1053 0 n2 ns1053 0 -0.00143909406262
Gc1_1054 0 n2 ns1054 0 0.00104369591879
Gc1_1055 0 n2 ns1055 0 2.81957737049e-05
Gc1_1056 0 n2 ns1056 0 -0.000880591977274
Gc1_1057 0 n2 ns1057 0 0.000152271663219
Gc1_1058 0 n2 ns1058 0 -0.00200687111663
Gc1_1059 0 n2 ns1059 0 0.000364495941211
Gc1_1060 0 n2 ns1060 0 -0.00110963322632
Gc1_1061 0 n2 ns1061 0 -0.000523275167369
Gc1_1062 0 n2 ns1062 0 -7.74229142034e-06
Gc1_1063 0 n2 ns1063 0 7.48099172296e-05
Gc1_1064 0 n2 ns1064 0 4.61881331745e-07
Gc1_1065 0 n2 ns1065 0 -8.31752038143e-05
Gc1_1066 0 n2 ns1066 0 1.34689668897e-06
Gc1_1067 0 n2 ns1067 0 7.87960797442e-06
Gc1_1068 0 n2 ns1068 0 0.000323617204125
Gc1_1069 0 n2 ns1069 0 -3.15726665381e-05
Gc1_1070 0 n2 ns1070 0 0.000122332182459
Gc1_1071 0 n2 ns1071 0 0.000126499958312
Gc1_1072 0 n2 ns1072 0 2.3801364843e-05
Gc1_1073 0 n2 ns1073 0 0.000527509510182
Gc1_1074 0 n2 ns1074 0 -0.000333294193955
Gc1_1075 0 n2 ns1075 0 -0.000150339887699
Gc1_1076 0 n2 ns1076 0 0.000118699040218
Gc1_1077 0 n2 ns1077 0 -9.45643222433e-05
Gc1_1078 0 n2 ns1078 0 0.000556448312217
Gc1_1079 0 n2 ns1079 0 0.000927719425389
Gc1_1080 0 n2 ns1080 0 -9.22464597281e-05
Gc1_1081 0 n2 ns1081 0 0.000312620777715
Gc1_1082 0 n2 ns1082 0 -0.000715266736449
Gc1_1083 0 n2 ns1083 0 0.000233911800388
Gc1_1084 0 n2 ns1084 0 -0.000715424320254
Gc1_1085 0 n2 ns1085 0 0.000152400514897
Gc1_1086 0 n2 ns1086 0 -0.000571885643397
Gc1_1087 0 n2 ns1087 0 -0.00426914983032
Gc1_1088 0 n2 ns1088 0 -0.00355835045959
Gc1_1089 0 n2 ns1089 0 -0.00392148023704
Gc1_1090 0 n2 ns1090 0 -0.00305316824152
Gc1_1091 0 n2 ns1091 0 -0.000158629704668
Gc1_1092 0 n2 ns1092 0 0.00154294980942
Gc1_1093 0 n2 ns1093 0 -0.000248103707204
Gc1_1094 0 n2 ns1094 0 -0.000516041437051
Gc1_1095 0 n2 ns1095 0 -0.000774087942193
Gc1_1096 0 n2 ns1096 0 -0.00156127734541
Gc1_1097 0 n2 ns1097 0 -5.48814235404e-05
Gc1_1098 0 n2 ns1098 0 -0.000919168041333
Gc1_1099 0 n2 ns1099 0 -0.000309201393952
Gc1_1100 0 n2 ns1100 0 -2.74457320015e-06
Gc1_1101 0 n2 ns1101 0 6.73848726692e-05
Gc1_1102 0 n2 ns1102 0 1.13480748969e-05
Gc1_1103 0 n2 ns1103 0 -0.000702830395867
Gc1_1104 0 n2 ns1104 0 0.00130218654597
Gc1_1105 0 n2 ns1105 0 -0.00179526659916
Gc1_1106 0 n2 ns1106 0 0.00184008264272
Gc1_1107 0 n2 ns1107 0 -0.000237012235179
Gc1_1108 0 n2 ns1108 0 0.000684360962491
Gc1_1109 0 n2 ns1109 0 0.000168329570267
Gc1_1110 0 n2 ns1110 0 -0.000436149417137
Gc1_1111 0 n2 ns1111 0 -6.16709869971e-05
Gc1_1112 0 n2 ns1112 0 -0.000114316096923
Gc1_1113 0 n2 ns1113 0 9.31070660281e-05
Gc1_1114 0 n2 ns1114 0 0.000114905511042
Gc1_1115 0 n2 ns1115 0 0.000589267224356
Gc1_1116 0 n2 ns1116 0 -0.000349277373835
Gc1_1117 0 n2 ns1117 0 0.000347010023952
Gc1_1118 0 n2 ns1118 0 -0.000740124317349
Gc1_1119 0 n2 ns1119 0 -0.000192825416948
Gc1_1120 0 n2 ns1120 0 -0.000483628477192
Gc1_1121 0 n2 ns1121 0 -0.000181339790347
Gc1_1122 0 n2 ns1122 0 -0.000432268642205
Gc1_1123 0 n2 ns1123 0 -0.000556556324253
Gc1_1124 0 n2 ns1124 0 -0.000163260497735
Gc1_1125 0 n2 ns1125 0 -0.00416921251288
Gc1_1126 0 n2 ns1126 0 0.000465076895563
Gc1_1127 0 n2 ns1127 0 -0.00362933618743
Gc1_1128 0 n2 ns1128 0 0.00047196277825
Gc1_1129 0 n2 ns1129 0 0.000430724619885
Gc1_1130 0 n2 ns1130 0 0.00131487988482
Gc1_1131 0 n2 ns1131 0 -0.00025389799285
Gc1_1132 0 n2 ns1132 0 -0.000274624389861
Gc1_1133 0 n2 ns1133 0 -0.000877400042931
Gc1_1134 0 n2 ns1134 0 -0.00104148340741
Gc1_1135 0 n2 ns1135 0 -0.000121926636108
Gc1_1136 0 n2 ns1136 0 -0.000663144362135
Gc1_1137 0 n2 ns1137 0 -0.00020147974049
Gc1_1138 0 n2 ns1138 0 2.47181573315e-06
Gc1_1139 0 n2 ns1139 0 6.62689940028e-05
Gc1_1140 0 n2 ns1140 0 -7.67182228287e-06
Gc1_1141 0 n2 ns1141 0 0.000303822010324
Gc1_1142 0 n2 ns1142 0 -0.000319738995813
Gc1_1143 0 n2 ns1143 0 0.000714457670918
Gc1_1144 0 n2 ns1144 0 -0.000518263666799
Gc1_1145 0 n2 ns1145 0 0.00016834696514
Gc1_1146 0 n2 ns1146 0 -0.000220015153989
Gc1_1147 0 n2 ns1147 0 -0.000149618415617
Gc1_1148 0 n2 ns1148 0 9.98079287091e-05
Gc1_1149 0 n2 ns1149 0 -0.000267871218881
Gc1_1150 0 n2 ns1150 0 -3.98688022316e-06
Gc1_1151 0 n2 ns1151 0 8.43103251776e-05
Gc1_1152 0 n2 ns1152 0 9.58848021556e-06
Gc1_1153 0 n2 ns1153 0 6.88628797475e-05
Gc1_1154 0 n2 ns1154 0 -0.000152191261604
Gc1_1155 0 n2 ns1155 0 -0.000369637817349
Gc1_1156 0 n2 ns1156 0 -0.000118210877203
Gc1_1157 0 n2 ns1157 0 -0.000368652353076
Gc1_1158 0 n2 ns1158 0 9.49706855938e-05
Gc1_1159 0 n2 ns1159 0 -0.000456825135799
Gc1_1160 0 n2 ns1160 0 0.000181093241349
Gc1_1161 0 n2 ns1161 0 -0.00033863634277
Gc1_1162 0 n2 ns1162 0 -4.14452953045e-05
Gc1_1163 0 n2 ns1163 0 -0.00148733529098
Gc1_1164 0 n2 ns1164 0 0.00129995389103
Gc1_1165 0 n2 ns1165 0 -0.00127140974557
Gc1_1166 0 n2 ns1166 0 0.00116844053369
Gc1_1167 0 n2 ns1167 0 0.000431641344721
Gc1_1168 0 n2 ns1168 0 0.00033201878407
Gc1_1169 0 n2 ns1169 0 -0.000145350332993
Gc1_1170 0 n2 ns1170 0 -7.23104193542e-05
Gc1_1171 0 n2 ns1171 0 -0.000568248439602
Gc1_1172 0 n2 ns1172 0 -0.000212541503127
Gc1_1173 0 n2 ns1173 0 -7.13412666867e-05
Gc1_1174 0 n2 ns1174 0 -0.000130244027133
Gc1_1175 0 n2 ns1175 0 -6.48131783503e-05
Gc1_1176 0 n2 ns1176 0 -1.16969567711e-05
Gc1_1177 0 n2 ns1177 0 2.04616220745e-05
Gc1_1178 0 n2 ns1178 0 7.86963325851e-06
Gc1_1179 0 n2 ns1179 0 0.000111247231431
Gc1_1180 0 n2 ns1180 0 0.000562833981712
Gc1_1181 0 n2 ns1181 0 0.000645311491181
Gc1_1182 0 n2 ns1182 0 0.000779890200672
Gc1_1183 0 n2 ns1183 0 5.83245631382e-05
Gc1_1184 0 n2 ns1184 0 0.000257201054539
Gc1_1185 0 n2 ns1185 0 -1.73702196937e-05
Gc1_1186 0 n2 ns1186 0 -0.000101928569401
Gc1_1187 0 n2 ns1187 0 0.000200196352807
Gc1_1188 0 n2 ns1188 0 0.000250191454724
Gc1_1189 0 n2 ns1189 0 3.89590322945e-05
Gc1_1190 0 n2 ns1190 0 -0.000115358826103
Gc1_1191 0 n2 ns1191 0 -0.000407519868614
Gc1_1192 0 n2 ns1192 0 -0.000467006323458
Gc1_1193 0 n2 ns1193 0 -0.000194523452329
Gc1_1194 0 n2 ns1194 0 -0.000206285862573
Gc1_1195 0 n2 ns1195 0 -5.06220135802e-05
Gc1_1196 0 n2 ns1196 0 -4.53282613509e-05
Gc1_1197 0 n2 ns1197 0 4.39378751645e-05
Gc1_1198 0 n2 ns1198 0 -0.000120791536996
Gc1_1199 0 n2 ns1199 0 5.82958374475e-05
Gc1_1200 0 n2 ns1200 0 0.000545606559082
Gc1_1201 0 n2 ns1201 0 8.49383145743e-05
Gc1_1202 0 n2 ns1202 0 0.00221422259316
Gc1_1203 0 n2 ns1203 0 8.27241291926e-05
Gc1_1204 0 n2 ns1204 0 0.00187141973358
Gc1_1205 0 n2 ns1205 0 0.000881955249339
Gc1_1206 0 n2 ns1206 0 0.000476664501839
Gc1_1207 0 n2 ns1207 0 -0.000152309931483
Gc1_1208 0 n2 ns1208 0 -8.37368436635e-05
Gc1_1209 0 n2 ns1209 0 -0.000811264933435
Gc1_1210 0 n2 ns1210 0 -0.000529205887834
Gc1_1211 0 n2 ns1211 0 -0.000207539411095
Gc1_1212 0 n2 ns1212 0 -0.000897989673515
Gc1_1213 0 n2 ns1213 0 -0.000240164253557
Gc1_1214 0 n2 ns1214 0 1.22016024616e-05
Gc1_1215 0 n2 ns1215 0 -3.52673963199e-05
Gc1_1216 0 n2 ns1216 0 2.05513874664e-05
Gd1_1 0 n2 ni1 0 -0.00273215711331
Gd1_2 0 n2 ni2 0 -0.00298142341207
Gd1_3 0 n2 ni3 0 -0.00164082235846
Gd1_4 0 n2 ni4 0 0.000103411683779
Gd1_5 0 n2 ni5 0 2.03180791744e-05
Gd1_6 0 n2 ni6 0 0.00022558955716
Gd1_7 0 n2 ni7 0 -0.000389099767392
Gd1_8 0 n2 ni8 0 -6.00321594437e-05
Gd1_9 0 n2 ni9 0 -0.00032995404557
Gd1_10 0 n2 ni10 0 -0.00235573319829
Gd1_11 0 n2 ni11 0 -0.000270409684626
Gd1_12 0 n2 ni12 0 -4.02835663378e-05
Gd1_13 0 n2 ni13 0 0.000189811728009
Gd1_14 0 n2 ni14 0 -0.000437042198426
Gd1_15 0 n2 ni15 0 -4.25222473322e-05
Gd1_16 0 n2 ni16 0 -0.000107812457767
Gd1_17 0 n2 ni17 0 0.000750056202305
Gd1_18 0 n2 ni18 0 -0.00362329520257
Gd1_19 0 n2 ni19 0 0.000716684275031
Gd1_20 0 n2 ni20 0 0.000267725651273
Gd1_21 0 n2 ni21 0 -0.000335965851981
Gd1_22 0 n2 ni22 0 0.000540084451516
Gd1_23 0 n2 ni23 0 0.00100866542727
Gd1_24 0 n2 ni24 0 -0.000440998306448
Gd1_25 0 n2 ni25 0 0.000584750907206
Gd1_26 0 n2 ni26 0 0.000108560418385
Gd1_27 0 n2 ni27 0 0.000507782259855
Gd1_28 0 n2 ni28 0 3.85954237032e-05
Gd1_29 0 n2 ni29 0 9.08849240255e-05
Gd1_30 0 n2 ni30 0 0.00137664268094
Gd1_31 0 n2 ni31 0 -0.000449140945268
Gd1_32 0 n2 ni32 0 0.000213955283349
Gc2_1 0 n4 ns1 0 0.00202298941377
Gc2_2 0 n4 ns2 0 -0.00557715149074
Gc2_3 0 n4 ns3 0 0.0017227471045
Gc2_4 0 n4 ns4 0 -0.00415045461781
Gc2_5 0 n4 ns5 0 -0.000805370755493
Gc2_6 0 n4 ns6 0 -0.000934828893377
Gc2_7 0 n4 ns7 0 0.000595408924715
Gc2_8 0 n4 ns8 0 0.000117237653257
Gc2_9 0 n4 ns9 0 -0.000112191057965
Gc2_10 0 n4 ns10 0 0.000421081845465
Gc2_11 0 n4 ns11 0 4.25211710142e-05
Gc2_12 0 n4 ns12 0 7.8597183773e-05
Gc2_13 0 n4 ns13 0 -0.00090696543256
Gc2_14 0 n4 ns14 0 0.000278485926771
Gc2_15 0 n4 ns15 0 0.000464858056958
Gc2_16 0 n4 ns16 0 -3.45908370921e-05
Gc2_17 0 n4 ns17 0 -4.79420706539e-05
Gc2_18 0 n4 ns18 0 0.000166977759487
Gc2_19 0 n4 ns19 0 -0.000457004669163
Gc2_20 0 n4 ns20 0 -0.000647169666655
Gc2_21 0 n4 ns21 0 -0.000521419246844
Gc2_22 0 n4 ns22 0 0.00114439785404
Gc2_23 0 n4 ns23 0 0.00599132534349
Gc2_24 0 n4 ns24 0 0.00370608412382
Gc2_25 0 n4 ns25 0 0.00404434754889
Gc2_26 0 n4 ns26 0 0.00347242929462
Gc2_27 0 n4 ns27 0 0.0034131531246
Gc2_28 0 n4 ns28 0 0.00626780524889
Gc2_29 0 n4 ns29 0 0.000731543410666
Gc2_30 0 n4 ns30 0 -0.000159822303257
Gc2_31 0 n4 ns31 0 -0.00747649636185
Gc2_32 0 n4 ns32 0 -0.000996730837891
Gc2_33 0 n4 ns33 0 0.00384113286903
Gc2_34 0 n4 ns34 0 -0.00795995295198
Gc2_35 0 n4 ns35 0 0.00388304027689
Gc2_36 0 n4 ns36 0 7.88027835621e-06
Gc2_37 0 n4 ns37 0 -0.000137401363015
Gc2_38 0 n4 ns38 0 2.60407580391e-05
Gc2_39 0 n4 ns39 0 0.00112979543442
Gc2_40 0 n4 ns40 0 -0.00338209133843
Gc2_41 0 n4 ns41 0 -0.000152156391365
Gc2_42 0 n4 ns42 0 -0.00227057584575
Gc2_43 0 n4 ns43 0 -0.000774697128701
Gc2_44 0 n4 ns44 0 -0.000810688414504
Gc2_45 0 n4 ns45 0 0.000481626287889
Gc2_46 0 n4 ns46 0 9.80787040031e-05
Gc2_47 0 n4 ns47 0 -0.000117324056755
Gc2_48 0 n4 ns48 0 0.000502200635742
Gc2_49 0 n4 ns49 0 0.000103641094154
Gc2_50 0 n4 ns50 0 0.000147057235613
Gc2_51 0 n4 ns51 0 -0.000530414133473
Gc2_52 0 n4 ns52 0 0.000317711699118
Gc2_53 0 n4 ns53 0 0.000677217921224
Gc2_54 0 n4 ns54 0 -5.49949993937e-05
Gc2_55 0 n4 ns55 0 0.000163479975898
Gc2_56 0 n4 ns56 0 0.000370154819039
Gc2_57 0 n4 ns57 0 -0.000280890359809
Gc2_58 0 n4 ns58 0 -0.000333441233271
Gc2_59 0 n4 ns59 0 -0.000628496340184
Gc2_60 0 n4 ns60 0 0.00119566615264
Gc2_61 0 n4 ns61 0 0.00499627229409
Gc2_62 0 n4 ns62 0 0.00239651558888
Gc2_63 0 n4 ns63 0 0.00316354455224
Gc2_64 0 n4 ns64 0 0.00254078607752
Gc2_65 0 n4 ns65 0 0.00325076938537
Gc2_66 0 n4 ns66 0 0.00523813776977
Gc2_67 0 n4 ns67 0 0.00107932837585
Gc2_68 0 n4 ns68 0 -0.000145240129955
Gc2_69 0 n4 ns69 0 -0.00628601198476
Gc2_70 0 n4 ns70 0 -0.000350875717551
Gc2_71 0 n4 ns71 0 0.00286829109863
Gc2_72 0 n4 ns72 0 -0.00583324470735
Gc2_73 0 n4 ns73 0 0.00448443254542
Gc2_74 0 n4 ns74 0 -4.66887125943e-06
Gc2_75 0 n4 ns75 0 9.37287594627e-05
Gc2_76 0 n4 ns76 0 -0.000158381807989
Gc2_77 0 n4 ns77 0 0.00045138268595
Gc2_78 0 n4 ns78 0 -0.00214858303585
Gc2_79 0 n4 ns79 0 0.000623957315169
Gc2_80 0 n4 ns80 0 -0.000748452704854
Gc2_81 0 n4 ns81 0 -0.000921823386142
Gc2_82 0 n4 ns82 0 0.000251815219665
Gc2_83 0 n4 ns83 0 0.000308096263788
Gc2_84 0 n4 ns84 0 -0.000361219218561
Gc2_85 0 n4 ns85 0 0.000569685857209
Gc2_86 0 n4 ns86 0 0.000291664116577
Gc2_87 0 n4 ns87 0 0.000189500870035
Gc2_88 0 n4 ns88 0 0.000110466957091
Gc2_89 0 n4 ns89 0 -0.000148577141952
Gc2_90 0 n4 ns90 0 7.65203464953e-05
Gc2_91 0 n4 ns91 0 1.73036624261e-05
Gc2_92 0 n4 ns92 0 -0.0010273871005
Gc2_93 0 n4 ns93 0 0.000715004376475
Gc2_94 0 n4 ns94 0 7.626986936e-05
Gc2_95 0 n4 ns95 0 0.000461039781089
Gc2_96 0 n4 ns96 0 -0.000557043812633
Gc2_97 0 n4 ns97 0 0.00128259935138
Gc2_98 0 n4 ns98 0 0.00163315906042
Gc2_99 0 n4 ns99 0 -0.000688333955658
Gc2_100 0 n4 ns100 0 0.00249929479694
Gc2_101 0 n4 ns101 0 -0.00116596256479
Gc2_102 0 n4 ns102 0 0.00304631144954
Gc2_103 0 n4 ns103 0 0.00348090135943
Gc2_104 0 n4 ns104 0 -0.000739361683714
Gc2_105 0 n4 ns105 0 0.00127462696325
Gc2_106 0 n4 ns106 0 -0.000746089962548
Gc2_107 0 n4 ns107 0 -0.000898098661421
Gc2_108 0 n4 ns108 0 -0.00048474975146
Gc2_109 0 n4 ns109 0 -0.00373858706876
Gc2_110 0 n4 ns110 0 5.27370555422e-05
Gc2_111 0 n4 ns111 0 0.00319803040948
Gc2_112 0 n4 ns112 0 4.25683755043e-05
Gc2_113 0 n4 ns113 0 -0.000248050177298
Gc2_114 0 n4 ns114 0 8.45311128168e-05
Gc2_115 0 n4 ns115 0 0.000451347784873
Gc2_116 0 n4 ns116 0 -0.00137734386235
Gc2_117 0 n4 ns117 0 0.00113000701191
Gc2_118 0 n4 ns118 0 -0.000828737520564
Gc2_119 0 n4 ns119 0 -6.4478819122e-05
Gc2_120 0 n4 ns120 0 0.00012248496426
Gc2_121 0 n4 ns121 0 -5.43277636478e-05
Gc2_122 0 n4 ns122 0 -6.0263787488e-06
Gc2_123 0 n4 ns123 0 0.000264451314773
Gc2_124 0 n4 ns124 0 -0.000636946063942
Gc2_125 0 n4 ns125 0 0.00017799298229
Gc2_126 0 n4 ns126 0 4.80023927421e-05
Gc2_127 0 n4 ns127 0 -3.15707856471e-05
Gc2_128 0 n4 ns128 0 0.000131960500205
Gc2_129 0 n4 ns129 0 -0.00112601272865
Gc2_130 0 n4 ns130 0 0.000491583144968
Gc2_131 0 n4 ns131 0 0.000405846678581
Gc2_132 0 n4 ns132 0 1.1124099284e-05
Gc2_133 0 n4 ns133 0 -0.000253764402492
Gc2_134 0 n4 ns134 0 -0.000363337553035
Gc2_135 0 n4 ns135 0 0.000722508205946
Gc2_136 0 n4 ns136 0 -0.00146034256842
Gc2_137 0 n4 ns137 0 -0.00102818055444
Gc2_138 0 n4 ns138 0 0.00281786401395
Gc2_139 0 n4 ns139 0 -0.000806923085328
Gc2_140 0 n4 ns140 0 0.00330708907226
Gc2_141 0 n4 ns141 0 -0.00213178110421
Gc2_142 0 n4 ns142 0 -0.00199426142718
Gc2_143 0 n4 ns143 0 0.000685492661108
Gc2_144 0 n4 ns144 0 -0.00102628911655
Gc2_145 0 n4 ns145 0 0.00123883574934
Gc2_146 0 n4 ns146 0 -0.00049316961394
Gc2_147 0 n4 ns147 0 -0.00122132558967
Gc2_148 0 n4 ns148 0 0.00296644894248
Gc2_149 0 n4 ns149 0 0.00159907360116
Gc2_150 0 n4 ns150 0 1.44752465747e-05
Gc2_151 0 n4 ns151 0 -0.000305263014606
Gc2_152 0 n4 ns152 0 0.000123496733868
Gc2_153 0 n4 ns153 0 -0.00016849231623
Gc2_154 0 n4 ns154 0 -0.000347856564091
Gc2_155 0 n4 ns155 0 -0.000470262956892
Gc2_156 0 n4 ns156 0 0.000281597602056
Gc2_157 0 n4 ns157 0 0.000147879090473
Gc2_158 0 n4 ns158 0 -4.10750609968e-05
Gc2_159 0 n4 ns159 0 7.34566576303e-06
Gc2_160 0 n4 ns160 0 -2.68854257392e-05
Gc2_161 0 n4 ns161 0 -0.000493298402026
Gc2_162 0 n4 ns162 0 -0.000305639944627
Gc2_163 0 n4 ns163 0 0.000169318275644
Gc2_164 0 n4 ns164 0 -7.55206654736e-05
Gc2_165 0 n4 ns165 0 1.25999028793e-05
Gc2_166 0 n4 ns166 0 7.91391066359e-05
Gc2_167 0 n4 ns167 0 0.000527064815124
Gc2_168 0 n4 ns168 0 0.00105188573634
Gc2_169 0 n4 ns169 0 0.000602342363987
Gc2_170 0 n4 ns170 0 -0.0002155343359
Gc2_171 0 n4 ns171 0 0.000174462463155
Gc2_172 0 n4 ns172 0 -9.43802281231e-06
Gc2_173 0 n4 ns173 0 -0.00101543974622
Gc2_174 0 n4 ns174 0 -0.00034889779878
Gc2_175 0 n4 ns175 0 0.00105419059712
Gc2_176 0 n4 ns176 0 0.00443046971639
Gc2_177 0 n4 ns177 0 0.00134703419286
Gc2_178 0 n4 ns178 0 0.00416274331062
Gc2_179 0 n4 ns179 0 -0.00162596468254
Gc2_180 0 n4 ns180 0 0.00066293676304
Gc2_181 0 n4 ns181 0 -2.5250896641e-05
Gc2_182 0 n4 ns182 0 -0.0008220631001
Gc2_183 0 n4 ns183 0 2.13616037316e-05
Gc2_184 0 n4 ns184 0 -0.00145231004
Gc2_185 0 n4 ns185 0 -0.000507107551334
Gc2_186 0 n4 ns186 0 0.00100740539939
Gc2_187 0 n4 ns187 0 0.000567617121974
Gc2_188 0 n4 ns188 0 -8.66716062858e-06
Gc2_189 0 n4 ns189 0 -0.000122061111298
Gc2_190 0 n4 ns190 0 2.62186025174e-06
Gc2_191 0 n4 ns191 0 -3.50799494229e-05
Gc2_192 0 n4 ns192 0 0.00018905459992
Gc2_193 0 n4 ns193 0 7.81793868921e-05
Gc2_194 0 n4 ns194 0 0.00121043202528
Gc2_195 0 n4 ns195 0 2.32755227327e-05
Gc2_196 0 n4 ns196 0 0.000191284850399
Gc2_197 0 n4 ns197 0 -9.06113336346e-05
Gc2_198 0 n4 ns198 0 -0.000156449455373
Gc2_199 0 n4 ns199 0 -0.000231278483455
Gc2_200 0 n4 ns200 0 0.000399365711636
Gc2_201 0 n4 ns201 0 6.69262329499e-05
Gc2_202 0 n4 ns202 0 -0.000163346453958
Gc2_203 0 n4 ns203 0 5.08340554893e-05
Gc2_204 0 n4 ns204 0 -0.000358099269887
Gc2_205 0 n4 ns205 0 0.000964304567071
Gc2_206 0 n4 ns206 0 -0.00055769917515
Gc2_207 0 n4 ns207 0 0.000282951787564
Gc2_208 0 n4 ns208 0 -0.000832447790248
Gc2_209 0 n4 ns209 0 0.000394393297116
Gc2_210 0 n4 ns210 0 -0.000792516195598
Gc2_211 0 n4 ns211 0 1.4250890587e-05
Gc2_212 0 n4 ns212 0 0.00113451269799
Gc2_213 0 n4 ns213 0 0.00400165973915
Gc2_214 0 n4 ns214 0 0.0034816297119
Gc2_215 0 n4 ns215 0 0.00370915434158
Gc2_216 0 n4 ns216 0 0.00289979540305
Gc2_217 0 n4 ns217 0 0.000488293256583
Gc2_218 0 n4 ns218 0 0.00119547887294
Gc2_219 0 n4 ns219 0 -0.000323374691287
Gc2_220 0 n4 ns220 0 -0.000462742573466
Gc2_221 0 n4 ns221 0 -0.00130416424236
Gc2_222 0 n4 ns222 0 -0.0013484408199
Gc2_223 0 n4 ns223 0 -0.000627613081842
Gc2_224 0 n4 ns224 0 -0.000565139769505
Gc2_225 0 n4 ns225 0 6.06573766255e-05
Gc2_226 0 n4 ns226 0 1.38575314038e-05
Gc2_227 0 n4 ns227 0 -6.34534466962e-05
Gc2_228 0 n4 ns228 0 -2.82148977589e-06
Gc2_229 0 n4 ns229 0 0.000149141154058
Gc2_230 0 n4 ns230 0 0.000337007902549
Gc2_231 0 n4 ns231 0 0.000691260735186
Gc2_232 0 n4 ns232 0 0.000344104548396
Gc2_233 0 n4 ns233 0 -3.78042105985e-05
Gc2_234 0 n4 ns234 0 9.07878652427e-05
Gc2_235 0 n4 ns235 0 9.35641504393e-06
Gc2_236 0 n4 ns236 0 1.12107334214e-05
Gc2_237 0 n4 ns237 0 0.000217561554159
Gc2_238 0 n4 ns238 0 0.000312208881771
Gc2_239 0 n4 ns239 0 -4.10047289518e-05
Gc2_240 0 n4 ns240 0 -9.05952922251e-05
Gc2_241 0 n4 ns241 0 -0.000179584952332
Gc2_242 0 n4 ns242 0 -0.000344339080203
Gc2_243 0 n4 ns243 0 -4.99477154495e-05
Gc2_244 0 n4 ns244 0 -0.000799925430098
Gc2_245 0 n4 ns245 0 -0.000315778259339
Gc2_246 0 n4 ns246 0 -0.000500961308832
Gc2_247 0 n4 ns247 0 -0.000261119964847
Gc2_248 0 n4 ns248 0 -0.00062293732057
Gc2_249 0 n4 ns249 0 0.000643945260805
Gc2_250 0 n4 ns250 0 0.000444929888653
Gc2_251 0 n4 ns251 0 0.00315980705074
Gc2_252 0 n4 ns252 0 -0.00018736376937
Gc2_253 0 n4 ns253 0 0.00276530961709
Gc2_254 0 n4 ns254 0 -0.000285458615732
Gc2_255 0 n4 ns255 0 0.000580523230552
Gc2_256 0 n4 ns256 0 0.000499054658153
Gc2_257 0 n4 ns257 0 -0.000239809372427
Gc2_258 0 n4 ns258 0 -0.000176703451445
Gc2_259 0 n4 ns259 0 -0.000987775889154
Gc2_260 0 n4 ns260 0 -0.000490684257952
Gc2_261 0 n4 ns261 0 -0.000405426531272
Gc2_262 0 n4 ns262 0 -0.000245508034345
Gc2_263 0 n4 ns263 0 4.93681605308e-05
Gc2_264 0 n4 ns264 0 1.23571735484e-05
Gc2_265 0 n4 ns265 0 -1.23583399264e-05
Gc2_266 0 n4 ns266 0 -1.11022626186e-05
Gc2_267 0 n4 ns267 0 0.000103257280549
Gc2_268 0 n4 ns268 0 0.000229176978867
Gc2_269 0 n4 ns269 0 0.000485950816671
Gc2_270 0 n4 ns270 0 -0.00044877639458
Gc2_271 0 n4 ns271 0 -5.44996256032e-05
Gc2_272 0 n4 ns272 0 2.1737379262e-06
Gc2_273 0 n4 ns273 0 8.50636058241e-05
Gc2_274 0 n4 ns274 0 -5.13468243315e-06
Gc2_275 0 n4 ns275 0 0.000205707200057
Gc2_276 0 n4 ns276 0 -4.26872863815e-05
Gc2_277 0 n4 ns277 0 -5.13967527828e-05
Gc2_278 0 n4 ns278 0 -1.47206717729e-06
Gc2_279 0 n4 ns279 0 -0.000218317018267
Gc2_280 0 n4 ns280 0 1.08814354433e-05
Gc2_281 0 n4 ns281 0 -0.000386685797076
Gc2_282 0 n4 ns282 0 -0.000123193968456
Gc2_283 0 n4 ns283 0 -0.000308598613878
Gc2_284 0 n4 ns284 0 4.78198441118e-05
Gc2_285 0 n4 ns285 0 -0.000362189218107
Gc2_286 0 n4 ns286 0 2.38745444646e-05
Gc2_287 0 n4 ns287 0 0.000266153764093
Gc2_288 0 n4 ns288 0 -0.000172137060967
Gc2_289 0 n4 ns289 0 0.000704034288277
Gc2_290 0 n4 ns290 0 -0.00147016165196
Gc2_291 0 n4 ns291 0 0.000595165740058
Gc2_292 0 n4 ns292 0 -0.00130829448141
Gc2_293 0 n4 ns293 0 0.000175307780974
Gc2_294 0 n4 ns294 0 0.000268055427847
Gc2_295 0 n4 ns295 0 -0.000125578477976
Gc2_296 0 n4 ns296 0 -7.71738056765e-05
Gc2_297 0 n4 ns297 0 -0.000451401666156
Gc2_298 0 n4 ns298 0 -0.000170262364408
Gc2_299 0 n4 ns299 0 -0.000181570252734
Gc2_300 0 n4 ns300 0 5.17930149254e-05
Gc2_301 0 n4 ns301 0 7.41509103765e-05
Gc2_302 0 n4 ns302 0 1.02050212482e-05
Gc2_303 0 n4 ns303 0 1.77119952827e-05
Gc2_304 0 n4 ns304 0 -3.25481237512e-05
Gc2_305 0 n4 ns305 0 0.000175635217073
Gc2_306 0 n4 ns306 0 4.90065043019e-05
Gc2_307 0 n4 ns307 0 0.000589869925136
Gc2_308 0 n4 ns308 0 -0.000187193906103
Gc2_309 0 n4 ns309 0 6.11740506754e-05
Gc2_310 0 n4 ns310 0 7.02046485093e-06
Gc2_311 0 n4 ns311 0 3.35339074487e-07
Gc2_312 0 n4 ns312 0 -4.82245520852e-05
Gc2_313 0 n4 ns313 0 6.93578231422e-05
Gc2_314 0 n4 ns314 0 -0.000130197914996
Gc2_315 0 n4 ns315 0 -1.9368735811e-05
Gc2_316 0 n4 ns316 0 1.7789763336e-05
Gc2_317 0 n4 ns317 0 -0.000118037497688
Gc2_318 0 n4 ns318 0 7.13245031125e-05
Gc2_319 0 n4 ns319 0 -0.000149695834122
Gc2_320 0 n4 ns320 0 4.32152225652e-05
Gc2_321 0 n4 ns321 0 -5.37374102739e-05
Gc2_322 0 n4 ns322 0 7.99211862382e-05
Gc2_323 0 n4 ns323 0 -4.77789316161e-05
Gc2_324 0 n4 ns324 0 6.19882090728e-05
Gc2_325 0 n4 ns325 0 6.19740136912e-05
Gc2_326 0 n4 ns326 0 -4.51513536759e-05
Gc2_327 0 n4 ns327 0 -0.000203089649104
Gc2_328 0 n4 ns328 0 -0.00064672846998
Gc2_329 0 n4 ns329 0 -0.000182911468454
Gc2_330 0 n4 ns330 0 -0.000580961171375
Gc2_331 0 n4 ns331 0 0.000195131182222
Gc2_332 0 n4 ns332 0 0.000440326128404
Gc2_333 0 n4 ns333 0 -7.70603512955e-05
Gc2_334 0 n4 ns334 0 -9.26055729573e-05
Gc2_335 0 n4 ns335 0 -0.000338370000918
Gc2_336 0 n4 ns336 0 -0.000416797495256
Gc2_337 0 n4 ns337 0 -0.00017186029286
Gc2_338 0 n4 ns338 0 -0.00036077418078
Gc2_339 0 n4 ns339 0 -2.65921173658e-05
Gc2_340 0 n4 ns340 0 1.88024301445e-05
Gc2_341 0 n4 ns341 0 -3.58522824253e-05
Gc2_342 0 n4 ns342 0 1.11827098872e-05
Gc2_343 0 n4 ns343 0 0.00138043558036
Gc2_344 0 n4 ns344 0 -0.0045725897116
Gc2_345 0 n4 ns345 0 0.00159546037151
Gc2_346 0 n4 ns346 0 -0.00358036683863
Gc2_347 0 n4 ns347 0 -0.00135428984035
Gc2_348 0 n4 ns348 0 -0.000736439700126
Gc2_349 0 n4 ns349 0 0.000578962667732
Gc2_350 0 n4 ns350 0 -2.67498042306e-05
Gc2_351 0 n4 ns351 0 0.000376539903183
Gc2_352 0 n4 ns352 0 0.000603240314485
Gc2_353 0 n4 ns353 0 0.000148540407679
Gc2_354 0 n4 ns354 0 0.000115575202131
Gc2_355 0 n4 ns355 0 -0.000237237316926
Gc2_356 0 n4 ns356 0 0.000422214989683
Gc2_357 0 n4 ns357 0 0.000118795008533
Gc2_358 0 n4 ns358 0 -0.00126188911654
Gc2_359 0 n4 ns359 0 0.000467991170406
Gc2_360 0 n4 ns360 0 -5.8682761444e-06
Gc2_361 0 n4 ns361 0 0.000247243976687
Gc2_362 0 n4 ns362 0 -0.000843541195167
Gc2_363 0 n4 ns363 0 0.00158095544297
Gc2_364 0 n4 ns364 0 0.00164070399721
Gc2_365 0 n4 ns365 0 0.00257041070509
Gc2_366 0 n4 ns366 0 0.00322770081605
Gc2_367 0 n4 ns367 0 0.00125896169227
Gc2_368 0 n4 ns368 0 0.00350753812027
Gc2_369 0 n4 ns369 0 0.00343242434077
Gc2_370 0 n4 ns370 0 0.000715015319706
Gc2_371 0 n4 ns371 0 0.00128793381134
Gc2_372 0 n4 ns372 0 -0.000543398165975
Gc2_373 0 n4 ns373 0 -0.00347221856172
Gc2_374 0 n4 ns374 0 -0.000127756037331
Gc2_375 0 n4 ns375 0 -0.00058295244493
Gc2_376 0 n4 ns376 0 -0.00230507661823
Gc2_377 0 n4 ns377 0 0.00384634527164
Gc2_378 0 n4 ns378 0 9.4679128541e-06
Gc2_379 0 n4 ns379 0 -0.000158856417026
Gc2_380 0 n4 ns380 0 4.75640461992e-05
Gc2_381 0 n4 ns381 0 0.000767878408037
Gc2_382 0 n4 ns382 0 -0.00213773464691
Gc2_383 0 n4 ns383 0 0.00193652150818
Gc2_384 0 n4 ns384 0 -0.00160885591892
Gc2_385 0 n4 ns385 0 -0.000379280872443
Gc2_386 0 n4 ns386 0 -6.25418156999e-05
Gc2_387 0 n4 ns387 0 3.88149251324e-05
Gc2_388 0 n4 ns388 0 2.31488181508e-05
Gc2_389 0 n4 ns389 0 0.000553005449934
Gc2_390 0 n4 ns390 0 -0.000355680537589
Gc2_391 0 n4 ns391 0 0.000174480387314
Gc2_392 0 n4 ns392 0 7.61354233342e-05
Gc2_393 0 n4 ns393 0 -0.000128485035576
Gc2_394 0 n4 ns394 0 0.000203939202552
Gc2_395 0 n4 ns395 0 -0.00129930513794
Gc2_396 0 n4 ns396 0 -0.000256832195139
Gc2_397 0 n4 ns397 0 0.000376095693522
Gc2_398 0 n4 ns398 0 -9.34895822051e-06
Gc2_399 0 n4 ns399 0 -0.000240468473599
Gc2_400 0 n4 ns400 0 -0.000627953568873
Gc2_401 0 n4 ns401 0 0.00162044470522
Gc2_402 0 n4 ns402 0 -0.000909157799716
Gc2_403 0 n4 ns403 0 -0.000743273466149
Gc2_404 0 n4 ns404 0 0.00217126050102
Gc2_405 0 n4 ns405 0 -0.000804637471186
Gc2_406 0 n4 ns406 0 0.00286996706501
Gc2_407 0 n4 ns407 0 -0.000920060533643
Gc2_408 0 n4 ns408 0 -0.00260942233326
Gc2_409 0 n4 ns409 0 0.000980373203207
Gc2_410 0 n4 ns410 0 -0.000993535708162
Gc2_411 0 n4 ns411 0 0.00111356173871
Gc2_412 0 n4 ns412 0 -0.000190579322289
Gc2_413 0 n4 ns413 0 -0.00196220491948
Gc2_414 0 n4 ns414 0 0.00268218776202
Gc2_415 0 n4 ns415 0 0.00207708268156
Gc2_416 0 n4 ns416 0 1.34212123385e-05
Gc2_417 0 n4 ns417 0 -0.000279293684336
Gc2_418 0 n4 ns418 0 0.000108967052985
Gc2_419 0 n4 ns419 0 -0.000148647838229
Gc2_420 0 n4 ns420 0 -0.000587787467455
Gc2_421 0 n4 ns421 0 -0.000522528393372
Gc2_422 0 n4 ns422 0 -0.000307343293849
Gc2_423 0 n4 ns423 0 0.000102427234844
Gc2_424 0 n4 ns424 0 -9.51592251227e-05
Gc2_425 0 n4 ns425 0 2.61063691538e-05
Gc2_426 0 n4 ns426 0 9.92874426959e-05
Gc2_427 0 n4 ns427 0 -0.000362986361749
Gc2_428 0 n4 ns428 0 -0.000568163211229
Gc2_429 0 n4 ns429 0 0.000204999241461
Gc2_430 0 n4 ns430 0 -7.59663511931e-06
Gc2_431 0 n4 ns431 0 6.1246071281e-05
Gc2_432 0 n4 ns432 0 0.000159876099859
Gc2_433 0 n4 ns433 0 -0.000105287092449
Gc2_434 0 n4 ns434 0 0.00137470872431
Gc2_435 0 n4 ns435 0 0.000585136206232
Gc2_436 0 n4 ns436 0 4.43813180813e-05
Gc2_437 0 n4 ns437 0 -6.94365852474e-05
Gc2_438 0 n4 ns438 0 0.000160275708447
Gc2_439 0 n4 ns439 0 -0.00088021330886
Gc2_440 0 n4 ns440 0 -0.00115902718924
Gc2_441 0 n4 ns441 0 -0.000205181099928
Gc2_442 0 n4 ns442 0 0.00387029046323
Gc2_443 0 n4 ns443 0 0.000230032614302
Gc2_444 0 n4 ns444 0 0.00392653078449
Gc2_445 0 n4 ns445 0 -0.00244025042566
Gc2_446 0 n4 ns446 0 -0.000167046342064
Gc2_447 0 n4 ns447 0 0.000206217431011
Gc2_448 0 n4 ns448 0 -0.000925372447932
Gc2_449 0 n4 ns449 0 0.000739966553066
Gc2_450 0 n4 ns450 0 -0.00110085277748
Gc2_451 0 n4 ns451 0 -0.000509608110708
Gc2_452 0 n4 ns452 0 0.00199356785608
Gc2_453 0 n4 ns453 0 0.000915198334231
Gc2_454 0 n4 ns454 0 -9.38783699231e-06
Gc2_455 0 n4 ns455 0 -0.00014733299577
Gc2_456 0 n4 ns456 0 1.00638378862e-05
Gc2_457 0 n4 ns457 0 -0.00010311952662
Gc2_458 0 n4 ns458 0 -0.000145883449615
Gc2_459 0 n4 ns459 0 -0.000257670793958
Gc2_460 0 n4 ns460 0 0.000643132067553
Gc2_461 0 n4 ns461 0 4.55435817084e-05
Gc2_462 0 n4 ns462 0 -2.9935357106e-05
Gc2_463 0 n4 ns463 0 -5.74333326442e-05
Gc2_464 0 n4 ns464 0 -8.18740303506e-05
Gc2_465 0 n4 ns465 0 -0.000517797985437
Gc2_466 0 n4 ns466 0 0.000162638989897
Gc2_467 0 n4 ns467 0 0.000122352311713
Gc2_468 0 n4 ns468 0 -0.000132389790867
Gc2_469 0 n4 ns469 0 0.000172033866587
Gc2_470 0 n4 ns470 0 -9.68729084695e-05
Gc2_471 0 n4 ns471 0 0.00113446274404
Gc2_472 0 n4 ns472 0 8.68014061491e-05
Gc2_473 0 n4 ns473 0 0.000519467220182
Gc2_474 0 n4 ns474 0 -0.000663621278718
Gc2_475 0 n4 ns475 0 0.00047408886019
Gc2_476 0 n4 ns476 0 -0.000474503864296
Gc2_477 0 n4 ns477 0 -0.000530229980713
Gc2_478 0 n4 ns478 0 0.000843349838057
Gc2_479 0 n4 ns479 0 0.00325631855018
Gc2_480 0 n4 ns480 0 0.00434276778089
Gc2_481 0 n4 ns481 0 0.00317526892792
Gc2_482 0 n4 ns482 0 0.00375852103991
Gc2_483 0 n4 ns483 0 -0.000111474027261
Gc2_484 0 n4 ns484 0 0.00119923941896
Gc2_485 0 n4 ns485 0 -0.000273731693537
Gc2_486 0 n4 ns486 0 -0.000580111693623
Gc2_487 0 n4 ns487 0 -0.000993692864493
Gc2_488 0 n4 ns488 0 -0.00144422980372
Gc2_489 0 n4 ns489 0 -0.00059039973784
Gc2_490 0 n4 ns490 0 -0.000110842941303
Gc2_491 0 n4 ns491 0 0.000207247173548
Gc2_492 0 n4 ns492 0 3.19872707265e-06
Gc2_493 0 n4 ns493 0 -6.6028670738e-05
Gc2_494 0 n4 ns494 0 -1.53681493322e-05
Gc2_495 0 n4 ns495 0 0.000107707110243
Gc2_496 0 n4 ns496 0 0.000287102695033
Gc2_497 0 n4 ns497 0 0.000544248262369
Gc2_498 0 n4 ns498 0 0.000618360534514
Gc2_499 0 n4 ns499 0 -3.44959765018e-05
Gc2_500 0 n4 ns500 0 1.23828305151e-05
Gc2_501 0 n4 ns501 0 -3.25412157639e-05
Gc2_502 0 n4 ns502 0 5.46414811359e-05
Gc2_503 0 n4 ns503 0 4.14178287585e-05
Gc2_504 0 n4 ns504 0 0.000477551767188
Gc2_505 0 n4 ns505 0 -1.58936988341e-06
Gc2_506 0 n4 ns506 0 -0.000138441182098
Gc2_507 0 n4 ns507 0 -5.73950680444e-05
Gc2_508 0 n4 ns508 0 -0.000434933169482
Gc2_509 0 n4 ns509 0 0.000337332187048
Gc2_510 0 n4 ns510 0 -0.000919203030351
Gc2_511 0 n4 ns511 0 -0.000156188596517
Gc2_512 0 n4 ns512 0 -0.00073049039938
Gc2_513 0 n4 ns513 0 -4.94676417093e-05
Gc2_514 0 n4 ns514 0 -0.000825281937152
Gc2_515 0 n4 ns515 0 0.000591680721931
Gc2_516 0 n4 ns516 0 0.00078624097776
Gc2_517 0 n4 ns517 0 0.00407034493388
Gc2_518 0 n4 ns518 0 0.000956269196852
Gc2_519 0 n4 ns519 0 0.00361578464542
Gc2_520 0 n4 ns520 0 0.000679150077429
Gc2_521 0 n4 ns521 0 0.000647195023869
Gc2_522 0 n4 ns522 0 0.000701565626453
Gc2_523 0 n4 ns523 0 -0.000284588249791
Gc2_524 0 n4 ns524 0 -0.000258092750406
Gc2_525 0 n4 ns525 0 -0.00117036669512
Gc2_526 0 n4 ns526 0 -0.000736234675961
Gc2_527 0 n4 ns527 0 -0.000498911230245
Gc2_528 0 n4 ns528 0 -0.000381659552137
Gc2_529 0 n4 ns529 0 4.85552060996e-05
Gc2_530 0 n4 ns530 0 1.58672799034e-05
Gc2_531 0 n4 ns531 0 -3.14200631646e-05
Gc2_532 0 n4 ns532 0 -9.93457392755e-06
Gc2_533 0 n4 ns533 0 0.000150607914218
Gc2_534 0 n4 ns534 0 0.000306776710141
Gc2_535 0 n4 ns535 0 0.00068313179706
Gc2_536 0 n4 ns536 0 -0.000184674083793
Gc2_537 0 n4 ns537 0 8.94149043819e-06
Gc2_538 0 n4 ns538 0 4.28558319467e-05
Gc2_539 0 n4 ns539 0 3.25083668046e-05
Gc2_540 0 n4 ns540 0 1.04123384725e-05
Gc2_541 0 n4 ns541 0 0.000267328298218
Gc2_542 0 n4 ns542 0 5.903084295e-05
Gc2_543 0 n4 ns543 0 -6.35484837981e-05
Gc2_544 0 n4 ns544 0 -3.37226089405e-05
Gc2_545 0 n4 ns545 0 -0.000281158174881
Gc2_546 0 n4 ns546 0 -9.76793479283e-05
Gc2_547 0 n4 ns547 0 -0.000404133703564
Gc2_548 0 n4 ns548 0 -0.000365658598099
Gc2_549 0 n4 ns549 0 -0.000405174309389
Gc2_550 0 n4 ns550 0 -0.00011219038046
Gc2_551 0 n4 ns551 0 -0.000455129739254
Gc2_552 0 n4 ns552 0 -0.000178392508223
Gc2_553 0 n4 ns553 0 0.000451874065427
Gc2_554 0 n4 ns554 0 -7.4962339433e-05
Gc2_555 0 n4 ns555 0 0.00156871346154
Gc2_556 0 n4 ns556 0 -0.00145956053929
Gc2_557 0 n4 ns557 0 0.00134557704738
Gc2_558 0 n4 ns558 0 -0.0013240145338
Gc2_559 0 n4 ns559 0 0.000278945290735
Gc2_560 0 n4 ns560 0 0.00024138800958
Gc2_561 0 n4 ns561 0 -0.000161998784554
Gc2_562 0 n4 ns562 0 -8.54043020171e-05
Gc2_563 0 n4 ns563 0 -0.000604351735148
Gc2_564 0 n4 ns564 0 -0.000142805315164
Gc2_565 0 n4 ns565 0 -0.000236981604705
Gc2_566 0 n4 ns566 0 0.000122811574165
Gc2_567 0 n4 ns567 0 0.000104599517857
Gc2_568 0 n4 ns568 0 1.25380306629e-05
Gc2_569 0 n4 ns569 0 -1.67104303766e-05
Gc2_570 0 n4 ns570 0 -1.38625918853e-05
Gc2_571 0 n4 ns571 0 6.1467058357e-05
Gc2_572 0 n4 ns572 0 0.000179432110624
Gc2_573 0 n4 ns573 0 0.000361203714408
Gc2_574 0 n4 ns574 0 -0.000153432274649
Gc2_575 0 n4 ns575 0 1.98416650551e-05
Gc2_576 0 n4 ns576 0 3.28961080289e-05
Gc2_577 0 n4 ns577 0 3.07768714301e-05
Gc2_578 0 n4 ns578 0 -4.41042066724e-05
Gc2_579 0 n4 ns579 0 0.00010632075223
Gc2_580 0 n4 ns580 0 -0.000103336285238
Gc2_581 0 n4 ns581 0 -2.51335617468e-05
Gc2_582 0 n4 ns582 0 1.71559767632e-05
Gc2_583 0 n4 ns583 0 -0.00012279156084
Gc2_584 0 n4 ns584 0 4.65797832301e-05
Gc2_585 0 n4 ns585 0 -0.000214042629304
Gc2_586 0 n4 ns586 0 3.9686971458e-05
Gc2_587 0 n4 ns587 0 -0.000114087199651
Gc2_588 0 n4 ns588 0 0.000119491875346
Gc2_589 0 n4 ns589 0 -0.000115531396203
Gc2_590 0 n4 ns590 0 0.000124183064026
Gc2_591 0 n4 ns591 0 5.15845888802e-05
Gc2_592 0 n4 ns592 0 -8.86345558576e-05
Gc2_593 0 n4 ns593 0 -0.000185467218421
Gc2_594 0 n4 ns594 0 -0.00091187146383
Gc2_595 0 n4 ns595 0 -0.000165679108738
Gc2_596 0 n4 ns596 0 -0.000813620290203
Gc2_597 0 n4 ns597 0 0.000184854840554
Gc2_598 0 n4 ns598 0 0.000416803606957
Gc2_599 0 n4 ns599 0 -9.58409354739e-05
Gc2_600 0 n4 ns600 0 -8.44230989286e-05
Gc2_601 0 n4 ns601 0 -0.000364198240129
Gc2_602 0 n4 ns602 0 -0.000333267710618
Gc2_603 0 n4 ns603 0 -0.000158053553994
Gc2_604 0 n4 ns604 0 -0.000222603038054
Gc2_605 0 n4 ns605 0 2.43804780648e-06
Gc2_606 0 n4 ns606 0 1.18683058503e-05
Gc2_607 0 n4 ns607 0 -2.38456180003e-05
Gc2_608 0 n4 ns608 0 -3.43537384479e-06
Gc2_609 0 n4 ns609 0 0.00248240988367
Gc2_610 0 n4 ns610 0 -0.00368694375512
Gc2_611 0 n4 ns611 0 0.00494155853641
Gc2_612 0 n4 ns612 0 -0.0087021891956
Gc2_613 0 n4 ns613 0 -0.00376758810793
Gc2_614 0 n4 ns614 0 -0.00260130060093
Gc2_615 0 n4 ns615 0 0.00127129050457
Gc2_616 0 n4 ns616 0 0.000978234686766
Gc2_617 0 n4 ns617 0 -0.000358423856533
Gc2_618 0 n4 ns618 0 -0.000878490409459
Gc2_619 0 n4 ns619 0 -0.00011413171593
Gc2_620 0 n4 ns620 0 -0.000106249261565
Gc2_621 0 n4 ns621 0 -0.000992868452002
Gc2_622 0 n4 ns622 0 6.31412446486e-05
Gc2_623 0 n4 ns623 0 0.00167205483114
Gc2_624 0 n4 ns624 0 -3.98998542737e-05
Gc2_625 0 n4 ns625 0 0.000568578178421
Gc2_626 0 n4 ns626 0 0.000811144698683
Gc2_627 0 n4 ns627 0 0.0004205375235
Gc2_628 0 n4 ns628 0 0.00115508869245
Gc2_629 0 n4 ns629 0 0.000980703844773
Gc2_630 0 n4 ns630 0 -0.0041328166496
Gc2_631 0 n4 ns631 0 -0.000427421421769
Gc2_632 0 n4 ns632 0 -0.00482986773136
Gc2_633 0 n4 ns633 0 0.000358687163213
Gc2_634 0 n4 ns634 0 -0.00428071981192
Gc2_635 0 n4 ns635 0 0.00672524160364
Gc2_636 0 n4 ns636 0 0.0073988435715
Gc2_637 0 n4 ns637 0 0.000888763742912
Gc2_638 0 n4 ns638 0 -0.000280487618556
Gc2_639 0 n4 ns639 0 -0.0054868681455
Gc2_640 0 n4 ns640 0 -0.00358697321043
Gc2_641 0 n4 ns641 0 0.00102952788316
Gc2_642 0 n4 ns642 0 0.00888205542022
Gc2_643 0 n4 ns643 0 -0.00349451716143
Gc2_644 0 n4 ns644 0 5.27473266084e-06
Gc2_645 0 n4 ns645 0 0.00047085446853
Gc2_646 0 n4 ns646 0 -0.000308231473634
Gc2_647 0 n4 ns647 0 -0.000519312671819
Gc2_648 0 n4 ns648 0 -0.000168383847758
Gc2_649 0 n4 ns649 0 -0.000123263875703
Gc2_650 0 n4 ns650 0 0.00206771510709
Gc2_651 0 n4 ns651 0 0.0013319448531
Gc2_652 0 n4 ns652 0 -0.000933101361858
Gc2_653 0 n4 ns653 0 -0.000276530987861
Gc2_654 0 n4 ns654 0 0.000185226689297
Gc2_655 0 n4 ns655 0 5.00608476973e-05
Gc2_656 0 n4 ns656 0 -0.000129580276997
Gc2_657 0 n4 ns657 0 -2.64131951424e-05
Gc2_658 0 n4 ns658 0 -8.35133980074e-05
Gc2_659 0 n4 ns659 0 0.00181586866649
Gc2_660 0 n4 ns660 0 -0.000360961613292
Gc2_661 0 n4 ns661 0 -0.000231883131249
Gc2_662 0 n4 ns662 0 0.000920327833095
Gc2_663 0 n4 ns663 0 -0.000590670843307
Gc2_664 0 n4 ns664 0 0.000398156281826
Gc2_665 0 n4 ns665 0 -0.0017683150274
Gc2_666 0 n4 ns666 0 -0.00095286960433
Gc2_667 0 n4 ns667 0 0.0025562323953
Gc2_668 0 n4 ns668 0 0.00299524430897
Gc2_669 0 n4 ns669 0 -0.00896613178285
Gc2_670 0 n4 ns670 0 0.00314966709641
Gc2_671 0 n4 ns671 0 -0.00630524323352
Gc2_672 0 n4 ns672 0 0.00179509686457
Gc2_673 0 n4 ns673 0 -0.00951584265282
Gc2_674 0 n4 ns674 0 -0.00168507808967
Gc2_675 0 n4 ns675 0 0.00169411165338
Gc2_676 0 n4 ns676 0 0.000825142569657
Gc2_677 0 n4 ns677 0 -0.00344129620269
Gc2_678 0 n4 ns678 0 0.0108861809578
Gc2_679 0 n4 ns679 0 -0.0141313990657
Gc2_680 0 n4 ns680 0 -0.0012921537648
Gc2_681 0 n4 ns681 0 -0.00572162955648
Gc2_682 0 n4 ns682 0 -4.79852009911e-05
Gc2_683 0 n4 ns683 0 -0.000397744891155
Gc2_684 0 n4 ns684 0 0.000571072901845
Gc2_685 0 n4 ns685 0 -0.00111496004181
Gc2_686 0 n4 ns686 0 -0.000418499951943
Gc2_687 0 n4 ns687 0 -0.00431336875128
Gc2_688 0 n4 ns688 0 -0.00156475516817
Gc2_689 0 n4 ns689 0 -0.00204456709848
Gc2_690 0 n4 ns690 0 0.0010176146381
Gc2_691 0 n4 ns691 0 0.000963056534841
Gc2_692 0 n4 ns692 0 -0.000500076951833
Gc2_693 0 n4 ns693 0 -0.000800660230216
Gc2_694 0 n4 ns694 0 0.00023000420015
Gc2_695 0 n4 ns695 0 -0.000112654101829
Gc2_696 0 n4 ns696 0 -5.97497840088e-05
Gc2_697 0 n4 ns697 0 0.000952765872439
Gc2_698 0 n4 ns698 0 -1.99084103635e-05
Gc2_699 0 n4 ns699 0 0.000262805108067
Gc2_700 0 n4 ns700 0 -0.000910405154435
Gc2_701 0 n4 ns701 0 0.000892503199287
Gc2_702 0 n4 ns702 0 0.000271409096655
Gc2_703 0 n4 ns703 0 0.00078344074569
Gc2_704 0 n4 ns704 0 -7.9514372434e-05
Gc2_705 0 n4 ns705 0 -0.00233009978448
Gc2_706 0 n4 ns706 0 -0.000452043313524
Gc2_707 0 n4 ns707 0 -0.00162732691746
Gc2_708 0 n4 ns708 0 -0.000700924876679
Gc2_709 0 n4 ns709 0 -0.000716919582372
Gc2_710 0 n4 ns710 0 -0.00152557444543
Gc2_711 0 n4 ns711 0 0.00302039236047
Gc2_712 0 n4 ns712 0 0.000168330807177
Gc2_713 0 n4 ns713 0 0.00131690238691
Gc2_714 0 n4 ns714 0 -0.00089493063933
Gc2_715 0 n4 ns715 0 -0.000759355184632
Gc2_716 0 n4 ns716 0 -0.00160131854422
Gc2_717 0 n4 ns717 0 0.00292573127731
Gc2_718 0 n4 ns718 0 0.00025615090994
Gc2_719 0 n4 ns719 0 -0.00313050152683
Gc2_720 0 n4 ns720 0 -2.91810126204e-05
Gc2_721 0 n4 ns721 0 0.000391462585391
Gc2_722 0 n4 ns722 0 -0.000226824396969
Gc2_723 0 n4 ns723 0 -0.000381498276459
Gc2_724 0 n4 ns724 0 -7.54662793285e-05
Gc2_725 0 n4 ns725 0 -0.00105130680608
Gc2_726 0 n4 ns726 0 0.00183969720328
Gc2_727 0 n4 ns727 0 -7.87506830052e-05
Gc2_728 0 n4 ns728 0 0.000249009320023
Gc2_729 0 n4 ns729 0 1.5833253909e-05
Gc2_730 0 n4 ns730 0 -0.000203390171598
Gc2_731 0 n4 ns731 0 -0.000259519186237
Gc2_732 0 n4 ns732 0 0.000822038329353
Gc2_733 0 n4 ns733 0 -0.000113417434413
Gc2_734 0 n4 ns734 0 -3.37185014035e-05
Gc2_735 0 n4 ns735 0 0.000526403031115
Gc2_736 0 n4 ns736 0 -0.000760111390513
Gc2_737 0 n4 ns737 0 -0.000555018758085
Gc2_738 0 n4 ns738 0 0.000390178440692
Gc2_739 0 n4 ns739 0 0.000753583531444
Gc2_740 0 n4 ns740 0 7.94997121972e-05
Gc2_741 0 n4 ns741 0 0.000325948053195
Gc2_742 0 n4 ns742 0 -7.45804017611e-05
Gc2_743 0 n4 ns743 0 -0.000665722129962
Gc2_744 0 n4 ns744 0 0.00121919267036
Gc2_745 0 n4 ns745 0 0.00103495727545
Gc2_746 0 n4 ns746 0 -0.00333838312974
Gc2_747 0 n4 ns747 0 0.000794811979536
Gc2_748 0 n4 ns748 0 -0.00374402795202
Gc2_749 0 n4 ns749 0 -0.00112062464102
Gc2_750 0 n4 ns750 0 -0.00023226371984
Gc2_751 0 n4 ns751 0 0.000592082568247
Gc2_752 0 n4 ns752 0 -0.0012339883301
Gc2_753 0 n4 ns753 0 0.000855457874449
Gc2_754 0 n4 ns754 0 -0.00220997009413
Gc2_755 0 n4 ns755 0 0.00132935197588
Gc2_756 0 n4 ns756 0 -0.00255494919981
Gc2_757 0 n4 ns757 0 -0.00146932374326
Gc2_758 0 n4 ns758 0 -2.24733091412e-05
Gc2_759 0 n4 ns759 0 8.5377772962e-05
Gc2_760 0 n4 ns760 0 3.95492512235e-06
Gc2_761 0 n4 ns761 0 -6.40809767606e-05
Gc2_762 0 n4 ns762 0 -0.000582667663028
Gc2_763 0 n4 ns763 0 -0.000160043928037
Gc2_764 0 n4 ns764 0 0.000313329355637
Gc2_765 0 n4 ns765 0 -0.000236999722761
Gc2_766 0 n4 ns766 0 -3.70219795707e-05
Gc2_767 0 n4 ns767 0 5.11072540571e-05
Gc2_768 0 n4 ns768 0 9.38215050309e-05
Gc2_769 0 n4 ns769 0 0.000484098345443
Gc2_770 0 n4 ns770 0 0.000346730318435
Gc2_771 0 n4 ns771 0 -0.000163796205688
Gc2_772 0 n4 ns772 0 6.1091713782e-05
Gc2_773 0 n4 ns773 0 -0.000235350796558
Gc2_774 0 n4 ns774 0 -3.41688172211e-05
Gc2_775 0 n4 ns775 0 0.000638827045929
Gc2_776 0 n4 ns776 0 0.00084640807484
Gc2_777 0 n4 ns777 0 0.000767103725222
Gc2_778 0 n4 ns778 0 -0.000328898737181
Gc2_779 0 n4 ns779 0 0.000543988310176
Gc2_780 0 n4 ns780 0 -0.000187515380302
Gc2_781 0 n4 ns781 0 0.000331702164417
Gc2_782 0 n4 ns782 0 -1.88035960309e-05
Gc2_783 0 n4 ns783 0 -0.00260321749052
Gc2_784 0 n4 ns784 0 -0.00622737199978
Gc2_785 0 n4 ns785 0 -0.00261996066463
Gc2_786 0 n4 ns786 0 -0.00564928641292
Gc2_787 0 n4 ns787 0 -0.0011384293914
Gc2_788 0 n4 ns788 0 0.00157515323455
Gc2_789 0 n4 ns789 0 -8.97313815577e-05
Gc2_790 0 n4 ns790 0 -0.000944201236862
Gc2_791 0 n4 ns791 0 -0.000265255818939
Gc2_792 0 n4 ns792 0 -0.0023964135811
Gc2_793 0 n4 ns793 0 0.000258183384632
Gc2_794 0 n4 ns794 0 -0.00156298502718
Gc2_795 0 n4 ns795 0 -0.000615824341239
Gc2_796 0 n4 ns796 0 -1.43750324229e-05
Gc2_797 0 n4 ns797 0 6.22005318751e-05
Gc2_798 0 n4 ns798 0 -7.5501725159e-07
Gc2_799 0 n4 ns799 0 -0.000170700926165
Gc2_800 0 n4 ns800 0 0.000159461193651
Gc2_801 0 n4 ns801 0 -0.000186723959622
Gc2_802 0 n4 ns802 0 0.000568828415065
Gc2_803 0 n4 ns803 0 -9.26197632868e-05
Gc2_804 0 n4 ns804 0 0.000267285756595
Gc2_805 0 n4 ns805 0 0.000148085808675
Gc2_806 0 n4 ns806 0 -0.000120317856155
Gc2_807 0 n4 ns807 0 0.000373962882713
Gc2_808 0 n4 ns808 0 -0.000362735603297
Gc2_809 0 n4 ns809 0 -8.21225098587e-05
Gc2_810 0 n4 ns810 0 0.00015411263171
Gc2_811 0 n4 ns811 0 0.000123282372847
Gc2_812 0 n4 ns812 0 0.000346155764055
Gc2_813 0 n4 ns813 0 0.000821241166292
Gc2_814 0 n4 ns814 0 -0.000339822094979
Gc2_815 0 n4 ns815 0 0.000138451109715
Gc2_816 0 n4 ns816 0 -0.000755814713416
Gc2_817 0 n4 ns817 0 6.06655015964e-05
Gc2_818 0 n4 ns818 0 -0.000729062856943
Gc2_819 0 n4 ns819 0 -8.08005131655e-05
Gc2_820 0 n4 ns820 0 -0.000484790655588
Gc2_821 0 n4 ns821 0 -0.00516353915468
Gc2_822 0 n4 ns822 0 -0.00254509904834
Gc2_823 0 n4 ns823 0 -0.00466819904513
Gc2_824 0 n4 ns824 0 -0.00216421675438
Gc2_825 0 n4 ns825 0 0.00018241871396
Gc2_826 0 n4 ns826 0 0.00185765604324
Gc2_827 0 n4 ns827 0 -0.000327509877761
Gc2_828 0 n4 ns828 0 -0.000538073195156
Gc2_829 0 n4 ns829 0 -0.00110123216607
Gc2_830 0 n4 ns830 0 -0.00177395041228
Gc2_831 0 n4 ns831 0 -0.000139049707663
Gc2_832 0 n4 ns832 0 -0.00123231708124
Gc2_833 0 n4 ns833 0 -0.000371191113189
Gc2_834 0 n4 ns834 0 3.13976858313e-07
Gc2_835 0 n4 ns835 0 5.05872659568e-05
Gc2_836 0 n4 ns836 0 1.2194814889e-05
Gc2_837 0 n4 ns837 0 -0.000240477678015
Gc2_838 0 n4 ns838 0 0.000666373501336
Gc2_839 0 n4 ns839 0 -0.000545072902693
Gc2_840 0 n4 ns840 0 0.00106539480894
Gc2_841 0 n4 ns841 0 -9.77466459153e-06
Gc2_842 0 n4 ns842 0 0.000368420599377
Gc2_843 0 n4 ns843 0 1.73484636507e-05
Gc2_844 0 n4 ns844 0 -0.000258201376583
Gc2_845 0 n4 ns845 0 -0.000151705808595
Gc2_846 0 n4 ns846 0 -0.000146550230861
Gc2_847 0 n4 ns847 0 0.00010189129407
Gc2_848 0 n4 ns848 0 9.55995271698e-05
Gc2_849 0 n4 ns849 0 0.000423673713656
Gc2_850 0 n4 ns850 0 -0.000288991192029
Gc2_851 0 n4 ns851 0 9.86768753603e-05
Gc2_852 0 n4 ns852 0 -0.000655409586207
Gc2_853 0 n4 ns853 0 -0.000318199788199
Gc2_854 0 n4 ns854 0 -0.000373216043967
Gc2_855 0 n4 ns855 0 -0.000345045129377
Gc2_856 0 n4 ns856 0 -0.000320714096643
Gc2_857 0 n4 ns857 0 -0.00050629864171
Gc2_858 0 n4 ns858 0 -0.000103950198069
Gc2_859 0 n4 ns859 0 -0.00386431818474
Gc2_860 0 n4 ns860 0 0.0010317276293
Gc2_861 0 n4 ns861 0 -0.00336572534082
Gc2_862 0 n4 ns862 0 0.000958512633682
Gc2_863 0 n4 ns863 0 0.000664401329085
Gc2_864 0 n4 ns864 0 0.00123060818287
Gc2_865 0 n4 ns865 0 -0.00028542375036
Gc2_866 0 n4 ns866 0 -0.000250500040764
Gc2_867 0 n4 ns867 0 -0.00105259387242
Gc2_868 0 n4 ns868 0 -0.000969424045911
Gc2_869 0 n4 ns869 0 -0.000167563568347
Gc2_870 0 n4 ns870 0 -0.000752608624117
Gc2_871 0 n4 ns871 0 -0.000218050162165
Gc2_872 0 n4 ns872 0 1.84200878629e-07
Gc2_873 0 n4 ns873 0 1.51577755558e-05
Gc2_874 0 n4 ns874 0 2.64495058439e-05
Gc2_875 0 n4 ns875 0 0.000114485688838
Gc2_876 0 n4 ns876 0 0.000196597060903
Gc2_877 0 n4 ns877 0 0.000419646814894
Gc2_878 0 n4 ns878 0 0.000120710574463
Gc2_879 0 n4 ns879 0 4.81686307317e-05
Gc2_880 0 n4 ns880 0 6.37704882858e-06
Gc2_881 0 n4 ns881 0 -5.99496261959e-05
Gc2_882 0 n4 ns882 0 -1.53252129371e-06
Gc2_883 0 n4 ns883 0 -0.000127579206587
Gc2_884 0 n4 ns884 0 0.000164048864426
Gc2_885 0 n4 ns885 0 9.84429962963e-05
Gc2_886 0 n4 ns886 0 -4.47047393281e-05
Gc2_887 0 n4 ns887 0 -5.97173218978e-05
Gc2_888 0 n4 ns888 0 -0.000407287226026
Gc2_889 0 n4 ns889 0 -0.000327762284971
Gc2_890 0 n4 ns890 0 -0.000215092764951
Gc2_891 0 n4 ns891 0 -0.000291231415125
Gc2_892 0 n4 ns892 0 4.62349776917e-05
Gc2_893 0 n4 ns893 0 -0.000296858250441
Gc2_894 0 n4 ns894 0 9.33018213916e-05
Gc2_895 0 n4 ns895 0 -0.000290982952245
Gc2_896 0 n4 ns896 0 0.000237195291369
Gc2_897 0 n4 ns897 0 -0.00130641233898
Gc2_898 0 n4 ns898 0 0.00207144173855
Gc2_899 0 n4 ns899 0 -0.00111033474671
Gc2_900 0 n4 ns900 0 0.00180627935114
Gc2_901 0 n4 ns901 0 0.000732858108085
Gc2_902 0 n4 ns902 0 0.000524606673801
Gc2_903 0 n4 ns903 0 -0.000187085717752
Gc2_904 0 n4 ns904 0 -9.56960825562e-05
Gc2_905 0 n4 ns905 0 -0.000804002871321
Gc2_906 0 n4 ns906 0 -0.00042631742603
Gc2_907 0 n4 ns907 0 -0.000141222497359
Gc2_908 0 n4 ns908 0 -0.000564147127577
Gc2_909 0 n4 ns909 0 -0.000166832920668
Gc2_910 0 n4 ns910 0 -1.29078224752e-05
Gc2_911 0 n4 ns911 0 4.67402387402e-06
Gc2_912 0 n4 ns912 0 5.81924400657e-06
Gc2_913 0 n4 ns913 0 0.000111346285247
Gc2_914 0 n4 ns914 0 0.000546246110737
Gc2_915 0 n4 ns915 0 0.000641229180008
Gc2_916 0 n4 ns916 0 0.000749746601619
Gc2_917 0 n4 ns917 0 5.40696092859e-05
Gc2_918 0 n4 ns918 0 0.000245471952933
Gc2_919 0 n4 ns919 0 -1.45853069258e-05
Gc2_920 0 n4 ns920 0 -9.54107204535e-05
Gc2_921 0 n4 ns921 0 0.000195681665029
Gc2_922 0 n4 ns922 0 0.000249029348637
Gc2_923 0 n4 ns923 0 3.87678908525e-05
Gc2_924 0 n4 ns924 0 -0.000114208472817
Gc2_925 0 n4 ns925 0 -0.000402001130381
Gc2_926 0 n4 ns926 0 -0.000460239132769
Gc2_927 0 n4 ns927 0 -0.000193835509029
Gc2_928 0 n4 ns928 0 -0.000200331052332
Gc2_929 0 n4 ns929 0 -5.08580598149e-05
Gc2_930 0 n4 ns930 0 -4.13184426511e-05
Gc2_931 0 n4 ns931 0 4.23728896916e-05
Gc2_932 0 n4 ns932 0 -0.000114163655948
Gc2_933 0 n4 ns933 0 5.43919134227e-05
Gc2_934 0 n4 ns934 0 0.000540064489785
Gc2_935 0 n4 ns935 0 7.83626920356e-05
Gc2_936 0 n4 ns936 0 0.00219955755015
Gc2_937 0 n4 ns937 0 7.72187995121e-05
Gc2_938 0 n4 ns938 0 0.00185941849173
Gc2_939 0 n4 ns939 0 0.000874011631896
Gc2_940 0 n4 ns940 0 0.000472244086632
Gc2_941 0 n4 ns941 0 -0.00015135505891
Gc2_942 0 n4 ns942 0 -8.30727930755e-05
Gc2_943 0 n4 ns943 0 -0.00080500019921
Gc2_944 0 n4 ns944 0 -0.000523658614448
Gc2_945 0 n4 ns945 0 -0.000206011187061
Gc2_946 0 n4 ns946 0 -0.000887210945297
Gc2_947 0 n4 ns947 0 -0.000237079847788
Gc2_948 0 n4 ns948 0 1.18075813824e-05
Gc2_949 0 n4 ns949 0 -3.40223694791e-05
Gc2_950 0 n4 ns950 0 1.91982960791e-05
Gc2_951 0 n4 ns951 0 0.000936342396988
Gc2_952 0 n4 ns952 0 -0.00215689762249
Gc2_953 0 n4 ns953 0 0.00135234695819
Gc2_954 0 n4 ns954 0 -0.00440699878045
Gc2_955 0 n4 ns955 0 -0.00242967394385
Gc2_956 0 n4 ns956 0 -0.00130465088631
Gc2_957 0 n4 ns957 0 0.00101329104313
Gc2_958 0 n4 ns958 0 0.000437824267197
Gc2_959 0 n4 ns959 0 -0.000785856896797
Gc2_960 0 n4 ns960 0 -0.000481408502692
Gc2_961 0 n4 ns961 0 -0.000135129748678
Gc2_962 0 n4 ns962 0 -8.64444652626e-05
Gc2_963 0 n4 ns963 0 0.000348150100271
Gc2_964 0 n4 ns964 0 0.000127846015636
Gc2_965 0 n4 ns965 0 0.000724737792986
Gc2_966 0 n4 ns966 0 -0.00084276037195
Gc2_967 0 n4 ns967 0 0.00065421487513
Gc2_968 0 n4 ns968 0 0.000483667648891
Gc2_969 0 n4 ns969 0 0.000351719223867
Gc2_970 0 n4 ns970 0 0.000207627557827
Gc2_971 0 n4 ns971 0 -0.00119367788858
Gc2_972 0 n4 ns972 0 -0.00191445344874
Gc2_973 0 n4 ns973 0 -0.0014498100303
Gc2_974 0 n4 ns974 0 -0.000899266161932
Gc2_975 0 n4 ns975 0 -0.000411999985512
Gc2_976 0 n4 ns976 0 -0.00157783911393
Gc2_977 0 n4 ns977 0 0.00460601446417
Gc2_978 0 n4 ns978 0 0.00201030634708
Gc2_979 0 n4 ns979 0 0.00139207364486
Gc2_980 0 n4 ns980 0 -0.000646096004291
Gc2_981 0 n4 ns981 0 -0.00207041452833
Gc2_982 0 n4 ns982 0 -0.00147566487259
Gc2_983 0 n4 ns983 0 0.00260871907191
Gc2_984 0 n4 ns984 0 0.00295502194872
Gc2_985 0 n4 ns985 0 -0.00354020621958
Gc2_986 0 n4 ns986 0 -9.14423178337e-06
Gc2_987 0 n4 ns987 0 0.000293044040518
Gc2_988 0 n4 ns988 0 -0.00015289806015
Gc2_989 0 n4 ns989 0 -0.000760545549823
Gc2_990 0 n4 ns990 0 -5.99068390714e-05
Gc2_991 0 n4 ns991 0 -0.00245504387851
Gc2_992 0 n4 ns992 0 0.00143570040059
Gc2_993 0 n4 ns993 0 -0.000416374574467
Gc2_994 0 n4 ns994 0 0.000640929173143
Gc2_995 0 n4 ns995 0 0.000243363868446
Gc2_996 0 n4 ns996 0 -0.000385582450793
Gc2_997 0 n4 ns997 0 -0.000659515253165
Gc2_998 0 n4 ns998 0 0.000702392101855
Gc2_999 0 n4 ns999 0 -9.46800078971e-05
Gc2_1000 0 n4 ns1000 0 -3.98176320303e-05
Gc2_1001 0 n4 ns1001 0 0.000958785490174
Gc2_1002 0 n4 ns1002 0 -0.00063792250129
Gc2_1003 0 n4 ns1003 0 -0.00065280108728
Gc2_1004 0 n4 ns1004 0 -0.00014582345958
Gc2_1005 0 n4 ns1005 0 0.000755892571454
Gc2_1006 0 n4 ns1006 0 0.000198526377058
Gc2_1007 0 n4 ns1007 0 0.000369270847163
Gc2_1008 0 n4 ns1008 0 -9.52349947852e-05
Gc2_1009 0 n4 ns1009 0 -0.00146985654131
Gc2_1010 0 n4 ns1010 0 0.00107990978281
Gc2_1011 0 n4 ns1011 0 0.000617084116704
Gc2_1012 0 n4 ns1012 0 -0.00193063993058
Gc2_1013 0 n4 ns1013 0 0.00069852489404
Gc2_1014 0 n4 ns1014 0 -0.00268458684105
Gc2_1015 0 n4 ns1015 0 -0.000167507786864
Gc2_1016 0 n4 ns1016 0 -0.000721231649909
Gc2_1017 0 n4 ns1017 0 0.000899734210764
Gc2_1018 0 n4 ns1018 0 -0.00120214771694
Gc2_1019 0 n4 ns1019 0 0.000854517711073
Gc2_1020 0 n4 ns1020 0 -0.00182134795764
Gc2_1021 0 n4 ns1021 0 0.00198303335904
Gc2_1022 0 n4 ns1022 0 -0.00252307519726
Gc2_1023 0 n4 ns1023 0 -0.00201179457017
Gc2_1024 0 n4 ns1024 0 -2.61285139105e-05
Gc2_1025 0 n4 ns1025 0 0.000113646621088
Gc2_1026 0 n4 ns1026 0 -1.25023156488e-05
Gc2_1027 0 n4 ns1027 0 9.99588190405e-05
Gc2_1028 0 n4 ns1028 0 -0.000895253783801
Gc2_1029 0 n4 ns1029 0 0.000183196012249
Gc2_1030 0 n4 ns1030 0 0.000281633071956
Gc2_1031 0 n4 ns1031 0 -7.8394715512e-05
Gc2_1032 0 n4 ns1032 0 -0.000239943239221
Gc2_1033 0 n4 ns1033 0 -8.61813745471e-05
Gc2_1034 0 n4 ns1034 0 0.000143700111869
Gc2_1035 0 n4 ns1035 0 0.000203988543133
Gc2_1036 0 n4 ns1036 0 0.000596059318131
Gc2_1037 0 n4 ns1037 0 -0.000173019816673
Gc2_1038 0 n4 ns1038 0 2.52544325481e-05
Gc2_1039 0 n4 ns1039 0 -9.82760187169e-05
Gc2_1040 0 n4 ns1040 0 -0.000258951282026
Gc2_1041 0 n4 ns1041 0 0.000147063044376
Gc2_1042 0 n4 ns1042 0 0.00108718480392
Gc2_1043 0 n4 ns1043 0 0.00084734455229
Gc2_1044 0 n4 ns1044 0 -7.63937678779e-05
Gc2_1045 0 n4 ns1045 0 0.000480820297815
Gc2_1046 0 n4 ns1046 0 2.71283154229e-05
Gc2_1047 0 n4 ns1047 0 0.000254839367867
Gc2_1048 0 n4 ns1048 0 0.000356618493177
Gc2_1049 0 n4 ns1049 0 -0.000867863424234
Gc2_1050 0 n4 ns1050 0 -0.00652116530369
Gc2_1051 0 n4 ns1051 0 -0.00111742532678
Gc2_1052 0 n4 ns1052 0 -0.0061079784381
Gc2_1053 0 n4 ns1053 0 -0.00153323028862
Gc2_1054 0 n4 ns1054 0 0.000997090724365
Gc2_1055 0 n4 ns1055 0 0.000111209057616
Gc2_1056 0 n4 ns1056 0 -0.00108273567518
Gc2_1057 0 n4 ns1057 0 0.000230098843263
Gc2_1058 0 n4 ns1058 0 -0.00239198068856
Gc2_1059 0 n4 ns1059 0 0.000553587511921
Gc2_1060 0 n4 ns1060 0 -0.00169778197913
Gc2_1061 0 n4 ns1061 0 -0.000792126937622
Gc2_1062 0 n4 ns1062 0 -1.09513197844e-05
Gc2_1063 0 n4 ns1063 0 5.68198444454e-05
Gc2_1064 0 n4 ns1064 0 4.76196860602e-06
Gc2_1065 0 n4 ns1065 0 -0.0002490380124
Gc2_1066 0 n4 ns1066 0 -1.3241363251e-05
Gc2_1067 0 n4 ns1067 0 -0.000404701329091
Gc2_1068 0 n4 ns1068 0 0.000464347866756
Gc2_1069 0 n4 ns1069 0 -0.000131375960982
Gc2_1070 0 n4 ns1070 0 0.000198706078804
Gc2_1071 0 n4 ns1071 0 0.000114160814633
Gc2_1072 0 n4 ns1072 0 -2.44426540523e-05
Gc2_1073 0 n4 ns1073 0 0.000554827436929
Gc2_1074 0 n4 ns1074 0 -0.000198733575249
Gc2_1075 0 n4 ns1075 0 -0.000156549290586
Gc2_1076 0 n4 ns1076 0 0.000137592281165
Gc2_1077 0 n4 ns1077 0 -7.45921918633e-05
Gc2_1078 0 n4 ns1078 0 0.000432331183166
Gc2_1079 0 n4 ns1079 0 0.000990372673908
Gc2_1080 0 n4 ns1080 0 0.00015199303976
Gc2_1081 0 n4 ns1081 0 0.000436132809106
Gc2_1082 0 n4 ns1082 0 -0.000684918472117
Gc2_1083 0 n4 ns1083 0 0.000307331354749
Gc2_1084 0 n4 ns1084 0 -0.000593136007209
Gc2_1085 0 n4 ns1085 0 8.19418411301e-05
Gc2_1086 0 n4 ns1086 0 -0.000535488727331
Gc2_1087 0 n4 ns1087 0 -0.00494965149216
Gc2_1088 0 n4 ns1088 0 -0.00448467283989
Gc2_1089 0 n4 ns1089 0 -0.00456731115732
Gc2_1090 0 n4 ns1090 0 -0.00390169088367
Gc2_1091 0 n4 ns1091 0 -0.000368474843167
Gc2_1092 0 n4 ns1092 0 0.00183973982692
Gc2_1093 0 n4 ns1093 0 -0.000270682357361
Gc2_1094 0 n4 ns1094 0 -0.00066639729798
Gc2_1095 0 n4 ns1095 0 -0.000806226890191
Gc2_1096 0 n4 ns1096 0 -0.00194442649591
Gc2_1097 0 n4 ns1097 0 -1.13416503068e-05
Gc2_1098 0 n4 ns1098 0 -0.0011452564425
Gc2_1099 0 n4 ns1099 0 -0.00038838703381
Gc2_1100 0 n4 ns1100 0 -8.86135322299e-06
Gc2_1101 0 n4 ns1101 0 9.57035284469e-05
Gc2_1102 0 n4 ns1102 0 -1.38538850854e-05
Gc2_1103 0 n4 ns1103 0 -0.000515599485509
Gc2_1104 0 n4 ns1104 0 0.000743412353851
Gc2_1105 0 n4 ns1105 0 -0.00125453543956
Gc2_1106 0 n4 ns1106 0 0.000725615324867
Gc2_1107 0 n4 ns1107 0 -0.000174602576721
Gc2_1108 0 n4 ns1108 0 0.000370784622966
Gc2_1109 0 n4 ns1109 0 0.000147397217145
Gc2_1110 0 n4 ns1110 0 -0.000260840180025
Gc2_1111 0 n4 ns1111 0 -5.30391768784e-05
Gc2_1112 0 n4 ns1112 0 -0.000334308277488
Gc2_1113 0 n4 ns1113 0 3.64935304195e-05
Gc2_1114 0 n4 ns1114 0 0.0001724438434
Gc2_1115 0 n4 ns1115 0 0.000580005681118
Gc2_1116 0 n4 ns1116 0 7.86077148616e-05
Gc2_1117 0 n4 ns1117 0 0.000429067169629
Gc2_1118 0 n4 ns1118 0 -0.000570122171531
Gc2_1119 0 n4 ns1119 0 -0.000225129000606
Gc2_1120 0 n4 ns1120 0 -0.000498266846468
Gc2_1121 0 n4 ns1121 0 -0.000305582190408
Gc2_1122 0 n4 ns1122 0 -0.000384439485484
Gc2_1123 0 n4 ns1123 0 -0.000572151139563
Gc2_1124 0 n4 ns1124 0 -0.000440133733245
Gc2_1125 0 n4 ns1125 0 -0.00504103286768
Gc2_1126 0 n4 ns1126 0 -0.000373115653093
Gc2_1127 0 n4 ns1127 0 -0.00443103465755
Gc2_1128 0 n4 ns1128 0 -0.000226169646535
Gc2_1129 0 n4 ns1129 0 0.000314867100305
Gc2_1130 0 n4 ns1130 0 0.00135121663324
Gc2_1131 0 n4 ns1131 0 -0.000280265193849
Gc2_1132 0 n4 ns1132 0 -0.000322976236733
Gc2_1133 0 n4 ns1133 0 -0.000916267147771
Gc2_1134 0 n4 ns1134 0 -0.00107011716939
Gc2_1135 0 n4 ns1135 0 -0.000100433912295
Gc2_1136 0 n4 ns1136 0 -0.000572221428559
Gc2_1137 0 n4 ns1137 0 -0.000185015074587
Gc2_1138 0 n4 ns1138 0 -1.51740579705e-05
Gc2_1139 0 n4 ns1139 0 0.000106730015812
Gc2_1140 0 n4 ns1140 0 -2.59281441578e-05
Gc2_1141 0 n4 ns1141 0 4.15892662246e-05
Gc2_1142 0 n4 ns1142 0 0.000141538141435
Gc2_1143 0 n4 ns1143 0 0.00014663504798
Gc2_1144 0 n4 ns1144 0 -2.08755633873e-05
Gc2_1145 0 n4 ns1145 0 5.96486345019e-05
Gc2_1146 0 n4 ns1146 0 9.73344372936e-06
Gc2_1147 0 n4 ns1147 0 -7.67439656692e-05
Gc2_1148 0 n4 ns1148 0 -4.65380926743e-05
Gc2_1149 0 n4 ns1149 0 -0.000252241796902
Gc2_1150 0 n4 ns1150 0 -4.52753874209e-06
Gc2_1151 0 n4 ns1151 0 0.000106940104384
Gc2_1152 0 n4 ns1152 0 2.6604994626e-05
Gc2_1153 0 n4 ns1153 0 0.000184400403878
Gc2_1154 0 n4 ns1154 0 -0.000272093255227
Gc2_1155 0 n4 ns1155 0 -0.000285162092069
Gc2_1156 0 n4 ns1156 0 -0.000284720676412
Gc2_1157 0 n4 ns1157 0 -0.000391338684227
Gc2_1158 0 n4 ns1158 0 1.96552883227e-06
Gc2_1159 0 n4 ns1159 0 -0.000451931953806
Gc2_1160 0 n4 ns1160 0 0.000101646548517
Gc2_1161 0 n4 ns1161 0 -0.000462593813646
Gc2_1162 0 n4 ns1162 0 6.75460606109e-06
Gc2_1163 0 n4 ns1163 0 -0.0023055085181
Gc2_1164 0 n4 ns1164 0 0.00166092055442
Gc2_1165 0 n4 ns1165 0 -0.001979690702
Gc2_1166 0 n4 ns1166 0 0.00148722735301
Gc2_1167 0 n4 ns1167 0 0.000608662884452
Gc2_1168 0 n4 ns1168 0 0.000624747821731
Gc2_1169 0 n4 ns1169 0 -0.000204705417493
Gc2_1170 0 n4 ns1170 0 -0.000120165762586
Gc2_1171 0 n4 ns1171 0 -0.000793894546404
Gc2_1172 0 n4 ns1172 0 -0.000443446311774
Gc2_1173 0 n4 ns1173 0 -0.000117129161827
Gc2_1174 0 n4 ns1174 0 -0.000372866088266
Gc2_1175 0 n4 ns1175 0 -0.000122427165827
Gc2_1176 0 n4 ns1176 0 -1.54401330804e-05
Gc2_1177 0 n4 ns1177 0 2.76170990932e-05
Gc2_1178 0 n4 ns1178 0 1.37293463063e-06
Gc2_1179 0 n4 ns1179 0 0.000157024624135
Gc2_1180 0 n4 ns1180 0 0.000171012985338
Gc2_1181 0 n4 ns1181 0 0.000698937098637
Gc2_1182 0 n4 ns1182 0 -6.73866382297e-05
Gc2_1183 0 n4 ns1183 0 9.2239145633e-06
Gc2_1184 0 n4 ns1184 0 -3.12975863578e-05
Gc2_1185 0 n4 ns1185 0 -3.2551180432e-06
Gc2_1186 0 n4 ns1186 0 4.61572113304e-05
Gc2_1187 0 n4 ns1187 0 4.08521126064e-05
Gc2_1188 0 n4 ns1188 0 0.000213245656693
Gc2_1189 0 n4 ns1189 0 5.08949652535e-05
Gc2_1190 0 n4 ns1190 0 -8.74685021484e-05
Gc2_1191 0 n4 ns1191 0 -0.000281666138306
Gc2_1192 0 n4 ns1192 0 -0.000337471064296
Gc2_1193 0 n4 ns1193 0 -0.000286173758109
Gc2_1194 0 n4 ns1194 0 -9.03751781178e-05
Gc2_1195 0 n4 ns1195 0 -0.000152071026972
Gc2_1196 0 n4 ns1196 0 7.39674706434e-05
Gc2_1197 0 n4 ns1197 0 -0.000116563756843
Gc2_1198 0 n4 ns1198 0 7.36505953777e-05
Gc2_1199 0 n4 ns1199 0 -9.0578284416e-05
Gc2_1200 0 n4 ns1200 0 0.00038664190392
Gc2_1201 0 n4 ns1201 0 -0.000334112218684
Gc2_1202 0 n4 ns1202 0 0.00208626630747
Gc2_1203 0 n4 ns1203 0 -0.000273036120295
Gc2_1204 0 n4 ns1204 0 0.00178677350064
Gc2_1205 0 n4 ns1205 0 0.000775719415112
Gc2_1206 0 n4 ns1206 0 0.000417190593402
Gc2_1207 0 n4 ns1207 0 -0.000154830375355
Gc2_1208 0 n4 ns1208 0 -7.35428794444e-05
Gc2_1209 0 n4 ns1209 0 -0.000748378992033
Gc2_1210 0 n4 ns1210 0 -0.000417874988613
Gc2_1211 0 n4 ns1211 0 -0.000158461930049
Gc2_1212 0 n4 ns1212 0 -0.000740896496243
Gc2_1213 0 n4 ns1213 0 -0.000209110279483
Gc2_1214 0 n4 ns1214 0 -1.77663984687e-05
Gc2_1215 0 n4 ns1215 0 4.55198516392e-06
Gc2_1216 0 n4 ns1216 0 -6.9019050853e-07
Gd2_1 0 n4 ni1 0 -0.00298142355421
Gd2_2 0 n4 ni2 0 -0.000496043184577
Gd2_3 0 n4 ni3 0 -0.00172649041428
Gd2_4 0 n4 ni4 0 -0.000892364259668
Gd2_5 0 n4 ni5 0 0.000254011466955
Gd2_6 0 n4 ni6 0 0.000278025160847
Gd2_7 0 n4 ni7 0 1.56790139241e-05
Gd2_8 0 n4 ni8 0 -5.6830096936e-05
Gd2_9 0 n4 ni9 0 -0.000110991104464
Gd2_10 0 n4 ni10 0 -0.00322359832163
Gd2_11 0 n4 ni11 0 -0.00179626083791
Gd2_12 0 n4 ni12 0 0.000108582294317
Gd2_13 0 n4 ni13 0 0.000190137818487
Gd2_14 0 n4 ni14 0 8.10065860141e-05
Gd2_15 0 n4 ni15 0 -2.53597167548e-05
Gd2_16 0 n4 ni16 0 2.94049324593e-05
Gd2_17 0 n4 ni17 0 -0.0036236491205
Gd2_18 0 n4 ni18 0 0.000392487837148
Gd2_19 0 n4 ni19 0 0.000128531835714
Gd2_20 0 n4 ni20 0 0.000412072895393
Gd2_21 0 n4 ni21 0 -0.000215365159191
Gd2_22 0 n4 ni22 0 0.000228690338834
Gd2_23 0 n4 ni23 0 0.00062623956016
Gd2_24 0 n4 ni24 0 -2.03198896614e-05
Gd2_25 0 n4 ni25 0 0.000201957449054
Gd2_26 0 n4 ni26 0 -0.00175719503105
Gd2_27 0 n4 ni27 0 0.000495136748021
Gd2_28 0 n4 ni28 0 -0.000452130145979
Gd2_29 0 n4 ni29 0 0.000212964085114
Gd2_30 0 n4 ni30 0 0.000813641066179
Gd2_31 0 n4 ni31 0 8.88251216707e-06
Gd2_32 0 n4 ni32 0 -0.0001248708498
Gc3_1 0 n6 ns1 0 0.000663706614126
Gc3_2 0 n6 ns2 0 -0.00182045745499
Gc3_3 0 n6 ns3 0 0.00132640091576
Gc3_4 0 n6 ns4 0 -0.00156607127236
Gc3_5 0 n6 ns5 0 -0.000983195710631
Gc3_6 0 n6 ns6 0 -0.000179506808043
Gc3_7 0 n6 ns7 0 0.000145493605265
Gc3_8 0 n6 ns8 0 -0.000147271130326
Gc3_9 0 n6 ns9 0 0.000526612019507
Gc3_10 0 n6 ns10 0 0.00033273141004
Gc3_11 0 n6 ns11 0 0.00013651730953
Gc3_12 0 n6 ns12 0 0.000103701711122
Gc3_13 0 n6 ns13 0 0.000367852888455
Gc3_14 0 n6 ns14 0 0.000386652774733
Gc3_15 0 n6 ns15 0 -0.000238761731102
Gc3_16 0 n6 ns16 0 -0.00152977406537
Gc3_17 0 n6 ns17 0 0.000582889788601
Gc3_18 0 n6 ns18 0 -0.000127012644292
Gc3_19 0 n6 ns19 0 0.000578388475821
Gc3_20 0 n6 ns20 0 -0.000651944235163
Gc3_21 0 n6 ns21 0 0.00229369969312
Gc3_22 0 n6 ns22 0 0.00126625295936
Gc3_23 0 n6 ns23 0 -0.000602526948688
Gc3_24 0 n6 ns24 0 0.00185765844181
Gc3_25 0 n6 ns25 0 -0.00101281389897
Gc3_26 0 n6 ns26 0 0.00234353618642
Gc3_27 0 n6 ns27 0 0.00234286586633
Gc3_28 0 n6 ns28 0 -0.00296957379784
Gc3_29 0 n6 ns29 0 0.00116648271266
Gc3_30 0 n6 ns30 0 -0.000575875988767
Gc3_31 0 n6 ns31 0 9.75174791674e-05
Gc3_32 0 n6 ns32 0 0.000587782903997
Gc3_33 0 n6 ns33 0 -0.00311655369025
Gc3_34 0 n6 ns34 0 0.00207749085055
Gc3_35 0 n6 ns35 0 0.00260543503436
Gc3_36 0 n6 ns36 0 1.7483238327e-05
Gc3_37 0 n6 ns37 0 -0.000197670178352
Gc3_38 0 n6 ns38 0 4.6392351014e-05
Gc3_39 0 n6 ns39 0 0.000451382930668
Gc3_40 0 n6 ns40 0 -0.00214858295988
Gc3_41 0 n6 ns41 0 0.00062395819968
Gc3_42 0 n6 ns42 0 -0.000748452370233
Gc3_43 0 n6 ns43 0 -0.000921823212246
Gc3_44 0 n6 ns44 0 0.000251815381936
Gc3_45 0 n6 ns45 0 0.00030809618004
Gc3_46 0 n6 ns46 0 -0.000361219331218
Gc3_47 0 n6 ns47 0 0.000569685991868
Gc3_48 0 n6 ns48 0 0.000291664078168
Gc3_49 0 n6 ns49 0 0.000189500858697
Gc3_50 0 n6 ns50 0 0.00011046692577
Gc3_51 0 n6 ns51 0 -0.000148577388458
Gc3_52 0 n6 ns52 0 7.65202535405e-05
Gc3_53 0 n6 ns53 0 1.73035702409e-05
Gc3_54 0 n6 ns54 0 -0.00102738727772
Gc3_55 0 n6 ns55 0 0.000715004338933
Gc3_56 0 n6 ns56 0 7.6269731445e-05
Gc3_57 0 n6 ns57 0 0.000461039755371
Gc3_58 0 n6 ns58 0 -0.000557044058098
Gc3_59 0 n6 ns59 0 0.00128259956136
Gc3_60 0 n6 ns60 0 0.00163315921603
Gc3_61 0 n6 ns61 0 -0.000688333619312
Gc3_62 0 n6 ns62 0 0.00249929522862
Gc3_63 0 n6 ns63 0 -0.00116596228975
Gc3_64 0 n6 ns64 0 0.00304631179831
Gc3_65 0 n6 ns65 0 0.00348090171801
Gc3_66 0 n6 ns66 0 -0.000739361507013
Gc3_67 0 n6 ns67 0 0.00127462692144
Gc3_68 0 n6 ns68 0 -0.000746089989724
Gc3_69 0 n6 ns69 0 -0.000898098940848
Gc3_70 0 n6 ns70 0 -0.000484749999832
Gc3_71 0 n6 ns71 0 -0.00373858719119
Gc3_72 0 n6 ns72 0 5.27365266354e-05
Gc3_73 0 n6 ns73 0 0.00319803030364
Gc3_74 0 n6 ns74 0 4.25683623467e-05
Gc3_75 0 n6 ns75 0 -0.000248050214472
Gc3_76 0 n6 ns76 0 8.45310645219e-05
Gc3_77 0 n6 ns77 0 0.000644112226888
Gc3_78 0 n6 ns78 0 -0.00284211273312
Gc3_79 0 n6 ns79 0 -0.00100117550212
Gc3_80 0 n6 ns80 0 -0.000379269534425
Gc3_81 0 n6 ns81 0 -0.000445745273594
Gc3_82 0 n6 ns82 0 7.854083773e-05
Gc3_83 0 n6 ns83 0 0.0003707562235
Gc3_84 0 n6 ns84 0 -0.000195688113814
Gc3_85 0 n6 ns85 0 8.69953811755e-05
Gc3_86 0 n6 ns86 0 -5.95976587024e-05
Gc3_87 0 n6 ns87 0 0.000270028850624
Gc3_88 0 n6 ns88 0 0.000101792133813
Gc3_89 0 n6 ns89 0 -0.000785769192562
Gc3_90 0 n6 ns90 0 -0.000163771074313
Gc3_91 0 n6 ns91 0 -0.00011987034204
Gc3_92 0 n6 ns92 0 0.000911988818117
Gc3_93 0 n6 ns93 0 0.000447684669061
Gc3_94 0 n6 ns94 0 0.000332130518438
Gc3_95 0 n6 ns95 0 -0.000528789087883
Gc3_96 0 n6 ns96 0 -0.000536304504663
Gc3_97 0 n6 ns97 0 -0.00109565268204
Gc3_98 0 n6 ns98 0 -0.000464444120162
Gc3_99 0 n6 ns99 0 0.00414445600244
Gc3_100 0 n6 ns100 0 0.00504225847217
Gc3_101 0 n6 ns101 0 0.00275866680941
Gc3_102 0 n6 ns102 0 0.00528178210148
Gc3_103 0 n6 ns103 0 0.000281580427987
Gc3_104 0 n6 ns104 0 0.00499231054741
Gc3_105 0 n6 ns105 0 0.00113355293147
Gc3_106 0 n6 ns106 0 -0.000811341587138
Gc3_107 0 n6 ns107 0 -0.00524232276685
Gc3_108 0 n6 ns108 0 -0.00132069479697
Gc3_109 0 n6 ns109 0 0.00288867056618
Gc3_110 0 n6 ns110 0 -0.00389632930127
Gc3_111 0 n6 ns111 0 0.00487484125111
Gc3_112 0 n6 ns112 0 -3.58895524756e-05
Gc3_113 0 n6 ns113 0 -2.90171589674e-05
Gc3_114 0 n6 ns114 0 -4.5828624197e-05
Gc3_115 0 n6 ns115 0 0.000254803786694
Gc3_116 0 n6 ns116 0 -0.0022448063012
Gc3_117 0 n6 ns117 0 0.000122424310111
Gc3_118 0 n6 ns118 0 -0.000679678670472
Gc3_119 0 n6 ns119 0 -0.00079586700347
Gc3_120 0 n6 ns120 0 0.000255416780339
Gc3_121 0 n6 ns121 0 0.000252426567971
Gc3_122 0 n6 ns122 0 -0.000517818806109
Gc3_123 0 n6 ns123 0 4.43787275692e-05
Gc3_124 0 n6 ns124 0 0.000247087582731
Gc3_125 0 n6 ns125 0 0.000290885171493
Gc3_126 0 n6 ns126 0 4.22134867734e-06
Gc3_127 0 n6 ns127 0 -0.000178652748214
Gc3_128 0 n6 ns128 0 0.00024633144913
Gc3_129 0 n6 ns129 0 0.00102419432254
Gc3_130 0 n6 ns130 0 -0.000466223597735
Gc3_131 0 n6 ns131 0 0.00117147360766
Gc3_132 0 n6 ns132 0 -0.000264744718531
Gc3_133 0 n6 ns133 0 0.000772242842248
Gc3_134 0 n6 ns134 0 -0.000622024414896
Gc3_135 0 n6 ns135 0 0.000425153069958
Gc3_136 0 n6 ns136 0 0.00218217495777
Gc3_137 0 n6 ns137 0 0.00168846483889
Gc3_138 0 n6 ns138 0 0.00568501305446
Gc3_139 0 n6 ns139 0 0.0012119242889
Gc3_140 0 n6 ns140 0 0.00575540273044
Gc3_141 0 n6 ns141 0 0.00326671714701
Gc3_142 0 n6 ns142 0 0.000399068882865
Gc3_143 0 n6 ns143 0 0.000976358271782
Gc3_144 0 n6 ns144 0 -0.000998721297823
Gc3_145 0 n6 ns145 0 -0.00154576000436
Gc3_146 0 n6 ns146 0 -0.00134578687736
Gc3_147 0 n6 ns147 0 -0.00379994980921
Gc3_148 0 n6 ns148 0 -0.00016877504925
Gc3_149 0 n6 ns149 0 0.00310493013376
Gc3_150 0 n6 ns150 0 2.29859863762e-05
Gc3_151 0 n6 ns151 0 -0.000179884792488
Gc3_152 0 n6 ns152 0 2.60195814925e-05
Gc3_153 0 n6 ns153 0 0.000342792753212
Gc3_154 0 n6 ns154 0 -0.000752918632069
Gc3_155 0 n6 ns155 0 0.00114154972349
Gc3_156 0 n6 ns156 0 -4.45754474195e-05
Gc3_157 0 n6 ns157 0 -8.5752351166e-05
Gc3_158 0 n6 ns158 0 0.000357458607886
Gc3_159 0 n6 ns159 0 -0.000163895009842
Gc3_160 0 n6 ns160 0 -0.000106329568183
Gc3_161 0 n6 ns161 0 0.000256353218976
Gc3_162 0 n6 ns162 0 -0.000166711132646
Gc3_163 0 n6 ns163 0 0.00018503627302
Gc3_164 0 n6 ns164 0 -8.44209513471e-05
Gc3_165 0 n6 ns165 0 1.53933075971e-05
Gc3_166 0 n6 ns166 0 -0.000272255556021
Gc3_167 0 n6 ns167 0 -0.000600574395774
Gc3_168 0 n6 ns168 0 -0.000454659648112
Gc3_169 0 n6 ns169 0 0.000383560336478
Gc3_170 0 n6 ns170 0 -0.000713714092949
Gc3_171 0 n6 ns171 0 -7.44098778372e-05
Gc3_172 0 n6 ns172 0 -0.00118203391198
Gc3_173 0 n6 ns173 0 0.00133459354089
Gc3_174 0 n6 ns174 0 -0.000463350871121
Gc3_175 0 n6 ns175 0 0.00261300438032
Gc3_176 0 n6 ns176 0 0.00396439619483
Gc3_177 0 n6 ns177 0 0.00238137768198
Gc3_178 0 n6 ns178 0 0.00410613797184
Gc3_179 0 n6 ns179 0 -0.00113903624132
Gc3_180 0 n6 ns180 0 -0.00153087527285
Gc3_181 0 n6 ns181 0 0.000424191554954
Gc3_182 0 n6 ns182 0 -0.00105506792996
Gc3_183 0 n6 ns183 0 0.000167234258026
Gc3_184 0 n6 ns184 0 -0.000793333349825
Gc3_185 0 n6 ns185 0 -0.00151946619917
Gc3_186 0 n6 ns186 0 0.002410356217
Gc3_187 0 n6 ns187 0 0.00148718970928
Gc3_188 0 n6 ns188 0 3.22354104198e-05
Gc3_189 0 n6 ns189 0 -0.000261822910103
Gc3_190 0 n6 ns190 0 9.50906105239e-05
Gc3_191 0 n6 ns191 0 -0.00018759317626
Gc3_192 0 n6 ns192 0 7.12981051319e-05
Gc3_193 0 n6 ns193 0 -0.000247932341528
Gc3_194 0 n6 ns194 0 0.000530117684704
Gc3_195 0 n6 ns195 0 -1.04379808452e-05
Gc3_196 0 n6 ns196 0 7.16206431104e-05
Gc3_197 0 n6 ns197 0 0.00015165488746
Gc3_198 0 n6 ns198 0 -1.40459326723e-05
Gc3_199 0 n6 ns199 0 -0.000180078312776
Gc3_200 0 n6 ns200 0 -7.84149926479e-05
Gc3_201 0 n6 ns201 0 0.000129157626694
Gc3_202 0 n6 ns202 0 -0.000132908814588
Gc3_203 0 n6 ns203 0 -0.000227111289056
Gc3_204 0 n6 ns204 0 -0.000248212549596
Gc3_205 0 n6 ns205 0 0.000155389817387
Gc3_206 0 n6 ns206 0 0.000552362410864
Gc3_207 0 n6 ns207 0 0.000237288301494
Gc3_208 0 n6 ns208 0 -0.000396713946051
Gc3_209 0 n6 ns209 0 -0.000197279588948
Gc3_210 0 n6 ns210 0 -0.00030669780803
Gc3_211 0 n6 ns211 0 -0.000505938281243
Gc3_212 0 n6 ns212 0 -0.00037578372901
Gc3_213 0 n6 ns213 0 0.00231621760156
Gc3_214 0 n6 ns214 0 0.00315502871839
Gc3_215 0 n6 ns215 0 0.00239280265382
Gc3_216 0 n6 ns216 0 0.00299975299727
Gc3_217 0 n6 ns217 0 -0.00130415274529
Gc3_218 0 n6 ns218 0 0.000668846014848
Gc3_219 0 n6 ns219 0 -0.000124829707544
Gc3_220 0 n6 ns220 0 -0.000789528716777
Gc3_221 0 n6 ns221 0 -0.000348838134253
Gc3_222 0 n6 ns222 0 -0.00134373143272
Gc3_223 0 n6 ns223 0 -0.000581393707394
Gc3_224 0 n6 ns224 0 0.00102110563486
Gc3_225 0 n6 ns225 0 0.000563898004351
Gc3_226 0 n6 ns226 0 4.96857866127e-06
Gc3_227 0 n6 ns227 0 -9.83298572913e-05
Gc3_228 0 n6 ns228 0 -2.65488824537e-06
Gc3_229 0 n6 ns229 0 -0.000347254475488
Gc3_230 0 n6 ns230 0 0.000598229164864
Gc3_231 0 n6 ns231 0 -0.000737574505754
Gc3_232 0 n6 ns232 0 0.00141762091615
Gc3_233 0 n6 ns233 0 -0.000225816422405
Gc3_234 0 n6 ns234 0 0.000335653153094
Gc3_235 0 n6 ns235 0 9.34836872754e-05
Gc3_236 0 n6 ns236 0 -0.000242566055164
Gc3_237 0 n6 ns237 0 -0.000141848780337
Gc3_238 0 n6 ns238 0 0.000442509748034
Gc3_239 0 n6 ns239 0 7.39931026072e-05
Gc3_240 0 n6 ns240 0 -0.000154190129387
Gc3_241 0 n6 ns241 0 5.93928255528e-05
Gc3_242 0 n6 ns242 0 -0.000459767042736
Gc3_243 0 n6 ns243 0 0.000822031206664
Gc3_244 0 n6 ns244 0 -0.000467166399361
Gc3_245 0 n6 ns245 0 0.00020796447068
Gc3_246 0 n6 ns246 0 -0.000672388030121
Gc3_247 0 n6 ns247 0 0.000308743432225
Gc3_248 0 n6 ns248 0 -0.000579044984941
Gc3_249 0 n6 ns249 0 -0.000117368733999
Gc3_250 0 n6 ns250 0 0.000927191623183
Gc3_251 0 n6 ns251 0 0.00327029146264
Gc3_252 0 n6 ns252 0 0.00249542625406
Gc3_253 0 n6 ns253 0 0.00307505869074
Gc3_254 0 n6 ns254 0 0.00205360928514
Gc3_255 0 n6 ns255 0 0.000373244575274
Gc3_256 0 n6 ns256 0 0.00136373020434
Gc3_257 0 n6 ns257 0 -0.000346094505408
Gc3_258 0 n6 ns258 0 -0.000466745437797
Gc3_259 0 n6 ns259 0 -0.00127519994534
Gc3_260 0 n6 ns260 0 -0.00137315166687
Gc3_261 0 n6 ns261 0 -0.000550516457856
Gc3_262 0 n6 ns262 0 -0.000508308008891
Gc3_263 0 n6 ns263 0 4.28553149802e-05
Gc3_264 0 n6 ns264 0 2.16482470347e-06
Gc3_265 0 n6 ns265 0 -1.5888040526e-06
Gc3_266 0 n6 ns266 0 -4.07211731217e-05
Gc3_267 0 n6 ns267 0 0.000201834743997
Gc3_268 0 n6 ns268 0 0.000457888608712
Gc3_269 0 n6 ns269 0 0.000924599992007
Gc3_270 0 n6 ns270 0 0.000776583205181
Gc3_271 0 n6 ns271 0 3.01228681389e-05
Gc3_272 0 n6 ns272 0 0.000197569372774
Gc3_273 0 n6 ns273 0 -1.44174722846e-05
Gc3_274 0 n6 ns274 0 -5.899672992e-05
Gc3_275 0 n6 ns275 0 0.000260328667603
Gc3_276 0 n6 ns276 0 0.000303776521753
Gc3_277 0 n6 ns277 0 -3.09115122999e-05
Gc3_278 0 n6 ns278 0 -9.88176754246e-05
Gc3_279 0 n6 ns279 0 -0.00024602602043
Gc3_280 0 n6 ns280 0 -0.000432202469465
Gc3_281 0 n6 ns281 0 -3.68631500425e-05
Gc3_282 0 n6 ns282 0 -0.000842872077999
Gc3_283 0 n6 ns283 0 -0.00026324650764
Gc3_284 0 n6 ns284 0 -0.000525881760786
Gc3_285 0 n6 ns285 0 -0.000162992464695
Gc3_286 0 n6 ns286 0 -0.000686854246837
Gc3_287 0 n6 ns287 0 0.000669461607157
Gc3_288 0 n6 ns288 0 0.000543527588193
Gc3_289 0 n6 ns289 0 0.00297025176109
Gc3_290 0 n6 ns290 0 -4.21431049359e-05
Gc3_291 0 n6 ns291 0 0.00259828157317
Gc3_292 0 n6 ns292 0 -0.000174295916238
Gc3_293 0 n6 ns293 0 0.000741705091288
Gc3_294 0 n6 ns294 0 0.000761770843858
Gc3_295 0 n6 ns295 0 -0.000272118714799
Gc3_296 0 n6 ns296 0 -0.000215915450004
Gc3_297 0 n6 ns297 0 -0.00113969700349
Gc3_298 0 n6 ns298 0 -0.00075746158165
Gc3_299 0 n6 ns299 0 -0.000456139380044
Gc3_300 0 n6 ns300 0 -0.00063854745568
Gc3_301 0 n6 ns301 0 -4.64943757856e-05
Gc3_302 0 n6 ns302 0 3.06881048155e-05
Gc3_303 0 n6 ns303 0 -5.49248435977e-05
Gc3_304 0 n6 ns304 0 1.06945033511e-05
Gc3_305 0 n6 ns305 0 4.84320133208e-05
Gc3_306 0 n6 ns306 0 0.00019838888493
Gc3_307 0 n6 ns307 0 0.000205689319479
Gc3_308 0 n6 ns308 0 -0.000587119153111
Gc3_309 0 n6 ns309 0 -0.000105539635428
Gc3_310 0 n6 ns310 0 -4.77315417748e-05
Gc3_311 0 n6 ns311 0 0.000108322899911
Gc3_312 0 n6 ns312 0 3.89567896913e-05
Gc3_313 0 n6 ns313 0 0.000188373288308
Gc3_314 0 n6 ns314 0 -1.87706300065e-05
Gc3_315 0 n6 ns315 0 -5.66466610506e-05
Gc3_316 0 n6 ns316 0 1.09146081243e-06
Gc3_317 0 n6 ns317 0 -0.000173585735099
Gc3_318 0 n6 ns318 0 4.54494039641e-05
Gc3_319 0 n6 ns319 0 -0.000406075381646
Gc3_320 0 n6 ns320 0 -9.27943649313e-05
Gc3_321 0 n6 ns321 0 -0.000355958449269
Gc3_322 0 n6 ns322 0 7.581437217e-05
Gc3_323 0 n6 ns323 0 -0.000443676621655
Gc3_324 0 n6 ns324 0 8.6547920377e-05
Gc3_325 0 n6 ns325 0 0.0002311266489
Gc3_326 0 n6 ns326 0 -0.000274716081521
Gc3_327 0 n6 ns327 0 0.000787719908895
Gc3_328 0 n6 ns328 0 -0.00172317187144
Gc3_329 0 n6 ns329 0 0.000670484773771
Gc3_330 0 n6 ns330 0 -0.00151388866949
Gc3_331 0 n6 ns331 0 4.26615675733e-06
Gc3_332 0 n6 ns332 0 7.06073514558e-05
Gc3_333 0 n6 ns333 0 -9.84949765752e-05
Gc3_334 0 n6 ns334 0 -4.43004476255e-05
Gc3_335 0 n6 ns335 0 -0.000303232900553
Gc3_336 0 n6 ns336 0 5.551151324e-05
Gc3_337 0 n6 ns337 0 -0.000110886990238
Gc3_338 0 n6 ns338 0 0.000399214976202
Gc3_339 0 n6 ns339 0 0.00015002522816
Gc3_340 0 n6 ns340 0 -6.57147722083e-06
Gc3_341 0 n6 ns341 0 1.66670819036e-05
Gc3_342 0 n6 ns342 0 -3.04989230025e-05
Gc3_343 0 n6 ns343 0 0.00101857483056
Gc3_344 0 n6 ns344 0 -0.00417064587764
Gc3_345 0 n6 ns345 0 -0.000450600768654
Gc3_346 0 n6 ns346 0 -0.00198287472728
Gc3_347 0 n6 ns347 0 -0.000982384646662
Gc3_348 0 n6 ns348 0 -0.000226853045926
Gc3_349 0 n6 ns349 0 0.00062877995432
Gc3_350 0 n6 ns350 0 -1.76215357285e-05
Gc3_351 0 n6 ns351 0 0.000271642575219
Gc3_352 0 n6 ns352 0 5.94069708308e-05
Gc3_353 0 n6 ns353 0 0.000241043395447
Gc3_354 0 n6 ns354 0 0.000120225395165
Gc3_355 0 n6 ns355 0 -0.000536511946942
Gc3_356 0 n6 ns356 0 -0.000135044491796
Gc3_357 0 n6 ns357 0 -0.000609932419027
Gc3_358 0 n6 ns358 0 0.000553805412928
Gc3_359 0 n6 ns359 0 0.000332055961826
Gc3_360 0 n6 ns360 0 0.000318182639834
Gc3_361 0 n6 ns361 0 -0.000505570984735
Gc3_362 0 n6 ns362 0 -0.000634154820013
Gc3_363 0 n6 ns363 0 -0.000470809607953
Gc3_364 0 n6 ns364 0 -0.000794050630112
Gc3_365 0 n6 ns365 0 0.00311150812885
Gc3_366 0 n6 ns366 0 0.00520471354135
Gc3_367 0 n6 ns367 0 0.00181245562041
Gc3_368 0 n6 ns368 0 0.00537506102547
Gc3_369 0 n6 ns369 0 -0.000229226975525
Gc3_370 0 n6 ns370 0 0.00450554534382
Gc3_371 0 n6 ns371 0 0.00116554409036
Gc3_372 0 n6 ns372 0 -0.000843870855829
Gc3_373 0 n6 ns373 0 -0.00520255251548
Gc3_374 0 n6 ns374 0 -0.00148637510462
Gc3_375 0 n6 ns375 0 0.0035390200392
Gc3_376 0 n6 ns376 0 -0.00466151280428
Gc3_377 0 n6 ns377 0 0.00467939920298
Gc3_378 0 n6 ns378 0 -1.8608349121e-05
Gc3_379 0 n6 ns379 0 -6.60298932461e-05
Gc3_380 0 n6 ns380 0 -1.85228525998e-05
Gc3_381 0 n6 ns381 0 0.0010988754771
Gc3_382 0 n6 ns382 0 -0.00481944117069
Gc3_383 0 n6 ns383 0 0.00086013254771
Gc3_384 0 n6 ns384 0 -0.00358387997908
Gc3_385 0 n6 ns385 0 -0.00116983366663
Gc3_386 0 n6 ns386 0 -0.000693247345005
Gc3_387 0 n6 ns387 0 0.00060635193375
Gc3_388 0 n6 ns388 0 -0.000129223349017
Gc3_389 0 n6 ns389 0 -0.000108820076141
Gc3_390 0 n6 ns390 0 0.000219867914475
Gc3_391 0 n6 ns391 0 0.000286583397645
Gc3_392 0 n6 ns392 0 5.09290118452e-05
Gc3_393 0 n6 ns393 0 -0.000365729162614
Gc3_394 0 n6 ns394 0 0.000614050393896
Gc3_395 0 n6 ns395 0 0.000701549060107
Gc3_396 0 n6 ns396 0 -2.00362255661e-05
Gc3_397 0 n6 ns397 0 0.000958399575927
Gc3_398 0 n6 ns398 0 -6.46980134868e-05
Gc3_399 0 n6 ns399 0 0.000346226612859
Gc3_400 0 n6 ns400 0 -0.000607750531645
Gc3_401 0 n6 ns401 0 0.000302219237141
Gc3_402 0 n6 ns402 0 0.00135670445173
Gc3_403 0 n6 ns403 0 0.00356763507196
Gc3_404 0 n6 ns404 0 0.00641574655126
Gc3_405 0 n6 ns405 0 0.0025278376192
Gc3_406 0 n6 ns406 0 0.0063904658483
Gc3_407 0 n6 ns407 0 0.00210808232723
Gc3_408 0 n6 ns408 0 0.00177082769767
Gc3_409 0 n6 ns409 0 0.0010739836011
Gc3_410 0 n6 ns410 0 -0.000941596861921
Gc3_411 0 n6 ns411 0 -0.00349829563857
Gc3_412 0 n6 ns412 0 -0.00115371356953
Gc3_413 0 n6 ns413 0 -0.000467751613427
Gc3_414 0 n6 ns414 0 -0.0020139540359
Gc3_415 0 n6 ns415 0 0.00383260777997
Gc3_416 0 n6 ns416 0 -4.47751608046e-06
Gc3_417 0 n6 ns417 0 -0.000118625836953
Gc3_418 0 n6 ns418 0 3.33501741233e-06
Gc3_419 0 n6 ns419 0 0.000663077239274
Gc3_420 0 n6 ns420 0 -0.00181219364794
Gc3_421 0 n6 ns421 0 0.00181199028202
Gc3_422 0 n6 ns422 0 -0.00118985014806
Gc3_423 0 n6 ns423 0 -0.000317329783709
Gc3_424 0 n6 ns424 0 8.57406716454e-05
Gc3_425 0 n6 ns425 0 -0.000141806949318
Gc3_426 0 n6 ns426 0 -0.000135753668392
Gc3_427 0 n6 ns427 0 0.000255138554269
Gc3_428 0 n6 ns428 0 -3.41304189699e-05
Gc3_429 0 n6 ns429 0 0.000214620132564
Gc3_430 0 n6 ns430 0 -5.14925203547e-05
Gc3_431 0 n6 ns431 0 1.61873363871e-05
Gc3_432 0 n6 ns432 0 7.73583203095e-05
Gc3_433 0 n6 ns433 0 -0.000360495269511
Gc3_434 0 n6 ns434 0 -0.000835277145967
Gc3_435 0 n6 ns435 0 0.000584623935372
Gc3_436 0 n6 ns436 0 -0.000727410200681
Gc3_437 0 n6 ns437 0 0.000122615743897
Gc3_438 0 n6 ns438 0 -0.0012925399896
Gc3_439 0 n6 ns439 0 0.00181415314302
Gc3_440 0 n6 ns440 0 0.000210440672293
Gc3_441 0 n6 ns441 0 0.00300190550709
Gc3_442 0 n6 ns442 0 0.00429496574592
Gc3_443 0 n6 ns443 0 0.00256930922898
Gc3_444 0 n6 ns444 0 0.00451586490873
Gc3_445 0 n6 ns445 0 -6.21630684996e-05
Gc3_446 0 n6 ns446 0 -0.00189791125472
Gc3_447 0 n6 ns447 0 0.000673721822786
Gc3_448 0 n6 ns448 0 -0.00107267224292
Gc3_449 0 n6 ns449 0 -1.53273930237e-06
Gc3_450 0 n6 ns450 0 -0.000651799284284
Gc3_451 0 n6 ns451 0 -0.00224402185025
Gc3_452 0 n6 ns452 0 0.0021742273482
Gc3_453 0 n6 ns453 0 0.00197072411715
Gc3_454 0 n6 ns454 0 1.44166705509e-05
Gc3_455 0 n6 ns455 0 -0.000225810670489
Gc3_456 0 n6 ns456 0 7.05318099703e-05
Gc3_457 0 n6 ns457 0 -6.6352374882e-05
Gc3_458 0 n6 ns458 0 -4.22360226694e-05
Gc3_459 0 n6 ns459 0 8.93939821245e-05
Gc3_460 0 n6 ns460 0 0.000388253366196
Gc3_461 0 n6 ns461 0 9.31023909262e-05
Gc3_462 0 n6 ns462 0 0.000104588402808
Gc3_463 0 n6 ns463 0 2.78992231435e-05
Gc3_464 0 n6 ns464 0 8.79423346579e-05
Gc3_465 0 n6 ns465 0 -5.24755982594e-05
Gc3_466 0 n6 ns466 0 -0.000203300377705
Gc3_467 0 n6 ns467 0 0.000167899449421
Gc3_468 0 n6 ns468 0 -0.000112874817224
Gc3_469 0 n6 ns469 0 -0.000200037384517
Gc3_470 0 n6 ns470 0 -0.00032126926186
Gc3_471 0 n6 ns471 0 -0.000311908820816
Gc3_472 0 n6 ns472 0 0.000501724610665
Gc3_473 0 n6 ns473 0 0.000231353369962
Gc3_474 0 n6 ns474 0 -0.000426011356446
Gc3_475 0 n6 ns475 0 -0.000350624161873
Gc3_476 0 n6 ns476 0 -0.00050600425297
Gc3_477 0 n6 ns477 0 -9.49536536919e-05
Gc3_478 0 n6 ns478 0 -0.000815923467382
Gc3_479 0 n6 ns479 0 0.00226036280865
Gc3_480 0 n6 ns480 0 0.00324284758568
Gc3_481 0 n6 ns481 0 0.0023160841007
Gc3_482 0 n6 ns482 0 0.00326485888397
Gc3_483 0 n6 ns483 0 -0.0017478012499
Gc3_484 0 n6 ns484 0 -6.26748233815e-05
Gc3_485 0 n6 ns485 0 4.31378392526e-05
Gc3_486 0 n6 ns486 0 -0.000904188909729
Gc3_487 0 n6 ns487 0 3.49440963058e-05
Gc3_488 0 n6 ns488 0 -0.00111625397391
Gc3_489 0 n6 ns489 0 -0.000711812984526
Gc3_490 0 n6 ns490 0 0.00174162664914
Gc3_491 0 n6 ns491 0 0.000867006303284
Gc3_492 0 n6 ns492 0 1.85212452464e-05
Gc3_493 0 n6 ns493 0 -0.000163066380226
Gc3_494 0 n6 ns494 0 2.89701163969e-05
Gc3_495 0 n6 ns495 0 -0.000386229025205
Gc3_496 0 n6 ns496 0 0.000291234433293
Gc3_497 0 n6 ns497 0 -0.000910383629782
Gc3_498 0 n6 ns498 0 0.000849618601225
Gc3_499 0 n6 ns499 0 -0.000228500692669
Gc3_500 0 n6 ns500 0 0.00012499364539
Gc3_501 0 n6 ns501 0 0.000163291952413
Gc3_502 0 n6 ns502 0 -0.000148715558854
Gc3_503 0 n6 ns503 0 -0.000312150742109
Gc3_504 0 n6 ns504 0 0.000253100706171
Gc3_505 0 n6 ns505 0 0.00010492358566
Gc3_506 0 n6 ns506 0 -0.000142324632545
Gc3_507 0 n6 ns507 0 6.79272447591e-05
Gc3_508 0 n6 ns508 0 -0.000250202860127
Gc3_509 0 n6 ns509 0 0.000839753680164
Gc3_510 0 n6 ns510 0 5.6934560822e-05
Gc3_511 0 n6 ns511 0 0.000304299332027
Gc3_512 0 n6 ns512 0 -0.000540791371715
Gc3_513 0 n6 ns513 0 0.000220433879041
Gc3_514 0 n6 ns514 0 -0.000327644572785
Gc3_515 0 n6 ns515 0 -0.000510331005402
Gc3_516 0 n6 ns516 0 0.000572926412175
Gc3_517 0 n6 ns517 0 0.00293293403858
Gc3_518 0 n6 ns518 0 0.0029375190901
Gc3_519 0 n6 ns519 0 0.00287861451295
Gc3_520 0 n6 ns520 0 0.0025414599261
Gc3_521 0 n6 ns521 0 -0.000192916358993
Gc3_522 0 n6 ns522 0 0.00124727354772
Gc3_523 0 n6 ns523 0 -0.000309478910292
Gc3_524 0 n6 ns524 0 -0.000557986457617
Gc3_525 0 n6 ns525 0 -0.00100822614638
Gc3_526 0 n6 ns526 0 -0.00132293543
Gc3_527 0 n6 ns527 0 -0.000525008396494
Gc3_528 0 n6 ns528 0 0.000116896406048
Gc3_529 0 n6 ns529 0 0.00023580455171
Gc3_530 0 n6 ns530 0 2.77227100974e-06
Gc3_531 0 n6 ns531 0 -1.77280836979e-05
Gc3_532 0 n6 ns532 0 -4.58005525787e-05
Gc3_533 0 n6 ns533 0 9.70916715208e-05
Gc3_534 0 n6 ns534 0 0.000485974170986
Gc3_535 0 n6 ns535 0 0.000633613536684
Gc3_536 0 n6 ns536 0 0.00108392361369
Gc3_537 0 n6 ns537 0 -3.97773414441e-05
Gc3_538 0 n6 ns538 0 0.000155403512858
Gc3_539 0 n6 ns539 0 7.2384422305e-07
Gc3_540 0 n6 ns540 0 -4.17189122369e-05
Gc3_541 0 n6 ns541 0 0.000113963688722
Gc3_542 0 n6 ns542 0 0.000479338776022
Gc3_543 0 n6 ns543 0 1.05876184784e-05
Gc3_544 0 n6 ns544 0 -0.000146786135228
Gc3_545 0 n6 ns545 0 -0.000136096001803
Gc3_546 0 n6 ns546 0 -0.000552298587444
Gc3_547 0 n6 ns547 0 0.000318456893451
Gc3_548 0 n6 ns548 0 -0.000939638205238
Gc3_549 0 n6 ns549 0 -0.000112285581773
Gc3_550 0 n6 ns550 0 -0.000718801881915
Gc3_551 0 n6 ns551 0 4.27102146885e-05
Gc3_552 0 n6 ns552 0 -0.000844868505859
Gc3_553 0 n6 ns553 0 0.00059065687085
Gc3_554 0 n6 ns554 0 0.00085827740887
Gc3_555 0 n6 ns555 0 0.00370914013156
Gc3_556 0 n6 ns556 0 0.000951795214966
Gc3_557 0 n6 ns557 0 0.00329986264708
Gc3_558 0 n6 ns558 0 0.000660742795926
Gc3_559 0 n6 ns559 0 0.000809836571293
Gc3_560 0 n6 ns560 0 0.00103436773861
Gc3_561 0 n6 ns561 0 -0.000325557467337
Gc3_562 0 n6 ns562 0 -0.000305432679538
Gc3_563 0 n6 ns563 0 -0.0013405436308
Gc3_564 0 n6 ns564 0 -0.00105026344887
Gc3_565 0 n6 ns565 0 -0.000540654669133
Gc3_566 0 n6 ns566 0 -0.000831050640041
Gc3_567 0 n6 ns567 0 -6.85440017824e-05
Gc3_568 0 n6 ns568 0 3.47808292396e-05
Gc3_569 0 n6 ns569 0 -5.60871145446e-05
Gc3_570 0 n6 ns570 0 -4.46100725878e-06
Gc3_571 0 n6 ns571 0 0.000144666477928
Gc3_572 0 n6 ns572 0 0.000314190540134
Gc3_573 0 n6 ns573 0 0.000669770500872
Gc3_574 0 n6 ns574 0 -0.000164919713055
Gc3_575 0 n6 ns575 0 9.05010699212e-06
Gc3_576 0 n6 ns576 0 4.67116331425e-05
Gc3_577 0 n6 ns577 0 3.24758197525e-05
Gc3_578 0 n6 ns578 0 9.45477452012e-06
Gc3_579 0 n6 ns579 0 0.00026834625139
Gc3_580 0 n6 ns580 0 6.15056956392e-05
Gc3_581 0 n6 ns581 0 -6.31918466032e-05
Gc3_582 0 n6 ns582 0 -3.4024285934e-05
Gc3_583 0 n6 ns583 0 -0.00028032865408
Gc3_584 0 n6 ns584 0 -0.000101824185213
Gc3_585 0 n6 ns585 0 -0.000403801229677
Gc3_586 0 n6 ns586 0 -0.000367376477342
Gc3_587 0 n6 ns587 0 -0.00040537974701
Gc3_588 0 n6 ns588 0 -0.000112228866458
Gc3_589 0 n6 ns589 0 -0.000454604107381
Gc3_590 0 n6 ns590 0 -0.000178036951683
Gc3_591 0 n6 ns591 0 0.000450450130835
Gc3_592 0 n6 ns592 0 -7.5425888061e-05
Gc3_593 0 n6 ns593 0 0.00156266653707
Gc3_594 0 n6 ns594 0 -0.00146809085697
Gc3_595 0 n6 ns595 0 0.00134046538202
Gc3_596 0 n6 ns596 0 -0.00133150925143
Gc3_597 0 n6 ns597 0 0.000277828102236
Gc3_598 0 n6 ns598 0 0.000242749389385
Gc3_599 0 n6 ns599 0 -0.000162326793649
Gc3_600 0 n6 ns600 0 -8.51311426199e-05
Gc3_601 0 n6 ns601 0 -0.000603981136072
Gc3_602 0 n6 ns602 0 -0.000141543961318
Gc3_603 0 n6 ns603 0 -0.000236657071075
Gc3_604 0 n6 ns604 0 0.000127700576383
Gc3_605 0 n6 ns605 0 0.000105937129595
Gc3_606 0 n6 ns606 0 1.23670984956e-05
Gc3_607 0 n6 ns607 0 -1.76838846253e-05
Gc3_608 0 n6 ns608 0 -1.37697154182e-05
Gc3_609 0 n6 ns609 0 -0.000990125944285
Gc3_610 0 n6 ns610 0 0.000232251432044
Gc3_611 0 n6 ns611 0 -0.00303202858407
Gc3_612 0 n6 ns612 0 0.00113518158957
Gc3_613 0 n6 ns613 0 -0.00013043286339
Gc3_614 0 n6 ns614 0 0.000966963964154
Gc3_615 0 n6 ns615 0 0.000243550572709
Gc3_616 0 n6 ns616 0 -0.000411273080212
Gc3_617 0 n6 ns617 0 -0.000734058458623
Gc3_618 0 n6 ns618 0 -8.01140991416e-06
Gc3_619 0 n6 ns619 0 -0.000103835231437
Gc3_620 0 n6 ns620 0 -2.4987049772e-05
Gc3_621 0 n6 ns621 0 0.00104837249296
Gc3_622 0 n6 ns622 0 0.000338193777542
Gc3_623 0 n6 ns623 0 -0.000316328527597
Gc3_624 0 n6 ns624 0 -0.00114250535422
Gc3_625 0 n6 ns625 0 0.000458504081136
Gc3_626 0 n6 ns626 0 2.85224031633e-05
Gc3_627 0 n6 ns627 0 0.000294899043807
Gc3_628 0 n6 ns628 0 -0.000532465347811
Gc3_629 0 n6 ns629 0 -0.00252328252226
Gc3_630 0 n6 ns630 0 0.00015395276365
Gc3_631 0 n6 ns631 0 -0.00161552399751
Gc3_632 0 n6 ns632 0 0.00107508873829
Gc3_633 0 n6 ns633 0 -0.000784971927883
Gc3_634 0 n6 ns634 0 4.0310132881e-05
Gc3_635 0 n6 ns635 0 0.00194642318506
Gc3_636 0 n6 ns636 0 -0.00198277158667
Gc3_637 0 n6 ns637 0 0.00120830632336
Gc3_638 0 n6 ns638 0 -0.000683993481796
Gc3_639 0 n6 ns639 0 0.000491538715729
Gc3_640 0 n6 ns640 0 3.74917248388e-05
Gc3_641 0 n6 ns641 0 0.0027197571837
Gc3_642 0 n6 ns642 0 -0.00105886130882
Gc3_643 0 n6 ns643 0 -0.00226896570604
Gc3_644 0 n6 ns644 0 -9.48529707816e-06
Gc3_645 0 n6 ns645 0 0.000223491087021
Gc3_646 0 n6 ns646 0 -7.6195808534e-05
Gc3_647 0 n6 ns647 0 -0.00111360037263
Gc3_648 0 n6 ns648 0 -0.000417433692059
Gc3_649 0 n6 ns649 0 -0.00430709988555
Gc3_650 0 n6 ns650 0 -0.00155646900793
Gc3_651 0 n6 ns651 0 -0.00204422896863
Gc3_652 0 n6 ns652 0 0.00102092101602
Gc3_653 0 n6 ns653 0 0.00096329257046
Gc3_654 0 n6 ns654 0 -0.00050235430363
Gc3_655 0 n6 ns655 0 -0.000799737927049
Gc3_656 0 n6 ns656 0 0.000229994460984
Gc3_657 0 n6 ns657 0 -0.000112630946279
Gc3_658 0 n6 ns658 0 -6.01396375974e-05
Gc3_659 0 n6 ns659 0 0.000951955160071
Gc3_660 0 n6 ns660 0 -2.2043152e-05
Gc3_661 0 n6 ns661 0 0.000262544750273
Gc3_662 0 n6 ns662 0 -0.000913293790596
Gc3_663 0 n6 ns663 0 0.000893319234936
Gc3_664 0 n6 ns664 0 0.000270206256188
Gc3_665 0 n6 ns665 0 0.000785016223313
Gc3_666 0 n6 ns666 0 -8.19256112095e-05
Gc3_667 0 n6 ns667 0 -0.00233093126844
Gc3_668 0 n6 ns668 0 -0.000447250971139
Gc3_669 0 n6 ns669 0 -0.00163090584528
Gc3_670 0 n6 ns670 0 -0.00068923173328
Gc3_671 0 n6 ns671 0 -0.000719895300431
Gc3_672 0 n6 ns672 0 -0.00151641401001
Gc3_673 0 n6 ns673 0 0.00302299654579
Gc3_674 0 n6 ns674 0 0.000177304538646
Gc3_675 0 n6 ns675 0 0.00131685952597
Gc3_676 0 n6 ns676 0 -0.000896496279139
Gc3_677 0 n6 ns677 0 -0.000759129343895
Gc3_678 0 n6 ns678 0 -0.00161284151876
Gc3_679 0 n6 ns679 0 0.00292885246829
Gc3_680 0 n6 ns680 0 0.000227752768121
Gc3_681 0 n6 ns681 0 -0.00314017883584
Gc3_682 0 n6 ns682 0 -2.77485970031e-05
Gc3_683 0 n6 ns683 0 0.000393189632131
Gc3_684 0 n6 ns684 0 -0.000229300928391
Gc3_685 0 n6 ns685 0 -0.000407588999736
Gc3_686 0 n6 ns686 0 -0.000247115744963
Gc3_687 0 n6 ns687 0 0.000482191079143
Gc3_688 0 n6 ns688 0 0.00257924510857
Gc3_689 0 n6 ns689 0 0.00129982897495
Gc3_690 0 n6 ns690 0 -0.000970985704851
Gc3_691 0 n6 ns691 0 -0.000412304219688
Gc3_692 0 n6 ns692 0 7.38820893415e-05
Gc3_693 0 n6 ns693 0 0.000165365448578
Gc3_694 0 n6 ns694 0 0.000564544962386
Gc3_695 0 n6 ns695 0 -0.000130507439846
Gc3_696 0 n6 ns696 0 -0.000116350386507
Gc3_697 0 n6 ns697 0 0.00168408520729
Gc3_698 0 n6 ns698 0 -0.00113759185007
Gc3_699 0 n6 ns699 0 -0.000689918335935
Gc3_700 0 n6 ns700 0 0.00180134264516
Gc3_701 0 n6 ns701 0 -9.94918997542e-05
Gc3_702 0 n6 ns702 0 0.00044699290726
Gc3_703 0 n6 ns703 0 -0.00166118745451
Gc3_704 0 n6 ns704 0 -0.00084271082048
Gc3_705 0 n6 ns705 0 0.00329342312353
Gc3_706 0 n6 ns706 0 0.00411662184582
Gc3_707 0 n6 ns707 0 -0.00676152442181
Gc3_708 0 n6 ns708 0 -0.00017485914756
Gc3_709 0 n6 ns709 0 -0.00480086303393
Gc3_710 0 n6 ns710 0 -0.00149149912739
Gc3_711 0 n6 ns711 0 -0.0115052317792
Gc3_712 0 n6 ns712 0 -0.00118209350169
Gc3_713 0 n6 ns713 0 0.00169888122767
Gc3_714 0 n6 ns714 0 6.84348649562e-05
Gc3_715 0 n6 ns715 0 -0.00270866206637
Gc3_716 0 n6 ns716 0 0.00889921425037
Gc3_717 0 n6 ns717 0 -0.0140391333702
Gc3_718 0 n6 ns718 0 -0.00375199089798
Gc3_719 0 n6 ns719 0 -0.00620181640145
Gc3_720 0 n6 ns720 0 -6.13665481485e-05
Gc3_721 0 n6 ns721 0 -0.000422244604761
Gc3_722 0 n6 ns722 0 0.000612688734418
Gc3_723 0 n6 ns723 0 -0.00079124308661
Gc3_724 0 n6 ns724 0 -0.000989224898605
Gc3_725 0 n6 ns725 0 -0.00329740663824
Gc3_726 0 n6 ns726 0 -0.00169196565221
Gc3_727 0 n6 ns727 0 -0.00193952947915
Gc3_728 0 n6 ns728 0 0.00102290050418
Gc3_729 0 n6 ns729 0 0.000883968199363
Gc3_730 0 n6 ns730 0 -0.000363565015405
Gc3_731 0 n6 ns731 0 -0.000164812813039
Gc3_732 0 n6 ns732 0 0.000146254074994
Gc3_733 0 n6 ns733 0 -0.000265027250785
Gc3_734 0 n6 ns734 0 -3.8045426162e-06
Gc3_735 0 n6 ns735 0 0.000390713057667
Gc3_736 0 n6 ns736 0 0.000340903471948
Gc3_737 0 n6 ns737 0 0.00109825083087
Gc3_738 0 n6 ns738 0 -0.000624321248458
Gc3_739 0 n6 ns739 0 0.00134261571676
Gc3_740 0 n6 ns740 0 -0.000317704010288
Gc3_741 0 n6 ns741 0 0.0011930610927
Gc3_742 0 n6 ns742 0 -0.000656052349621
Gc3_743 0 n6 ns743 0 -0.00172974597819
Gc3_744 0 n6 ns744 0 -0.000897229008326
Gc3_745 0 n6 ns745 0 -0.0046942230155
Gc3_746 0 n6 ns746 0 -0.00441885096654
Gc3_747 0 n6 ns747 0 -0.00364528390889
Gc3_748 0 n6 ns748 0 -0.00469282650938
Gc3_749 0 n6 ns749 0 0.00306358260921
Gc3_750 0 n6 ns750 0 0.00180773835341
Gc3_751 0 n6 ns751 0 0.000950592280472
Gc3_752 0 n6 ns752 0 -0.00121933101919
Gc3_753 0 n6 ns753 0 -0.0017259381402
Gc3_754 0 n6 ns754 0 -0.00292869093201
Gc3_755 0 n6 ns755 0 0.002543756456
Gc3_756 0 n6 ns756 0 -0.000561039293483
Gc3_757 0 n6 ns757 0 -0.00319874082827
Gc3_758 0 n6 ns758 0 -3.80883562336e-05
Gc3_759 0 n6 ns759 0 0.000336519303493
Gc3_760 0 n6 ns760 0 -0.000161717110164
Gc3_761 0 n6 ns761 0 -0.000585993408596
Gc3_762 0 n6 ns762 0 0.000320022372095
Gc3_763 0 n6 ns763 0 -0.00135526586764
Gc3_764 0 n6 ns764 0 0.0025684420883
Gc3_765 0 n6 ns765 0 -0.000199162220273
Gc3_766 0 n6 ns766 0 0.000542278813167
Gc3_767 0 n6 ns767 0 0.000210568750947
Gc3_768 0 n6 ns768 0 -0.000408689255195
Gc3_769 0 n6 ns769 0 -0.000153431873903
Gc3_770 0 n6 ns770 0 0.000439171168886
Gc3_771 0 n6 ns771 0 -0.000114444750698
Gc3_772 0 n6 ns772 0 0.000109547491818
Gc3_773 0 n6 ns773 0 0.000915941098187
Gc3_774 0 n6 ns774 0 -0.000610078302292
Gc3_775 0 n6 ns775 0 -5.97399463228e-05
Gc3_776 0 n6 ns776 0 -0.000326641458354
Gc3_777 0 n6 ns777 0 0.000623249103598
Gc3_778 0 n6 ns778 0 -0.000534558653665
Gc3_779 0 n6 ns779 0 0.000201458513584
Gc3_780 0 n6 ns780 0 -0.000716143441427
Gc3_781 0 n6 ns781 0 -0.00100491517461
Gc3_782 0 n6 ns782 0 0.000987316720442
Gc3_783 0 n6 ns783 0 -0.0028914838509
Gc3_784 0 n6 ns784 0 -0.00273333060924
Gc3_785 0 n6 ns785 0 -0.00263321419666
Gc3_786 0 n6 ns786 0 -0.00312878724292
Gc3_787 0 n6 ns787 0 -0.000353182585333
Gc3_788 0 n6 ns788 0 0.00104265609892
Gc3_789 0 n6 ns789 0 0.000315055861854
Gc3_790 0 n6 ns790 0 -0.00136793808841
Gc3_791 0 n6 ns791 0 -0.000124971953582
Gc3_792 0 n6 ns792 0 -0.00308358919914
Gc3_793 0 n6 ns793 0 0.00102636786045
Gc3_794 0 n6 ns794 0 -0.00341824576844
Gc3_795 0 n6 ns795 0 -0.00161262801468
Gc3_796 0 n6 ns796 0 -2.94422583978e-05
Gc3_797 0 n6 ns797 0 0.00011205329831
Gc3_798 0 n6 ns798 0 -6.43299217113e-06
Gc3_799 0 n6 ns799 0 -7.24567163254e-05
Gc3_800 0 n6 ns800 0 -0.00031528252185
Gc3_801 0 n6 ns801 0 -0.000191406080084
Gc3_802 0 n6 ns802 0 0.000246933564132
Gc3_803 0 n6 ns803 0 -0.000111844237493
Gc3_804 0 n6 ns804 0 2.26800894814e-05
Gc3_805 0 n6 ns805 0 -7.91018153098e-05
Gc3_806 0 n6 ns806 0 -8.35212790095e-06
Gc3_807 0 n6 ns807 0 0.000173381802974
Gc3_808 0 n6 ns808 0 0.000232445965875
Gc3_809 0 n6 ns809 0 -6.70480182021e-05
Gc3_810 0 n6 ns810 0 0.0001243117816
Gc3_811 0 n6 ns811 0 6.24464104413e-05
Gc3_812 0 n6 ns812 0 -0.0002057186453
Gc3_813 0 n6 ns813 0 0.000353071046346
Gc3_814 0 n6 ns814 0 0.000581544181317
Gc3_815 0 n6 ns815 0 0.000384083389861
Gc3_816 0 n6 ns816 0 -0.000300008291245
Gc3_817 0 n6 ns817 0 9.16911265364e-05
Gc3_818 0 n6 ns818 0 -6.16548278632e-05
Gc3_819 0 n6 ns819 0 -0.000101462851603
Gc3_820 0 n6 ns820 0 -2.54298215067e-05
Gc3_821 0 n6 ns821 0 -0.00418345376438
Gc3_822 0 n6 ns822 0 -0.0046005353686
Gc3_823 0 n6 ns823 0 -0.00394925463974
Gc3_824 0 n6 ns824 0 -0.00419401133175
Gc3_825 0 n6 ns825 0 -0.000650709481709
Gc3_826 0 n6 ns826 0 0.00182292034039
Gc3_827 0 n6 ns827 0 -0.000209299361256
Gc3_828 0 n6 ns828 0 -0.000926387295494
Gc3_829 0 n6 ns829 0 -0.000720047333934
Gc3_830 0 n6 ns830 0 -0.0024333653831
Gc3_831 0 n6 ns831 0 0.000143516155925
Gc3_832 0 n6 ns832 0 -0.0016625788349
Gc3_833 0 n6 ns833 0 -0.000612125098705
Gc3_834 0 n6 ns834 0 -1.76634556477e-05
Gc3_835 0 n6 ns835 0 7.72061601789e-05
Gc3_836 0 n6 ns836 0 1.47536441732e-06
Gc3_837 0 n6 ns837 0 0.000333174813581
Gc3_838 0 n6 ns838 0 -0.000176131892676
Gc3_839 0 n6 ns839 0 0.00123585801724
Gc3_840 0 n6 ns840 0 -0.000402696543283
Gc3_841 0 n6 ns841 0 0.000229380532988
Gc3_842 0 n6 ns842 0 -3.09832962435e-05
Gc3_843 0 n6 ns843 0 -7.52378021176e-05
Gc3_844 0 n6 ns844 0 5.64919039665e-05
Gc3_845 0 n6 ns845 0 0.000300437373244
Gc3_846 0 n6 ns846 0 -0.000387155234535
Gc3_847 0 n6 ns847 0 -7.2427782415e-05
Gc3_848 0 n6 ns848 0 0.000110289500512
Gc3_849 0 n6 ns849 0 -0.000177171850068
Gc3_850 0 n6 ns850 0 0.000397411945171
Gc3_851 0 n6 ns851 0 0.000417678707679
Gc3_852 0 n6 ns852 0 -0.000204160152624
Gc3_853 0 n6 ns853 0 -7.63840763108e-05
Gc3_854 0 n6 ns854 0 -0.000560633564776
Gc3_855 0 n6 ns855 0 -0.000211404835966
Gc3_856 0 n6 ns856 0 -0.000510967081502
Gc3_857 0 n6 ns857 0 -4.87225905103e-05
Gc3_858 0 n6 ns858 0 -0.000362594836301
Gc3_859 0 n6 ns859 0 -0.00475856024084
Gc3_860 0 n6 ns860 0 -0.00140212477389
Gc3_861 0 n6 ns861 0 -0.00431368371071
Gc3_862 0 n6 ns862 0 -0.00117819468377
Gc3_863 0 n6 ns863 0 0.000610067117048
Gc3_864 0 n6 ns864 0 0.00170754914661
Gc3_865 0 n6 ns865 0 -0.000386863348687
Gc3_866 0 n6 ns866 0 -0.00049257725812
Gc3_867 0 n6 ns867 0 -0.0014258699034
Gc3_868 0 n6 ns868 0 -0.00162853632383
Gc3_869 0 n6 ns869 0 -0.000235917250419
Gc3_870 0 n6 ns870 0 -0.00132891973858
Gc3_871 0 n6 ns871 0 -0.000380423039527
Gc3_872 0 n6 ns872 0 -3.30860652057e-06
Gc3_873 0 n6 ns873 0 2.93370171547e-05
Gc3_874 0 n6 ns874 0 2.59924566181e-05
Gc3_875 0 n6 ns875 0 -0.000304530516182
Gc3_876 0 n6 ns876 0 0.00105224150303
Gc3_877 0 n6 ns877 0 -0.000502207239583
Gc3_878 0 n6 ns878 0 0.00130663444305
Gc3_879 0 n6 ns879 0 -9.84902241441e-05
Gc3_880 0 n6 ns880 0 0.000505010638642
Gc3_881 0 n6 ns881 0 9.33439545801e-05
Gc3_882 0 n6 ns882 0 -0.000317827279048
Gc3_883 0 n6 ns883 0 -3.77867436725e-06
Gc3_884 0 n6 ns884 0 -1.4399445649e-05
Gc3_885 0 n6 ns885 0 0.000102938705588
Gc3_886 0 n6 ns886 0 3.60586978631e-05
Gc3_887 0 n6 ns887 0 0.000216116059068
Gc3_888 0 n6 ns888 0 -0.000463748027072
Gc3_889 0 n6 ns889 0 5.51044147126e-05
Gc3_890 0 n6 ns890 0 -0.000689893807858
Gc3_891 0 n6 ns891 0 -0.000287524580396
Gc3_892 0 n6 ns892 0 -0.000369444045485
Gc3_893 0 n6 ns893 0 -0.000256703199902
Gc3_894 0 n6 ns894 0 -0.000346068342188
Gc3_895 0 n6 ns895 0 -0.000453741075536
Gc3_896 0 n6 ns896 0 0.000164769597422
Gc3_897 0 n6 ns897 0 -0.00363531293818
Gc3_898 0 n6 ns898 0 0.00193249922167
Gc3_899 0 n6 ns899 0 -0.00316380486779
Gc3_900 0 n6 ns900 0 0.00171008243092
Gc3_901 0 n6 ns901 0 0.00103806486675
Gc3_902 0 n6 ns902 0 0.00140086156793
Gc3_903 0 n6 ns903 0 -0.000337273525572
Gc3_904 0 n6 ns904 0 -0.000270615930252
Gc3_905 0 n6 ns905 0 -0.00135277988823
Gc3_906 0 n6 ns906 0 -0.00117206296965
Gc3_907 0 n6 ns907 0 -0.000273057189864
Gc3_908 0 n6 ns908 0 -0.0011976651609
Gc3_909 0 n6 ns909 0 -0.000313305194829
Gc3_910 0 n6 ns910 0 -7.77666479302e-06
Gc3_911 0 n6 ns911 0 1.37759691457e-05
Gc3_912 0 n6 ns912 0 1.74564712554e-05
Gc3_913 0 n6 ns913 0 0.000303289906982
Gc3_914 0 n6 ns914 0 -0.000315787768742
Gc3_915 0 n6 ns915 0 0.000712694291595
Gc3_916 0 n6 ns916 0 -0.000513111087261
Gc3_917 0 n6 ns917 0 0.000168443618709
Gc3_918 0 n6 ns918 0 -0.000218069695665
Gc3_919 0 n6 ns919 0 -0.000149851512029
Gc3_920 0 n6 ns920 0 9.86520041099e-05
Gc3_921 0 n6 ns921 0 -0.000268007517864
Gc3_922 0 n6 ns922 0 -3.72268963094e-06
Gc3_923 0 n6 ns923 0 8.45909751131e-05
Gc3_924 0 n6 ns924 0 9.61674777556e-06
Gc3_925 0 n6 ns925 0 6.95177952082e-05
Gc3_926 0 n6 ns926 0 -0.000153708375672
Gc3_927 0 n6 ns927 0 -0.000368594711762
Gc3_928 0 n6 ns928 0 -0.0001189498667
Gc3_929 0 n6 ns929 0 -0.000367706872014
Gc3_930 0 n6 ns930 0 9.47886538036e-05
Gc3_931 0 n6 ns931 0 -0.000454928579603
Gc3_932 0 n6 ns932 0 0.000180985571753
Gc3_933 0 n6 ns933 0 -0.000339558048255
Gc3_934 0 n6 ns934 0 -3.80795834641e-05
Gc3_935 0 n6 ns935 0 -0.00148875153957
Gc3_936 0 n6 ns936 0 0.00131165565972
Gc3_937 0 n6 ns937 0 -0.00127243652002
Gc3_938 0 n6 ns938 0 0.00117830973256
Gc3_939 0 n6 ns939 0 0.000433973623475
Gc3_940 0 n6 ns940 0 0.000334640148555
Gc3_941 0 n6 ns941 0 -0.000145372519969
Gc3_942 0 n6 ns942 0 -7.25797710385e-05
Gc3_943 0 n6 ns943 0 -0.000568700244769
Gc3_944 0 n6 ns944 0 -0.000215685513579
Gc3_945 0 n6 ns945 0 -6.94309936854e-05
Gc3_946 0 n6 ns946 0 -0.000141179626963
Gc3_947 0 n6 ns947 0 -6.88013129047e-05
Gc3_948 0 n6 ns948 0 -1.12346599839e-05
Gc3_949 0 n6 ns949 0 1.96968267389e-05
Gc3_950 0 n6 ns950 0 7.67689583197e-06
Gc3_951 0 n6 ns951 0 0.00220895910179
Gc3_952 0 n6 ns952 0 -0.00345295402767
Gc3_953 0 n6 ns953 0 0.00454825646708
Gc3_954 0 n6 ns954 0 -0.00711657779073
Gc3_955 0 n6 ns955 0 -0.003438484171
Gc3_956 0 n6 ns956 0 -0.00251948992685
Gc3_957 0 n6 ns957 0 0.00111225931182
Gc3_958 0 n6 ns958 0 0.000750518021373
Gc3_959 0 n6 ns959 0 -0.000673371497741
Gc3_960 0 n6 ns960 0 -0.000106439502596
Gc3_961 0 n6 ns961 0 -0.000187332497864
Gc3_962 0 n6 ns962 0 -0.00013088942602
Gc3_963 0 n6 ns963 0 -0.000470213566718
Gc3_964 0 n6 ns964 0 -0.000764236350031
Gc3_965 0 n6 ns965 0 0.000705950709212
Gc3_966 0 n6 ns966 0 0.000566219630736
Gc3_967 0 n6 ns967 0 0.00097002145005
Gc3_968 0 n6 ns968 0 0.000977158978219
Gc3_969 0 n6 ns969 0 0.000382708179174
Gc3_970 0 n6 ns970 0 0.00121764791397
Gc3_971 0 n6 ns971 0 0.000922955745747
Gc3_972 0 n6 ns972 0 -0.00258653671434
Gc3_973 0 n6 ns973 0 0.00192343996187
Gc3_974 0 n6 ns974 0 -0.00711795985686
Gc3_975 0 n6 ns975 0 0.002141070747
Gc3_976 0 n6 ns976 0 -0.00684116282914
Gc3_977 0 n6 ns977 0 0.00475288380064
Gc3_978 0 n6 ns978 0 0.00662624249119
Gc3_979 0 n6 ns979 0 0.00114021485872
Gc3_980 0 n6 ns980 0 -0.00105003151267
Gc3_981 0 n6 ns981 0 -0.00421156133285
Gc3_982 0 n6 ns982 0 -0.00499449123047
Gc3_983 0 n6 ns983 0 0.00178370194972
Gc3_984 0 n6 ns984 0 0.00610287393287
Gc3_985 0 n6 ns985 0 -0.00416886928021
Gc3_986 0 n6 ns986 0 -1.06370908262e-05
Gc3_987 0 n6 ns987 0 0.000376612339912
Gc3_988 0 n6 ns988 0 -0.000225783203498
Gc3_989 0 n6 ns989 0 0.00128665808544
Gc3_990 0 n6 ns990 0 -0.00282368340003
Gc3_991 0 n6 ns991 0 0.00240949047973
Gc3_992 0 n6 ns992 0 -0.00468579045352
Gc3_993 0 n6 ns993 0 -0.00236322286347
Gc3_994 0 n6 ns994 0 -0.00139029700192
Gc3_995 0 n6 ns995 0 0.00083209914271
Gc3_996 0 n6 ns996 0 0.000583610462101
Gc3_997 0 n6 ns997 0 -0.000209521971152
Gc3_998 0 n6 ns998 0 -0.000210361642128
Gc3_999 0 n6 ns999 0 -0.000300753640682
Gc3_1000 0 n6 ns1000 0 -7.79986203031e-05
Gc3_1001 0 n6 ns1001 0 -0.000324315505217
Gc3_1002 0 n6 ns1002 0 0.000160681227961
Gc3_1003 0 n6 ns1003 0 0.00128849354441
Gc3_1004 0 n6 ns1004 0 -2.47706958013e-05
Gc3_1005 0 n6 ns1005 0 0.00127307185477
Gc3_1006 0 n6 ns1006 0 0.00014801464021
Gc3_1007 0 n6 ns1007 0 0.000830663875073
Gc3_1008 0 n6 ns1008 0 -3.65823553593e-05
Gc3_1009 0 n6 ns1009 0 -0.000339916914365
Gc3_1010 0 n6 ns1010 0 -0.0020579090363
Gc3_1011 0 n6 ns1011 0 -0.00307614545827
Gc3_1012 0 n6 ns1012 0 -0.00579965401648
Gc3_1013 0 n6 ns1013 0 -0.00218919793745
Gc3_1014 0 n6 ns1014 0 -0.00587321801554
Gc3_1015 0 n6 ns1015 0 0.00391198199655
Gc3_1016 0 n6 ns1016 0 0.00359103841832
Gc3_1017 0 n6 ns1017 0 0.00109240562697
Gc3_1018 0 n6 ns1018 0 -0.00112103532928
Gc3_1019 0 n6 ns1019 0 -0.00259108726219
Gc3_1020 0 n6 ns1020 0 -0.00314285994978
Gc3_1021 0 n6 ns1021 0 0.00234913573564
Gc3_1022 0 n6 ns1022 0 0.0017143652184
Gc3_1023 0 n6 ns1023 0 -0.00372744775179
Gc3_1024 0 n6 ns1024 0 1.16060768375e-05
Gc3_1025 0 n6 ns1025 0 0.000243587683804
Gc3_1026 0 n6 ns1026 0 -0.000118063161351
Gc3_1027 0 n6 ns1027 0 -0.000882445751283
Gc3_1028 0 n6 ns1028 0 0.000130067911762
Gc3_1029 0 n6 ns1029 0 -0.00249110453145
Gc3_1030 0 n6 ns1030 0 0.00211013455027
Gc3_1031 0 n6 ns1031 0 -0.000480948786903
Gc3_1032 0 n6 ns1032 0 0.000887017679846
Gc3_1033 0 n6 ns1033 0 0.000412844828049
Gc3_1034 0 n6 ns1034 0 -0.000472907935324
Gc3_1035 0 n6 ns1035 0 -0.000264401708014
Gc3_1036 0 n6 ns1036 0 0.000325195447284
Gc3_1037 0 n6 ns1037 0 -0.000175839594919
Gc3_1038 0 n6 ns1038 0 9.3703221426e-05
Gc3_1039 0 n6 ns1039 0 0.00106170624684
Gc3_1040 0 n6 ns1040 0 -0.000272359465603
Gc3_1041 0 n6 ns1041 0 0.000159654672316
Gc3_1042 0 n6 ns1042 0 -0.0006705480681
Gc3_1043 0 n6 ns1043 0 0.000847031552527
Gc3_1044 0 n6 ns1044 0 -0.000561484711756
Gc3_1045 0 n6 ns1045 0 0.000467409537997
Gc3_1046 0 n6 ns1046 0 -0.000894450258058
Gc3_1047 0 n6 ns1047 0 -0.00155453489372
Gc3_1048 0 n6 ns1048 0 0.000681127851644
Gc3_1049 0 n6 ns1049 0 -0.00368898968184
Gc3_1050 0 n6 ns1050 0 -0.00271846452817
Gc3_1051 0 n6 ns1051 0 -0.00313475950855
Gc3_1052 0 n6 ns1052 0 -0.00326232332583
Gc3_1053 0 n6 ns1053 0 0.000440908251015
Gc3_1054 0 n6 ns1054 0 0.000783760248466
Gc3_1055 0 n6 ns1055 0 0.00057850613818
Gc3_1056 0 n6 ns1056 0 -0.00139514430133
Gc3_1057 0 n6 ns1057 0 -0.000177987996855
Gc3_1058 0 n6 ns1058 0 -0.00288548259411
Gc3_1059 0 n6 ns1059 0 0.00165628214024
Gc3_1060 0 n6 ns1060 0 -0.00343216974443
Gc3_1061 0 n6 ns1061 0 -0.0021525963424
Gc3_1062 0 n6 ns1062 0 -2.50443749255e-05
Gc3_1063 0 n6 ns1063 0 0.00013748323668
Gc3_1064 0 n6 ns1064 0 -2.11568285257e-05
Gc3_1065 0 n6 ns1065 0 -0.000190134376217
Gc3_1066 0 n6 ns1066 0 -0.000319966297752
Gc3_1067 0 n6 ns1067 0 -0.000539799963571
Gc3_1068 0 n6 ns1068 0 0.000670484855638
Gc3_1069 0 n6 ns1069 0 -0.000171204988127
Gc3_1070 0 n6 ns1070 0 2.54511516803e-05
Gc3_1071 0 n6 ns1071 0 -3.02897405094e-05
Gc3_1072 0 n6 ns1072 0 -0.000102784347931
Gc3_1073 0 n6 ns1073 0 -4.05352170519e-05
Gc3_1074 0 n6 ns1074 0 0.000383150900587
Gc3_1075 0 n6 ns1075 0 -8.22866830244e-05
Gc3_1076 0 n6 ns1076 0 0.000141904010193
Gc3_1077 0 n6 ns1077 0 0.000419131472205
Gc3_1078 0 n6 ns1078 0 -0.000407174737125
Gc3_1079 0 n6 ns1079 0 0.000110340100615
Gc3_1080 0 n6 ns1080 0 0.000574679671787
Gc3_1081 0 n6 ns1081 0 0.000487339811517
Gc3_1082 0 n6 ns1082 0 -0.000261342741743
Gc3_1083 0 n6 ns1083 0 7.5007479852e-05
Gc3_1084 0 n6 ns1084 0 -7.20081414006e-05
Gc3_1085 0 n6 ns1085 0 -0.000293741660044
Gc3_1086 0 n6 ns1086 0 0.000276394466076
Gc3_1087 0 n6 ns1087 0 -0.00352136899643
Gc3_1088 0 n6 ns1088 0 -0.00495909166268
Gc3_1089 0 n6 ns1089 0 -0.00337789488438
Gc3_1090 0 n6 ns1090 0 -0.00468642963523
Gc3_1091 0 n6 ns1091 0 -0.000975784751206
Gc3_1092 0 n6 ns1092 0 0.00160890055531
Gc3_1093 0 n6 ns1093 0 -5.30833475721e-05
Gc3_1094 0 n6 ns1094 0 -0.00111473974792
Gc3_1095 0 n6 ns1095 0 -0.000363723128162
Gc3_1096 0 n6 ns1096 0 -0.00271188739815
Gc3_1097 0 n6 ns1097 0 0.000393864277259
Gc3_1098 0 n6 ns1098 0 -0.00203370413134
Gc3_1099 0 n6 ns1099 0 -0.000836587365552
Gc3_1100 0 n6 ns1100 0 -2.09316575595e-05
Gc3_1101 0 n6 ns1101 0 0.000108257712282
Gc3_1102 0 n6 ns1102 0 -1.54106574871e-05
Gc3_1103 0 n6 ns1103 0 0.000320171736493
Gc3_1104 0 n6 ns1104 0 -0.000585118064013
Gc3_1105 0 n6 ns1105 0 0.00113128851748
Gc3_1106 0 n6 ns1106 0 -0.000923879319353
Gc3_1107 0 n6 ns1107 0 0.000237376206725
Gc3_1108 0 n6 ns1108 0 -0.000183252897483
Gc3_1109 0 n6 ns1109 0 -0.000166836399769
Gc3_1110 0 n6 ns1110 0 0.000155703597892
Gc3_1111 0 n6 ns1111 0 0.000321427559659
Gc3_1112 0 n6 ns1112 0 -0.000327666149997
Gc3_1113 0 n6 ns1113 0 -0.00012331002845
Gc3_1114 0 n6 ns1114 0 0.000137646295952
Gc3_1115 0 n6 ns1115 0 -0.000226202420866
Gc3_1116 0 n6 ns1116 0 0.000545629624569
Gc3_1117 0 n6 ns1117 0 0.00047672388249
Gc3_1118 0 n6 ns1118 0 0.000275255427087
Gc3_1119 0 n6 ns1119 0 8.01455013422e-05
Gc3_1120 0 n6 ns1120 0 -0.000441506754768
Gc3_1121 0 n6 ns1121 0 -0.000161910711616
Gc3_1122 0 n6 ns1122 0 -0.000276611455155
Gc3_1123 0 n6 ns1123 0 -3.80624044392e-05
Gc3_1124 0 n6 ns1124 0 -0.000529277559637
Gc3_1125 0 n6 ns1125 0 -0.00506889735406
Gc3_1126 0 n6 ns1126 0 -0.00321945926253
Gc3_1127 0 n6 ns1127 0 -0.00465613753511
Gc3_1128 0 n6 ns1128 0 -0.00278643252067
Gc3_1129 0 n6 ns1129 0 7.0521662226e-05
Gc3_1130 0 n6 ns1130 0 0.00168540799806
Gc3_1131 0 n6 ns1131 0 -0.000343380508651
Gc3_1132 0 n6 ns1132 0 -0.000605631905614
Gc3_1133 0 n6 ns1133 0 -0.00114717005306
Gc3_1134 0 n6 ns1134 0 -0.00173138054764
Gc3_1135 0 n6 ns1135 0 -0.000102106286788
Gc3_1136 0 n6 ns1136 0 -0.00114310446977
Gc3_1137 0 n6 ns1137 0 -0.000371465380556
Gc3_1138 0 n6 ns1138 0 -1.03775686846e-05
Gc3_1139 0 n6 ns1139 0 8.99952594763e-05
Gc3_1140 0 n6 ns1140 0 -7.65217708858e-06
Gc3_1141 0 n6 ns1141 0 -0.000456560896729
Gc3_1142 0 n6 ns1142 0 0.00102510375885
Gc3_1143 0 n6 ns1143 0 -0.000872652337724
Gc3_1144 0 n6 ns1144 0 0.000722680150463
Gc3_1145 0 n6 ns1145 0 -0.000191454286864
Gc3_1146 0 n6 ns1146 0 0.000410851249842
Gc3_1147 0 n6 ns1147 0 0.000174113412341
Gc3_1148 0 n6 ns1148 0 -0.000255936922512
Gc3_1149 0 n6 ns1149 0 7.62261904626e-05
Gc3_1150 0 n6 ns1150 0 -0.000187782988841
Gc3_1151 0 n6 ns1151 0 4.14584968125e-05
Gc3_1152 0 n6 ns1152 0 9.7105583692e-05
Gc3_1153 0 n6 ns1153 0 0.00029209678032
Gc3_1154 0 n6 ns1154 0 -9.23856210825e-05
Gc3_1155 0 n6 ns1155 0 0.000289986858034
Gc3_1156 0 n6 ns1156 0 -0.000553917563791
Gc3_1157 0 n6 ns1157 0 -0.000235878029487
Gc3_1158 0 n6 ns1158 0 -0.00043414484013
Gc3_1159 0 n6 ns1159 0 -0.000267899116211
Gc3_1160 0 n6 ns1160 0 -0.00034081285634
Gc3_1161 0 n6 ns1161 0 -0.000514597688005
Gc3_1162 0 n6 ns1162 0 -0.000134492997867
Gc3_1163 0 n6 ns1163 0 -0.00469441750273
Gc3_1164 0 n6 ns1164 0 0.000795736652815
Gc3_1165 0 n6 ns1165 0 -0.00412530376909
Gc3_1166 0 n6 ns1166 0 0.000755446279532
Gc3_1167 0 n6 ns1167 0 0.000778866714788
Gc3_1168 0 n6 ns1168 0 0.00149045039947
Gc3_1169 0 n6 ns1169 0 -0.000342799052612
Gc3_1170 0 n6 ns1170 0 -0.000332028504119
Gc3_1171 0 n6 ns1171 0 -0.00127560885159
Gc3_1172 0 n6 ns1172 0 -0.00124605065679
Gc3_1173 0 n6 ns1173 0 -0.000221614807076
Gc3_1174 0 n6 ns1174 0 -0.00107042763139
Gc3_1175 0 n6 ns1175 0 -0.000292050728832
Gc3_1176 0 n6 ns1176 0 -2.50661950988e-05
Gc3_1177 0 n6 ns1177 0 0.000100060343323
Gc3_1178 0 n6 ns1178 0 -2.83123583976e-05
Gc3_1179 0 n6 ns1179 0 4.226521446e-05
Gc3_1180 0 n6 ns1180 0 0.000141695221066
Gc3_1181 0 n6 ns1181 0 0.000150549353068
Gc3_1182 0 n6 ns1182 0 -3.1788285674e-05
Gc3_1183 0 n6 ns1183 0 5.81375747424e-05
Gc3_1184 0 n6 ns1184 0 9.42100990556e-06
Gc3_1185 0 n6 ns1185 0 -7.59595593564e-05
Gc3_1186 0 n6 ns1186 0 -4.73388730128e-05
Gc3_1187 0 n6 ns1187 0 -0.000252632667907
Gc3_1188 0 n6 ns1188 0 -5.38653409402e-06
Gc3_1189 0 n6 ns1189 0 0.000107050810368
Gc3_1190 0 n6 ns1190 0 2.66869179236e-05
Gc3_1191 0 n6 ns1191 0 0.000183676677867
Gc3_1192 0 n6 ns1192 0 -0.000271620771903
Gc3_1193 0 n6 ns1193 0 -0.000287811598479
Gc3_1194 0 n6 ns1194 0 -0.000284386980982
Gc3_1195 0 n6 ns1195 0 -0.000393355447733
Gc3_1196 0 n6 ns1196 0 3.20725627455e-06
Gc3_1197 0 n6 ns1197 0 -0.000454403689383
Gc3_1198 0 n6 ns1198 0 0.000103372820422
Gc3_1199 0 n6 ns1199 0 -0.000463659202495
Gc3_1200 0 n6 ns1200 0 7.79435841155e-06
Gc3_1201 0 n6 ns1201 0 -0.00230847797776
Gc3_1202 0 n6 ns1202 0 0.00167299040992
Gc3_1203 0 n6 ns1203 0 -0.00198214304499
Gc3_1204 0 n6 ns1204 0 0.0014976961072
Gc3_1205 0 n6 ns1205 0 0.00061439182172
Gc3_1206 0 n6 ns1206 0 0.000625108237397
Gc3_1207 0 n6 ns1207 0 -0.000205720864713
Gc3_1208 0 n6 ns1208 0 -0.000119906727744
Gc3_1209 0 n6 ns1209 0 -0.000798859496129
Gc3_1210 0 n6 ns1210 0 -0.000443191134634
Gc3_1211 0 n6 ns1211 0 -0.000119744728835
Gc3_1212 0 n6 ns1212 0 -0.000373126345722
Gc3_1213 0 n6 ns1213 0 -0.000121612925399
Gc3_1214 0 n6 ns1214 0 -1.47725352964e-05
Gc3_1215 0 n6 ns1215 0 3.00501738727e-05
Gc3_1216 0 n6 ns1216 0 -7.24163119572e-07
Gd3_1 0 n6 ni1 0 -0.00164082218632
Gd3_2 0 n6 ni2 0 -0.00172649053814
Gd3_3 0 n6 ni3 0 0.000490069859221
Gd3_4 0 n6 ni4 0 -0.00160703925723
Gd3_5 0 n6 ni5 0 -0.00054612419171
Gd3_6 0 n6 ni6 0 0.000420595520814
Gd3_7 0 n6 ni7 0 0.000722066386088
Gd3_8 0 n6 ni8 0 0.000105761706142
Gd3_9 0 n6 ni9 0 -4.20588438573e-05
Gd3_10 0 n6 ni10 0 -0.00086137128403
Gd3_11 0 n6 ni11 0 -0.0030657627467
Gd3_12 0 n6 ni12 0 -0.00160985946959
Gd3_13 0 n6 ni13 0 0.000296742530056
Gd3_14 0 n6 ni14 0 0.000608944288864
Gd3_15 0 n6 ni15 0 0.000251818381592
Gd3_16 0 n6 ni16 0 -1.37728987598e-05
Gd3_17 0 n6 ni17 0 0.00071654243822
Gd3_18 0 n6 ni18 0 0.000128465541743
Gd3_19 0 n6 ni19 0 0.000301463342672
Gd3_20 0 n6 ni20 0 -0.000460176582459
Gd3_21 0 n6 ni21 0 0.00080237657
Gd3_22 0 n6 ni22 0 -9.39856067994e-05
Gd3_23 0 n6 ni23 0 -0.000449608689452
Gd3_24 0 n6 ni24 0 0.000831679463211
Gd3_25 0 n6 ni25 0 -0.000446363583726
Gd3_26 0 n6 ni26 0 -0.00324549580165
Gd3_27 0 n6 ni27 0 -0.00241871916145
Gd3_28 0 n6 ni28 0 0.000716158685617
Gd3_29 0 n6 ni29 0 5.89220986454e-05
Gd3_30 0 n6 ni30 0 -0.000683230255506
Gd3_31 0 n6 ni31 0 0.000841377688128
Gd3_32 0 n6 ni32 0 6.00328917639e-06
Gc4_1 0 n8 ns1 0 0.000118183521485
Gc4_2 0 n8 ns2 0 -0.000371130369762
Gc4_3 0 n8 ns3 0 0.000415133770909
Gc4_4 0 n8 ns4 0 0.000402930659636
Gc4_5 0 n8 ns5 0 0.000153813049376
Gc4_6 0 n8 ns6 0 0.000233920118251
Gc4_7 0 n8 ns7 0 -5.40863976376e-07
Gc4_8 0 n8 ns8 0 0.000112693236916
Gc4_9 0 n8 ns9 0 0.000251050056656
Gc4_10 0 n8 ns10 0 -0.000596579233544
Gc4_11 0 n8 ns11 0 0.000157181939096
Gc4_12 0 n8 ns12 0 3.44499629263e-05
Gc4_13 0 n8 ns13 0 -0.000115691624091
Gc4_14 0 n8 ns14 0 -0.000277013198634
Gc4_15 0 n8 ns15 0 -0.001226981789
Gc4_16 0 n8 ns16 0 0.000778034223212
Gc4_17 0 n8 ns17 0 0.000247678479374
Gc4_18 0 n8 ns18 0 0.00012757155755
Gc4_19 0 n8 ns19 0 -0.000371130293344
Gc4_20 0 n8 ns20 0 -0.000187541622431
Gc4_21 0 n8 ns21 0 0.000157419642253
Gc4_22 0 n8 ns22 0 -0.0017899238822
Gc4_23 0 n8 ns23 0 -0.00173733628006
Gc4_24 0 n8 ns24 0 0.00227709101937
Gc4_25 0 n8 ns25 0 -0.00134564011782
Gc4_26 0 n8 ns26 0 0.00271945503316
Gc4_27 0 n8 ns27 0 -0.00258665935285
Gc4_28 0 n8 ns28 0 -0.00123937557872
Gc4_29 0 n8 ns29 0 0.000510603023403
Gc4_30 0 n8 ns30 0 -0.000939562190609
Gc4_31 0 n8 ns31 0 0.00131977586928
Gc4_32 0 n8 ns32 0 -0.000765537170838
Gc4_33 0 n8 ns33 0 -0.000665333020446
Gc4_34 0 n8 ns34 0 0.00226451985454
Gc4_35 0 n8 ns35 0 0.00110436365298
Gc4_36 0 n8 ns36 0 2.89640829618e-05
Gc4_37 0 n8 ns37 0 -0.000339738609322
Gc4_38 0 n8 ns38 0 0.000138853463044
Gc4_39 0 n8 ns39 0 0.0004513476984
Gc4_40 0 n8 ns40 0 -0.00137734387827
Gc4_41 0 n8 ns41 0 0.00113000683641
Gc4_42 0 n8 ns42 0 -0.000828737509846
Gc4_43 0 n8 ns43 0 -6.44789065689e-05
Gc4_44 0 n8 ns44 0 0.000122484961209
Gc4_45 0 n8 ns45 0 -5.43277079236e-05
Gc4_46 0 n8 ns46 0 -6.02637576356e-06
Gc4_47 0 n8 ns47 0 0.000264451310468
Gc4_48 0 n8 ns48 0 -0.000636946025102
Gc4_49 0 n8 ns49 0 0.000177992989114
Gc4_50 0 n8 ns50 0 4.80023916887e-05
Gc4_51 0 n8 ns51 0 -3.15707474048e-05
Gc4_52 0 n8 ns52 0 0.000131960463331
Gc4_53 0 n8 ns53 0 -0.0011260126937
Gc4_54 0 n8 ns54 0 0.000491583146335
Gc4_55 0 n8 ns55 0 0.000405846703544
Gc4_56 0 n8 ns56 0 1.11241071346e-05
Gc4_57 0 n8 ns57 0 -0.000253764359543
Gc4_58 0 n8 ns58 0 -0.000363337533035
Gc4_59 0 n8 ns59 0 0.000722508161776
Gc4_60 0 n8 ns60 0 -0.00146034252453
Gc4_61 0 n8 ns61 0 -0.00102818066931
Gc4_62 0 n8 ns62 0 0.00281786415613
Gc4_63 0 n8 ns63 0 -0.000806923179559
Gc4_64 0 n8 ns64 0 0.00330708919187
Gc4_65 0 n8 ns65 0 -0.00213178107023
Gc4_66 0 n8 ns66 0 -0.00199426136816
Gc4_67 0 n8 ns67 0 0.000685492654699
Gc4_68 0 n8 ns68 0 -0.00102628912499
Gc4_69 0 n8 ns69 0 0.00123883571667
Gc4_70 0 n8 ns70 0 -0.000493169666272
Gc4_71 0 n8 ns71 0 -0.00122132559986
Gc4_72 0 n8 ns72 0 0.00296644889103
Gc4_73 0 n8 ns73 0 0.00159907358723
Gc4_74 0 n8 ns74 0 1.44752750849e-05
Gc4_75 0 n8 ns75 0 -0.000305262988488
Gc4_76 0 n8 ns76 0 0.000123496747469
Gc4_77 0 n8 ns77 0 0.000254803889124
Gc4_78 0 n8 ns78 0 -0.00224480629562
Gc4_79 0 n8 ns79 0 0.000122424682534
Gc4_80 0 n8 ns80 0 -0.000679678489556
Gc4_81 0 n8 ns81 0 -0.000795866928145
Gc4_82 0 n8 ns82 0 0.000255416848117
Gc4_83 0 n8 ns83 0 0.000252426527771
Gc4_84 0 n8 ns84 0 -0.000517818849143
Gc4_85 0 n8 ns85 0 4.43787768778e-05
Gc4_86 0 n8 ns86 0 0.00024708757819
Gc4_87 0 n8 ns87 0 0.000290885170614
Gc4_88 0 n8 ns88 0 4.22133505059e-06
Gc4_89 0 n8 ns89 0 -0.000178652841255
Gc4_90 0 n8 ns90 0 0.000246331391075
Gc4_91 0 n8 ns91 0 0.00102419429609
Gc4_92 0 n8 ns92 0 -0.000466223682792
Gc4_93 0 n8 ns93 0 0.00117147360335
Gc4_94 0 n8 ns94 0 -0.000264744782185
Gc4_95 0 n8 ns95 0 0.000772242853516
Gc4_96 0 n8 ns96 0 -0.000622024526509
Gc4_97 0 n8 ns97 0 0.000425153168936
Gc4_98 0 n8 ns98 0 0.00218217505755
Gc4_99 0 n8 ns99 0 0.00168846505428
Gc4_100 0 n8 ns100 0 0.00568501335569
Gc4_101 0 n8 ns101 0 0.00121192446839
Gc4_102 0 n8 ns102 0 0.00575540297783
Gc4_103 0 n8 ns103 0 0.00326671733711
Gc4_104 0 n8 ns104 0 0.000399068914313
Gc4_105 0 n8 ns105 0 0.00097635824723
Gc4_106 0 n8 ns106 0 -0.000998721300829
Gc4_107 0 n8 ns107 0 -0.00154576016174
Gc4_108 0 n8 ns108 0 -0.00134578692806
Gc4_109 0 n8 ns109 0 -0.00379994989359
Gc4_110 0 n8 ns110 0 -0.000168775146602
Gc4_111 0 n8 ns111 0 0.00310493013725
Gc4_112 0 n8 ns112 0 2.2986010295e-05
Gc4_113 0 n8 ns113 0 -0.000179884812182
Gc4_114 0 n8 ns114 0 2.60195925536e-05
Gc4_115 0 n8 ns115 0 0.000421151594756
Gc4_116 0 n8 ns116 0 -0.00228849749432
Gc4_117 0 n8 ns117 0 -0.00145945427333
Gc4_118 0 n8 ns118 0 0.000452416872925
Gc4_119 0 n8 ns119 0 -0.000608605694873
Gc4_120 0 n8 ns120 0 0.000215988925344
Gc4_121 0 n8 ns121 0 0.000347161993288
Gc4_122 0 n8 ns122 0 -0.000219471733173
Gc4_123 0 n8 ns123 0 1.23221834692e-05
Gc4_124 0 n8 ns124 0 0.000491419426364
Gc4_125 0 n8 ns125 0 0.000296707547776
Gc4_126 0 n8 ns126 0 -2.0448788535e-05
Gc4_127 0 n8 ns127 0 -0.000584706768399
Gc4_128 0 n8 ns128 0 -0.000619827971352
Gc4_129 0 n8 ns129 0 0.000472544643981
Gc4_130 0 n8 ns130 0 -2.46501396553e-06
Gc4_131 0 n8 ns131 0 0.000462188103521
Gc4_132 0 n8 ns132 0 -0.000350764719586
Gc4_133 0 n8 ns133 0 -0.000292769718453
Gc4_134 0 n8 ns134 0 -0.00127053273883
Gc4_135 0 n8 ns135 0 -0.000597402183153
Gc4_136 0 n8 ns136 0 0.000494115347217
Gc4_137 0 n8 ns137 0 0.00749861706638
Gc4_138 0 n8 ns138 0 0.0060097232331
Gc4_139 0 n8 ns139 0 0.00570759021004
Gc4_140 0 n8 ns140 0 0.00593208657863
Gc4_141 0 n8 ns141 0 0.00113261439403
Gc4_142 0 n8 ns142 0 0.00548594675267
Gc4_143 0 n8 ns143 0 0.00089202690671
Gc4_144 0 n8 ns144 0 -0.000828180144902
Gc4_145 0 n8 ns145 0 -0.00618595263822
Gc4_146 0 n8 ns146 0 -0.00158843330839
Gc4_147 0 n8 ns147 0 0.00267297766731
Gc4_148 0 n8 ns148 0 -0.00441663088913
Gc4_149 0 n8 ns149 0 0.00477491572963
Gc4_150 0 n8 ns150 0 -2.69140707901e-05
Gc4_151 0 n8 ns151 0 3.52229876331e-05
Gc4_152 0 n8 ns152 0 -7.66933389423e-05
Gc4_153 0 n8 ns153 0 0.000232701737015
Gc4_154 0 n8 ns154 0 -0.00187902255862
Gc4_155 0 n8 ns155 0 0.000276932155174
Gc4_156 0 n8 ns156 0 -0.000447663546274
Gc4_157 0 n8 ns157 0 -0.000939787426794
Gc4_158 0 n8 ns158 0 0.000330522666101
Gc4_159 0 n8 ns159 0 0.000385024660597
Gc4_160 0 n8 ns160 0 -0.000477074909554
Gc4_161 0 n8 ns161 0 0.000330397997426
Gc4_162 0 n8 ns162 0 0.000462158543959
Gc4_163 0 n8 ns163 0 0.000251011175475
Gc4_164 0 n8 ns164 0 -4.42284293122e-05
Gc4_165 0 n8 ns165 0 -0.000378063874362
Gc4_166 0 n8 ns166 0 -5.24068736601e-05
Gc4_167 0 n8 ns167 0 0.000655873978569
Gc4_168 0 n8 ns168 0 -0.000925132844741
Gc4_169 0 n8 ns169 0 0.00080877666709
Gc4_170 0 n8 ns170 0 -0.0004140384879
Gc4_171 0 n8 ns171 0 0.000396980653652
Gc4_172 0 n8 ns172 0 -0.00086841160498
Gc4_173 0 n8 ns173 0 0.000887484283781
Gc4_174 0 n8 ns174 0 0.00210252090525
Gc4_175 0 n8 ns175 0 0.00278919288865
Gc4_176 0 n8 ns176 0 0.0042572000496
Gc4_177 0 n8 ns177 0 0.00212010846444
Gc4_178 0 n8 ns178 0 0.00446811153619
Gc4_179 0 n8 ns179 0 0.00350227239911
Gc4_180 0 n8 ns180 0 0.000384946498595
Gc4_181 0 n8 ns181 0 0.000898206490109
Gc4_182 0 n8 ns182 0 -0.000960876441408
Gc4_183 0 n8 ns183 0 -0.00182224324447
Gc4_184 0 n8 ns184 0 -0.00121525438801
Gc4_185 0 n8 ns185 0 -0.00385448401292
Gc4_186 0 n8 ns186 0 -0.000102557502687
Gc4_187 0 n8 ns187 0 0.0031184004934
Gc4_188 0 n8 ns188 0 3.45956818294e-05
Gc4_189 0 n8 ns189 0 -0.000153228885966
Gc4_190 0 n8 ns190 0 2.87837580709e-05
Gc4_191 0 n8 ns191 0 0.000124893708314
Gc4_192 0 n8 ns192 0 -0.000486462479112
Gc4_193 0 n8 ns193 0 0.000602162238795
Gc4_194 0 n8 ns194 0 9.90249496383e-05
Gc4_195 0 n8 ns195 0 -0.000266521305471
Gc4_196 0 n8 ns196 0 0.00048478222278
Gc4_197 0 n8 ns197 0 -1.80682960082e-05
Gc4_198 0 n8 ns198 0 -0.000191608949362
Gc4_199 0 n8 ns199 0 0.000355097879036
Gc4_200 0 n8 ns200 0 -0.000171098232309
Gc4_201 0 n8 ns201 0 0.000181103297399
Gc4_202 0 n8 ns202 0 -7.42336510202e-05
Gc4_203 0 n8 ns203 0 -2.07504903948e-05
Gc4_204 0 n8 ns204 0 -0.000318100462141
Gc4_205 0 n8 ns205 0 -0.00076553073459
Gc4_206 0 n8 ns206 0 -0.000349160656127
Gc4_207 0 n8 ns207 0 0.000294690644303
Gc4_208 0 n8 ns208 0 -0.000555550715345
Gc4_209 0 n8 ns209 0 -0.000188459036839
Gc4_210 0 n8 ns210 0 -0.00097650070827
Gc4_211 0 n8 ns211 0 0.00122128597075
Gc4_212 0 n8 ns212 0 -0.000690142916111
Gc4_213 0 n8 ns213 0 0.00192931708539
Gc4_214 0 n8 ns214 0 0.00295932667277
Gc4_215 0 n8 ns215 0 0.00178732317334
Gc4_216 0 n8 ns216 0 0.00324518380418
Gc4_217 0 n8 ns217 0 -0.00124985983385
Gc4_218 0 n8 ns218 0 -0.00139678150907
Gc4_219 0 n8 ns219 0 0.000407392406082
Gc4_220 0 n8 ns220 0 -0.00105193088406
Gc4_221 0 n8 ns221 0 0.000209620586132
Gc4_222 0 n8 ns222 0 -0.000790150446369
Gc4_223 0 n8 ns223 0 -0.00144933040221
Gc4_224 0 n8 ns224 0 0.0024755722932
Gc4_225 0 n8 ns225 0 0.0014805831354
Gc4_226 0 n8 ns226 0 2.84490603478e-05
Gc4_227 0 n8 ns227 0 -0.000230234445594
Gc4_228 0 n8 ns228 0 7.22670462716e-05
Gc4_229 0 n8 ns229 0 -0.000140560069482
Gc4_230 0 n8 ns230 0 0.000126062132409
Gc4_231 0 n8 ns231 0 -2.71942428894e-05
Gc4_232 0 n8 ns232 0 0.00099913367734
Gc4_233 0 n8 ns233 0 2.27828970512e-05
Gc4_234 0 n8 ns234 0 0.000173423077788
Gc4_235 0 n8 ns235 0 0.000153419231821
Gc4_236 0 n8 ns236 0 -8.32665812239e-05
Gc4_237 0 n8 ns237 0 -0.000134814944462
Gc4_238 0 n8 ns238 0 -7.06162419919e-05
Gc4_239 0 n8 ns239 0 0.000141366736576
Gc4_240 0 n8 ns240 0 -0.000142124425709
Gc4_241 0 n8 ns241 0 -0.000282411733411
Gc4_242 0 n8 ns242 0 -0.000355418876515
Gc4_243 0 n8 ns243 0 0.000184390132393
Gc4_244 0 n8 ns244 0 0.000499902602163
Gc4_245 0 n8 ns245 0 0.000300618935207
Gc4_246 0 n8 ns246 0 -0.000425928786289
Gc4_247 0 n8 ns247 0 -7.964493665e-05
Gc4_248 0 n8 ns248 0 -0.000374145011329
Gc4_249 0 n8 ns249 0 -0.000494853238208
Gc4_250 0 n8 ns250 0 -0.000256560309331
Gc4_251 0 n8 ns251 0 0.00207558120119
Gc4_252 0 n8 ns252 0 0.00335624829802
Gc4_253 0 n8 ns253 0 0.00218337439338
Gc4_254 0 n8 ns254 0 0.00315789810943
Gc4_255 0 n8 ns255 0 -0.00113527061749
Gc4_256 0 n8 ns256 0 0.000966165021558
Gc4_257 0 n8 ns257 0 -0.000154848536468
Gc4_258 0 n8 ns258 0 -0.000834958224386
Gc4_259 0 n8 ns259 0 -0.000502455410919
Gc4_260 0 n8 ns260 0 -0.00165127102901
Gc4_261 0 n8 ns261 0 -0.000635790366883
Gc4_262 0 n8 ns262 0 0.000577476622276
Gc4_263 0 n8 ns263 0 0.000457204411625
Gc4_264 0 n8 ns264 0 2.45341516849e-05
Gc4_265 0 n8 ns265 0 -0.000138846343573
Gc4_266 0 n8 ns266 0 1.71582293679e-05
Gc4_267 0 n8 ns267 0 -0.000452902013973
Gc4_268 0 n8 ns268 0 0.000560278601928
Gc4_269 0 n8 ns269 0 -0.00112071551756
Gc4_270 0 n8 ns270 0 0.00119590916052
Gc4_271 0 n8 ns271 0 -0.000306919113216
Gc4_272 0 n8 ns272 0 0.000260159473883
Gc4_273 0 n8 ns273 0 0.000132183783575
Gc4_274 0 n8 ns274 0 -0.000182602093257
Gc4_275 0 n8 ns275 0 -0.000179194527482
Gc4_276 0 n8 ns276 0 0.000476022426123
Gc4_277 0 n8 ns277 0 7.2280535783e-05
Gc4_278 0 n8 ns278 0 -0.000148915824041
Gc4_279 0 n8 ns279 0 0.000134656588625
Gc4_280 0 n8 ns280 0 -0.000419691073935
Gc4_281 0 n8 ns281 0 0.000821777215811
Gc4_282 0 n8 ns282 0 -0.000420477997968
Gc4_283 0 n8 ns283 0 0.000173233332949
Gc4_284 0 n8 ns284 0 -0.00063683180964
Gc4_285 0 n8 ns285 0 0.000240551583014
Gc4_286 0 n8 ns286 0 -0.000500670656783
Gc4_287 0 n8 ns287 0 -0.000173115260297
Gc4_288 0 n8 ns288 0 0.000827233724553
Gc4_289 0 n8 ns289 0 0.00331859979478
Gc4_290 0 n8 ns290 0 0.00229857981963
Gc4_291 0 n8 ns291 0 0.00312145819369
Gc4_292 0 n8 ns292 0 0.00189827032007
Gc4_293 0 n8 ns293 0 0.000197219815973
Gc4_294 0 n8 ns294 0 0.00114303865644
Gc4_295 0 n8 ns295 0 -0.000317344832614
Gc4_296 0 n8 ns296 0 -0.00043012771485
Gc4_297 0 n8 ns297 0 -0.00111778594675
Gc4_298 0 n8 ns298 0 -0.00112436813573
Gc4_299 0 n8 ns299 0 -0.000491895212798
Gc4_300 0 n8 ns300 0 -0.000110305379288
Gc4_301 0 n8 ns301 0 0.000137835881404
Gc4_302 0 n8 ns302 0 -1.38161287608e-05
Gc4_303 0 n8 ns303 0 1.93070177742e-05
Gc4_304 0 n8 ns304 0 -4.79681036273e-05
Gc4_305 0 n8 ns305 0 0.000576736386305
Gc4_306 0 n8 ns306 0 -4.79590614805e-05
Gc4_307 0 n8 ns307 0 0.00180828650323
Gc4_308 0 n8 ns308 0 0.000361223497208
Gc4_309 0 n8 ns309 0 0.000271018811513
Gc4_310 0 n8 ns310 0 1.14904803165e-06
Gc4_311 0 n8 ns311 0 -0.000194867005011
Gc4_312 0 n8 ns312 0 5.83973704795e-05
Gc4_313 0 n8 ns313 0 0.000176826958347
Gc4_314 0 n8 ns314 0 0.000249470243259
Gc4_315 0 n8 ns315 0 -4.68648431308e-05
Gc4_316 0 n8 ns316 0 -0.000103439705781
Gc4_317 0 n8 ns317 0 -0.000270812412521
Gc4_318 0 n8 ns318 0 -0.000298550944185
Gc4_319 0 n8 ns319 0 4.14772453828e-06
Gc4_320 0 n8 ns320 0 -0.00092917423717
Gc4_321 0 n8 ns321 0 -0.000281877249874
Gc4_322 0 n8 ns322 0 -0.000656521219175
Gc4_323 0 n8 ns323 0 -0.000210907549483
Gc4_324 0 n8 ns324 0 -0.000858052570815
Gc4_325 0 n8 ns325 0 0.000823539923524
Gc4_326 0 n8 ns326 0 0.000630707489268
Gc4_327 0 n8 ns327 0 0.00376391226394
Gc4_328 0 n8 ns328 0 0.000494407632706
Gc4_329 0 n8 ns329 0 0.00328090807762
Gc4_330 0 n8 ns330 0 0.000288207222011
Gc4_331 0 n8 ns331 0 0.000791029134874
Gc4_332 0 n8 ns332 0 0.000494238378805
Gc4_333 0 n8 ns333 0 -0.000247952207504
Gc4_334 0 n8 ns334 0 -0.00018661983101
Gc4_335 0 n8 ns335 0 -0.00112990555212
Gc4_336 0 n8 ns336 0 -0.000583812292725
Gc4_337 0 n8 ns337 0 -0.000484414840114
Gc4_338 0 n8 ns338 0 -0.000489376240315
Gc4_339 0 n8 ns339 0 7.43858657396e-06
Gc4_340 0 n8 ns340 0 3.23883602199e-05
Gc4_341 0 n8 ns341 0 -0.000119443337227
Gc4_342 0 n8 ns342 0 4.59560131471e-05
Gc4_343 0 n8 ns343 0 0.000387321882079
Gc4_344 0 n8 ns344 0 -0.00231280698265
Gc4_345 0 n8 ns345 0 0.000562279882772
Gc4_346 0 n8 ns346 0 -0.00215317958628
Gc4_347 0 n8 ns347 0 -0.000759136191118
Gc4_348 0 n8 ns348 0 -0.000213825619039
Gc4_349 0 n8 ns349 0 0.000154045165033
Gc4_350 0 n8 ns350 0 -0.000245320760379
Gc4_351 0 n8 ns351 0 -1.28527343565e-05
Gc4_352 0 n8 ns352 0 -0.000210645642706
Gc4_353 0 n8 ns353 0 0.000228168449921
Gc4_354 0 n8 ns354 0 7.08168084549e-05
Gc4_355 0 n8 ns355 0 0.000269260739544
Gc4_356 0 n8 ns356 0 0.000867728420929
Gc4_357 0 n8 ns357 0 0.000359773483081
Gc4_358 0 n8 ns358 0 -7.73889242746e-05
Gc4_359 0 n8 ns359 0 0.00102970591381
Gc4_360 0 n8 ns360 0 -4.27924256854e-05
Gc4_361 0 n8 ns361 0 0.000609308049382
Gc4_362 0 n8 ns362 0 -0.000182824782975
Gc4_363 0 n8 ns363 0 0.000892379057714
Gc4_364 0 n8 ns364 0 0.000842692659319
Gc4_365 0 n8 ns365 0 5.92412948467e-05
Gc4_366 0 n8 ns366 0 0.00451506654416
Gc4_367 0 n8 ns367 0 -4.87192670668e-05
Gc4_368 0 n8 ns368 0 0.00476286254082
Gc4_369 0 n8 ns369 0 0.000836546193458
Gc4_370 0 n8 ns370 0 -0.00212025992933
Gc4_371 0 n8 ns371 0 0.00100892518418
Gc4_372 0 n8 ns372 0 -0.000949082723906
Gc4_373 0 n8 ns373 0 0.000268503644537
Gc4_374 0 n8 ns374 0 -0.000271188315939
Gc4_375 0 n8 ns375 0 -0.00304201470268
Gc4_376 0 n8 ns376 0 0.00282365856668
Gc4_377 0 n8 ns377 0 0.00272431421292
Gc4_378 0 n8 ns378 0 -3.37697443962e-06
Gc4_379 0 n8 ns379 0 -0.000128177077846
Gc4_380 0 n8 ns380 0 3.64027858952e-06
Gc4_381 0 n8 ns381 0 0.000893029329438
Gc4_382 0 n8 ns382 0 -0.00381327825801
Gc4_383 0 n8 ns383 0 -0.000701444286016
Gc4_384 0 n8 ns384 0 -0.00118752545662
Gc4_385 0 n8 ns385 0 -0.00094955445213
Gc4_386 0 n8 ns386 0 -4.22495019741e-05
Gc4_387 0 n8 ns387 0 0.000469312291092
Gc4_388 0 n8 ns388 0 -0.000180835288567
Gc4_389 0 n8 ns389 0 -2.3551283554e-05
Gc4_390 0 n8 ns390 0 0.000448269012465
Gc4_391 0 n8 ns391 0 0.000294938143753
Gc4_392 0 n8 ns392 0 -1.4436427493e-05
Gc4_393 0 n8 ns393 0 -0.000357518651092
Gc4_394 0 n8 ns394 0 -0.000373260936032
Gc4_395 0 n8 ns395 0 0.000372082002679
Gc4_396 0 n8 ns396 0 -8.30169042293e-05
Gc4_397 0 n8 ns397 0 0.000568627419526
Gc4_398 0 n8 ns398 0 -0.00042199787696
Gc4_399 0 n8 ns399 0 -7.81282913945e-05
Gc4_400 0 n8 ns400 0 -0.00132673820885
Gc4_401 0 n8 ns401 0 -0.000301875647514
Gc4_402 0 n8 ns402 0 0.000394738335912
Gc4_403 0 n8 ns403 0 0.00677398685081
Gc4_404 0 n8 ns404 0 0.00741615437242
Gc4_405 0 n8 ns405 0 0.00511681547366
Gc4_406 0 n8 ns406 0 0.00709038203901
Gc4_407 0 n8 ns407 0 0.00067700259539
Gc4_408 0 n8 ns408 0 0.00530280982434
Gc4_409 0 n8 ns409 0 0.000859813157612
Gc4_410 0 n8 ns410 0 -0.000919253906208
Gc4_411 0 n8 ns411 0 -0.00632069596647
Gc4_412 0 n8 ns412 0 -0.00199930584024
Gc4_413 0 n8 ns413 0 0.00324569396216
Gc4_414 0 n8 ns414 0 -0.00526252598918
Gc4_415 0 n8 ns415 0 0.00455511526468
Gc4_416 0 n8 ns416 0 -4.97384854872e-06
Gc4_417 0 n8 ns417 0 -1.7503767455e-05
Gc4_418 0 n8 ns418 0 -4.45661738334e-05
Gc4_419 0 n8 ns419 0 0.00116251584416
Gc4_420 0 n8 ns420 0 -0.00436697891956
Gc4_421 0 n8 ns421 0 0.00132837457382
Gc4_422 0 n8 ns422 0 -0.00286535740834
Gc4_423 0 n8 ns423 0 -0.00122101435998
Gc4_424 0 n8 ns424 0 -0.000551928586463
Gc4_425 0 n8 ns425 0 0.000635770321712
Gc4_426 0 n8 ns426 0 -9.82366206958e-05
Gc4_427 0 n8 ns427 0 0.000168777710668
Gc4_428 0 n8 ns428 0 0.000609520567687
Gc4_429 0 n8 ns429 0 0.000258329284921
Gc4_430 0 n8 ns430 0 -4.83334215302e-05
Gc4_431 0 n8 ns431 0 -0.000563164432869
Gc4_432 0 n8 ns432 0 0.000121112350728
Gc4_433 0 n8 ns433 0 0.000515387333454
Gc4_434 0 n8 ns434 0 -0.000868850687831
Gc4_435 0 n8 ns435 0 0.000619203801496
Gc4_436 0 n8 ns436 0 -0.000510794312079
Gc4_437 0 n8 ns437 0 8.15704302005e-05
Gc4_438 0 n8 ns438 0 -0.00122940782309
Gc4_439 0 n8 ns439 0 0.00103333386455
Gc4_440 0 n8 ns440 0 0.00166633980605
Gc4_441 0 n8 ns441 0 0.00587063919778
Gc4_442 0 n8 ns442 0 0.00566027652849
Gc4_443 0 n8 ns443 0 0.00447843387516
Gc4_444 0 n8 ns444 0 0.00562551780008
Gc4_445 0 n8 ns445 0 0.0027209398681
Gc4_446 0 n8 ns446 0 0.00187785782859
Gc4_447 0 n8 ns447 0 0.000928604830939
Gc4_448 0 n8 ns448 0 -0.000916253456367
Gc4_449 0 n8 ns449 0 -0.00411431436779
Gc4_450 0 n8 ns450 0 -0.00115603618261
Gc4_451 0 n8 ns451 0 -0.000647563043473
Gc4_452 0 n8 ns452 0 -0.00222976902758
Gc4_453 0 n8 ns453 0 0.00379699937955
Gc4_454 0 n8 ns454 0 1.50094654575e-05
Gc4_455 0 n8 ns455 0 -0.000128508337925
Gc4_456 0 n8 ns456 0 3.19880002869e-05
Gc4_457 0 n8 ns457 0 0.000368852954372
Gc4_458 0 n8 ns458 0 -0.00143332388569
Gc4_459 0 n8 ns459 0 0.00109016926112
Gc4_460 0 n8 ns460 0 -0.0010537037164
Gc4_461 0 n8 ns461 0 -0.000592904662091
Gc4_462 0 n8 ns462 0 0.000205589813539
Gc4_463 0 n8 ns463 0 7.69348161399e-05
Gc4_464 0 n8 ns464 0 -0.000181811661854
Gc4_465 0 n8 ns465 0 0.000433593263923
Gc4_466 0 n8 ns466 0 4.63038598498e-05
Gc4_467 0 n8 ns467 0 0.000197183169467
Gc4_468 0 n8 ns468 0 -5.40977916827e-05
Gc4_469 0 n8 ns469 0 -5.38666761607e-05
Gc4_470 0 n8 ns470 0 -4.4176981899e-05
Gc4_471 0 n8 ns471 0 -0.000643409608929
Gc4_472 0 n8 ns472 0 -0.000827292321412
Gc4_473 0 n8 ns473 0 0.000374271206957
Gc4_474 0 n8 ns474 0 -0.000579885432972
Gc4_475 0 n8 ns475 0 -0.000132222041471
Gc4_476 0 n8 ns476 0 -0.00110454890707
Gc4_477 0 n8 ns477 0 0.00179467433255
Gc4_478 0 n8 ns478 0 -9.72194295727e-05
Gc4_479 0 n8 ns479 0 0.00257444974004
Gc4_480 0 n8 ns480 0 0.00280282377725
Gc4_481 0 n8 ns481 0 0.00218405872152
Gc4_482 0 n8 ns482 0 0.00322925480126
Gc4_483 0 n8 ns483 0 -0.000209452401405
Gc4_484 0 n8 ns484 0 -0.00188407005873
Gc4_485 0 n8 ns485 0 0.000656049617345
Gc4_486 0 n8 ns486 0 -0.00104296180187
Gc4_487 0 n8 ns487 0 6.01140799612e-05
Gc4_488 0 n8 ns488 0 -0.000495108527768
Gc4_489 0 n8 ns489 0 -0.00215974568369
Gc4_490 0 n8 ns490 0 0.00245392066267
Gc4_491 0 n8 ns491 0 0.00201562940427
Gc4_492 0 n8 ns492 0 3.66146550419e-06
Gc4_493 0 n8 ns493 0 -0.000180448311905
Gc4_494 0 n8 ns494 0 4.18177296219e-05
Gc4_495 0 n8 ns495 0 -9.57874080382e-05
Gc4_496 0 n8 ns496 0 0.000107969682595
Gc4_497 0 n8 ns497 0 0.000137417330515
Gc4_498 0 n8 ns498 0 0.000899689069308
Gc4_499 0 n8 ns499 0 8.20273821537e-05
Gc4_500 0 n8 ns500 0 0.000259774896378
Gc4_501 0 n8 ns501 0 6.26557931319e-05
Gc4_502 0 n8 ns502 0 -2.1292399348e-05
Gc4_503 0 n8 ns503 0 1.20564846294e-05
Gc4_504 0 n8 ns504 0 -0.000210162946753
Gc4_505 0 n8 ns505 0 0.000179635376599
Gc4_506 0 n8 ns506 0 -0.000117168564276
Gc4_507 0 n8 ns507 0 -0.000257932668821
Gc4_508 0 n8 ns508 0 -0.000427955932899
Gc4_509 0 n8 ns509 0 -0.00030774254804
Gc4_510 0 n8 ns510 0 0.000492700708653
Gc4_511 0 n8 ns511 0 0.000286399493641
Gc4_512 0 n8 ns512 0 -0.000408311553475
Gc4_513 0 n8 ns513 0 -0.000243905895408
Gc4_514 0 n8 ns514 0 -0.000508345447436
Gc4_515 0 n8 ns515 0 -0.00013143655864
Gc4_516 0 n8 ns516 0 -0.000742650246286
Gc4_517 0 n8 ns517 0 0.00180125988657
Gc4_518 0 n8 ns518 0 0.00323191772433
Gc4_519 0 n8 ns519 0 0.00191937633408
Gc4_520 0 n8 ns520 0 0.00324069380367
Gc4_521 0 n8 ns521 0 -0.00159601013053
Gc4_522 0 n8 ns522 0 0.000289532869159
Gc4_523 0 n8 ns523 0 6.47648560169e-06
Gc4_524 0 n8 ns524 0 -0.000951423698081
Gc4_525 0 n8 ns525 0 -0.000117184725879
Gc4_526 0 n8 ns526 0 -0.00144054586684
Gc4_527 0 n8 ns527 0 -0.000750215636569
Gc4_528 0 n8 ns528 0 0.00128817198311
Gc4_529 0 n8 ns529 0 0.000752115042475
Gc4_530 0 n8 ns530 0 3.34988690395e-05
Gc4_531 0 n8 ns531 0 -0.000201350096239
Gc4_532 0 n8 ns532 0 4.32740305651e-05
Gc4_533 0 n8 ns533 0 -0.000383226793666
Gc4_534 0 n8 ns534 0 0.000275572346095
Gc4_535 0 n8 ns535 0 -0.000914887240703
Gc4_536 0 n8 ns536 0 0.000836143019998
Gc4_537 0 n8 ns537 0 -0.00023035855898
Gc4_538 0 n8 ns538 0 0.00011818797936
Gc4_539 0 n8 ns539 0 0.000164786686263
Gc4_540 0 n8 ns540 0 -0.00014465184013
Gc4_541 0 n8 ns541 0 -0.000313527804575
Gc4_542 0 n8 ns542 0 0.00025072013419
Gc4_543 0 n8 ns543 0 0.000104614069029
Gc4_544 0 n8 ns544 0 -0.00014079615603
Gc4_545 0 n8 ns545 0 7.1031216513e-05
Gc4_546 0 n8 ns546 0 -0.000245079063997
Gc4_547 0 n8 ns547 0 0.000835945686545
Gc4_548 0 n8 ns548 0 6.41338520186e-05
Gc4_549 0 n8 ns549 0 0.000303783424553
Gc4_550 0 n8 ns550 0 -0.000534133259827
Gc4_551 0 n8 ns551 0 0.000218162006878
Gc4_552 0 n8 ns552 0 -0.000319903075056
Gc4_553 0 n8 ns553 0 -0.000514212926518
Gc4_554 0 n8 ns554 0 0.000561877680371
Gc4_555 0 n8 ns555 0 0.00290992215557
Gc4_556 0 n8 ns556 0 0.00291555148911
Gc4_557 0 n8 ns557 0 0.00285780690532
Gc4_558 0 n8 ns558 0 0.00252443311127
Gc4_559 0 n8 ns559 0 -0.000209754645107
Gc4_560 0 n8 ns560 0 0.00123514818995
Gc4_561 0 n8 ns561 0 -0.000305539876746
Gc4_562 0 n8 ns562 0 -0.000556569130401
Gc4_563 0 n8 ns563 0 -0.000991278138958
Gc4_564 0 n8 ns564 0 -0.00131261268013
Gc4_565 0 n8 ns565 0 -0.000519603956969
Gc4_566 0 n8 ns566 0 0.000133864451275
Gc4_567 0 n8 ns567 0 0.000239367077835
Gc4_568 0 n8 ns568 0 2.6448220422e-06
Gc4_569 0 n8 ns569 0 -1.74698036267e-05
Gc4_570 0 n8 ns570 0 -4.59097574186e-05
Gc4_571 0 n8 ns571 0 0.000107822579337
Gc4_572 0 n8 ns572 0 0.000291244792416
Gc4_573 0 n8 ns573 0 0.000540173903514
Gc4_574 0 n8 ns574 0 0.000630259996479
Gc4_575 0 n8 ns575 0 -4.19314401563e-05
Gc4_576 0 n8 ns576 0 3.36809760217e-06
Gc4_577 0 n8 ns577 0 -2.64686605939e-05
Gc4_578 0 n8 ns578 0 6.41333025114e-05
Gc4_579 0 n8 ns579 0 4.0474582358e-05
Gc4_580 0 n8 ns580 0 0.000492803530801
Gc4_581 0 n8 ns581 0 1.24155233689e-06
Gc4_582 0 n8 ns582 0 -0.000141560663251
Gc4_583 0 n8 ns583 0 -5.76415894344e-05
Gc4_584 0 n8 ns584 0 -0.0004525695139
Gc4_585 0 n8 ns585 0 0.000340106643897
Gc4_586 0 n8 ns586 0 -0.000930957507983
Gc4_587 0 n8 ns587 0 -0.000154494245732
Gc4_588 0 n8 ns588 0 -0.000739620710097
Gc4_589 0 n8 ns589 0 -4.54925627113e-05
Gc4_590 0 n8 ns590 0 -0.000838923507219
Gc4_591 0 n8 ns591 0 0.000603289707409
Gc4_592 0 n8 ns592 0 0.000795089730949
Gc4_593 0 n8 ns593 0 0.00412026398711
Gc4_594 0 n8 ns594 0 0.000975222132379
Gc4_595 0 n8 ns595 0 0.00365863520249
Gc4_596 0 n8 ns596 0 0.000694837823791
Gc4_597 0 n8 ns597 0 0.000648792714607
Gc4_598 0 n8 ns598 0 0.000702170031034
Gc4_599 0 n8 ns599 0 -0.000286194391323
Gc4_600 0 n8 ns600 0 -0.000260382379343
Gc4_601 0 n8 ns601 0 -0.00117768271958
Gc4_602 0 n8 ns602 0 -0.000740193111629
Gc4_603 0 n8 ns603 0 -0.000499381379904
Gc4_604 0 n8 ns604 0 -0.000383547710407
Gc4_605 0 n8 ns605 0 4.71440560608e-05
Gc4_606 0 n8 ns606 0 1.54494588795e-05
Gc4_607 0 n8 ns607 0 -3.20556282273e-05
Gc4_608 0 n8 ns608 0 -1.03896454049e-05
Gc4_609 0 n8 ns609 0 -0.000318331379868
Gc4_610 0 n8 ns610 0 -0.000203576597128
Gc4_611 0 n8 ns611 0 -0.00101006587096
Gc4_612 0 n8 ns612 0 0.000813253795718
Gc4_613 0 n8 ns613 0 -0.000340872943242
Gc4_614 0 n8 ns614 0 -0.000147465377917
Gc4_615 0 n8 ns615 0 7.36092209464e-05
Gc4_616 0 n8 ns616 0 -7.85184470035e-05
Gc4_617 0 n8 ns617 0 -0.000354042666384
Gc4_618 0 n8 ns618 0 0.000858327873903
Gc4_619 0 n8 ns619 0 -5.32886146958e-05
Gc4_620 0 n8 ns620 0 -2.80987048245e-06
Gc4_621 0 n8 ns621 0 0.000552067984163
Gc4_622 0 n8 ns622 0 -0.000859237262385
Gc4_623 0 n8 ns623 0 -0.000645391410629
Gc4_624 0 n8 ns624 0 0.000859431121941
Gc4_625 0 n8 ns625 0 0.000590975907843
Gc4_626 0 n8 ns626 0 0.000359813590966
Gc4_627 0 n8 ns627 0 0.000175605835919
Gc4_628 0 n8 ns628 0 0.000441356949298
Gc4_629 0 n8 ns629 0 -0.000298230234985
Gc4_630 0 n8 ns630 0 0.00107756225954
Gc4_631 0 n8 ns631 0 0.00185386174924
Gc4_632 0 n8 ns632 0 -0.00390865726194
Gc4_633 0 n8 ns633 0 0.00141899038833
Gc4_634 0 n8 ns634 0 -0.004046565007
Gc4_635 0 n8 ns635 0 -0.00178468252268
Gc4_636 0 n8 ns636 0 -0.000115267128635
Gc4_637 0 n8 ns637 0 0.000462694387515
Gc4_638 0 n8 ns638 0 -0.00108070908855
Gc4_639 0 n8 ns639 0 0.00106619381203
Gc4_640 0 n8 ns640 0 -0.0020001132273
Gc4_641 0 n8 ns641 0 0.000944013671547
Gc4_642 0 n8 ns642 0 -0.00179817225267
Gc4_643 0 n8 ns643 0 -0.000985788677259
Gc4_644 0 n8 ns644 0 -3.61283418254e-05
Gc4_645 0 n8 ns645 0 0.000152032779255
Gc4_646 0 n8 ns646 0 -2.96456696814e-05
Gc4_647 0 n8 ns647 0 -0.000391390365871
Gc4_648 0 n8 ns648 0 -6.19725381853e-05
Gc4_649 0 n8 ns649 0 -0.00108271599158
Gc4_650 0 n8 ns650 0 0.00185691683616
Gc4_651 0 n8 ns651 0 -8.40797777083e-05
Gc4_652 0 n8 ns652 0 0.000253375750754
Gc4_653 0 n8 ns653 0 1.83347552534e-05
Gc4_654 0 n8 ns654 0 -0.0002051502982
Gc4_655 0 n8 ns655 0 -0.000260773508331
Gc4_656 0 n8 ns656 0 0.000826577882706
Gc4_657 0 n8 ns657 0 -0.000112404551433
Gc4_658 0 n8 ns658 0 -3.36961540906e-05
Gc4_659 0 n8 ns659 0 0.00053194497376
Gc4_660 0 n8 ns660 0 -0.000765683126676
Gc4_661 0 n8 ns661 0 -0.000550532065568
Gc4_662 0 n8 ns662 0 0.00039034655858
Gc4_663 0 n8 ns663 0 0.000756960526634
Gc4_664 0 n8 ns664 0 8.01648432639e-05
Gc4_665 0 n8 ns665 0 0.000331254795285
Gc4_666 0 n8 ns666 0 -7.24571254902e-05
Gc4_667 0 n8 ns667 0 -0.000671248808494
Gc4_668 0 n8 ns668 0 0.00122151134862
Gc4_669 0 n8 ns669 0 0.0010208139558
Gc4_670 0 n8 ns670 0 -0.00333582413475
Gc4_671 0 n8 ns671 0 0.000783116375063
Gc4_672 0 n8 ns672 0 -0.0037418536664
Gc4_673 0 n8 ns673 0 -0.00112439040618
Gc4_674 0 n8 ns674 0 -0.000225126313632
Gc4_675 0 n8 ns675 0 0.000592723315027
Gc4_676 0 n8 ns676 0 -0.00123479754806
Gc4_677 0 n8 ns677 0 0.00086049913992
Gc4_678 0 n8 ns678 0 -0.0022163298032
Gc4_679 0 n8 ns679 0 0.00133450198042
Gc4_680 0 n8 ns680 0 -0.00256967053934
Gc4_681 0 n8 ns681 0 -0.00147575147351
Gc4_682 0 n8 ns682 0 -2.18035290431e-05
Gc4_683 0 n8 ns683 0 8.74189742286e-05
Gc4_684 0 n8 ns684 0 2.68693863423e-06
Gc4_685 0 n8 ns685 0 -0.000787919564228
Gc4_686 0 n8 ns686 0 -0.000999531156172
Gc4_687 0 n8 ns687 0 -0.00329524251736
Gc4_688 0 n8 ns688 0 -0.00171291034764
Gc4_689 0 n8 ns689 0 -0.00194186150188
Gc4_690 0 n8 ns690 0 0.00101715357863
Gc4_691 0 n8 ns691 0 0.000885485782308
Gc4_692 0 n8 ns692 0 -0.000360942122921
Gc4_693 0 n8 ns693 0 -0.000167151380754
Gc4_694 0 n8 ns694 0 0.000144844389713
Gc4_695 0 n8 ns695 0 -0.000265302131211
Gc4_696 0 n8 ns696 0 -3.08581205403e-06
Gc4_697 0 n8 ns697 0 0.000392472664837
Gc4_698 0 n8 ns698 0 0.000344877283569
Gc4_699 0 n8 ns699 0 0.00109614397676
Gc4_700 0 n8 ns700 0 -0.000620525496727
Gc4_701 0 n8 ns701 0 0.00134110020911
Gc4_702 0 n8 ns702 0 -0.000315188111377
Gc4_703 0 n8 ns703 0 0.00119000084556
Gc4_704 0 n8 ns704 0 -0.000651731520355
Gc4_705 0 n8 ns705 0 -0.00173017820354
Gc4_706 0 n8 ns706 0 -0.000901533735326
Gc4_707 0 n8 ns707 0 -0.00469372019698
Gc4_708 0 n8 ns708 0 -0.00443136801736
Gc4_709 0 n8 ns709 0 -0.00364529558451
Gc4_710 0 n8 ns710 0 -0.00470293798555
Gc4_711 0 n8 ns711 0 0.00305711936597
Gc4_712 0 n8 ns712 0 0.00180679703057
Gc4_713 0 n8 ns713 0 0.000951088231864
Gc4_714 0 n8 ns714 0 -0.00121902721701
Gc4_715 0 n8 ns715 0 -0.00172103499991
Gc4_716 0 n8 ns716 0 -0.00292715729773
Gc4_717 0 n8 ns717 0 0.00254515967128
Gc4_718 0 n8 ns718 0 -0.000558633290877
Gc4_719 0 n8 ns719 0 -0.00319861396913
Gc4_720 0 n8 ns720 0 -3.75505811364e-05
Gc4_721 0 n8 ns721 0 0.000337713335212
Gc4_722 0 n8 ns722 0 -0.000162582189458
Gc4_723 0 n8 ns723 0 -0.000647089397689
Gc4_724 0 n8 ns724 0 0.000123871094259
Gc4_725 0 n8 ns725 0 6.92818273431e-05
Gc4_726 0 n8 ns726 0 0.00311074240816
Gc4_727 0 n8 ns727 0 0.00128102959398
Gc4_728 0 n8 ns728 0 -0.000706280886163
Gc4_729 0 n8 ns729 0 -0.000301000634145
Gc4_730 0 n8 ns730 0 -0.000112816007731
Gc4_731 0 n8 ns731 0 0.000227848593476
Gc4_732 0 n8 ns732 0 0.000113933065404
Gc4_733 0 n8 ns733 0 -0.000142697353873
Gc4_734 0 n8 ns734 0 3.99759200792e-05
Gc4_735 0 n8 ns735 0 0.00208595093558
Gc4_736 0 n8 ns736 0 -0.000858379023617
Gc4_737 0 n8 ns737 0 -0.000263617394168
Gc4_738 0 n8 ns738 0 0.00117382834158
Gc4_739 0 n8 ns739 0 -0.000292481844017
Gc4_740 0 n8 ns740 0 -0.000108689488076
Gc4_741 0 n8 ns741 0 -0.00190776812645
Gc4_742 0 n8 ns742 0 -0.00140289988613
Gc4_743 0 n8 ns743 0 0.00295984997762
Gc4_744 0 n8 ns744 0 0.00365168544595
Gc4_745 0 n8 ns745 0 -0.0105370736157
Gc4_746 0 n8 ns746 0 -0.000340125174533
Gc4_747 0 n8 ns747 0 -0.00810073303837
Gc4_748 0 n8 ns748 0 -0.00151698401443
Gc4_749 0 n8 ns749 0 -0.0110165572381
Gc4_750 0 n8 ns750 0 -0.000150782946953
Gc4_751 0 n8 ns751 0 0.00146881418635
Gc4_752 0 n8 ns752 0 -2.03565398679e-05
Gc4_753 0 n8 ns753 0 -0.00344134585586
Gc4_754 0 n8 ns754 0 0.00830492509152
Gc4_755 0 n8 ns755 0 -0.014216847093
Gc4_756 0 n8 ns756 0 -0.00419056096867
Gc4_757 0 n8 ns757 0 -0.00627549564564
Gc4_758 0 n8 ns758 0 -5.74515569568e-05
Gc4_759 0 n8 ns759 0 -0.000342051323282
Gc4_760 0 n8 ns760 0 0.000585671936471
Gc4_761 0 n8 ns761 0 -0.000832767782922
Gc4_762 0 n8 ns762 0 -0.000680423537847
Gc4_763 0 n8 ns763 0 -0.00340156819886
Gc4_764 0 n8 ns764 0 -0.00159697873335
Gc4_765 0 n8 ns765 0 -0.00180096832523
Gc4_766 0 n8 ns766 0 0.00112632167295
Gc4_767 0 n8 ns767 0 0.00074140900538
Gc4_768 0 n8 ns768 0 -0.000485993120135
Gc4_769 0 n8 ns769 0 -0.00046964094462
Gc4_770 0 n8 ns770 0 4.77140863897e-05
Gc4_771 0 n8 ns771 0 -0.000164513259715
Gc4_772 0 n8 ns772 0 5.53121029555e-05
Gc4_773 0 n8 ns773 0 0.000687414993645
Gc4_774 0 n8 ns774 0 0.00013719144756
Gc4_775 0 n8 ns775 0 0.000818693907716
Gc4_776 0 n8 ns776 0 -0.000894048483493
Gc4_777 0 n8 ns777 0 0.000971652153137
Gc4_778 0 n8 ns778 0 -0.000288927621886
Gc4_779 0 n8 ns779 0 0.000761378215601
Gc4_780 0 n8 ns780 0 -0.000533915441132
Gc4_781 0 n8 ns781 0 -0.00216571282866
Gc4_782 0 n8 ns782 0 -0.000887608007173
Gc4_783 0 n8 ns783 0 -0.00623989464695
Gc4_784 0 n8 ns784 0 -0.00279233650517
Gc4_785 0 n8 ns785 0 -0.00494167438589
Gc4_786 0 n8 ns786 0 -0.00324008901964
Gc4_787 0 n8 ns787 0 0.00355747634293
Gc4_788 0 n8 ns788 0 0.00202932041383
Gc4_789 0 n8 ns789 0 0.000838280658309
Gc4_790 0 n8 ns790 0 -0.00119230507499
Gc4_791 0 n8 ns791 0 -0.00216556488365
Gc4_792 0 n8 ns792 0 -0.00293383053234
Gc4_793 0 n8 ns793 0 0.00244148767288
Gc4_794 0 n8 ns794 0 -0.000615464477524
Gc4_795 0 n8 ns795 0 -0.00319169070868
Gc4_796 0 n8 ns796 0 -4.540901356e-05
Gc4_797 0 n8 ns797 0 0.000361895742645
Gc4_798 0 n8 ns798 0 -0.000158068588399
Gc4_799 0 n8 ns799 0 -8.18978327129e-05
Gc4_800 0 n8 ns800 0 -6.26958555937e-05
Gc4_801 0 n8 ns801 0 0.000107235806263
Gc4_802 0 n8 ns802 0 0.00155400380929
Gc4_803 0 n8 ns803 0 0.000102279155078
Gc4_804 0 n8 ns804 0 0.000232453861801
Gc4_805 0 n8 ns805 0 2.98193959468e-06
Gc4_806 0 n8 ns806 0 -0.00022773918347
Gc4_807 0 n8 ns807 0 -0.000218858447943
Gc4_808 0 n8 ns808 0 0.000420044839758
Gc4_809 0 n8 ns809 0 -0.00010546271443
Gc4_810 0 n8 ns810 0 6.51315555607e-05
Gc4_811 0 n8 ns811 0 0.000606986663487
Gc4_812 0 n8 ns812 0 -0.000562111006714
Gc4_813 0 n8 ns813 0 -0.00046221799921
Gc4_814 0 n8 ns814 0 -0.000186574748847
Gc4_815 0 n8 ns815 0 0.0004095012667
Gc4_816 0 n8 ns816 0 -0.000338121479316
Gc4_817 0 n8 ns817 0 -6.75544738497e-05
Gc4_818 0 n8 ns818 0 -0.0004931827603
Gc4_819 0 n8 ns819 0 -0.000985130207625
Gc4_820 0 n8 ns820 0 0.00112257638213
Gc4_821 0 n8 ns821 0 -0.00258317433846
Gc4_822 0 n8 ns822 0 -0.00154758766185
Gc4_823 0 n8 ns823 0 -0.00236231558637
Gc4_824 0 n8 ns824 0 -0.00210701823642
Gc4_825 0 n8 ns825 0 0.000117858304757
Gc4_826 0 n8 ns826 0 0.000947885451012
Gc4_827 0 n8 ns827 0 0.000251497309538
Gc4_828 0 n8 ns828 0 -0.00132813258404
Gc4_829 0 n8 ns829 0 -0.000478600087002
Gc4_830 0 n8 ns830 0 -0.00299425595065
Gc4_831 0 n8 ns831 0 0.000915521658583
Gc4_832 0 n8 ns832 0 -0.00360356249965
Gc4_833 0 n8 ns833 0 -0.00164395815632
Gc4_834 0 n8 ns834 0 -2.58460576873e-05
Gc4_835 0 n8 ns835 0 0.000100729732176
Gc4_836 0 n8 ns836 0 6.68757624381e-07
Gc4_837 0 n8 ns837 0 -0.000129015034841
Gc4_838 0 n8 ns838 0 0.000124816128502
Gc4_839 0 n8 ns839 0 -8.46411674737e-05
Gc4_840 0 n8 ns840 0 0.00055667160838
Gc4_841 0 n8 ns841 0 -0.000177770108519
Gc4_842 0 n8 ns842 0 0.000191025905053
Gc4_843 0 n8 ns843 0 -1.38055942055e-05
Gc4_844 0 n8 ns844 0 -8.53164677232e-05
Gc4_845 0 n8 ns845 0 0.00034232517416
Gc4_846 0 n8 ns846 0 0.000361722151552
Gc4_847 0 n8 ns847 0 -6.82280414389e-05
Gc4_848 0 n8 ns848 0 6.02452444818e-05
Gc4_849 0 n8 ns849 0 -0.000174769879135
Gc4_850 0 n8 ns850 0 -0.000392515286009
Gc4_851 0 n8 ns851 0 0.000304820857257
Gc4_852 0 n8 ns852 0 0.000527046224937
Gc4_853 0 n8 ns853 0 0.000415446357407
Gc4_854 0 n8 ns854 0 -0.000311293744723
Gc4_855 0 n8 ns855 0 0.000185634397856
Gc4_856 0 n8 ns856 0 -0.000114191589682
Gc4_857 0 n8 ns857 0 -2.77537734751e-05
Gc4_858 0 n8 ns858 0 0.000262687749575
Gc4_859 0 n8 ns859 0 -0.00393547002506
Gc4_860 0 n8 ns860 0 -0.0036744952387
Gc4_861 0 n8 ns861 0 -0.00373198656563
Gc4_862 0 n8 ns862 0 -0.00342417326941
Gc4_863 0 n8 ns863 0 -0.000243276879573
Gc4_864 0 n8 ns864 0 0.00204164603871
Gc4_865 0 n8 ns865 0 -0.000262098580504
Gc4_866 0 n8 ns866 0 -0.000954672597852
Gc4_867 0 n8 ns867 0 -0.00103910830339
Gc4_868 0 n8 ns868 0 -0.00270169249435
Gc4_869 0 n8 ns869 0 3.20656077635e-05
Gc4_870 0 n8 ns870 0 -0.0022354245223
Gc4_871 0 n8 ns871 0 -0.000743761632643
Gc4_872 0 n8 ns872 0 -1.78679182474e-05
Gc4_873 0 n8 ns873 0 8.22856551795e-05
Gc4_874 0 n8 ns874 0 -1.16894944534e-05
Gc4_875 0 n8 ns875 0 0.000494170050242
Gc4_876 0 n8 ns876 0 -0.000679871362432
Gc4_877 0 n8 ns877 0 0.00151753334799
Gc4_878 0 n8 ns878 0 -0.000946071919077
Gc4_879 0 n8 ns879 0 0.000309590287055
Gc4_880 0 n8 ns880 0 -0.000216035589933
Gc4_881 0 n8 ns881 0 -0.000137644041362
Gc4_882 0 n8 ns882 0 0.000131725000704
Gc4_883 0 n8 ns883 0 0.000185289635087
Gc4_884 0 n8 ns884 0 -0.000531106691906
Gc4_885 0 n8 ns885 0 -8.45115467362e-05
Gc4_886 0 n8 ns886 0 0.000158081716377
Gc4_887 0 n8 ns887 0 -6.17347397779e-05
Gc4_888 0 n8 ns888 0 0.000608174404086
Gc4_889 0 n8 ns889 0 0.000396928232972
Gc4_890 0 n8 ns890 0 -0.000139858077178
Gc4_891 0 n8 ns891 0 -0.000131538399173
Gc4_892 0 n8 ns892 0 -0.000537767642398
Gc4_893 0 n8 ns893 0 -0.000331183788219
Gc4_894 0 n8 ns894 0 -0.000464686786905
Gc4_895 0 n8 ns895 0 -6.81189024528e-05
Gc4_896 0 n8 ns896 0 -0.000585596972084
Gc4_897 0 n8 ns897 0 -0.00486753614561
Gc4_898 0 n8 ns898 0 -0.0020548882376
Gc4_899 0 n8 ns899 0 -0.00441372850458
Gc4_900 0 n8 ns900 0 -0.00172090229733
Gc4_901 0 n8 ns901 0 0.000370602534835
Gc4_902 0 n8 ns902 0 0.00153305674965
Gc4_903 0 n8 ns903 0 -0.000352205312763
Gc4_904 0 n8 ns904 0 -0.000468625225281
Gc4_905 0 n8 ns905 0 -0.00123105556158
Gc4_906 0 n8 ns906 0 -0.00143506332898
Gc4_907 0 n8 ns907 0 -0.000169407273433
Gc4_908 0 n8 ns908 0 -0.000976332729649
Gc4_909 0 n8 ns909 0 -0.000300533023667
Gc4_910 0 n8 ns910 0 -5.07398288573e-06
Gc4_911 0 n8 ns911 0 2.74408767924e-05
Gc4_912 0 n8 ns912 0 2.69014313889e-05
Gc4_913 0 n8 ns913 0 -0.000705624181743
Gc4_914 0 n8 ns914 0 0.00129924567567
Gc4_915 0 n8 ns915 0 -0.00181295437706
Gc4_916 0 n8 ns916 0 0.00186167906475
Gc4_917 0 n8 ns917 0 -0.000246229221734
Gc4_918 0 n8 ns918 0 0.000685254558642
Gc4_919 0 n8 ns919 0 0.000174929960536
Gc4_920 0 n8 ns920 0 -0.000435871340697
Gc4_921 0 n8 ns921 0 -6.02044090304e-05
Gc4_922 0 n8 ns922 0 -0.000107669458636
Gc4_923 0 n8 ns923 0 9.39182950609e-05
Gc4_924 0 n8 ns924 0 0.000114133884508
Gc4_925 0 n8 ns925 0 0.000592060301096
Gc4_926 0 n8 ns926 0 -0.000356864233192
Gc4_927 0 n8 ns927 0 0.00035283336724
Gc4_928 0 n8 ns928 0 -0.000742012045796
Gc4_929 0 n8 ns929 0 -0.000187844079443
Gc4_930 0 n8 ns930 0 -0.000485517118003
Gc4_931 0 n8 ns931 0 -0.000173976016993
Gc4_932 0 n8 ns932 0 -0.000434709342713
Gc4_933 0 n8 ns933 0 -0.000558215948009
Gc4_934 0 n8 ns934 0 -0.000160509171618
Gc4_935 0 n8 ns935 0 -0.00417438725068
Gc4_936 0 n8 ns936 0 0.000457743846402
Gc4_937 0 n8 ns937 0 -0.00363344469258
Gc4_938 0 n8 ns938 0 0.000465165828509
Gc4_939 0 n8 ns939 0 0.000424186842823
Gc4_940 0 n8 ns940 0 0.00132366818365
Gc4_941 0 n8 ns941 0 -0.000252452871315
Gc4_942 0 n8 ns942 0 -0.00027630212455
Gc4_943 0 n8 ns943 0 -0.00087014331887
Gc4_944 0 n8 ns944 0 -0.00105164815126
Gc4_945 0 n8 ns945 0 -0.000116688950483
Gc4_946 0 n8 ns946 0 -0.000681887755767
Gc4_947 0 n8 ns947 0 -0.000208529233073
Gc4_948 0 n8 ns948 0 1.91005637244e-06
Gc4_949 0 n8 ns949 0 6.5501537812e-05
Gc4_950 0 n8 ns950 0 -5.98444114088e-06
Gc4_951 0 n8 ns951 0 -0.000717027885151
Gc4_952 0 n8 ns952 0 -0.000512394344253
Gc4_953 0 n8 ns953 0 -0.00227258052433
Gc4_954 0 n8 ns954 0 0.00101736968757
Gc4_955 0 n8 ns955 0 -0.000225071849682
Gc4_956 0 n8 ns956 0 0.000852290671541
Gc4_957 0 n8 ns957 0 0.000163382690934
Gc4_958 0 n8 ns958 0 -0.000237688045747
Gc4_959 0 n8 ns959 0 -0.000125058320095
Gc4_960 0 n8 ns960 0 0.000343354349211
Gc4_961 0 n8 ns961 0 -0.000250274318845
Gc4_962 0 n8 ns962 0 -2.1622305275e-05
Gc4_963 0 n8 ns963 0 0.000407622021221
Gc4_964 0 n8 ns964 0 0.000288600121724
Gc4_965 0 n8 ns965 0 0.000348974347447
Gc4_966 0 n8 ns966 0 -0.000319313721132
Gc4_967 0 n8 ns967 0 0.00110090950146
Gc4_968 0 n8 ns968 0 -0.000299151605059
Gc4_969 0 n8 ns969 0 0.000848090645216
Gc4_970 0 n8 ns970 0 -0.000743016153044
Gc4_971 0 n8 ns971 0 -0.00173907813969
Gc4_972 0 n8 ns972 0 2.31033666915e-05
Gc4_973 0 n8 ns973 0 -0.00337684446322
Gc4_974 0 n8 ns974 0 -0.00366810390792
Gc4_975 0 n8 ns975 0 -0.002649005045
Gc4_976 0 n8 ns976 0 -0.00409637690508
Gc4_977 0 n8 ns977 0 0.00119345413101
Gc4_978 0 n8 ns978 0 -0.000430996566918
Gc4_979 0 n8 ns979 0 0.000943103015733
Gc4_980 0 n8 ns980 0 -0.00115750656651
Gc4_981 0 n8 ns981 0 6.06026008632e-05
Gc4_982 0 n8 ns982 0 -0.00163821146664
Gc4_983 0 n8 ns983 0 0.00254908835379
Gc4_984 0 n8 ns984 0 -0.00233709779476
Gc4_985 0 n8 ns985 0 -0.00248842224926
Gc4_986 0 n8 ns986 0 3.51871892732e-06
Gc4_987 0 n8 ns987 0 0.00013171085651
Gc4_988 0 n8 ns988 0 -3.02360699297e-05
Gc4_989 0 n8 ns989 0 0.00213713614682
Gc4_990 0 n8 ns990 0 -0.00318333116222
Gc4_991 0 n8 ns991 0 0.00468279393427
Gc4_992 0 n8 ns992 0 -0.00647666470155
Gc4_993 0 n8 ns993 0 -0.00338318837173
Gc4_994 0 n8 ns994 0 -0.00226945705879
Gc4_995 0 n8 ns995 0 0.00120224170222
Gc4_996 0 n8 ns996 0 0.000659663611799
Gc4_997 0 n8 ns997 0 -0.000278289567355
Gc4_998 0 n8 ns998 0 -0.000540021612794
Gc4_999 0 n8 ns999 0 -0.000276113915102
Gc4_1000 0 n8 ns1000 0 5.63044174254e-06
Gc4_1001 0 n8 ns1001 0 -0.000403686678649
Gc4_1002 0 n8 ns1002 0 -0.000341626878893
Gc4_1003 0 n8 ns1003 0 0.0014738868308
Gc4_1004 0 n8 ns1004 0 4.82397203429e-05
Gc4_1005 0 n8 ns1005 0 0.00102612477144
Gc4_1006 0 n8 ns1006 0 0.000222831844869
Gc4_1007 0 n8 ns1007 0 0.000427001163117
Gc4_1008 0 n8 ns1008 0 0.000414099213602
Gc4_1009 0 n8 ns1009 0 0.000881542588595
Gc4_1010 0 n8 ns1010 0 -0.00304242609415
Gc4_1011 0 n8 ns1011 0 -0.00222918067146
Gc4_1012 0 n8 ns1012 0 -0.00806547084848
Gc4_1013 0 n8 ns1013 0 -0.00155982098018
Gc4_1014 0 n8 ns1014 0 -0.0075506257189
Gc4_1015 0 n8 ns1015 0 0.00537055466145
Gc4_1016 0 n8 ns1016 0 0.00809302767698
Gc4_1017 0 n8 ns1017 0 0.000820842024096
Gc4_1018 0 n8 ns1018 0 -0.00122188015071
Gc4_1019 0 n8 ns1019 0 -0.00524651245863
Gc4_1020 0 n8 ns1020 0 -0.00598954176392
Gc4_1021 0 n8 ns1021 0 0.0014634818409
Gc4_1022 0 n8 ns1022 0 0.0053025761926
Gc4_1023 0 n8 ns1023 0 -0.00429856722743
Gc4_1024 0 n8 ns1024 0 1.51850365223e-06
Gc4_1025 0 n8 ns1025 0 0.000431191893461
Gc4_1026 0 n8 ns1026 0 -0.000237882486486
Gc4_1027 0 n8 ns1027 0 0.000944003539981
Gc4_1028 0 n8 ns1028 0 -0.0022033515412
Gc4_1029 0 n8 ns1029 0 0.00153134002336
Gc4_1030 0 n8 ns1030 0 -0.0042225470667
Gc4_1031 0 n8 ns1031 0 -0.00244335087004
Gc4_1032 0 n8 ns1032 0 -0.00108995866441
Gc4_1033 0 n8 ns1033 0 0.000870654905402
Gc4_1034 0 n8 ns1034 0 0.000321769319494
Gc4_1035 0 n8 ns1035 0 -0.000466252944998
Gc4_1036 0 n8 ns1036 0 -0.000422738011318
Gc4_1037 0 n8 ns1037 0 -0.000209568712731
Gc4_1038 0 n8 ns1038 0 4.13339083765e-05
Gc4_1039 0 n8 ns1039 0 0.00021638100054
Gc4_1040 0 n8 ns1040 0 1.76695916961e-05
Gc4_1041 0 n8 ns1041 0 0.0012564619627
Gc4_1042 0 n8 ns1042 0 -0.000518682169065
Gc4_1043 0 n8 ns1043 0 0.000921164466761
Gc4_1044 0 n8 ns1044 0 -2.2980762899e-05
Gc4_1045 0 n8 ns1045 0 0.000430138163917
Gc4_1046 0 n8 ns1046 0 -0.000114865706267
Gc4_1047 0 n8 ns1047 0 -0.000915240979588
Gc4_1048 0 n8 ns1048 0 -0.0021615619202
Gc4_1049 0 n8 ns1049 0 -0.00574349040982
Gc4_1050 0 n8 ns1050 0 -0.00434286563074
Gc4_1051 0 n8 ns1051 0 -0.0044595066486
Gc4_1052 0 n8 ns1052 0 -0.00454073940297
Gc4_1053 0 n8 ns1053 0 0.00443469675604
Gc4_1054 0 n8 ns1054 0 0.00413313168958
Gc4_1055 0 n8 ns1055 0 0.000937924886365
Gc4_1056 0 n8 ns1056 0 -0.00113661756953
Gc4_1057 0 n8 ns1057 0 -0.00314056173811
Gc4_1058 0 n8 ns1058 0 -0.00337658261335
Gc4_1059 0 n8 ns1059 0 0.00221283325268
Gc4_1060 0 n8 ns1060 0 0.0015238353088
Gc4_1061 0 n8 ns1061 0 -0.00374140548674
Gc4_1062 0 n8 ns1062 0 -1.886584881e-06
Gc4_1063 0 n8 ns1063 0 0.000320529322672
Gc4_1064 0 n8 ns1064 0 -0.000140577371992
Gc4_1065 0 n8 ns1065 0 -0.00029077445792
Gc4_1066 0 n8 ns1066 0 -0.000492377451468
Gc4_1067 0 n8 ns1067 0 -0.00088324909225
Gc4_1068 0 n8 ns1068 0 0.000780969326342
Gc4_1069 0 n8 ns1069 0 -0.000103872436475
Gc4_1070 0 n8 ns1070 0 0.000501402965426
Gc4_1071 0 n8 ns1071 0 0.000130284458758
Gc4_1072 0 n8 ns1072 0 -0.000287705314398
Gc4_1073 0 n8 ns1073 0 -0.000488223959832
Gc4_1074 0 n8 ns1074 0 0.00020427883062
Gc4_1075 0 n8 ns1075 0 -0.000141718325476
Gc4_1076 0 n8 ns1076 0 8.96695362005e-05
Gc4_1077 0 n8 ns1077 0 0.000894242146537
Gc4_1078 0 n8 ns1078 0 -0.000172675222956
Gc4_1079 0 n8 ns1079 0 -0.000347396991646
Gc4_1080 0 n8 ns1080 0 -0.000554619366441
Gc4_1081 0 n8 ns1081 0 0.000499805080459
Gc4_1082 0 n8 ns1082 0 -0.000323671456645
Gc4_1083 0 n8 ns1083 0 1.58192068619e-05
Gc4_1084 0 n8 ns1084 0 -0.000589155758754
Gc4_1085 0 n8 ns1085 0 -0.00166453225524
Gc4_1086 0 n8 ns1086 0 0.000709508794847
Gc4_1087 0 n8 ns1087 0 -0.00377789135131
Gc4_1088 0 n8 ns1088 0 -0.00141882293365
Gc4_1089 0 n8 ns1089 0 -0.00319616178044
Gc4_1090 0 n8 ns1090 0 -0.0021202700654
Gc4_1091 0 n8 ns1091 0 0.000911234887458
Gc4_1092 0 n8 ns1092 0 0.00063488515142
Gc4_1093 0 n8 ns1093 0 0.000508322100628
Gc4_1094 0 n8 ns1094 0 -0.00133355134601
Gc4_1095 0 n8 ns1095 0 -0.000534400353771
Gc4_1096 0 n8 ns1096 0 -0.00268303656977
Gc4_1097 0 n8 ns1097 0 0.00155331016538
Gc4_1098 0 n8 ns1098 0 -0.00342760391676
Gc4_1099 0 n8 ns1099 0 -0.00213466793993
Gc4_1100 0 n8 ns1100 0 -2.35682678508e-05
Gc4_1101 0 n8 ns1101 0 0.000133344926577
Gc4_1102 0 n8 ns1102 0 -1.36383645135e-05
Gc4_1103 0 n8 ns1103 0 -0.000116143289636
Gc4_1104 0 n8 ns1104 0 2.23840965782e-05
Gc4_1105 0 n8 ns1105 0 -5.05723501412e-05
Gc4_1106 0 n8 ns1106 0 0.000747896673321
Gc4_1107 0 n8 ns1107 0 -0.000144123177401
Gc4_1108 0 n8 ns1108 0 0.00010358395594
Gc4_1109 0 n8 ns1109 0 -2.84195474044e-05
Gc4_1110 0 n8 ns1110 0 -0.000118465231964
Gc4_1111 0 n8 ns1111 0 0.000114188099658
Gc4_1112 0 n8 ns1112 0 0.000515679461104
Gc4_1113 0 n8 ns1113 0 -8.14582867929e-05
Gc4_1114 0 n8 ns1114 0 6.39621565564e-05
Gc4_1115 0 n8 ns1115 0 9.51706366527e-05
Gc4_1116 0 n8 ns1116 0 -0.000581540585965
Gc4_1117 0 n8 ns1117 0 -3.08985294226e-05
Gc4_1118 0 n8 ns1118 0 0.000567534910895
Gc4_1119 0 n8 ns1119 0 0.000475011081483
Gc4_1120 0 n8 ns1120 0 -0.000217930599589
Gc4_1121 0 n8 ns1121 0 0.000115502577
Gc4_1122 0 n8 ns1122 0 -6.05725070326e-05
Gc4_1123 0 n8 ns1123 0 -0.000217843086002
Gc4_1124 0 n8 ns1124 0 0.00060761714067
Gc4_1125 0 n8 ns1125 0 -0.00319704567405
Gc4_1126 0 n8 ns1126 0 -0.00371936603097
Gc4_1127 0 n8 ns1127 0 -0.0030932484526
Gc4_1128 0 n8 ns1128 0 -0.00364693404986
Gc4_1129 0 n8 ns1129 0 -0.000450876075406
Gc4_1130 0 n8 ns1130 0 0.00181148294899
Gc4_1131 0 n8 ns1131 0 -0.00012204757995
Gc4_1132 0 n8 ns1132 0 -0.0011352060778
Gc4_1133 0 n8 ns1133 0 -0.000772983728034
Gc4_1134 0 n8 ns1134 0 -0.00296746002606
Gc4_1135 0 n8 ns1135 0 0.000251697110192
Gc4_1136 0 n8 ns1136 0 -0.00265603045741
Gc4_1137 0 n8 ns1137 0 -0.000975782062198
Gc4_1138 0 n8 ns1138 0 -1.68582454181e-05
Gc4_1139 0 n8 ns1139 0 0.000105327601943
Gc4_1140 0 n8 ns1140 0 -2.28157151802e-05
Gc4_1141 0 n8 ns1141 0 0.000334470157027
Gc4_1142 0 n8 ns1142 0 -0.000593536814699
Gc4_1143 0 n8 ns1143 0 0.00116712701623
Gc4_1144 0 n8 ns1144 0 -0.000937845128379
Gc4_1145 0 n8 ns1145 0 0.000246673758154
Gc4_1146 0 n8 ns1146 0 -0.000187354481203
Gc4_1147 0 n8 ns1147 0 -0.000172464797826
Gc4_1148 0 n8 ns1148 0 0.000157508695823
Gc4_1149 0 n8 ns1149 0 0.00032130752858
Gc4_1150 0 n8 ns1150 0 -0.000330480561043
Gc4_1151 0 n8 ns1151 0 -0.000124099237683
Gc4_1152 0 n8 ns1152 0 0.00013659440916
Gc4_1153 0 n8 ns1153 0 -0.000233665155814
Gc4_1154 0 n8 ns1154 0 0.000549336727977
Gc4_1155 0 n8 ns1155 0 0.000469063696768
Gc4_1156 0 n8 ns1156 0 0.000276724925328
Gc4_1157 0 n8 ns1157 0 7.80125104363e-05
Gc4_1158 0 n8 ns1158 0 -0.000439672746869
Gc4_1159 0 n8 ns1159 0 -0.000165327188087
Gc4_1160 0 n8 ns1160 0 -0.00027766971567
Gc4_1161 0 n8 ns1161 0 -2.9512979502e-05
Gc4_1162 0 n8 ns1162 0 -0.000530259634372
Gc4_1163 0 n8 ns1163 0 -0.00502762728991
Gc4_1164 0 n8 ns1164 0 -0.00323027066775
Gc4_1165 0 n8 ns1165 0 -0.00462039289751
Gc4_1166 0 n8 ns1166 0 -0.00279649792769
Gc4_1167 0 n8 ns1167 0 6.95930049535e-05
Gc4_1168 0 n8 ns1168 0 0.00167568924333
Gc4_1169 0 n8 ns1169 0 -0.000341532608228
Gc4_1170 0 n8 ns1170 0 -0.000604160848069
Gc4_1171 0 n8 ns1171 0 -0.00114278377014
Gc4_1172 0 n8 ns1172 0 -0.00172533062033
Gc4_1173 0 n8 ns1173 0 -0.000100423449463
Gc4_1174 0 n8 ns1174 0 -0.00114335465483
Gc4_1175 0 n8 ns1175 0 -0.000372366992514
Gc4_1176 0 n8 ns1176 0 -9.57592154261e-06
Gc4_1177 0 n8 ns1177 0 8.8535942685e-05
Gc4_1178 0 n8 ns1178 0 -6.43716537924e-06
Gc4_1179 0 n8 ns1179 0 -0.000525967381499
Gc4_1180 0 n8 ns1180 0 0.000740481739994
Gc4_1181 0 n8 ns1181 0 -0.00129655045281
Gc4_1182 0 n8 ns1182 0 0.000722193100699
Gc4_1183 0 n8 ns1183 0 -0.000182715809233
Gc4_1184 0 n8 ns1184 0 0.000365451661395
Gc4_1185 0 n8 ns1185 0 0.000151947287049
Gc4_1186 0 n8 ns1186 0 -0.000256973373742
Gc4_1187 0 n8 ns1187 0 -5.78118372898e-05
Gc4_1188 0 n8 ns1188 0 -0.000332342592075
Gc4_1189 0 n8 ns1189 0 3.68336654394e-05
Gc4_1190 0 n8 ns1190 0 0.000173742333179
Gc4_1191 0 n8 ns1191 0 0.000591007892897
Gc4_1192 0 n8 ns1192 0 8.19468985503e-05
Gc4_1193 0 n8 ns1193 0 0.000434458953122
Gc4_1194 0 n8 ns1194 0 -0.000563138657495
Gc4_1195 0 n8 ns1195 0 -0.000222669663759
Gc4_1196 0 n8 ns1196 0 -0.00049304021749
Gc4_1197 0 n8 ns1197 0 -0.000303462117077
Gc4_1198 0 n8 ns1198 0 -0.000374740667802
Gc4_1199 0 n8 ns1199 0 -0.000582140202491
Gc4_1200 0 n8 ns1200 0 -0.000448490258341
Gc4_1201 0 n8 ns1201 0 -0.00505953051144
Gc4_1202 0 n8 ns1202 0 -0.000403757045789
Gc4_1203 0 n8 ns1203 0 -0.0044461490478
Gc4_1204 0 n8 ns1204 0 -0.000251510860625
Gc4_1205 0 n8 ns1205 0 0.000293855110302
Gc4_1206 0 n8 ns1206 0 0.00134790454431
Gc4_1207 0 n8 ns1207 0 -0.000277389806436
Gc4_1208 0 n8 ns1208 0 -0.000322337980731
Gc4_1209 0 n8 ns1209 0 -0.000897847938279
Gc4_1210 0 n8 ns1210 0 -0.00106412461581
Gc4_1211 0 n8 ns1211 0 -9.21131140576e-05
Gc4_1212 0 n8 ns1212 0 -0.00056012550004
Gc4_1213 0 n8 ns1213 0 -0.000183944662506
Gc4_1214 0 n8 ns1214 0 -1.58708353787e-05
Gc4_1215 0 n8 ns1215 0 0.000109301031927
Gc4_1216 0 n8 ns1216 0 -2.67897356467e-05
Gd4_1 0 n8 ni1 0 0.000103411674593
Gd4_2 0 n8 ni2 0 -0.000892364216545
Gd4_3 0 n8 ni3 0 -0.00160703931522
Gd4_4 0 n8 ni4 0 0.000924348204249
Gd4_5 0 n8 ni5 0 -0.00145001852418
Gd4_6 0 n8 ni6 0 -0.000237536885178
Gd4_7 0 n8 ni7 0 0.000484721109707
Gd4_8 0 n8 ni8 0 0.000748269166363
Gd4_9 0 n8 ni9 0 -0.000450578337557
Gd4_10 0 n8 ni10 0 -0.00170290812291
Gd4_11 0 n8 ni11 0 -0.000578792094922
Gd4_12 0 n8 ni12 0 -0.00289217594278
Gd4_13 0 n8 ni13 0 -0.00121382901692
Gd4_14 0 n8 ni14 0 0.000468830550686
Gd4_15 0 n8 ni15 0 0.000598927279783
Gd4_16 0 n8 ni16 0 8.37793285758e-05
Gd4_17 0 n8 ni17 0 0.000277921332218
Gd4_18 0 n8 ni18 0 0.000427889614128
Gd4_19 0 n8 ni19 0 -0.000470612102451
Gd4_20 0 n8 ni20 0 0.000714737314217
Gd4_21 0 n8 ni21 0 -0.000269882036264
Gd4_22 0 n8 ni22 0 8.37773589229e-05
Gd4_23 0 n8 ni23 0 0.00013537598098
Gd4_24 0 n8 ni24 0 -0.000849247646652
Gd4_25 0 n8 ni25 0 0.00138029936117
Gd4_26 0 n8 ni26 0 9.62235876398e-05
Gd4_27 0 n8 ni27 0 -0.00300928589934
Gd4_28 0 n8 ni28 0 -0.00183119518446
Gd4_29 0 n8 ni29 0 -0.000211114824414
Gd4_30 0 n8 ni30 0 0.00011124128855
Gd4_31 0 n8 ni31 0 -0.000698732155487
Gd4_32 0 n8 ni32 0 0.000821141769623
Gc5_1 0 n10 ns1 0 -1.43765338206e-05
Gc5_2 0 n10 ns2 0 -0.000491981103526
Gc5_3 0 n10 ns3 0 -0.000129443470709
Gc5_4 0 n10 ns4 0 3.86656124912e-05
Gc5_5 0 n10 ns5 0 0.000173705613251
Gc5_6 0 n10 ns6 0 -0.000138061299307
Gc5_7 0 n10 ns7 0 -9.67788461965e-06
Gc5_8 0 n10 ns8 0 -8.16783883701e-05
Gc5_9 0 n10 ns9 0 -0.000544493134653
Gc5_10 0 n10 ns10 0 -0.000292601056916
Gc5_11 0 n10 ns11 0 0.000128701227121
Gc5_12 0 n10 ns12 0 -6.2162465321e-05
Gc5_13 0 n10 ns13 0 -3.21055330374e-05
Gc5_14 0 n10 ns14 0 0.000271121507094
Gc5_15 0 n10 ns15 0 0.000763615168099
Gc5_16 0 n10 ns16 0 0.00103121888621
Gc5_17 0 n10 ns17 0 0.000590064108943
Gc5_18 0 n10 ns18 0 -0.000146351855288
Gc5_19 0 n10 ns19 0 0.000278666449063
Gc5_20 0 n10 ns20 0 0.000139106872981
Gc5_21 0 n10 ns21 0 -0.001151656038
Gc5_22 0 n10 ns22 0 -2.24908603866e-06
Gc5_23 0 n10 ns23 0 0.000856471751474
Gc5_24 0 n10 ns24 0 0.00422259255463
Gc5_25 0 n10 ns25 0 0.00114326956425
Gc5_26 0 n10 ns26 0 0.00385105943584
Gc5_27 0 n10 ns27 0 -0.00108045206985
Gc5_28 0 n10 ns28 0 0.000975459056955
Gc5_29 0 n10 ns29 0 -0.000106912315751
Gc5_30 0 n10 ns30 0 -0.000672011760351
Gc5_31 0 n10 ns31 0 -0.000247549149629
Gc5_32 0 n10 ns32 0 -0.00142335129188
Gc5_33 0 n10 ns33 0 -0.000408326677279
Gc5_34 0 n10 ns34 0 0.000420393424914
Gc5_35 0 n10 ns35 0 0.000337907567056
Gc5_36 0 n10 ns36 0 -2.10451813006e-05
Gc5_37 0 n10 ns37 0 -0.000102154545571
Gc5_38 0 n10 ns38 0 -7.81803775547e-06
Gc5_39 0 n10 ns39 0 -0.000168492459558
Gc5_40 0 n10 ns40 0 -0.000347856587664
Gc5_41 0 n10 ns41 0 -0.000470263375941
Gc5_42 0 n10 ns42 0 0.00028159743694
Gc5_43 0 n10 ns43 0 0.000147878985664
Gc5_44 0 n10 ns44 0 -4.10751109357e-05
Gc5_45 0 n10 ns45 0 7.34572370667e-06
Gc5_46 0 n10 ns46 0 -2.6885395749e-05
Gc5_47 0 n10 ns47 0 -0.000493298445105
Gc5_48 0 n10 ns48 0 -0.000305639927995
Gc5_49 0 n10 ns49 0 0.000169318278756
Gc5_50 0 n10 ns50 0 -7.55206540764e-05
Gc5_51 0 n10 ns51 0 1.25999958137e-05
Gc5_52 0 n10 ns52 0 7.91391449933e-05
Gc5_53 0 n10 ns53 0 0.000527064845439
Gc5_54 0 n10 ns54 0 0.00105188581037
Gc5_55 0 n10 ns55 0 0.000602342372957
Gc5_56 0 n10 ns56 0 -0.000215534278909
Gc5_57 0 n10 ns57 0 0.000174462462593
Gc5_58 0 n10 ns58 0 -9.4379224508e-06
Gc5_59 0 n10 ns59 0 -0.0010154398264
Gc5_60 0 n10 ns60 0 -0.000348897872132
Gc5_61 0 n10 ns61 0 0.00105419046754
Gc5_62 0 n10 ns62 0 0.00443046954098
Gc5_63 0 n10 ns63 0 0.00134703408533
Gc5_64 0 n10 ns64 0 0.00416274316988
Gc5_65 0 n10 ns65 0 -0.00162596479278
Gc5_66 0 n10 ns66 0 0.000662936639837
Gc5_67 0 n10 ns67 0 -2.5250889447e-05
Gc5_68 0 n10 ns68 0 -0.000822063080512
Gc5_69 0 n10 ns69 0 2.13616614232e-05
Gc5_70 0 n10 ns70 0 -0.0014523098699
Gc5_71 0 n10 ns71 0 -0.000507107566271
Gc5_72 0 n10 ns72 0 0.0010074058385
Gc5_73 0 n10 ns73 0 0.000567617254413
Gc5_74 0 n10 ns74 0 -8.66716878835e-06
Gc5_75 0 n10 ns75 0 -0.000122061085005
Gc5_76 0 n10 ns76 0 2.62186793009e-06
Gc5_77 0 n10 ns77 0 0.000342792699475
Gc5_78 0 n10 ns78 0 -0.000752918675674
Gc5_79 0 n10 ns79 0 0.00114154951167
Gc5_80 0 n10 ns80 0 -4.45754880873e-05
Gc5_81 0 n10 ns81 0 -8.57523903162e-05
Gc5_82 0 n10 ns82 0 0.000357458570696
Gc5_83 0 n10 ns83 0 -0.000163894992035
Gc5_84 0 n10 ns84 0 -0.000106329538194
Gc5_85 0 n10 ns85 0 0.000256353185939
Gc5_86 0 n10 ns86 0 -0.000166711115929
Gc5_87 0 n10 ns87 0 0.000185036277559
Gc5_88 0 n10 ns88 0 -8.44209452942e-05
Gc5_89 0 n10 ns89 0 1.53933682677e-05
Gc5_90 0 n10 ns90 0 -0.000272255544544
Gc5_91 0 n10 ns91 0 -0.000600574367354
Gc5_92 0 n10 ns92 0 -0.000454659608949
Gc5_93 0 n10 ns93 0 0.000383560351393
Gc5_94 0 n10 ns94 0 -0.000713714061101
Gc5_95 0 n10 ns95 0 -7.44098605561e-05
Gc5_96 0 n10 ns96 0 -0.00118203385437
Gc5_97 0 n10 ns97 0 0.00133459349142
Gc5_98 0 n10 ns98 0 -0.000463350890087
Gc5_99 0 n10 ns99 0 0.00261300433104
Gc5_100 0 n10 ns100 0 0.00396439616801
Gc5_101 0 n10 ns101 0 0.00238137764326
Gc5_102 0 n10 ns102 0 0.00410613795345
Gc5_103 0 n10 ns103 0 -0.00113903631205
Gc5_104 0 n10 ns104 0 -0.00153087534594
Gc5_105 0 n10 ns105 0 0.000424191562205
Gc5_106 0 n10 ns106 0 -0.00105506791757
Gc5_107 0 n10 ns107 0 0.00016723430998
Gc5_108 0 n10 ns108 0 -0.000793333252287
Gc5_109 0 n10 ns109 0 -0.00151946618076
Gc5_110 0 n10 ns110 0 0.00241035642281
Gc5_111 0 n10 ns111 0 0.00148718975843
Gc5_112 0 n10 ns112 0 3.22354289652e-05
Gc5_113 0 n10 ns113 0 -0.0002618229188
Gc5_114 0 n10 ns114 0 9.50906546509e-05
Gc5_115 0 n10 ns115 0 0.00023270184412
Gc5_116 0 n10 ns116 0 -0.00187902260074
Gc5_117 0 n10 ns117 0 0.000276932464094
Gc5_118 0 n10 ns118 0 -0.000447663331216
Gc5_119 0 n10 ns119 0 -0.000939787359548
Gc5_120 0 n10 ns120 0 0.000330522703
Gc5_121 0 n10 ns121 0 0.000385024628666
Gc5_122 0 n10 ns122 0 -0.000477074923489
Gc5_123 0 n10 ns123 0 0.000330398032776
Gc5_124 0 n10 ns124 0 0.000462158557373
Gc5_125 0 n10 ns125 0 0.000251011178824
Gc5_126 0 n10 ns126 0 -4.42284427092e-05
Gc5_127 0 n10 ns127 0 -0.000378063943191
Gc5_128 0 n10 ns128 0 -5.24069422268e-05
Gc5_129 0 n10 ns129 0 0.000655873966783
Gc5_130 0 n10 ns130 0 -0.000925132923273
Gc5_131 0 n10 ns131 0 0.000808776670372
Gc5_132 0 n10 ns132 0 -0.000414038545613
Gc5_133 0 n10 ns133 0 0.000396980674825
Gc5_134 0 n10 ns134 0 -0.000868411702961
Gc5_135 0 n10 ns135 0 0.000887484361794
Gc5_136 0 n10 ns136 0 0.00210252099968
Gc5_137 0 n10 ns137 0 0.00278919307253
Gc5_138 0 n10 ns138 0 0.00425720035053
Gc5_139 0 n10 ns139 0 0.00212010861809
Gc5_140 0 n10 ns140 0 0.00446811178558
Gc5_141 0 n10 ns141 0 0.00350227254874
Gc5_142 0 n10 ns142 0 0.000384946498313
Gc5_143 0 n10 ns143 0 0.000898206472017
Gc5_144 0 n10 ns144 0 -0.000960876438378
Gc5_145 0 n10 ns145 0 -0.00182224336153
Gc5_146 0 n10 ns146 0 -0.00121525439903
Gc5_147 0 n10 ns147 0 -0.00385448407625
Gc5_148 0 n10 ns148 0 -0.000102557536996
Gc5_149 0 n10 ns149 0 0.0031184005055
Gc5_150 0 n10 ns150 0 3.45956891908e-05
Gc5_151 0 n10 ns151 0 -0.000153228942533
Gc5_152 0 n10 ns152 0 2.87838094097e-05
Gc5_153 0 n10 ns153 0 0.000204463909492
Gc5_154 0 n10 ns154 0 -0.00207556540799
Gc5_155 0 n10 ns155 0 -0.00199036785731
Gc5_156 0 n10 ns156 0 0.00059898761229
Gc5_157 0 n10 ns157 0 -0.000823722773536
Gc5_158 0 n10 ns158 0 0.000343196805966
Gc5_159 0 n10 ns159 0 0.00051916694627
Gc5_160 0 n10 ns160 0 -0.000309915359008
Gc5_161 0 n10 ns161 0 0.000122949695083
Gc5_162 0 n10 ns162 0 0.000490745006236
Gc5_163 0 n10 ns163 0 0.000291304928409
Gc5_164 0 n10 ns164 0 -1.02024570736e-05
Gc5_165 0 n10 ns165 0 -0.000617362016847
Gc5_166 0 n10 ns166 0 -0.000668588917339
Gc5_167 0 n10 ns167 0 0.000313023192577
Gc5_168 0 n10 ns168 0 9.90280108636e-05
Gc5_169 0 n10 ns169 0 0.000378716580449
Gc5_170 0 n10 ns170 0 -0.00019025407298
Gc5_171 0 n10 ns171 0 -0.000395033055821
Gc5_172 0 n10 ns172 0 -0.0010596451111
Gc5_173 0 n10 ns173 0 -0.000724890175072
Gc5_174 0 n10 ns174 0 0.000278444259875
Gc5_175 0 n10 ns175 0 0.00672252766417
Gc5_176 0 n10 ns176 0 0.00501548054796
Gc5_177 0 n10 ns177 0 0.00503480681903
Gc5_178 0 n10 ns178 0 0.00507984348019
Gc5_179 0 n10 ns179 0 0.0010204442583
Gc5_180 0 n10 ns180 0 0.00569040363799
Gc5_181 0 n10 ns181 0 0.00087922235961
Gc5_182 0 n10 ns182 0 -0.000840767827672
Gc5_183 0 n10 ns183 0 -0.00613931585468
Gc5_184 0 n10 ns184 0 -0.00167553252412
Gc5_185 0 n10 ns185 0 0.00275075099331
Gc5_186 0 n10 ns186 0 -0.00448605764409
Gc5_187 0 n10 ns187 0 0.00472586103981
Gc5_188 0 n10 ns188 0 -1.81904248213e-05
Gc5_189 0 n10 ns189 0 8.19722721987e-05
Gc5_190 0 n10 ns190 0 -0.00011771460218
Gc5_191 0 n10 ns191 0 0.000295866375828
Gc5_192 0 n10 ns192 0 -0.00183236839303
Gc5_193 0 n10 ns193 0 0.000575226765998
Gc5_194 0 n10 ns194 0 -3.08049860254e-05
Gc5_195 0 n10 ns195 0 -0.000885205864009
Gc5_196 0 n10 ns196 0 0.000435072164546
Gc5_197 0 n10 ns197 0 0.000372449402002
Gc5_198 0 n10 ns198 0 -0.000551053231631
Gc5_199 0 n10 ns199 0 0.000378718236797
Gc5_200 0 n10 ns200 0 0.00045246792893
Gc5_201 0 n10 ns201 0 0.000261597637635
Gc5_202 0 n10 ns202 0 -5.39115974791e-05
Gc5_203 0 n10 ns203 0 -0.000450055924714
Gc5_204 0 n10 ns204 0 -0.000143873152523
Gc5_205 0 n10 ns205 0 0.000670846469349
Gc5_206 0 n10 ns206 0 -0.000976750952263
Gc5_207 0 n10 ns207 0 0.000866308819923
Gc5_208 0 n10 ns208 0 -0.000451259645942
Gc5_209 0 n10 ns209 0 0.000498987659238
Gc5_210 0 n10 ns210 0 -0.000948791882664
Gc5_211 0 n10 ns211 0 0.000914749330464
Gc5_212 0 n10 ns212 0 0.00221307776003
Gc5_213 0 n10 ns213 0 0.00259490600677
Gc5_214 0 n10 ns214 0 0.00446611395922
Gc5_215 0 n10 ns215 0 0.0019527544139
Gc5_216 0 n10 ns216 0 0.00463472007448
Gc5_217 0 n10 ns217 0 0.00368267300179
Gc5_218 0 n10 ns218 0 0.000684389069558
Gc5_219 0 n10 ns219 0 0.000863552303447
Gc5_220 0 n10 ns220 0 -0.00100954265442
Gc5_221 0 n10 ns221 0 -0.00199258695937
Gc5_222 0 n10 ns222 0 -0.00153037699121
Gc5_223 0 n10 ns223 0 -0.00391023350561
Gc5_224 0 n10 ns224 0 -0.000572958920946
Gc5_225 0 n10 ns225 0 0.00300375525764
Gc5_226 0 n10 ns226 0 5.02121099472e-05
Gc5_227 0 n10 ns227 0 -0.000196103264115
Gc5_228 0 n10 ns228 0 5.03225778275e-05
Gc5_229 0 n10 ns229 0 2.15418465601e-05
Gc5_230 0 n10 ns230 0 -0.000536790460427
Gc5_231 0 n10 ns231 0 0.000196889525814
Gc5_232 0 n10 ns232 0 -0.000191590811133
Gc5_233 0 n10 ns233 0 -0.000350336383709
Gc5_234 0 n10 ns234 0 0.000385090967918
Gc5_235 0 n10 ns235 0 2.1238046171e-05
Gc5_236 0 n10 ns236 0 -0.000118240946165
Gc5_237 0 n10 ns237 0 0.000305038918274
Gc5_238 0 n10 ns238 0 -0.000142178204156
Gc5_239 0 n10 ns239 0 0.000178361021235
Gc5_240 0 n10 ns240 0 -6.63239627374e-05
Gc5_241 0 n10 ns241 0 6.7622888843e-05
Gc5_242 0 n10 ns242 0 -0.000258054177212
Gc5_243 0 n10 ns243 0 -0.000764377016877
Gc5_244 0 n10 ns244 0 -0.000285626002157
Gc5_245 0 n10 ns245 0 0.00025800607992
Gc5_246 0 n10 ns246 0 -0.000508003163771
Gc5_247 0 n10 ns247 0 -0.000261896544487
Gc5_248 0 n10 ns248 0 -0.000877810945664
Gc5_249 0 n10 ns249 0 0.00115552868246
Gc5_250 0 n10 ns250 0 -0.000806187734214
Gc5_251 0 n10 ns251 0 0.00196511914126
Gc5_252 0 n10 ns252 0 0.00271503281793
Gc5_253 0 n10 ns253 0 0.0018235317751
Gc5_254 0 n10 ns254 0 0.0030507069935
Gc5_255 0 n10 ns255 0 -0.00145703201133
Gc5_256 0 n10 ns256 0 -0.00162490853713
Gc5_257 0 n10 ns257 0 0.000439362798416
Gc5_258 0 n10 ns258 0 -0.00101700655885
Gc5_259 0 n10 ns259 0 0.000388698341756
Gc5_260 0 n10 ns260 0 -0.000536934018363
Gc5_261 0 n10 ns261 0 -0.00138032402678
Gc5_262 0 n10 ns262 0 0.00288911058487
Gc5_263 0 n10 ns263 0 0.00157508910975
Gc5_264 0 n10 ns264 0 1.6729282031e-05
Gc5_265 0 n10 ns265 0 -0.000189844218738
Gc5_266 0 n10 ns266 0 5.71630341643e-05
Gc5_267 0 n10 ns267 0 9.17941049459e-05
Gc5_268 0 n10 ns268 0 -0.000227532245263
Gc5_269 0 n10 ns269 0 0.000511089777345
Gc5_270 0 n10 ns270 0 0.000492912236575
Gc5_271 0 n10 ns271 0 0.000191856389567
Gc5_272 0 n10 ns272 0 -2.1298245343e-05
Gc5_273 0 n10 ns273 0 1.28797032451e-05
Gc5_274 0 n10 ns274 0 3.93780058685e-05
Gc5_275 0 n10 ns275 0 -0.000236187664058
Gc5_276 0 n10 ns276 0 -0.000102581163164
Gc5_277 0 n10 ns277 0 0.000132072445336
Gc5_278 0 n10 ns278 0 -0.000143193060551
Gc5_279 0 n10 ns279 0 -0.000259129784913
Gc5_280 0 n10 ns280 0 -0.000227161923908
Gc5_281 0 n10 ns281 0 0.000246237300684
Gc5_282 0 n10 ns282 0 0.000448598888619
Gc5_283 0 n10 ns283 0 0.00029937820255
Gc5_284 0 n10 ns284 0 -0.000532677568563
Gc5_285 0 n10 ns285 0 -0.000111154856132
Gc5_286 0 n10 ns286 0 -0.000506472692486
Gc5_287 0 n10 ns287 0 -0.00037527493195
Gc5_288 0 n10 ns288 0 -0.000190717878685
Gc5_289 0 n10 ns289 0 0.00280607027533
Gc5_290 0 n10 ns290 0 0.00386811338762
Gc5_291 0 n10 ns291 0 0.0028131964979
Gc5_292 0 n10 ns292 0 0.00360363712089
Gc5_293 0 n10 ns293 0 -0.00113449249458
Gc5_294 0 n10 ns294 0 0.000669004524749
Gc5_295 0 n10 ns295 0 -0.000128390521444
Gc5_296 0 n10 ns296 0 -0.000804347458284
Gc5_297 0 n10 ns297 0 -0.000461452844571
Gc5_298 0 n10 ns298 0 -0.0014463295233
Gc5_299 0 n10 ns299 0 -0.000663632270763
Gc5_300 0 n10 ns300 0 0.000813358114092
Gc5_301 0 n10 ns301 0 0.00053283912756
Gc5_302 0 n10 ns302 0 1.94332414349e-05
Gc5_303 0 n10 ns303 0 -0.000143823644202
Gc5_304 0 n10 ns304 0 2.71871011303e-05
Gc5_305 0 n10 ns305 0 1.7944391149e-06
Gc5_306 0 n10 ns306 0 -1.57605346692e-05
Gc5_307 0 n10 ns307 0 -3.92868509609e-05
Gc5_308 0 n10 ns308 0 0.00100971190687
Gc5_309 0 n10 ns309 0 0.000120593665502
Gc5_310 0 n10 ns310 0 0.000133060262005
Gc5_311 0 n10 ns311 0 -0.000176943272095
Gc5_312 0 n10 ns312 0 -0.000185648157355
Gc5_313 0 n10 ns313 0 -0.000435604434898
Gc5_314 0 n10 ns314 0 0.000232994036183
Gc5_315 0 n10 ns315 0 9.5037893757e-05
Gc5_316 0 n10 ns316 0 -0.000123464800924
Gc5_317 0 n10 ns317 0 0.000196163681311
Gc5_318 0 n10 ns318 0 -0.000146531856847
Gc5_319 0 n10 ns319 0 0.00117511233315
Gc5_320 0 n10 ns320 0 -0.00024267240649
Gc5_321 0 n10 ns321 0 0.000486321570322
Gc5_322 0 n10 ns322 0 -0.000715084468778
Gc5_323 0 n10 ns323 0 0.0005927410607
Gc5_324 0 n10 ns324 0 -0.000595185130151
Gc5_325 0 n10 ns325 0 -0.000296109206711
Gc5_326 0 n10 ns326 0 0.00112700102463
Gc5_327 0 n10 ns327 0 0.0032357981508
Gc5_328 0 n10 ns328 0 0.00405519424279
Gc5_329 0 n10 ns329 0 0.00307685510495
Gc5_330 0 n10 ns330 0 0.00342710559397
Gc5_331 0 n10 ns331 0 0.000340344469805
Gc5_332 0 n10 ns332 0 0.00122868498007
Gc5_333 0 n10 ns333 0 -0.00028359940423
Gc5_334 0 n10 ns334 0 -0.000471052858162
Gc5_335 0 n10 ns335 0 -0.00113529812027
Gc5_336 0 n10 ns336 0 -0.00138392014334
Gc5_337 0 n10 ns337 0 -0.000552084875301
Gc5_338 0 n10 ns338 0 -0.000583509940819
Gc5_339 0 n10 ns339 0 4.39690490158e-05
Gc5_340 0 n10 ns340 0 2.0549761467e-06
Gc5_341 0 n10 ns341 0 -9.35071661348e-05
Gc5_342 0 n10 ns342 0 1.20500499562e-06
Gc5_343 0 n10 ns343 0 -1.75597875564e-05
Gc5_344 0 n10 ns344 0 -0.000245031318336
Gc5_345 0 n10 ns345 0 0.000105583175075
Gc5_346 0 n10 ns346 0 0.000415080332871
Gc5_347 0 n10 ns347 0 0.000196188098746
Gc5_348 0 n10 ns348 0 0.000321949423058
Gc5_349 0 n10 ns349 0 -0.000189608296305
Gc5_350 0 n10 ns350 0 -4.16670461824e-05
Gc5_351 0 n10 ns351 0 -8.28030650722e-05
Gc5_352 0 n10 ns352 0 -0.000334486092024
Gc5_353 0 n10 ns353 0 0.000165510016252
Gc5_354 0 n10 ns354 0 -7.0689526351e-05
Gc5_355 0 n10 ns355 0 8.47427580983e-05
Gc5_356 0 n10 ns356 0 -0.000211479241244
Gc5_357 0 n10 ns357 0 -0.000299509246632
Gc5_358 0 n10 ns358 0 0.000299939261411
Gc5_359 0 n10 ns359 0 0.000408378086598
Gc5_360 0 n10 ns360 0 -0.000483997259636
Gc5_361 0 n10 ns361 0 -7.43797112775e-05
Gc5_362 0 n10 ns362 0 -0.000692757958876
Gc5_363 0 n10 ns363 0 0.000298340699773
Gc5_364 0 n10 ns364 0 -0.000830052247504
Gc5_365 0 n10 ns365 0 0.00179635403975
Gc5_366 0 n10 ns366 0 0.00385587586746
Gc5_367 0 n10 ns367 0 0.00182831227747
Gc5_368 0 n10 ns368 0 0.00390762082667
Gc5_369 0 n10 ns369 0 -0.00200222626432
Gc5_370 0 n10 ns370 0 -0.000726473442622
Gc5_371 0 n10 ns371 0 0.00025695275184
Gc5_372 0 n10 ns372 0 -0.00100760599602
Gc5_373 0 n10 ns373 0 0.000437374019457
Gc5_374 0 n10 ns374 0 -0.00107483384662
Gc5_375 0 n10 ns375 0 -0.000921402900626
Gc5_376 0 n10 ns376 0 0.00215389336367
Gc5_377 0 n10 ns377 0 0.00109760081291
Gc5_378 0 n10 ns378 0 2.73487390976e-05
Gc5_379 0 n10 ns379 0 -0.000238513793642
Gc5_380 0 n10 ns380 0 8.75077620033e-05
Gc5_381 0 n10 ns381 0 0.000469151296596
Gc5_382 0 n10 ns382 0 -0.00183099013995
Gc5_383 0 n10 ns383 0 0.00112837027854
Gc5_384 0 n10 ns384 0 -0.00146456386766
Gc5_385 0 n10 ns385 0 -0.000768516604709
Gc5_386 0 n10 ns386 0 -5.94809719563e-05
Gc5_387 0 n10 ns387 0 0.000157941749495
Gc5_388 0 n10 ns388 0 -0.00022359705518
Gc5_389 0 n10 ns389 0 0.000272636855508
Gc5_390 0 n10 ns390 0 0.00015878954658
Gc5_391 0 n10 ns391 0 0.000194077465147
Gc5_392 0 n10 ns392 0 -2.95440757793e-05
Gc5_393 0 n10 ns393 0 4.17016816907e-05
Gc5_394 0 n10 ns394 0 0.00039372249681
Gc5_395 0 n10 ns395 0 0.000163061415983
Gc5_396 0 n10 ns396 0 -0.000923794523659
Gc5_397 0 n10 ns397 0 0.00068300002747
Gc5_398 0 n10 ns398 0 -0.000490856583987
Gc5_399 0 n10 ns399 0 0.000335399903877
Gc5_400 0 n10 ns400 0 -0.000812144846721
Gc5_401 0 n10 ns401 0 0.00163903627629
Gc5_402 0 n10 ns402 0 0.00116544612661
Gc5_403 0 n10 ns403 0 0.00241399552748
Gc5_404 0 n10 ns404 0 0.00381691791741
Gc5_405 0 n10 ns405 0 0.00194385596902
Gc5_406 0 n10 ns406 0 0.00404378316732
Gc5_407 0 n10 ns407 0 0.00148975593785
Gc5_408 0 n10 ns408 0 -0.00201803634767
Gc5_409 0 n10 ns409 0 0.000857845517201
Gc5_410 0 n10 ns410 0 -0.000921304417688
Gc5_411 0 n10 ns411 0 -0.000382305998473
Gc5_412 0 n10 ns412 0 -0.000269778807837
Gc5_413 0 n10 ns413 0 -0.00322636847792
Gc5_414 0 n10 ns414 0 0.0025836561026
Gc5_415 0 n10 ns415 0 0.00268115967929
Gc5_416 0 n10 ns416 0 2.39419483142e-05
Gc5_417 0 n10 ns417 0 -0.000135599752136
Gc5_418 0 n10 ns418 0 2.98220989788e-05
Gc5_419 0 n10 ns419 0 0.000598570571115
Gc5_420 0 n10 ns420 0 -0.00353918313301
Gc5_421 0 n10 ns421 0 -0.00146066582727
Gc5_422 0 n10 ns422 0 -0.00112245882729
Gc5_423 0 n10 ns423 0 -0.00128267016062
Gc5_424 0 n10 ns424 0 3.16234250862e-05
Gc5_425 0 n10 ns425 0 0.000725895186204
Gc5_426 0 n10 ns426 0 -0.000201945587095
Gc5_427 0 n10 ns427 0 0.000141879542102
Gc5_428 0 n10 ns428 0 0.000551223489929
Gc5_429 0 n10 ns429 0 0.000283697176909
Gc5_430 0 n10 ns430 0 -1.63168191429e-05
Gc5_431 0 n10 ns431 0 -0.000399861650064
Gc5_432 0 n10 ns432 0 -0.000505635246406
Gc5_433 0 n10 ns433 0 9.8308460857e-05
Gc5_434 0 n10 ns434 0 -7.57234232057e-05
Gc5_435 0 n10 ns435 0 0.000364362997424
Gc5_436 0 n10 ns436 0 -0.00027332813243
Gc5_437 0 n10 ns437 0 -0.000328760499097
Gc5_438 0 n10 ns438 0 -0.00113252351821
Gc5_439 0 n10 ns439 0 -0.00033754920066
Gc5_440 0 n10 ns440 0 7.9652625008e-05
Gc5_441 0 n10 ns441 0 0.00629004344092
Gc5_442 0 n10 ns442 0 0.00589077903225
Gc5_443 0 n10 ns443 0 0.00468545963418
Gc5_444 0 n10 ns444 0 0.00577910155151
Gc5_445 0 n10 ns445 0 0.000511822514605
Gc5_446 0 n10 ns446 0 0.00535618506549
Gc5_447 0 n10 ns447 0 0.000843487401217
Gc5_448 0 n10 ns448 0 -0.000899585523996
Gc5_449 0 n10 ns449 0 -0.00625338441782
Gc5_450 0 n10 ns450 0 -0.00187896423056
Gc5_451 0 n10 ns451 0 0.00333946740241
Gc5_452 0 n10 ns452 0 -0.00503033685691
Gc5_453 0 n10 ns453 0 0.00459132705874
Gc5_454 0 n10 ns454 0 -1.91979941594e-05
Gc5_455 0 n10 ns455 0 4.27689123545e-05
Gc5_456 0 n10 ns456 0 -7.68806146401e-05
Gc5_457 0 n10 ns457 0 0.00113150052663
Gc5_458 0 n10 ns458 0 -0.00421936566962
Gc5_459 0 n10 ns459 0 0.00137868725044
Gc5_460 0 n10 ns460 0 -0.00239395564387
Gc5_461 0 n10 ns461 0 -0.00122041302475
Gc5_462 0 n10 ns462 0 -0.00039091785969
Gc5_463 0 n10 ns463 0 0.000661599100688
Gc5_464 0 n10 ns464 0 -0.000210649186542
Gc5_465 0 n10 ns465 0 0.000233112943819
Gc5_466 0 n10 ns466 0 0.000587719488284
Gc5_467 0 n10 ns467 0 0.000266898628771
Gc5_468 0 n10 ns468 0 -5.0575795311e-05
Gc5_469 0 n10 ns469 0 -0.000623624283061
Gc5_470 0 n10 ns470 0 3.04179699552e-05
Gc5_471 0 n10 ns471 0 0.000509165275158
Gc5_472 0 n10 ns472 0 -0.000863195172855
Gc5_473 0 n10 ns473 0 0.000667561040277
Gc5_474 0 n10 ns474 0 -0.000484313305033
Gc5_475 0 n10 ns475 0 0.000175165036002
Gc5_476 0 n10 ns476 0 -0.00122003749357
Gc5_477 0 n10 ns477 0 0.000985499683174
Gc5_478 0 n10 ns478 0 0.0017217643092
Gc5_479 0 n10 ns479 0 0.00536820648649
Gc5_480 0 n10 ns480 0 0.00561846958065
Gc5_481 0 n10 ns481 0 0.00404469773454
Gc5_482 0 n10 ns482 0 0.00557669368671
Gc5_483 0 n10 ns483 0 0.00286627313426
Gc5_484 0 n10 ns484 0 0.0022370770386
Gc5_485 0 n10 ns485 0 0.000894007491695
Gc5_486 0 n10 ns486 0 -0.000965129025288
Gc5_487 0 n10 ns487 0 -0.00425862070802
Gc5_488 0 n10 ns488 0 -0.0014890322248
Gc5_489 0 n10 ns489 0 -0.000693355107854
Gc5_490 0 n10 ns490 0 -0.00268887892043
Gc5_491 0 n10 ns491 0 0.00368352699642
Gc5_492 0 n10 ns492 0 2.97412222498e-05
Gc5_493 0 n10 ns493 0 -0.00016342880263
Gc5_494 0 n10 ns494 0 4.20396942303e-05
Gc5_495 0 n10 ns495 0 0.000360380097265
Gc5_496 0 n10 ns496 0 -0.00143134558579
Gc5_497 0 n10 ns497 0 0.00107181170493
Gc5_498 0 n10 ns498 0 -0.00106870854545
Gc5_499 0 n10 ns499 0 -0.000592345677351
Gc5_500 0 n10 ns500 0 0.00020567698931
Gc5_501 0 n10 ns501 0 7.61162090867e-05
Gc5_502 0 n10 ns502 0 -0.000181654914053
Gc5_503 0 n10 ns503 0 0.000429492527985
Gc5_504 0 n10 ns504 0 3.99108655855e-05
Gc5_505 0 n10 ns505 0 0.000197987800686
Gc5_506 0 n10 ns506 0 -5.35916128729e-05
Gc5_507 0 n10 ns507 0 -5.09142909242e-05
Gc5_508 0 n10 ns508 0 -3.78718972174e-05
Gc5_509 0 n10 ns509 0 -0.000643527060569
Gc5_510 0 n10 ns510 0 -0.000813627021721
Gc5_511 0 n10 ns511 0 0.000376028047835
Gc5_512 0 n10 ns512 0 -0.000576349505766
Gc5_513 0 n10 ns513 0 -0.000135542133499
Gc5_514 0 n10 ns514 0 -0.00109645294935
Gc5_515 0 n10 ns515 0 0.00178337621588
Gc5_516 0 n10 ns516 0 -0.000107096182233
Gc5_517 0 n10 ns517 0 0.00256675143909
Gc5_518 0 n10 ns518 0 0.00279876143238
Gc5_519 0 n10 ns519 0 0.00218081765804
Gc5_520 0 n10 ns520 0 0.00322768364858
Gc5_521 0 n10 ns521 0 -0.000219788717139
Gc5_522 0 n10 ns522 0 -0.00188106502046
Gc5_523 0 n10 ns523 0 0.000654915930337
Gc5_524 0 n10 ns524 0 -0.00104446600306
Gc5_525 0 n10 ns525 0 6.295370532e-05
Gc5_526 0 n10 ns526 0 -0.000494625226007
Gc5_527 0 n10 ns527 0 -0.00215982332622
Gc5_528 0 n10 ns528 0 0.00246614869421
Gc5_529 0 n10 ns529 0 0.00201936098309
Gc5_530 0 n10 ns530 0 4.89859781679e-06
Gc5_531 0 n10 ns531 0 -0.000176646021749
Gc5_532 0 n10 ns532 0 3.96819639389e-05
Gc5_533 0 n10 ns533 0 -6.32275768562e-05
Gc5_534 0 n10 ns534 0 -5.00113975017e-05
Gc5_535 0 n10 ns535 0 9.65699726567e-05
Gc5_536 0 n10 ns536 0 0.000400066368613
Gc5_537 0 n10 ns537 0 9.57319796368e-05
Gc5_538 0 n10 ns538 0 0.000104516459875
Gc5_539 0 n10 ns539 0 2.62742772846e-05
Gc5_540 0 n10 ns540 0 8.73879984674e-05
Gc5_541 0 n10 ns541 0 -5.36935128804e-05
Gc5_542 0 n10 ns542 0 -0.000202092900455
Gc5_543 0 n10 ns543 0 0.000167548627476
Gc5_544 0 n10 ns544 0 -0.000113058769723
Gc5_545 0 n10 ns545 0 -0.000198879986501
Gc5_546 0 n10 ns546 0 -0.000321443200435
Gc5_547 0 n10 ns547 0 -0.000306985211751
Gc5_548 0 n10 ns548 0 0.00049776119076
Gc5_549 0 n10 ns549 0 0.000232349602062
Gc5_550 0 n10 ns550 0 -0.000427451829776
Gc5_551 0 n10 ns551 0 -0.000346605371802
Gc5_552 0 n10 ns552 0 -0.000507307136541
Gc5_553 0 n10 ns553 0 -9.44651082176e-05
Gc5_554 0 n10 ns554 0 -0.000809593646067
Gc5_555 0 n10 ns555 0 0.00225569060538
Gc5_556 0 n10 ns556 0 0.0032472417833
Gc5_557 0 n10 ns557 0 0.00231106446179
Gc5_558 0 n10 ns558 0 0.00326737196483
Gc5_559 0 n10 ns559 0 -0.00174235347375
Gc5_560 0 n10 ns560 0 -6.11185088269e-05
Gc5_561 0 n10 ns561 0 4.34077005566e-05
Gc5_562 0 n10 ns562 0 -0.000903625009828
Gc5_563 0 n10 ns563 0 3.26752508027e-05
Gc5_564 0 n10 ns564 0 -0.00111746602627
Gc5_565 0 n10 ns565 0 -0.000713420548631
Gc5_566 0 n10 ns566 0 0.00174048731695
Gc5_567 0 n10 ns567 0 0.000867017797551
Gc5_568 0 n10 ns568 0 1.75792403425e-05
Gc5_569 0 n10 ns569 0 -0.000166309005534
Gc5_570 0 n10 ns570 0 3.16335590229e-05
Gc5_571 0 n10 ns571 0 -0.000108362149361
Gc5_572 0 n10 ns572 0 -0.000142189820983
Gc5_573 0 n10 ns573 0 -0.00027047426018
Gc5_574 0 n10 ns574 0 0.000666679349397
Gc5_575 0 n10 ns575 0 4.5654166748e-05
Gc5_576 0 n10 ns576 0 -2.47935846992e-05
Gc5_577 0 n10 ns577 0 -5.84297899401e-05
Gc5_578 0 n10 ns578 0 -8.40197153022e-05
Gc5_579 0 n10 ns579 0 -0.00051807026626
Gc5_580 0 n10 ns580 0 0.000166603906084
Gc5_581 0 n10 ns581 0 0.000122877992462
Gc5_582 0 n10 ns582 0 -0.000133119908892
Gc5_583 0 n10 ns583 0 0.000174291351031
Gc5_584 0 n10 ns584 0 -0.000102145156314
Gc5_585 0 n10 ns585 0 0.00113864498739
Gc5_586 0 n10 ns586 0 8.12146661684e-05
Gc5_587 0 n10 ns587 0 0.000520066038886
Gc5_588 0 n10 ns588 0 -0.000667243658469
Gc5_589 0 n10 ns589 0 0.000476374490247
Gc5_590 0 n10 ns590 0 -0.000477988711722
Gc5_591 0 n10 ns591 0 -0.000529718570106
Gc5_592 0 n10 ns592 0 0.000847868319359
Gc5_593 0 n10 ns593 0 0.00326467710961
Gc5_594 0 n10 ns594 0 0.00434577408567
Gc5_595 0 n10 ns595 0 0.00318276230485
Gc5_596 0 n10 ns596 0 0.00376028504797
Gc5_597 0 n10 ns597 0 -0.000106965052953
Gc5_598 0 n10 ns598 0 0.0011980547465
Gc5_599 0 n10 ns599 0 -0.000275223710473
Gc5_600 0 n10 ns600 0 -0.000578938469574
Gc5_601 0 n10 ns601 0 -0.000998544242544
Gc5_602 0 n10 ns602 0 -0.00143835310957
Gc5_603 0 n10 ns603 0 -0.000592723789322
Gc5_604 0 n10 ns604 0 -9.82868685696e-05
Gc5_605 0 n10 ns605 0 0.00021174858723
Gc5_606 0 n10 ns606 0 2.03372538361e-06
Gc5_607 0 n10 ns607 0 -6.85396249948e-05
Gc5_608 0 n10 ns608 0 -1.33880037812e-05
Gc5_609 0 n10 ns609 0 7.85600797387e-05
Gc5_610 0 n10 ns610 0 -0.000579077024749
Gc5_611 0 n10 ns611 0 0.000197591545506
Gc5_612 0 n10 ns612 0 -1.4558184798e-05
Gc5_613 0 n10 ns613 0 -8.23287196617e-06
Gc5_614 0 n10 ns614 0 -0.000104476836894
Gc5_615 0 n10 ns615 0 -7.37841250588e-05
Gc5_616 0 n10 ns616 0 0.000223639989944
Gc5_617 0 n10 ns617 0 0.000563587499909
Gc5_618 0 n10 ns618 0 0.000190902442589
Gc5_619 0 n10 ns619 0 -0.000160859988881
Gc5_620 0 n10 ns620 0 2.79706151368e-05
Gc5_621 0 n10 ns621 0 -0.00049602068458
Gc5_622 0 n10 ns622 0 0.000234127472682
Gc5_623 0 n10 ns623 0 0.00073343975544
Gc5_624 0 n10 ns624 0 0.000826239111506
Gc5_625 0 n10 ns625 0 0.000678384338428
Gc5_626 0 n10 ns626 0 -0.000298864109798
Gc5_627 0 n10 ns627 0 0.000535791879921
Gc5_628 0 n10 ns628 0 -0.000176132855674
Gc5_629 0 n10 ns629 0 0.000465778261234
Gc5_630 0 n10 ns630 0 -0.000299841176368
Gc5_631 0 n10 ns631 0 -0.00241274150801
Gc5_632 0 n10 ns632 0 -0.0058673979968
Gc5_633 0 n10 ns633 0 -0.00241776984513
Gc5_634 0 n10 ns634 0 -0.00521335104429
Gc5_635 0 n10 ns635 0 -0.000970058803904
Gc5_636 0 n10 ns636 0 0.00127742605292
Gc5_637 0 n10 ns637 0 -0.000118164496458
Gc5_638 0 n10 ns638 0 -0.000715926871139
Gc5_639 0 n10 ns639 0 -0.000272773548223
Gc5_640 0 n10 ns640 0 -0.00176649010852
Gc5_641 0 n10 ns641 0 0.000170143456553
Gc5_642 0 n10 ns642 0 -0.0008703125305
Gc5_643 0 n10 ns643 0 -0.000380143301984
Gc5_644 0 n10 ns644 0 2.24845611414e-07
Gc5_645 0 n10 ns645 0 4.43366955233e-05
Gc5_646 0 n10 ns646 0 1.85377353014e-05
Gc5_647 0 n10 ns647 0 -7.07521610073e-05
Gc5_648 0 n10 ns648 0 -0.00057036344257
Gc5_649 0 n10 ns649 0 -0.000180575477278
Gc5_650 0 n10 ns650 0 0.000320254460615
Gc5_651 0 n10 ns651 0 -0.000237999107677
Gc5_652 0 n10 ns652 0 -3.3180830367e-05
Gc5_653 0 n10 ns653 0 5.08281012942e-05
Gc5_654 0 n10 ns654 0 9.18874930998e-05
Gc5_655 0 n10 ns655 0 0.000483566866321
Gc5_656 0 n10 ns656 0 0.000346881221597
Gc5_657 0 n10 ns657 0 -0.000163643467745
Gc5_658 0 n10 ns658 0 6.14876274396e-05
Gc5_659 0 n10 ns659 0 -0.00023247013342
Gc5_660 0 n10 ns660 0 -3.39861068312e-05
Gc5_661 0 n10 ns661 0 0.000640964167657
Gc5_662 0 n10 ns662 0 0.000848298412309
Gc5_663 0 n10 ns663 0 0.000768040336886
Gc5_664 0 n10 ns664 0 -0.000327294289678
Gc5_665 0 n10 ns665 0 0.000545293469479
Gc5_666 0 n10 ns666 0 -0.000184266541505
Gc5_667 0 n10 ns667 0 0.000327488850996
Gc5_668 0 n10 ns668 0 -1.99316456257e-05
Gc5_669 0 n10 ns669 0 -0.00261264397059
Gc5_670 0 n10 ns670 0 -0.00623021788643
Gc5_671 0 n10 ns671 0 -0.00262770905793
Gc5_672 0 n10 ns672 0 -0.00565138468252
Gc5_673 0 n10 ns673 0 -0.00114340904887
Gc5_674 0 n10 ns674 0 0.00157668105386
Gc5_675 0 n10 ns675 0 -8.88754297726e-05
Gc5_676 0 n10 ns676 0 -0.000944307610341
Gc5_677 0 n10 ns677 0 -0.000259880007697
Gc5_678 0 n10 ns678 0 -0.00239756435815
Gc5_679 0 n10 ns679 0 0.00026152827259
Gc5_680 0 n10 ns680 0 -0.00156699422293
Gc5_681 0 n10 ns681 0 -0.000618204230196
Gc5_682 0 n10 ns682 0 -1.42179919213e-05
Gc5_683 0 n10 ns683 0 6.4587697496e-05
Gc5_684 0 n10 ns684 0 -1.86050913271e-06
Gc5_685 0 n10 ns685 0 -0.000598107821775
Gc5_686 0 n10 ns686 0 0.000335871323309
Gc5_687 0 n10 ns687 0 -0.00138838361116
Gc5_688 0 n10 ns688 0 0.00258930078933
Gc5_689 0 n10 ns689 0 -0.00020788257226
Gc5_690 0 n10 ns690 0 0.000549860835757
Gc5_691 0 n10 ns691 0 0.000215610980032
Gc5_692 0 n10 ns692 0 -0.000412648089828
Gc5_693 0 n10 ns693 0 -0.000151534208625
Gc5_694 0 n10 ns694 0 0.00044453748463
Gc5_695 0 n10 ns695 0 -0.000113316236268
Gc5_696 0 n10 ns696 0 0.00010916393767
Gc5_697 0 n10 ns697 0 0.000918502992882
Gc5_698 0 n10 ns698 0 -0.000617481332838
Gc5_699 0 n10 ns699 0 -5.44042334161e-05
Gc5_700 0 n10 ns700 0 -0.000327984112081
Gc5_701 0 n10 ns701 0 0.00062617111298
Gc5_702 0 n10 ns702 0 -0.000535397193915
Gc5_703 0 n10 ns703 0 0.000207109390106
Gc5_704 0 n10 ns704 0 -0.000715734540309
Gc5_705 0 n10 ns705 0 -0.00100873497759
Gc5_706 0 n10 ns706 0 0.000990612126783
Gc5_707 0 n10 ns707 0 -0.00290515262533
Gc5_708 0 n10 ns708 0 -0.00272333151253
Gc5_709 0 n10 ns709 0 -0.00264460456804
Gc5_710 0 n10 ns710 0 -0.00311989187947
Gc5_711 0 n10 ns711 0 -0.000351691372315
Gc5_712 0 n10 ns712 0 0.00104947847814
Gc5_713 0 n10 ns713 0 0.000314769589554
Gc5_714 0 n10 ns714 0 -0.00136851422639
Gc5_715 0 n10 ns715 0 -0.000125770334802
Gc5_716 0 n10 ns716 0 -0.00308886348973
Gc5_717 0 n10 ns717 0 0.00102658483161
Gc5_718 0 n10 ns718 0 -0.00342445991836
Gc5_719 0 n10 ns719 0 -0.00161462671181
Gc5_720 0 n10 ns720 0 -2.85776535702e-05
Gc5_721 0 n10 ns721 0 0.000113925169137
Gc5_722 0 n10 ns722 0 -7.59605490158e-06
Gc5_723 0 n10 ns723 0 -0.00084277577626
Gc5_724 0 n10 ns724 0 -0.00067725153781
Gc5_725 0 n10 ns725 0 -0.00343091381979
Gc5_726 0 n10 ns726 0 -0.00160729219058
Gc5_727 0 n10 ns727 0 -0.00181017245204
Gc5_728 0 n10 ns728 0 0.00112648751901
Gc5_729 0 n10 ns729 0 0.00074671744029
Gc5_730 0 n10 ns730 0 -0.000486805464464
Gc5_731 0 n10 ns731 0 -0.000471817929423
Gc5_732 0 n10 ns732 0 4.89693553888e-05
Gc5_733 0 n10 ns733 0 -0.000164352236989
Gc5_734 0 n10 ns734 0 5.6305897605e-05
Gc5_735 0 n10 ns735 0 0.000693296537181
Gc5_736 0 n10 ns736 0 0.000137954390481
Gc5_737 0 n10 ns737 0 0.000819967754808
Gc5_738 0 n10 ns738 0 -0.000889557697946
Gc5_739 0 n10 ns739 0 0.000972129380586
Gc5_740 0 n10 ns740 0 -0.000285564960436
Gc5_741 0 n10 ns741 0 0.000761284438515
Gc5_742 0 n10 ns742 0 -0.00052684557176
Gc5_743 0 n10 ns743 0 -0.00217138045642
Gc5_744 0 n10 ns744 0 -0.000890472335136
Gc5_745 0 n10 ns745 0 -0.00625389683791
Gc5_746 0 n10 ns746 0 -0.00280126670634
Gc5_747 0 n10 ns747 0 -0.00495400674892
Gc5_748 0 n10 ns748 0 -0.00324714365498
Gc5_749 0 n10 ns749 0 0.0035485546191
Gc5_750 0 n10 ns750 0 0.00203325631746
Gc5_751 0 n10 ns751 0 0.000838763850897
Gc5_752 0 n10 ns752 0 -0.00119292840803
Gc5_753 0 n10 ns753 0 -0.00215911120894
Gc5_754 0 n10 ns754 0 -0.00293674428399
Gc5_755 0 n10 ns755 0 0.00244344394125
Gc5_756 0 n10 ns756 0 -0.000616373779403
Gc5_757 0 n10 ns757 0 -0.0031926666411
Gc5_758 0 n10 ns758 0 -4.43483546463e-05
Gc5_759 0 n10 ns759 0 0.000364001869813
Gc5_760 0 n10 ns760 0 -0.000157794471215
Gc5_761 0 n10 ns761 0 -0.000168818489819
Gc5_762 0 n10 ns762 0 -0.000177717612235
Gc5_763 0 n10 ns763 0 0.00149743026997
Gc5_764 0 n10 ns764 0 0.00220429511797
Gc5_765 0 n10 ns765 0 0.00157615366234
Gc5_766 0 n10 ns766 0 -0.000978603625535
Gc5_767 0 n10 ns767 0 -0.000502143061133
Gc5_768 0 n10 ns768 0 5.11379273992e-05
Gc5_769 0 n10 ns769 0 0.000171495677081
Gc5_770 0 n10 ns770 0 0.000110474298313
Gc5_771 0 n10 ns771 0 -0.000129812259972
Gc5_772 0 n10 ns772 0 -7.35362135283e-06
Gc5_773 0 n10 ns773 0 0.00178122437567
Gc5_774 0 n10 ns774 0 -0.000848002874199
Gc5_775 0 n10 ns775 0 -0.000644087508839
Gc5_776 0 n10 ns776 0 0.00128356178187
Gc5_777 0 n10 ns777 0 -0.000483416285618
Gc5_778 0 n10 ns778 0 7.06101017862e-05
Gc5_779 0 n10 ns779 0 -0.00213412530082
Gc5_780 0 n10 ns780 0 -0.00120818657672
Gc5_781 0 n10 ns781 0 0.00296255869249
Gc5_782 0 n10 ns782 0 0.00384260257127
Gc5_783 0 n10 ns783 0 -0.0103529154226
Gc5_784 0 n10 ns784 0 0.00101359604209
Gc5_785 0 n10 ns785 0 -0.00793324956657
Gc5_786 0 n10 ns786 0 -0.000358208203357
Gc5_787 0 n10 ns787 0 -0.0104130925656
Gc5_788 0 n10 ns788 0 -0.000153205825357
Gc5_789 0 n10 ns789 0 0.00138555195723
Gc5_790 0 n10 ns790 0 8.50575739177e-06
Gc5_791 0 n10 ns791 0 -0.00391638637785
Gc5_792 0 n10 ns792 0 0.00831160248401
Gc5_793 0 n10 ns793 0 -0.0143746034903
Gc5_794 0 n10 ns794 0 -0.0044444796421
Gc5_795 0 n10 ns795 0 -0.00631937796306
Gc5_796 0 n10 ns796 0 -5.30303589463e-05
Gc5_797 0 n10 ns797 0 -0.000360685976535
Gc5_798 0 n10 ns798 0 0.000578469103599
Gc5_799 0 n10 ns799 0 -0.00091778259582
Gc5_800 0 n10 ns800 0 -0.000242738084231
Gc5_801 0 n10 ns801 0 -0.00335937187223
Gc5_802 0 n10 ns802 0 -0.00122124269592
Gc5_803 0 n10 ns803 0 -0.00189865050003
Gc5_804 0 n10 ns804 0 0.0013055605581
Gc5_805 0 n10 ns805 0 0.000827752108198
Gc5_806 0 n10 ns806 0 -0.000568327834783
Gc5_807 0 n10 ns807 0 -0.000298356219779
Gc5_808 0 n10 ns808 0 0.000198713667062
Gc5_809 0 n10 ns809 0 -0.000162554175474
Gc5_810 0 n10 ns810 0 -8.41642753202e-06
Gc5_811 0 n10 ns811 0 0.000466778599796
Gc5_812 0 n10 ns812 0 -8.14829321761e-05
Gc5_813 0 n10 ns813 0 0.000786535060972
Gc5_814 0 n10 ns814 0 -0.000959646084955
Gc5_815 0 n10 ns815 0 0.00101608165699
Gc5_816 0 n10 ns816 0 -0.000310643321277
Gc5_817 0 n10 ns817 0 0.000874656373988
Gc5_818 0 n10 ns818 0 -0.00059446258976
Gc5_819 0 n10 ns819 0 -0.00210405057264
Gc5_820 0 n10 ns820 0 -0.000570756536034
Gc5_821 0 n10 ns821 0 -0.00606217614309
Gc5_822 0 n10 ns822 0 -0.0018098525104
Gc5_823 0 n10 ns823 0 -0.00478753315431
Gc5_824 0 n10 ns824 0 -0.0024253193817
Gc5_825 0 n10 ns825 0 0.00398962216596
Gc5_826 0 n10 ns826 0 0.00228384228909
Gc5_827 0 n10 ns827 0 0.000776284538119
Gc5_828 0 n10 ns828 0 -0.00122803618874
Gc5_829 0 n10 ns829 0 -0.00251958442594
Gc5_830 0 n10 ns830 0 -0.0032331773408
Gc5_831 0 n10 ns831 0 0.00230988410345
Gc5_832 0 n10 ns832 0 -0.00119510825937
Gc5_833 0 n10 ns833 0 -0.00331754472499
Gc5_834 0 n10 ns834 0 -4.61042473335e-05
Gc5_835 0 n10 ns835 0 0.000359013703013
Gc5_836 0 n10 ns836 0 -0.000172617082771
Gc5_837 0 n10 ns837 0 7.77871023704e-05
Gc5_838 0 n10 ns838 0 -0.000557834998201
Gc5_839 0 n10 ns839 0 0.000365743890016
Gc5_840 0 n10 ns840 0 0.00102204624952
Gc5_841 0 n10 ns841 0 0.000196659587223
Gc5_842 0 n10 ns842 0 5.25997737103e-05
Gc5_843 0 n10 ns843 0 -7.22669122485e-05
Gc5_844 0 n10 ns844 0 -0.000153770108331
Gc5_845 0 n10 ns845 0 -0.000338389687555
Gc5_846 0 n10 ns846 0 0.000271594259443
Gc5_847 0 n10 ns847 0 -0.000117737136006
Gc5_848 0 n10 ns848 0 0.000113752968636
Gc5_849 0 n10 ns849 0 0.000724756121545
Gc5_850 0 n10 ns850 0 -0.000343252523839
Gc5_851 0 n10 ns851 0 -0.000484410676429
Gc5_852 0 n10 ns852 0 -0.000114166059036
Gc5_853 0 n10 ns853 0 0.000351853818152
Gc5_854 0 n10 ns854 0 -0.000310547038197
Gc5_855 0 n10 ns855 0 -0.000194178636213
Gc5_856 0 n10 ns856 0 -0.000439243995497
Gc5_857 0 n10 ns857 0 -0.00100861590489
Gc5_858 0 n10 ns858 0 0.000883583894404
Gc5_859 0 n10 ns859 0 -0.00268375833654
Gc5_860 0 n10 ns860 0 -0.00225052273969
Gc5_861 0 n10 ns861 0 -0.00245492301282
Gc5_862 0 n10 ns862 0 -0.00269137265137
Gc5_863 0 n10 ns863 0 -0.000155411399778
Gc5_864 0 n10 ns864 0 0.000748862021486
Gc5_865 0 n10 ns865 0 0.000290330421663
Gc5_866 0 n10 ns866 0 -0.00130111334524
Gc5_867 0 n10 ns867 0 -0.00025438521216
Gc5_868 0 n10 ns868 0 -0.00277356206449
Gc5_869 0 n10 ns869 0 0.00100242534837
Gc5_870 0 n10 ns870 0 -0.00322454820771
Gc5_871 0 n10 ns871 0 -0.00156334636309
Gc5_872 0 n10 ns872 0 -2.48568959776e-05
Gc5_873 0 n10 ns873 0 0.000100408875951
Gc5_874 0 n10 ns874 0 4.02948535846e-06
Gc5_875 0 n10 ns875 0 -0.000565234123757
Gc5_876 0 n10 ns876 0 0.000316870109515
Gc5_877 0 n10 ns877 0 -0.00148127881655
Gc5_878 0 n10 ns878 0 0.00130959795532
Gc5_879 0 n10 ns879 0 -0.000414910465001
Gc5_880 0 n10 ns880 0 0.000376025539645
Gc5_881 0 n10 ns881 0 0.000132925754079
Gc5_882 0 n10 ns882 0 -0.000196201534776
Gc5_883 0 n10 ns883 0 0.000303097395657
Gc5_884 0 n10 ns884 0 0.00034981947744
Gc5_885 0 n10 ns885 0 -6.49684034508e-05
Gc5_886 0 n10 ns886 0 0.000124066017816
Gc5_887 0 n10 ns887 0 0.000209123298886
Gc5_888 0 n10 ns888 0 -0.000389834767902
Gc5_889 0 n10 ns889 0 0.00065061295496
Gc5_890 0 n10 ns890 0 0.000433797094454
Gc5_891 0 n10 ns891 0 0.00056495197263
Gc5_892 0 n10 ns892 0 -0.000455413447848
Gc5_893 0 n10 ns893 0 0.000353897653896
Gc5_894 0 n10 ns894 0 -0.000247190315195
Gc5_895 0 n10 ns895 0 -0.000113113816473
Gc5_896 0 n10 ns896 0 2.79563459872e-05
Gc5_897 0 n10 ns897 0 -0.00437717823912
Gc5_898 0 n10 ns898 0 -0.00496722432648
Gc5_899 0 n10 ns899 0 -0.00411557329115
Gc5_900 0 n10 ns900 0 -0.00452175530538
Gc5_901 0 n10 ns901 0 -0.000810269804873
Gc5_902 0 n10 ns902 0 0.00200765920865
Gc5_903 0 n10 ns903 0 -0.000187904270624
Gc5_904 0 n10 ns904 0 -0.000967239105706
Gc5_905 0 n10 ns905 0 -0.000602750300083
Gc5_906 0 n10 ns906 0 -0.00262151209024
Gc5_907 0 n10 ns907 0 0.00018245074595
Gc5_908 0 n10 ns908 0 -0.00178615858812
Gc5_909 0 n10 ns909 0 -0.000651562793881
Gc5_910 0 n10 ns910 0 -1.97361605147e-05
Gc5_911 0 n10 ns911 0 9.78098613785e-05
Gc5_912 0 n10 ns912 0 -2.16618721488e-05
Gc5_913 0 n10 ns913 0 -7.09766733539e-05
Gc5_914 0 n10 ns914 0 -1.35732747178e-05
Gc5_915 0 n10 ns915 0 3.97428696991e-05
Gc5_916 0 n10 ns916 0 0.000333545097221
Gc5_917 0 n10 ns917 0 -2.98078836252e-05
Gc5_918 0 n10 ns918 0 0.000123582559285
Gc5_919 0 n10 ns919 0 0.000126345250211
Gc5_920 0 n10 ns920 0 2.17688170937e-05
Gc5_921 0 n10 ns921 0 0.000528767333433
Gc5_922 0 n10 ns922 0 -0.000332348202122
Gc5_923 0 n10 ns923 0 -0.000149604984011
Gc5_924 0 n10 ns924 0 0.000117691027642
Gc5_925 0 n10 ns925 0 -9.92742396478e-05
Gc5_926 0 n10 ns926 0 0.000549803315819
Gc5_927 0 n10 ns927 0 0.000923418067026
Gc5_928 0 n10 ns928 0 -9.950150652e-05
Gc5_929 0 n10 ns929 0 0.00031056291506
Gc5_930 0 n10 ns930 0 -0.000719314317521
Gc5_931 0 n10 ns931 0 0.000232242409213
Gc5_932 0 n10 ns932 0 -0.000722991264635
Gc5_933 0 n10 ns933 0 0.000157406599605
Gc5_934 0 n10 ns934 0 -0.000567261300052
Gc5_935 0 n10 ns935 0 -0.0042590659008
Gc5_936 0 n10 ns936 0 -0.00354698830455
Gc5_937 0 n10 ns937 0 -0.00391281020443
Gc5_938 0 n10 ns938 0 -0.00304418430024
Gc5_939 0 n10 ns939 0 -0.000150485314778
Gc5_940 0 n10 ns940 0 0.00155078868012
Gc5_941 0 n10 ns941 0 -0.000248805291788
Gc5_942 0 n10 ns942 0 -0.000517602652526
Gc5_943 0 n10 ns943 0 -0.000780560425298
Gc5_944 0 n10 ns944 0 -0.00157184343984
Gc5_945 0 n10 ns945 0 -5.70857803724e-05
Gc5_946 0 n10 ns946 0 -0.000937848011541
Gc5_947 0 n10 ns947 0 -0.000313877459589
Gc5_948 0 n10 ns948 0 -1.82253471976e-06
Gc5_949 0 n10 ns949 0 6.59800041964e-05
Gc5_950 0 n10 ns950 0 1.07474850662e-05
Gc5_951 0 n10 ns951 0 -0.000312331445619
Gc5_952 0 n10 ns952 0 -0.000112594827442
Gc5_953 0 n10 ns953 0 -0.000727408923354
Gc5_954 0 n10 ns954 0 0.00142177561483
Gc5_955 0 n10 ns955 0 -0.000347654544357
Gc5_956 0 n10 ns956 0 0.000100393484623
Gc5_957 0 n10 ns957 0 0.000216474465658
Gc5_958 0 n10 ns958 0 -0.000164964869323
Gc5_959 0 n10 ns959 0 6.07564784573e-05
Gc5_960 0 n10 ns960 0 0.000433804416766
Gc5_961 0 n10 ns961 0 -0.000132154122775
Gc5_962 0 n10 ns962 0 0.000124113458646
Gc5_963 0 n10 ns963 0 0.000590177799931
Gc5_964 0 n10 ns964 0 -0.000470820751575
Gc5_965 0 n10 ns965 0 0.000125924052719
Gc5_966 0 n10 ns966 0 0.000272587158903
Gc5_967 0 n10 ns967 0 0.000632435286917
Gc5_968 0 n10 ns968 0 -0.000410356794072
Gc5_969 0 n10 ns969 0 0.000233790134785
Gc5_970 0 n10 ns970 0 -0.000394441468203
Gc5_971 0 n10 ns971 0 -0.000335655559886
Gc5_972 0 n10 ns972 0 0.000704271115795
Gc5_973 0 n10 ns973 0 -0.00217864623844
Gc5_974 0 n10 ns974 0 -0.00447375674063
Gc5_975 0 n10 ns975 0 -0.00216348958075
Gc5_976 0 n10 ns976 0 -0.00443162132444
Gc5_977 0 n10 ns977 0 -0.00112780295673
Gc5_978 0 n10 ns978 0 0.00134175182835
Gc5_979 0 n10 ns979 0 0.000148367932323
Gc5_980 0 n10 ns980 0 -0.00127010814709
Gc5_981 0 n10 ns981 0 1.94660484497e-05
Gc5_982 0 n10 ns982 0 -0.00306327465667
Gc5_983 0 n10 ns983 0 0.000641156199815
Gc5_984 0 n10 ns984 0 -0.00283346908059
Gc5_985 0 n10 ns985 0 -0.00116730435181
Gc5_986 0 n10 ns986 0 -3.84532399036e-05
Gc5_987 0 n10 ns987 0 0.000102773309508
Gc5_988 0 n10 ns988 0 -1.11832964606e-05
Gc5_989 0 n10 ns989 0 -0.00104155911316
Gc5_990 0 n10 ns990 0 6.11757494278e-05
Gc5_991 0 n10 ns991 0 -0.00309309376771
Gc5_992 0 n10 ns992 0 0.00149454022166
Gc5_993 0 n10 ns993 0 -0.000327643695504
Gc5_994 0 n10 ns994 0 0.0011351744238
Gc5_995 0 n10 ns995 0 0.000220926873362
Gc5_996 0 n10 ns996 0 -0.000492375839981
Gc5_997 0 n10 ns997 0 -0.000375090727018
Gc5_998 0 n10 ns998 0 0.000141792085399
Gc5_999 0 n10 ns999 0 -0.000156121604107
Gc5_1000 0 n10 ns1000 0 9.55582130647e-05
Gc5_1001 0 n10 ns1001 0 0.000943357545885
Gc5_1002 0 n10 ns1002 0 0.00012468709521
Gc5_1003 0 n10 ns1003 0 0.00032627807191
Gc5_1004 0 n10 ns1004 0 -0.000825226492031
Gc5_1005 0 n10 ns1005 0 0.000752181210086
Gc5_1006 0 n10 ns1006 0 -0.000477355175007
Gc5_1007 0 n10 ns1007 0 0.000458445973314
Gc5_1008 0 n10 ns1008 0 -0.000830253495179
Gc5_1009 0 n10 ns1009 0 -0.0023086273437
Gc5_1010 0 n10 ns1010 0 -6.25193721645e-05
Gc5_1011 0 n10 ns1011 0 -0.00606874311317
Gc5_1012 0 n10 ns1012 0 -0.00214673416996
Gc5_1013 0 n10 ns1013 0 -0.00493939265833
Gc5_1014 0 n10 ns1014 0 -0.00270893810541
Gc5_1015 0 n10 ns1015 0 0.0017375241188
Gc5_1016 0 n10 ns1016 0 0.000166027799138
Gc5_1017 0 n10 ns1017 0 0.000785666153023
Gc5_1018 0 n10 ns1018 0 -0.00118069261692
Gc5_1019 0 n10 ns1019 0 -0.000506963761345
Gc5_1020 0 n10 ns1020 0 -0.00192607470469
Gc5_1021 0 n10 ns1021 0 0.00240223751925
Gc5_1022 0 n10 ns1022 0 -0.00261251653357
Gc5_1023 0 n10 ns1023 0 -0.00252330901895
Gc5_1024 0 n10 ns1024 0 -1.00914241179e-05
Gc5_1025 0 n10 ns1025 0 0.000195610451081
Gc5_1026 0 n10 ns1026 0 -4.94124833724e-05
Gc5_1027 0 n10 ns1027 0 0.0027546048812
Gc5_1028 0 n10 ns1028 0 -0.00382744924908
Gc5_1029 0 n10 ns1029 0 0.00637240436911
Gc5_1030 0 n10 ns1030 0 -0.00785560645097
Gc5_1031 0 n10 ns1031 0 -0.0029619289724
Gc5_1032 0 n10 ns1032 0 -0.00265540636548
Gc5_1033 0 n10 ns1033 0 0.000887685452169
Gc5_1034 0 n10 ns1034 0 0.00084757815551
Gc5_1035 0 n10 ns1035 0 -0.00050819733795
Gc5_1036 0 n10 ns1036 0 -0.000682793046956
Gc5_1037 0 n10 ns1037 0 -0.000247083309701
Gc5_1038 0 n10 ns1038 0 3.81276544848e-06
Gc5_1039 0 n10 ns1039 0 -0.000582891362201
Gc5_1040 0 n10 ns1040 0 -0.000214578213104
Gc5_1041 0 n10 ns1041 0 0.000953099109386
Gc5_1042 0 n10 ns1042 0 0.000167392884833
Gc5_1043 0 n10 ns1043 0 0.000673642192799
Gc5_1044 0 n10 ns1044 0 0.000459186431116
Gc5_1045 0 n10 ns1045 0 -3.96057890639e-05
Gc5_1046 0 n10 ns1046 0 0.000713503556978
Gc5_1047 0 n10 ns1047 0 0.000785542733808
Gc5_1048 0 n10 ns1048 0 -0.00302626262199
Gc5_1049 0 n10 ns1049 0 -0.00227801391967
Gc5_1050 0 n10 ns1050 0 -0.00679262564119
Gc5_1051 0 n10 ns1051 0 -0.00158982980673
Gc5_1052 0 n10 ns1052 0 -0.00643453509762
Gc5_1053 0 n10 ns1053 0 0.0058501839863
Gc5_1054 0 n10 ns1054 0 0.00789499582484
Gc5_1055 0 n10 ns1055 0 0.00075085451761
Gc5_1056 0 n10 ns1056 0 -0.00115454994533
Gc5_1057 0 n10 ns1057 0 -0.00560562621547
Gc5_1058 0 n10 ns1058 0 -0.00573561186337
Gc5_1059 0 n10 ns1059 0 0.00135886287475
Gc5_1060 0 n10 ns1060 0 0.00536271407899
Gc5_1061 0 n10 ns1061 0 -0.00426550011459
Gc5_1062 0 n10 ns1062 0 -1.82784524915e-06
Gc5_1063 0 n10 ns1063 0 0.000422453039979
Gc5_1064 0 n10 ns1064 0 -0.000231535275141
Gc5_1065 0 n10 ns1065 0 0.00104515733902
Gc5_1066 0 n10 ns1066 0 -0.00190119668754
Gc5_1067 0 n10 ns1067 0 0.00211083379227
Gc5_1068 0 n10 ns1068 0 -0.0041292029704
Gc5_1069 0 n10 ns1069 0 -0.00241822111533
Gc5_1070 0 n10 ns1070 0 -0.00102211051162
Gc5_1071 0 n10 ns1071 0 0.000878717026993
Gc5_1072 0 n10 ns1072 0 0.000310423486826
Gc5_1073 0 n10 ns1073 0 -0.000304231203688
Gc5_1074 0 n10 ns1074 0 -0.000280837835059
Gc5_1075 0 n10 ns1075 0 -0.000206962534322
Gc5_1076 0 n10 ns1076 0 -3.9345593177e-05
Gc5_1077 0 n10 ns1077 0 -0.00012082044475
Gc5_1078 0 n10 ns1078 0 -0.00017872677461
Gc5_1079 0 n10 ns1079 0 0.00111151289084
Gc5_1080 0 n10 ns1080 0 -0.000542676511003
Gc5_1081 0 n10 ns1081 0 0.000910313595107
Gc5_1082 0 n10 ns1082 0 7.35057220712e-06
Gc5_1083 0 n10 ns1083 0 0.000477752498245
Gc5_1084 0 n10 ns1084 0 -0.000125988180345
Gc5_1085 0 n10 ns1085 0 -0.000813139784849
Gc5_1086 0 n10 ns1086 0 -0.00180489948473
Gc5_1087 0 n10 ns1087 0 -0.00536456511321
Gc5_1088 0 n10 ns1088 0 -0.00304469325327
Gc5_1089 0 n10 ns1089 0 -0.0041295937028
Gc5_1090 0 n10 ns1090 0 -0.00345421091971
Gc5_1091 0 n10 ns1091 0 0.00500658763022
Gc5_1092 0 n10 ns1092 0 0.00434171238048
Gc5_1093 0 n10 ns1093 0 0.000862208153207
Gc5_1094 0 n10 ns1094 0 -0.00115697172555
Gc5_1095 0 n10 ns1095 0 -0.00359085915674
Gc5_1096 0 n10 ns1096 0 -0.00363651183105
Gc5_1097 0 n10 ns1097 0 0.00205028023291
Gc5_1098 0 n10 ns1098 0 0.000895399688929
Gc5_1099 0 n10 ns1099 0 -0.00387670046284
Gc5_1100 0 n10 ns1100 0 -1.94338379147e-07
Gc5_1101 0 n10 ns1101 0 0.000304910096384
Gc5_1102 0 n10 ns1102 0 -0.000147986860628
Gc5_1103 0 n10 ns1103 0 -0.000306093695108
Gc5_1104 0 n10 ns1104 0 -0.000484520763446
Gc5_1105 0 n10 ns1105 0 -0.000920807309706
Gc5_1106 0 n10 ns1106 0 0.00080689325077
Gc5_1107 0 n10 ns1107 0 -0.000112844503664
Gc5_1108 0 n10 ns1108 0 0.000510347589671
Gc5_1109 0 n10 ns1109 0 0.000134020170538
Gc5_1110 0 n10 ns1110 0 -0.000292717250567
Gc5_1111 0 n10 ns1111 0 -0.000485105893808
Gc5_1112 0 n10 ns1112 0 0.000212588879838
Gc5_1113 0 n10 ns1113 0 -0.000141787764204
Gc5_1114 0 n10 ns1114 0 8.98566921416e-05
Gc5_1115 0 n10 ns1115 0 0.000896773160323
Gc5_1116 0 n10 ns1116 0 -0.000181319287711
Gc5_1117 0 n10 ns1117 0 -0.000341569257461
Gc5_1118 0 n10 ns1118 0 -0.000548855640904
Gc5_1119 0 n10 ns1119 0 0.000505864961542
Gc5_1120 0 n10 ns1120 0 -0.000324377473038
Gc5_1121 0 n10 ns1121 0 2.16192870979e-05
Gc5_1122 0 n10 ns1122 0 -0.000586421467304
Gc5_1123 0 n10 ns1123 0 -0.00167054012798
Gc5_1124 0 n10 ns1124 0 0.000711923752153
Gc5_1125 0 n10 ns1125 0 -0.00381613981409
Gc5_1126 0 n10 ns1126 0 -0.00143902391477
Gc5_1127 0 n10 ns1127 0 -0.00323078912823
Gc5_1128 0 n10 ns1128 0 -0.0021384998179
Gc5_1129 0 n10 ns1129 0 0.000903480612206
Gc5_1130 0 n10 ns1130 0 0.000648287655722
Gc5_1131 0 n10 ns1131 0 0.000507335668679
Gc5_1132 0 n10 ns1132 0 -0.00133748773984
Gc5_1133 0 n10 ns1133 0 -0.000532718664285
Gc5_1134 0 n10 ns1134 0 -0.00269655167895
Gc5_1135 0 n10 ns1135 0 0.0015586693733
Gc5_1136 0 n10 ns1136 0 -0.00344313372681
Gc5_1137 0 n10 ns1137 0 -0.00214109559207
Gc5_1138 0 n10 ns1138 0 -2.29593271478e-05
Gc5_1139 0 n10 ns1139 0 0.000134472788094
Gc5_1140 0 n10 ns1140 0 -1.3687432913e-05
Gc5_1141 0 n10 ns1141 0 -0.000183850605069
Gc5_1142 0 n10 ns1142 0 -0.000323356159314
Gc5_1143 0 n10 ns1143 0 -0.00051564893954
Gc5_1144 0 n10 ns1144 0 0.000678907091424
Gc5_1145 0 n10 ns1145 0 -0.000166242687007
Gc5_1146 0 n10 ns1146 0 2.69765102223e-05
Gc5_1147 0 n10 ns1147 0 -3.20694607662e-05
Gc5_1148 0 n10 ns1148 0 -0.000102864351685
Gc5_1149 0 n10 ns1149 0 -3.68584800364e-05
Gc5_1150 0 n10 ns1150 0 0.000380693454968
Gc5_1151 0 n10 ns1151 0 -8.23990331661e-05
Gc5_1152 0 n10 ns1152 0 0.000141395438491
Gc5_1153 0 n10 ns1153 0 0.00041389056734
Gc5_1154 0 n10 ns1154 0 -0.000407043986635
Gc5_1155 0 n10 ns1155 0 0.000111448710626
Gc5_1156 0 n10 ns1156 0 0.000568955547215
Gc5_1157 0 n10 ns1157 0 0.000486663678417
Gc5_1158 0 n10 ns1158 0 -0.000264647727853
Gc5_1159 0 n10 ns1159 0 7.62923281149e-05
Gc5_1160 0 n10 ns1160 0 -7.75512476136e-05
Gc5_1161 0 n10 ns1161 0 -0.000291593557794
Gc5_1162 0 n10 ns1162 0 0.000280348491913
Gc5_1163 0 n10 ns1163 0 -0.00351948795385
Gc5_1164 0 n10 ns1164 0 -0.00493967056565
Gc5_1165 0 n10 ns1165 0 -0.00337537190921
Gc5_1166 0 n10 ns1166 0 -0.00466975559696
Gc5_1167 0 n10 ns1167 0 -0.00096718518368
Gc5_1168 0 n10 ns1168 0 0.00161903413068
Gc5_1169 0 n10 ns1169 0 -5.29515603847e-05
Gc5_1170 0 n10 ns1170 0 -0.00111567261765
Gc5_1171 0 n10 ns1171 0 -0.000367201718655
Gc5_1172 0 n10 ns1172 0 -0.0027242851348
Gc5_1173 0 n10 ns1173 0 0.000395034119131
Gc5_1174 0 n10 ns1174 0 -0.00206374720576
Gc5_1175 0 n10 ns1175 0 -0.000846001483992
Gc5_1176 0 n10 ns1176 0 -2.1415849522e-05
Gc5_1177 0 n10 ns1177 0 0.000105426778168
Gc5_1178 0 n10 ns1178 0 -1.32530389655e-05
Gc5_1179 0 n10 ns1179 0 -0.000257282287497
Gc5_1180 0 n10 ns1180 0 -2.42120518418e-05
Gc5_1181 0 n10 ns1181 0 -0.000436029730646
Gc5_1182 0 n10 ns1182 0 0.000443026353163
Gc5_1183 0 n10 ns1183 0 -0.000135955791032
Gc5_1184 0 n10 ns1184 0 0.000189603617178
Gc5_1185 0 n10 ns1185 0 0.000116524867985
Gc5_1186 0 n10 ns1186 0 -1.92348718633e-05
Gc5_1187 0 n10 ns1187 0 0.000547775410518
Gc5_1188 0 n10 ns1188 0 -0.000202937035098
Gc5_1189 0 n10 ns1189 0 -0.000156640975819
Gc5_1190 0 n10 ns1190 0 0.00014058545201
Gc5_1191 0 n10 ns1191 0 -6.09722782968e-05
Gc5_1192 0 n10 ns1192 0 0.000442931682495
Gc5_1193 0 n10 ns1193 0 0.000995271765388
Gc5_1194 0 n10 ns1194 0 0.000159489521941
Gc5_1195 0 n10 ns1195 0 0.000435506149472
Gc5_1196 0 n10 ns1196 0 -0.000679320974567
Gc5_1197 0 n10 ns1197 0 0.000304897826609
Gc5_1198 0 n10 ns1198 0 -0.000581471153007
Gc5_1199 0 n10 ns1199 0 6.81312068659e-05
Gc5_1200 0 n10 ns1200 0 -0.000547415643818
Gc5_1201 0 n10 ns1201 0 -0.0049903318116
Gc5_1202 0 n10 ns1202 0 -0.00451196025687
Gc5_1203 0 n10 ns1203 0 -0.00460163615907
Gc5_1204 0 n10 ns1204 0 -0.00392333223014
Gc5_1205 0 n10 ns1205 0 -0.000386183205236
Gc5_1206 0 n10 ns1206 0 0.0018399088525
Gc5_1207 0 n10 ns1207 0 -0.000269012003506
Gc5_1208 0 n10 ns1208 0 -0.0006659076839
Gc5_1209 0 n10 ns1209 0 -0.000791973111561
Gc5_1210 0 n10 ns1210 0 -0.0019397880544
Gc5_1211 0 n10 ns1211 0 -3.91175569576e-06
Gc5_1212 0 n10 ns1212 0 -0.00113473478605
Gc5_1213 0 n10 ns1213 0 -0.000387524432308
Gc5_1214 0 n10 ns1214 0 -1.00063991083e-05
Gc5_1215 0 n10 ns1215 0 9.85673174434e-05
Gc5_1216 0 n10 ns1216 0 -1.55897517561e-05
Gd5_1 0 n10 ni1 0 2.03179182567e-05
Gd5_2 0 n10 ni2 0 0.000254011542493
Gd5_3 0 n10 ni3 0 -0.000546124170407
Gd5_4 0 n10 ni4 0 -0.00145001859705
Gd5_5 0 n10 ni5 0 0.00119971073903
Gd5_6 0 n10 ni6 0 -0.00141419619456
Gd5_7 0 n10 ni7 0 -0.000228037877578
Gd5_8 0 n10 ni8 0 7.37971284635e-05
Gd5_9 0 n10 ni9 0 0.000185509171708
Gd5_10 0 n10 ni10 0 0.000144375620614
Gd5_11 0 n10 ni11 0 -0.00153552634176
Gd5_12 0 n10 ni12 0 -0.000248821008752
Gd5_13 0 n10 ni13 0 -0.002733373578
Gd5_14 0 n10 ni14 0 -0.00120857998738
Gd5_15 0 n10 ni15 0 0.000292597223403
Gd5_16 0 n10 ni16 0 0.000199132634583
Gd5_17 0 n10 ni17 0 -0.000333567775316
Gd5_18 0 n10 ni18 0 -0.000203225359427
Gd5_19 0 n10 ni19 0 0.000820585423425
Gd5_20 0 n10 ni20 0 -0.000263507808502
Gd5_21 0 n10 ni21 0 5.5689950602e-05
Gd5_22 0 n10 ni22 0 -1.76279353335e-05
Gd5_23 0 n10 ni23 0 -0.000303701156426
Gd5_24 0 n10 ni24 0 0.000703122324509
Gd5_25 0 n10 ni25 0 7.49800774057e-05
Gd5_26 0 n10 ni26 0 0.000337670359165
Gd5_27 0 n10 ni27 0 0.000649288062509
Gd5_28 0 n10 ni28 0 -0.00397110411588
Gd5_29 0 n10 ni29 0 -0.00181918206008
Gd5_30 0 n10 ni30 0 -0.000193998908127
Gd5_31 0 n10 ni31 0 5.32155550512e-05
Gd5_32 0 n10 ni32 0 0.000212178165532
Gc6_1 0 n12 ns1 0 7.35764281929e-05
Gc6_2 0 n12 ns2 0 0.000262329420834
Gc6_3 0 n12 ns3 0 0.000208066621864
Gc6_4 0 n12 ns4 0 0.00101994633925
Gc6_5 0 n12 ns5 0 0.000107247706865
Gc6_6 0 n12 ns6 0 1.12174702062e-05
Gc6_7 0 n12 ns7 0 -0.000188887637813
Gc6_8 0 n12 ns8 0 7.65896894168e-06
Gc6_9 0 n12 ns9 0 -0.000267663531689
Gc6_10 0 n12 ns10 0 0.000442551765735
Gc6_11 0 n12 ns11 0 5.81545982831e-05
Gc6_12 0 n12 ns12 0 -0.00012430129501
Gc6_13 0 n12 ns13 0 0.000220449821414
Gc6_14 0 n12 ns14 0 -0.00035183432193
Gc6_15 0 n12 ns15 0 0.000904265317642
Gc6_16 0 n12 ns16 0 -0.000738892717854
Gc6_17 0 n12 ns17 0 0.000237028267754
Gc6_18 0 n12 ns18 0 -0.000794122333818
Gc6_19 0 n12 ns19 0 0.000434938950884
Gc6_20 0 n12 ns20 0 -0.000799011191492
Gc6_21 0 n12 ns21 0 0.000189321035105
Gc6_22 0 n12 ns22 0 0.00120221521323
Gc6_23 0 n12 ns23 0 0.00376388149692
Gc6_24 0 n12 ns24 0 0.00299990575454
Gc6_25 0 n12 ns25 0 0.00343237404613
Gc6_26 0 n12 ns26 0 0.00244847123454
Gc6_27 0 n12 ns27 0 0.000785092561673
Gc6_28 0 n12 ns28 0 0.0010535756368
Gc6_29 0 n12 ns29 0 -0.000334368754641
Gc6_30 0 n12 ns30 0 -0.000366642204702
Gc6_31 0 n12 ns31 0 -0.00144416368992
Gc6_32 0 n12 ns32 0 -0.00109209040723
Gc6_33 0 n12 ns33 0 -0.000568869966492
Gc6_34 0 n12 ns34 0 -0.000485399900482
Gc6_35 0 n12 ns35 0 3.82515178096e-05
Gc6_36 0 n12 ns36 0 1.15146742997e-05
Gc6_37 0 n12 ns37 0 -0.000100243796939
Gc6_38 0 n12 ns38 0 3.37262917812e-06
Gc6_39 0 n12 ns39 0 -3.50799844093e-05
Gc6_40 0 n12 ns40 0 0.000189054610492
Gc6_41 0 n12 ns41 0 7.81792716713e-05
Gc6_42 0 n12 ns42 0 0.00121043196843
Gc6_43 0 n12 ns43 0 2.32754891717e-05
Gc6_44 0 n12 ns44 0 0.00019128483338
Gc6_45 0 n12 ns45 0 -9.06113127246e-05
Gc6_46 0 n12 ns46 0 -0.000156449448607
Gc6_47 0 n12 ns47 0 -0.000231278496031
Gc6_48 0 n12 ns48 0 0.000399365709296
Gc6_49 0 n12 ns49 0 6.69262324127e-05
Gc6_50 0 n12 ns50 0 -0.00016334644778
Gc6_51 0 n12 ns51 0 5.08340887005e-05
Gc6_52 0 n12 ns52 0 -0.000358099250981
Gc6_53 0 n12 ns53 0 0.000964304579134
Gc6_54 0 n12 ns54 0 -0.000557699150609
Gc6_55 0 n12 ns55 0 0.000282951790809
Gc6_56 0 n12 ns56 0 -0.000832447771261
Gc6_57 0 n12 ns57 0 0.000394393296678
Gc6_58 0 n12 ns58 0 -0.000792516160529
Gc6_59 0 n12 ns59 0 1.42508449694e-05
Gc6_60 0 n12 ns60 0 0.00113451266781
Gc6_61 0 n12 ns61 0 0.00400165959256
Gc6_62 0 n12 ns62 0 0.00348162959762
Gc6_63 0 n12 ns63 0 0.00370915421872
Gc6_64 0 n12 ns64 0 0.00289979530758
Gc6_65 0 n12 ns65 0 0.000488293190455
Gc6_66 0 n12 ns66 0 0.00119547893998
Gc6_67 0 n12 ns67 0 -0.000323374681638
Gc6_68 0 n12 ns68 0 -0.000462742586057
Gc6_69 0 n12 ns69 0 -0.00130416418082
Gc6_70 0 n12 ns70 0 -0.00134844089259
Gc6_71 0 n12 ns71 0 -0.000627613027905
Gc6_72 0 n12 ns72 0 -0.000565139918547
Gc6_73 0 n12 ns73 0 6.06573101923e-05
Gc6_74 0 n12 ns74 0 1.3857514532e-05
Gc6_75 0 n12 ns75 0 -6.34534434662e-05
Gc6_76 0 n12 ns76 0 -2.82151702135e-06
Gc6_77 0 n12 ns77 0 -0.000187593047012
Gc6_78 0 n12 ns78 0 7.12980834031e-05
Gc6_79 0 n12 ns79 0 -0.000247931927156
Gc6_80 0 n12 ns80 0 0.000530117901021
Gc6_81 0 n12 ns81 0 -1.04378964438e-05
Gc6_82 0 n12 ns82 0 7.16207049862e-05
Gc6_83 0 n12 ns83 0 0.000151654849428
Gc6_84 0 n12 ns84 0 -1.40459695307e-05
Gc6_85 0 n12 ns85 0 -0.000180078253964
Gc6_86 0 n12 ns86 0 -7.8414996704e-05
Gc6_87 0 n12 ns87 0 0.000129157625068
Gc6_88 0 n12 ns88 0 -0.000132908831002
Gc6_89 0 n12 ns89 0 -0.000227111399465
Gc6_90 0 n12 ns90 0 -0.000248212611185
Gc6_91 0 n12 ns91 0 0.00015538977829
Gc6_92 0 n12 ns92 0 0.000552362319766
Gc6_93 0 n12 ns93 0 0.000237288285873
Gc6_94 0 n12 ns94 0 -0.000396714016691
Gc6_95 0 n12 ns95 0 -0.000197279597824
Gc6_96 0 n12 ns96 0 -0.000306697931286
Gc6_97 0 n12 ns97 0 -0.000505938176346
Gc6_98 0 n12 ns98 0 -0.000375783657534
Gc6_99 0 n12 ns99 0 0.00231621779845
Gc6_100 0 n12 ns100 0 0.00315502891734
Gc6_101 0 n12 ns101 0 0.00239280281572
Gc6_102 0 n12 ns102 0 0.00299975315846
Gc6_103 0 n12 ns103 0 -0.00130415258565
Gc6_104 0 n12 ns104 0 0.000668846044295
Gc6_105 0 n12 ns105 0 -0.000124829727533
Gc6_106 0 n12 ns106 0 -0.000789528720441
Gc6_107 0 n12 ns107 0 -0.000348838265715
Gc6_108 0 n12 ns108 0 -0.00134373148349
Gc6_109 0 n12 ns109 0 -0.000581393783501
Gc6_110 0 n12 ns110 0 0.00102110554226
Gc6_111 0 n12 ns111 0 0.000563898008138
Gc6_112 0 n12 ns112 0 4.96855457082e-06
Gc6_113 0 n12 ns113 0 -9.83299010222e-05
Gc6_114 0 n12 ns114 0 -2.65489299369e-06
Gc6_115 0 n12 ns115 0 0.000124893799927
Gc6_116 0 n12 ns116 0 -0.000486462521792
Gc6_117 0 n12 ns117 0 0.00060216246327
Gc6_118 0 n12 ns118 0 9.90250963715e-05
Gc6_119 0 n12 ns119 0 -0.000266521227541
Gc6_120 0 n12 ns120 0 0.00048478223459
Gc6_121 0 n12 ns121 0 -1.80683431042e-05
Gc6_122 0 n12 ns122 0 -0.000191608946851
Gc6_123 0 n12 ns123 0 0.000355097887287
Gc6_124 0 n12 ns124 0 -0.000171098232382
Gc6_125 0 n12 ns125 0 0.000181103299676
Gc6_126 0 n12 ns126 0 -7.4233656683e-05
Gc6_127 0 n12 ns127 0 -2.07505242248e-05
Gc6_128 0 n12 ns128 0 -0.000318100492314
Gc6_129 0 n12 ns129 0 -0.000765530739885
Gc6_130 0 n12 ns130 0 -0.000349160696378
Gc6_131 0 n12 ns131 0 0.000294690645793
Gc6_132 0 n12 ns132 0 -0.000555550744595
Gc6_133 0 n12 ns133 0 -0.000188459026167
Gc6_134 0 n12 ns134 0 -0.000976500756772
Gc6_135 0 n12 ns135 0 0.00122128600077
Gc6_136 0 n12 ns136 0 -0.000690142868822
Gc6_137 0 n12 ns137 0 0.00192931713961
Gc6_138 0 n12 ns138 0 0.00295932680793
Gc6_139 0 n12 ns139 0 0.00178732321873
Gc6_140 0 n12 ns140 0 0.00324518391557
Gc6_141 0 n12 ns141 0 -0.00124985978309
Gc6_142 0 n12 ns142 0 -0.00139678146962
Gc6_143 0 n12 ns143 0 0.00040739240325
Gc6_144 0 n12 ns144 0 -0.00105193088846
Gc6_145 0 n12 ns145 0 0.000209620564677
Gc6_146 0 n12 ns146 0 -0.000790150500307
Gc6_147 0 n12 ns147 0 -0.00144933039245
Gc6_148 0 n12 ns148 0 0.00247557213213
Gc6_149 0 n12 ns149 0 0.00148058308315
Gc6_150 0 n12 ns150 0 2.84490671861e-05
Gc6_151 0 n12 ns151 0 -0.000230234505051
Gc6_152 0 n12 ns152 0 7.2267093159e-05
Gc6_153 0 n12 ns153 0 0.000295866352092
Gc6_154 0 n12 ns154 0 -0.00183236838697
Gc6_155 0 n12 ns155 0 0.000575226707769
Gc6_156 0 n12 ns156 0 -3.08049931996e-05
Gc6_157 0 n12 ns157 0 -0.000885205889225
Gc6_158 0 n12 ns158 0 0.000435072164633
Gc6_159 0 n12 ns159 0 0.00037244941667
Gc6_160 0 n12 ns160 0 -0.000551053231535
Gc6_161 0 n12 ns161 0 0.000378718234335
Gc6_162 0 n12 ns162 0 0.000452467940374
Gc6_163 0 n12 ns163 0 0.000261597639668
Gc6_164 0 n12 ns164 0 -5.39115983428e-05
Gc6_165 0 n12 ns165 0 -0.00045005591484
Gc6_166 0 n12 ns166 0 -0.000143873161462
Gc6_167 0 n12 ns167 0 0.000670846477646
Gc6_168 0 n12 ns168 0 -0.000976750948248
Gc6_169 0 n12 ns169 0 0.000866308826136
Gc6_170 0 n12 ns170 0 -0.000451259640771
Gc6_171 0 n12 ns171 0 0.000498987669859
Gc6_172 0 n12 ns172 0 -0.00094879187272
Gc6_173 0 n12 ns173 0 0.000914749316683
Gc6_174 0 n12 ns174 0 0.00221307777003
Gc6_175 0 n12 ns175 0 0.00259490597424
Gc6_176 0 n12 ns176 0 0.00446611399399
Gc6_177 0 n12 ns177 0 0.00195275438727
Gc6_178 0 n12 ns178 0 0.00463472010398
Gc6_179 0 n12 ns179 0 0.00368267300334
Gc6_180 0 n12 ns180 0 0.000684389085056
Gc6_181 0 n12 ns181 0 0.000863552303722
Gc6_182 0 n12 ns182 0 -0.00100954265665
Gc6_183 0 n12 ns183 0 -0.00199258695738
Gc6_184 0 n12 ns184 0 -0.00153037700702
Gc6_185 0 n12 ns185 0 -0.00391023349651
Gc6_186 0 n12 ns186 0 -0.000572958957955
Gc6_187 0 n12 ns187 0 0.00300375524197
Gc6_188 0 n12 ns188 0 5.02121405553e-05
Gc6_189 0 n12 ns189 0 -0.000196103251646
Gc6_190 0 n12 ns190 0 5.03225731283e-05
Gc6_191 0 n12 ns191 0 0.000224773733808
Gc6_192 0 n12 ns192 0 -0.00223604438484
Gc6_193 0 n12 ns193 0 -0.00201597784173
Gc6_194 0 n12 ns194 0 0.00029170051681
Gc6_195 0 n12 ns195 0 -0.00089131132318
Gc6_196 0 n12 ns196 0 0.000223643792214
Gc6_197 0 n12 ns197 0 0.000563861110563
Gc6_198 0 n12 ns198 0 -0.000226315121792
Gc6_199 0 n12 ns199 0 0.000103782067686
Gc6_200 0 n12 ns200 0 0.000538449085221
Gc6_201 0 n12 ns201 0 0.000294566359234
Gc6_202 0 n12 ns202 0 -1.70961462891e-05
Gc6_203 0 n12 ns203 0 -0.000611829609103
Gc6_204 0 n12 ns204 0 -0.000665401073418
Gc6_205 0 n12 ns205 0 0.000286608012138
Gc6_206 0 n12 ns206 0 9.22204131921e-05
Gc6_207 0 n12 ns207 0 0.000334943786625
Gc6_208 0 n12 ns208 0 -0.000199941199116
Gc6_209 0 n12 ns209 0 -0.000478572609209
Gc6_210 0 n12 ns210 0 -0.00106205137605
Gc6_211 0 n12 ns211 0 -0.000710321333507
Gc6_212 0 n12 ns212 0 0.000247781084824
Gc6_213 0 n12 ns213 0 0.00695542341874
Gc6_214 0 n12 ns214 0 0.00497857517096
Gc6_215 0 n12 ns215 0 0.00523915619428
Gc6_216 0 n12 ns216 0 0.0050624657272
Gc6_217 0 n12 ns217 0 0.00100716181953
Gc6_218 0 n12 ns218 0 0.00553276672594
Gc6_219 0 n12 ns219 0 0.000886965498332
Gc6_220 0 n12 ns220 0 -0.000820658752745
Gc6_221 0 n12 ns221 0 -0.00608002238806
Gc6_222 0 n12 ns222 0 -0.00150369238815
Gc6_223 0 n12 ns223 0 0.00274611712143
Gc6_224 0 n12 ns224 0 -0.00429504481377
Gc6_225 0 n12 ns225 0 0.00475194596774
Gc6_226 0 n12 ns226 0 -1.707551545e-05
Gc6_227 0 n12 ns227 0 0.000100368342943
Gc6_228 0 n12 ns228 0 -0.000130378286
Gc6_229 0 n12 ns229 0 0.000534715093923
Gc6_230 0 n12 ns230 0 -0.00219706336513
Gc6_231 0 n12 ns231 0 0.00111545348032
Gc6_232 0 n12 ns232 0 -0.000584313947613
Gc6_233 0 n12 ns233 0 -0.000723940639848
Gc6_234 0 n12 ns234 0 0.000222140681651
Gc6_235 0 n12 ns235 0 0.000235679952166
Gc6_236 0 n12 ns236 0 -0.000418662954178
Gc6_237 0 n12 ns237 0 0.000272943318282
Gc6_238 0 n12 ns238 0 0.000420281700382
Gc6_239 0 n12 ns239 0 0.000252606974997
Gc6_240 0 n12 ns240 0 -5.396008355e-05
Gc6_241 0 n12 ns241 0 -0.000421365010973
Gc6_242 0 n12 ns242 0 -6.54533898698e-06
Gc6_243 0 n12 ns243 0 0.000728424805374
Gc6_244 0 n12 ns244 0 -0.00102226895522
Gc6_245 0 n12 ns245 0 0.0008630837689
Gc6_246 0 n12 ns246 0 -0.000552019242889
Gc6_247 0 n12 ns247 0 0.000462475533185
Gc6_248 0 n12 ns248 0 -0.00107288444672
Gc6_249 0 n12 ns249 0 0.00103734337679
Gc6_250 0 n12 ns250 0 0.00227131553701
Gc6_251 0 n12 ns251 0 0.00334993092482
Gc6_252 0 n12 ns252 0 0.00494827354352
Gc6_253 0 n12 ns253 0 0.00260343493937
Gc6_254 0 n12 ns254 0 0.00505726931096
Gc6_255 0 n12 ns255 0 0.00367443743565
Gc6_256 0 n12 ns256 0 0.000380571054571
Gc6_257 0 n12 ns257 0 0.000889354727027
Gc6_258 0 n12 ns258 0 -0.00097898890251
Gc6_259 0 n12 ns259 0 -0.00194932660374
Gc6_260 0 n12 ns260 0 -0.00131254080625
Gc6_261 0 n12 ns261 0 -0.00393098870852
Gc6_262 0 n12 ns262 0 -0.000323341967194
Gc6_263 0 n12 ns263 0 0.0030816953038
Gc6_264 0 n12 ns264 0 5.01279038728e-05
Gc6_265 0 n12 ns265 0 -0.00018713724194
Gc6_266 0 n12 ns266 0 5.83769621437e-05
Gc6_267 0 n12 ns267 0 0.000253637229949
Gc6_268 0 n12 ns268 0 -0.0010114308279
Gc6_269 0 n12 ns269 0 0.000658014898409
Gc6_270 0 n12 ns270 0 -0.000455957299618
Gc6_271 0 n12 ns271 0 -0.000102439483532
Gc6_272 0 n12 ns272 0 0.000267816951932
Gc6_273 0 n12 ns273 0 -0.000182244480359
Gc6_274 0 n12 ns274 0 -0.000122457404705
Gc6_275 0 n12 ns275 0 3.61978963744e-05
Gc6_276 0 n12 ns276 0 -0.000339822047557
Gc6_277 0 n12 ns277 0 0.000209639193482
Gc6_278 0 n12 ns278 0 -2.98101678054e-05
Gc6_279 0 n12 ns279 0 0.000229133027209
Gc6_280 0 n12 ns280 0 -3.47364780912e-06
Gc6_281 0 n12 ns281 0 -0.00038600094885
Gc6_282 0 n12 ns282 0 -4.04210374842e-05
Gc6_283 0 n12 ns283 0 0.000594646012697
Gc6_284 0 n12 ns284 0 -0.000517893070314
Gc6_285 0 n12 ns285 0 0.000116649599729
Gc6_286 0 n12 ns286 0 -0.000864890615803
Gc6_287 0 n12 ns287 0 0.00092663992605
Gc6_288 0 n12 ns288 0 -0.0005615877746
Gc6_289 0 n12 ns289 0 0.00161553633853
Gc6_290 0 n12 ns290 0 0.0043602096079
Gc6_291 0 n12 ns291 0 0.00155435668544
Gc6_292 0 n12 ns292 0 0.00449478601332
Gc6_293 0 n12 ns293 0 -0.00146630055312
Gc6_294 0 n12 ns294 0 -0.00154345185292
Gc6_295 0 n12 ns295 0 0.000486905948308
Gc6_296 0 n12 ns296 0 -0.00106817288085
Gc6_297 0 n12 ns297 0 0.000473253796081
Gc6_298 0 n12 ns298 0 -0.000793229742568
Gc6_299 0 n12 ns299 0 -0.00141606739768
Gc6_300 0 n12 ns300 0 0.00254683991148
Gc6_301 0 n12 ns301 0 0.00150769000588
Gc6_302 0 n12 ns302 0 2.10671398408e-05
Gc6_303 0 n12 ns303 0 -0.000228581026459
Gc6_304 0 n12 ns304 0 7.50494961328e-05
Gc6_305 0 n12 ns305 0 1.96194045266e-05
Gc6_306 0 n12 ns306 0 -0.000646383440692
Gc6_307 0 n12 ns307 0 1.07669884791e-05
Gc6_308 0 n12 ns308 0 -0.000252130187849
Gc6_309 0 n12 ns309 0 0.000126430423992
Gc6_310 0 n12 ns310 0 -0.000216998633775
Gc6_311 0 n12 ns311 0 0.000144952802496
Gc6_312 0 n12 ns312 0 7.73658528019e-05
Gc6_313 0 n12 ns313 0 -0.000381405327325
Gc6_314 0 n12 ns314 0 -0.000544946254082
Gc6_315 0 n12 ns315 0 0.000162533876582
Gc6_316 0 n12 ns316 0 -1.831169232e-05
Gc6_317 0 n12 ns317 0 -0.000151107230638
Gc6_318 0 n12 ns318 0 0.000198313216525
Gc6_319 0 n12 ns319 0 0.00011339822321
Gc6_320 0 n12 ns320 0 0.00146563907162
Gc6_321 0 n12 ns321 0 0.00055094391399
Gc6_322 0 n12 ns322 0 0.00010909427424
Gc6_323 0 n12 ns323 0 4.89024968371e-07
Gc6_324 0 n12 ns324 0 0.000303132134225
Gc6_325 0 n12 ns325 0 -0.00118319163009
Gc6_326 0 n12 ns326 0 -0.000823237875471
Gc6_327 0 n12 ns327 0 -0.000482454143236
Gc6_328 0 n12 ns328 0 0.00391087781461
Gc6_329 0 n12 ns329 0 -8.15769734548e-06
Gc6_330 0 n12 ns330 0 0.00379975861947
Gc6_331 0 n12 ns331 0 -0.0018967435768
Gc6_332 0 n12 ns332 0 0.000506170957835
Gc6_333 0 n12 ns333 0 6.56918542984e-05
Gc6_334 0 n12 ns334 0 -0.000804750141628
Gc6_335 0 n12 ns335 0 0.000364256963505
Gc6_336 0 n12 ns336 0 -0.00136250423474
Gc6_337 0 n12 ns337 0 -0.00038553982834
Gc6_338 0 n12 ns338 0 0.00101241211242
Gc6_339 0 n12 ns339 0 0.000550383613424
Gc6_340 0 n12 ns340 0 -7.12002128035e-06
Gc6_341 0 n12 ns341 0 -0.000149756213766
Gc6_342 0 n12 ns342 0 1.00361240784e-05
Gc6_343 0 n12 ns343 0 -7.54369808632e-05
Gc6_344 0 n12 ns344 0 -2.14689426616e-05
Gc6_345 0 n12 ns345 0 5.77667033602e-06
Gc6_346 0 n12 ns346 0 0.000535730828561
Gc6_347 0 n12 ns347 0 2.71856227888e-05
Gc6_348 0 n12 ns348 0 -2.98341929859e-06
Gc6_349 0 n12 ns349 0 6.97592506746e-05
Gc6_350 0 n12 ns350 0 -4.86220821924e-05
Gc6_351 0 n12 ns351 0 -0.000256304755031
Gc6_352 0 n12 ns352 0 0.000103345992143
Gc6_353 0 n12 ns353 0 8.81134649671e-05
Gc6_354 0 n12 ns354 0 -0.00015355561418
Gc6_355 0 n12 ns355 0 -0.000197097823636
Gc6_356 0 n12 ns356 0 -0.00016799230588
Gc6_357 0 n12 ns357 0 0.000553818280173
Gc6_358 0 n12 ns358 0 0.000242988761628
Gc6_359 0 n12 ns359 0 0.000231469502817
Gc6_360 0 n12 ns360 0 -0.000525104276092
Gc6_361 0 n12 ns361 0 -1.65876972243e-05
Gc6_362 0 n12 ns362 0 -0.00039106461372
Gc6_363 0 n12 ns363 0 -0.000456126261862
Gc6_364 0 n12 ns364 0 0.000223005586491
Gc6_365 0 n12 ns365 0 0.00308682998655
Gc6_366 0 n12 ns366 0 0.00327782760765
Gc6_367 0 n12 ns367 0 0.00302496438816
Gc6_368 0 n12 ns368 0 0.00293324232068
Gc6_369 0 n12 ns369 0 -0.000637185929881
Gc6_370 0 n12 ns370 0 0.000972374893107
Gc6_371 0 n12 ns371 0 -0.000232719429958
Gc6_372 0 n12 ns372 0 -0.000647969874466
Gc6_373 0 n12 ns373 0 -0.000750278414347
Gc6_374 0 n12 ns374 0 -0.00134459839569
Gc6_375 0 n12 ns375 0 -0.000564285144364
Gc6_376 0 n12 ns376 0 0.000432111326244
Gc6_377 0 n12 ns377 0 0.000352409417917
Gc6_378 0 n12 ns378 0 -3.7219963056e-06
Gc6_379 0 n12 ns379 0 -5.24612933539e-05
Gc6_380 0 n12 ns380 0 -1.93674532753e-05
Gc6_381 0 n12 ns381 0 -0.000318385432595
Gc6_382 0 n12 ns382 0 0.000155210344276
Gc6_383 0 n12 ns383 0 -0.00063278179017
Gc6_384 0 n12 ns384 0 0.000547805419199
Gc6_385 0 n12 ns385 0 -9.38234937314e-05
Gc6_386 0 n12 ns386 0 0.000441613230044
Gc6_387 0 n12 ns387 0 3.8498324132e-05
Gc6_388 0 n12 ns388 0 -8.63993676541e-05
Gc6_389 0 n12 ns389 0 9.84098345124e-05
Gc6_390 0 n12 ns390 0 -0.000243863905171
Gc6_391 0 n12 ns391 0 0.000150557320003
Gc6_392 0 n12 ns392 0 -7.55628543749e-05
Gc6_393 0 n12 ns393 0 1.28918589231e-05
Gc6_394 0 n12 ns394 0 -0.000346341083464
Gc6_395 0 n12 ns395 0 -0.000582352261802
Gc6_396 0 n12 ns396 0 0.000299283392856
Gc6_397 0 n12 ns397 0 0.000198772029476
Gc6_398 0 n12 ns398 0 -0.000344918396021
Gc6_399 0 n12 ns399 0 -0.000329284704569
Gc6_400 0 n12 ns400 0 -0.000516516914974
Gc6_401 0 n12 ns401 0 0.000287653801379
Gc6_402 0 n12 ns402 0 -0.00113090028248
Gc6_403 0 n12 ns403 0 0.00141094721753
Gc6_404 0 n12 ns404 0 0.0023832302835
Gc6_405 0 n12 ns405 0 0.00148048829287
Gc6_406 0 n12 ns406 0 0.00263731337423
Gc6_407 0 n12 ns407 0 -0.00213510179306
Gc6_408 0 n12 ns408 0 -0.000711061175042
Gc6_409 0 n12 ns409 0 0.000233695103336
Gc6_410 0 n12 ns410 0 -0.000977806064239
Gc6_411 0 n12 ns411 0 0.000481325215547
Gc6_412 0 n12 ns412 0 -0.000914320678134
Gc6_413 0 n12 ns413 0 -0.000837366146498
Gc6_414 0 n12 ns414 0 0.00243014999574
Gc6_415 0 n12 ns415 0 0.0011399659687
Gc6_416 0 n12 ns416 0 1.80728456044e-05
Gc6_417 0 n12 ns417 0 -0.000183869914266
Gc6_418 0 n12 ns418 0 5.50576417666e-05
Gc6_419 0 n12 ns419 0 0.000438780504353
Gc6_420 0 n12 ns420 0 -0.00167295416785
Gc6_421 0 n12 ns421 0 0.00118461187586
Gc6_422 0 n12 ns422 0 -0.000997895372811
Gc6_423 0 n12 ns423 0 -0.000772301281231
Gc6_424 0 n12 ns424 0 9.75522377557e-05
Gc6_425 0 n12 ns425 0 0.000184122192754
Gc6_426 0 n12 ns426 0 -0.000333200685161
Gc6_427 0 n12 ns427 0 0.000338682453409
Gc6_428 0 n12 ns428 0 0.000142056556609
Gc6_429 0 n12 ns429 0 0.000205733945765
Gc6_430 0 n12 ns430 0 -3.29772139082e-05
Gc6_431 0 n12 ns431 0 -1.8635202315e-05
Gc6_432 0 n12 ns432 0 0.000296490747965
Gc6_433 0 n12 ns433 0 0.000149283238767
Gc6_434 0 n12 ns434 0 -0.000928476163628
Gc6_435 0 n12 ns435 0 0.000731494354719
Gc6_436 0 n12 ns436 0 -0.00047419003336
Gc6_437 0 n12 ns437 0 0.000424440486062
Gc6_438 0 n12 ns438 0 -0.000818308510449
Gc6_439 0 n12 ns439 0 0.00160860183552
Gc6_440 0 n12 ns440 0 0.00121224024322
Gc6_441 0 n12 ns441 0 0.00196100346291
Gc6_442 0 n12 ns442 0 0.00377345026631
Gc6_443 0 n12 ns443 0 0.00155462832855
Gc6_444 0 n12 ns444 0 0.00399666708432
Gc6_445 0 n12 ns445 0 0.00162516240797
Gc6_446 0 n12 ns446 0 -0.00166895200782
Gc6_447 0 n12 ns447 0 0.000820761879425
Gc6_448 0 n12 ns448 0 -0.000971271321472
Gc6_449 0 n12 ns449 0 -0.000527769450143
Gc6_450 0 n12 ns450 0 -0.000594045877445
Gc6_451 0 n12 ns451 0 -0.00325937856988
Gc6_452 0 n12 ns452 0 0.00212280775074
Gc6_453 0 n12 ns453 0 0.00256414813124
Gc6_454 0 n12 ns454 0 3.58373273257e-05
Gc6_455 0 n12 ns455 0 -0.000168824873604
Gc6_456 0 n12 ns456 0 3.91847810103e-05
Gc6_457 0 n12 ns457 0 0.00060018761095
Gc6_458 0 n12 ns458 0 -0.00356674415358
Gc6_459 0 n12 ns459 0 -0.00146025576494
Gc6_460 0 n12 ns460 0 -0.00117592939128
Gc6_461 0 n12 ns461 0 -0.00128918060728
Gc6_462 0 n12 ns462 0 1.51051242525e-05
Gc6_463 0 n12 ns463 0 0.000730624198909
Gc6_464 0 n12 ns464 0 -0.000193206407901
Gc6_465 0 n12 ns465 0 0.000136176261907
Gc6_466 0 n12 ns466 0 0.000549716160028
Gc6_467 0 n12 ns467 0 0.000285063082383
Gc6_468 0 n12 ns468 0 -1.62650198572e-05
Gc6_469 0 n12 ns469 0 -0.000397948850675
Gc6_470 0 n12 ns470 0 -0.000496696224801
Gc6_471 0 n12 ns471 0 9.49509234919e-05
Gc6_472 0 n12 ns472 0 -6.86499965385e-05
Gc6_473 0 n12 ns473 0 0.000364262417444
Gc6_474 0 n12 ns474 0 -0.000273236358558
Gc6_475 0 n12 ns475 0 -0.000335636082481
Gc6_476 0 n12 ns476 0 -0.00113110089065
Gc6_477 0 n12 ns477 0 -0.000330343092248
Gc6_478 0 n12 ns478 0 6.44158072099e-05
Gc6_479 0 n12 ns479 0 0.00632617232668
Gc6_480 0 n12 ns480 0 0.00587804771991
Gc6_481 0 n12 ns481 0 0.00471810867392
Gc6_482 0 n12 ns482 0 0.00577149478486
Gc6_483 0 n12 ns483 0 0.000480026556234
Gc6_484 0 n12 ns484 0 0.00533774259544
Gc6_485 0 n12 ns485 0 0.000843456646818
Gc6_486 0 n12 ns486 0 -0.000902815096418
Gc6_487 0 n12 ns487 0 -0.0062458117163
Gc6_488 0 n12 ns488 0 -0.00186725712063
Gc6_489 0 n12 ns489 0 0.00336164006745
Gc6_490 0 n12 ns490 0 -0.00500834326791
Gc6_491 0 n12 ns491 0 0.00459133929482
Gc6_492 0 n12 ns492 0 -1.96781561415e-05
Gc6_493 0 n12 ns493 0 4.16982872437e-05
Gc6_494 0 n12 ns494 0 -7.61514839518e-05
Gc6_495 0 n12 ns495 0 0.00114613616395
Gc6_496 0 n12 ns496 0 -0.00439539245789
Gc6_497 0 n12 ns497 0 0.00128215113219
Gc6_498 0 n12 ns498 0 -0.00297635832831
Gc6_499 0 n12 ns499 0 -0.00124413920922
Gc6_500 0 n12 ns500 0 -0.000583165252614
Gc6_501 0 n12 ns501 0 0.000647076696325
Gc6_502 0 n12 ns502 0 -8.12673521372e-05
Gc6_503 0 n12 ns503 0 0.000156578872864
Gc6_504 0 n12 ns504 0 0.000609356739608
Gc6_505 0 n12 ns505 0 0.000260478376783
Gc6_506 0 n12 ns506 0 -4.63433013412e-05
Gc6_507 0 n12 ns507 0 -0.000545110359389
Gc6_508 0 n12 ns508 0 0.000140785214165
Gc6_509 0 n12 ns509 0 0.000511288094106
Gc6_510 0 n12 ns510 0 -0.000855131834785
Gc6_511 0 n12 ns511 0 0.000618887826959
Gc6_512 0 n12 ns512 0 -0.000504746610569
Gc6_513 0 n12 ns513 0 6.94237529066e-05
Gc6_514 0 n12 ns514 0 -0.00121702979209
Gc6_515 0 n12 ns515 0 0.00103198481764
Gc6_516 0 n12 ns516 0 0.00163740468037
Gc6_517 0 n12 ns517 0 0.00588546427553
Gc6_518 0 n12 ns518 0 0.00561208602449
Gc6_519 0 n12 ns519 0 0.0044943910908
Gc6_520 0 n12 ns520 0 0.00559134697474
Gc6_521 0 n12 ns521 0 0.00268239823283
Gc6_522 0 n12 ns522 0 0.00186707018508
Gc6_523 0 n12 ns523 0 0.00092906315839
Gc6_524 0 n12 ns524 0 -0.000920764420209
Gc6_525 0 n12 ns525 0 -0.00410460197445
Gc6_526 0 n12 ns526 0 -0.00114357857004
Gc6_527 0 n12 ns527 0 -0.000623193836163
Gc6_528 0 n12 ns528 0 -0.00220780431102
Gc6_529 0 n12 ns529 0 0.00380208294783
Gc6_530 0 n12 ns530 0 1.43735501212e-05
Gc6_531 0 n12 ns531 0 -0.000116648214896
Gc6_532 0 n12 ns532 0 2.35136981778e-05
Gc6_533 0 n12 ns533 0 0.000661096227055
Gc6_534 0 n12 ns534 0 -0.00180490700426
Gc6_535 0 n12 ns535 0 0.00181197662931
Gc6_536 0 n12 ns536 0 -0.00115684446198
Gc6_537 0 n12 ns537 0 -0.000311597542049
Gc6_538 0 n12 ns538 0 9.50023020279e-05
Gc6_539 0 n12 ns539 0 -0.000145179062988
Gc6_540 0 n12 ns540 0 -0.0001402526972
Gc6_541 0 n12 ns541 0 0.000255557002926
Gc6_542 0 n12 ns542 0 -3.42986430933e-05
Gc6_543 0 n12 ns543 0 0.000214887215729
Gc6_544 0 n12 ns544 0 -5.26728067468e-05
Gc6_545 0 n12 ns545 0 1.43812745735e-05
Gc6_546 0 n12 ns546 0 7.25702840576e-05
Gc6_547 0 n12 ns547 0 -0.000355558840418
Gc6_548 0 n12 ns548 0 -0.000836104868598
Gc6_549 0 n12 ns549 0 0.000586195846461
Gc6_550 0 n12 ns550 0 -0.000730229736982
Gc6_551 0 n12 ns551 0 0.000126043252398
Gc6_552 0 n12 ns552 0 -0.00129393457529
Gc6_553 0 n12 ns553 0 0.0018086575964
Gc6_554 0 n12 ns554 0 0.000218479141391
Gc6_555 0 n12 ns555 0 0.0030009091641
Gc6_556 0 n12 ns556 0 0.00431070260349
Gc6_557 0 n12 ns557 0 0.00256961928804
Gc6_558 0 n12 ns558 0 0.00452756663527
Gc6_559 0 n12 ns559 0 -5.24955833351e-05
Gc6_560 0 n12 ns560 0 -0.00188483066713
Gc6_561 0 n12 ns561 0 0.000671845518011
Gc6_562 0 n12 ns562 0 -0.0010729545238
Gc6_563 0 n12 ns563 0 -9.82709846217e-06
Gc6_564 0 n12 ns564 0 -0.000659912080307
Gc6_565 0 n12 ns565 0 -0.00224691317934
Gc6_566 0 n12 ns566 0 0.00216312970791
Gc6_567 0 n12 ns567 0 0.00196887363127
Gc6_568 0 n12 ns568 0 1.64234663018e-05
Gc6_569 0 n12 ns569 0 -0.000227501954308
Gc6_570 0 n12 ns570 0 7.17241801136e-05
Gc6_571 0 n12 ns571 0 -0.000156447987267
Gc6_572 0 n12 ns572 0 -0.000602945895214
Gc6_573 0 n12 ns573 0 -0.000553553845636
Gc6_574 0 n12 ns574 0 -0.000306917007815
Gc6_575 0 n12 ns575 0 9.61940937833e-05
Gc6_576 0 n12 ns576 0 -9.99192156477e-05
Gc6_577 0 n12 ns577 0 2.97191998944e-05
Gc6_578 0 n12 ns578 0 0.000101861075963
Gc6_579 0 n12 ns579 0 -0.000370474774708
Gc6_580 0 n12 ns580 0 -0.000567304592488
Gc6_581 0 n12 ns581 0 0.00020639464531
Gc6_582 0 n12 ns582 0 -7.17151793056e-06
Gc6_583 0 n12 ns583 0 7.08805466438e-05
Gc6_584 0 n12 ns584 0 0.000162125055509
Gc6_585 0 n12 ns585 0 -9.63261354553e-05
Gc6_586 0 n12 ns586 0 0.00138254285534
Gc6_587 0 n12 ns587 0 0.000588588110556
Gc6_588 0 n12 ns588 0 4.57830834855e-05
Gc6_589 0 n12 ns589 0 -6.76605059257e-05
Gc6_590 0 n12 ns590 0 0.00016748050893
Gc6_591 0 n12 ns591 0 -0.000893128627247
Gc6_592 0 n12 ns592 0 -0.0011636825241
Gc6_593 0 n12 ns593 0 -0.00021077546042
Gc6_594 0 n12 ns594 0 0.00385550283456
Gc6_595 0 n12 ns595 0 0.000228061848501
Gc6_596 0 n12 ns596 0 0.00391433721011
Gc6_597 0 n12 ns597 0 -0.00245449838094
Gc6_598 0 n12 ns598 0 -0.000164623963735
Gc6_599 0 n12 ns599 0 0.000205809118896
Gc6_600 0 n12 ns600 0 -0.00092548153192
Gc6_601 0 n12 ns601 0 0.000747468619372
Gc6_602 0 n12 ns602 0 -0.00109595051729
Gc6_603 0 n12 ns603 0 -0.000505119019234
Gc6_604 0 n12 ns604 0 0.00201173778991
Gc6_605 0 n12 ns605 0 0.000919236912823
Gc6_606 0 n12 ns606 0 -9.41179619384e-06
Gc6_607 0 n12 ns607 0 -0.000145510821304
Gc6_608 0 n12 ns608 0 9.52635486195e-06
Gc6_609 0 n12 ns609 0 -0.000274075543665
Gc6_610 0 n12 ns610 0 0.000527632905135
Gc6_611 0 n12 ns611 0 -0.000552952050384
Gc6_612 0 n12 ns612 0 0.000782542256833
Gc6_613 0 n12 ns613 0 -8.09357716087e-05
Gc6_614 0 n12 ns614 0 0.000346035016024
Gc6_615 0 n12 ns615 0 0.000163705085801
Gc6_616 0 n12 ns616 0 -0.000192118112307
Gc6_617 0 n12 ns617 0 0.000271737919732
Gc6_618 0 n12 ns618 0 -0.000413671907072
Gc6_619 0 n12 ns619 0 -6.45827899951e-05
Gc6_620 0 n12 ns620 0 0.000148209424149
Gc6_621 0 n12 ns621 0 0.000263460893681
Gc6_622 0 n12 ns622 0 0.000346718072653
Gc6_623 0 n12 ns623 0 0.000742491830582
Gc6_624 0 n12 ns624 0 -0.000498117157914
Gc6_625 0 n12 ns625 0 6.05530361655e-05
Gc6_626 0 n12 ns626 0 -0.000711333882714
Gc6_627 0 n12 ns627 0 1.85338995323e-05
Gc6_628 0 n12 ns628 0 -0.000725232456312
Gc6_629 0 n12 ns629 0 -0.000122108674499
Gc6_630 0 n12 ns630 0 -0.000478951571167
Gc6_631 0 n12 ns631 0 -0.00446553871711
Gc6_632 0 n12 ns632 0 -0.00181224317096
Gc6_633 0 n12 ns633 0 -0.00400559701221
Gc6_634 0 n12 ns634 0 -0.00150560955189
Gc6_635 0 n12 ns635 0 0.000217939297751
Gc6_636 0 n12 ns636 0 0.00146371754073
Gc6_637 0 n12 ns637 0 -0.000283746940097
Gc6_638 0 n12 ns638 0 -0.000410295144873
Gc6_639 0 n12 ns639 0 -0.000975840617923
Gc6_640 0 n12 ns640 0 -0.00130442064236
Gc6_641 0 n12 ns641 0 -0.000110685215843
Gc6_642 0 n12 ns642 0 -0.000716364560668
Gc6_643 0 n12 ns643 0 -0.000241045251757
Gc6_644 0 n12 ns644 0 -1.91414540733e-06
Gc6_645 0 n12 ns645 0 5.08336741681e-05
Gc6_646 0 n12 ns646 0 1.54457497393e-05
Gc6_647 0 n12 ns647 0 -0.000176986367412
Gc6_648 0 n12 ns648 0 0.000162755773356
Gc6_649 0 n12 ns649 0 -0.00020644978704
Gc6_650 0 n12 ns650 0 0.000556689569993
Gc6_651 0 n12 ns651 0 -9.64226403359e-05
Gc6_652 0 n12 ns652 0 0.000261895576575
Gc6_653 0 n12 ns653 0 0.000150443852111
Gc6_654 0 n12 ns654 0 -0.000116606704932
Gc6_655 0 n12 ns655 0 0.000370933516343
Gc6_656 0 n12 ns656 0 -0.000362605166017
Gc6_657 0 n12 ns657 0 -8.21295379617e-05
Gc6_658 0 n12 ns658 0 0.000155036670625
Gc6_659 0 n12 ns659 0 0.000129394822154
Gc6_660 0 n12 ns660 0 0.000350014321089
Gc6_661 0 n12 ns661 0 0.000824714963041
Gc6_662 0 n12 ns662 0 -0.000335009196506
Gc6_663 0 n12 ns663 0 0.000140338742378
Gc6_664 0 n12 ns664 0 -0.000752261685182
Gc6_665 0 n12 ns665 0 6.29062039377e-05
Gc6_666 0 n12 ns666 0 -0.00072274101041
Gc6_667 0 n12 ns667 0 -8.65186363795e-05
Gc6_668 0 n12 ns668 0 -0.00048680903314
Gc6_669 0 n12 ns669 0 -0.0051750912025
Gc6_670 0 n12 ns670 0 -0.00255235097878
Gc6_671 0 n12 ns671 0 -0.00467764610072
Gc6_672 0 n12 ns672 0 -0.00217010728385
Gc6_673 0 n12 ns673 0 0.000174899798812
Gc6_674 0 n12 ns674 0 0.00186014223409
Gc6_675 0 n12 ns675 0 -0.000326431434063
Gc6_676 0 n12 ns676 0 -0.000538426340651
Gc6_677 0 n12 ns677 0 -0.00109373426353
Gc6_678 0 n12 ns678 0 -0.00177609813792
Gc6_679 0 n12 ns679 0 -0.00013379660588
Gc6_680 0 n12 ns680 0 -0.00124004942934
Gc6_681 0 n12 ns681 0 -0.000375489968333
Gc6_682 0 n12 ns682 0 1.49974753486e-06
Gc6_683 0 n12 ns683 0 5.46890939771e-05
Gc6_684 0 n12 ns684 0 1.02142765748e-05
Gc6_685 0 n12 ns685 0 -7.48884601569e-05
Gc6_686 0 n12 ns686 0 -0.000304088237277
Gc6_687 0 n12 ns687 0 -0.000198602001245
Gc6_688 0 n12 ns688 0 0.000263193018853
Gc6_689 0 n12 ns689 0 -0.000112655216945
Gc6_690 0 n12 ns690 0 2.87923285743e-05
Gc6_691 0 n12 ns691 0 -7.87293434674e-05
Gc6_692 0 n12 ns692 0 -1.15901074253e-05
Gc6_693 0 n12 ns693 0 0.000175504890344
Gc6_694 0 n12 ns694 0 0.000233830647903
Gc6_695 0 n12 ns695 0 -6.66480377432e-05
Gc6_696 0 n12 ns696 0 0.000123896445202
Gc6_697 0 n12 ns697 0 6.15383936593e-05
Gc6_698 0 n12 ns698 0 -0.000209594187368
Gc6_699 0 n12 ns699 0 0.000355196018027
Gc6_700 0 n12 ns700 0 0.000578873627478
Gc6_701 0 n12 ns701 0 0.000385210891704
Gc6_702 0 n12 ns702 0 -0.000301720869804
Gc6_703 0 n12 ns703 0 9.43731971506e-05
Gc6_704 0 n12 ns704 0 -6.37301951403e-05
Gc6_705 0 n12 ns705 0 -0.000101879485006
Gc6_706 0 n12 ns706 0 -2.19177571216e-05
Gc6_707 0 n12 ns707 0 -0.00418718779205
Gc6_708 0 n12 ns708 0 -0.00459130248143
Gc6_709 0 n12 ns709 0 -0.00395227020376
Gc6_710 0 n12 ns710 0 -0.00418623489532
Gc6_711 0 n12 ns711 0 -0.000648090419471
Gc6_712 0 n12 ns712 0 0.00183016631271
Gc6_713 0 n12 ns713 0 -0.000209488670027
Gc6_714 0 n12 ns714 0 -0.000927508266202
Gc6_715 0 n12 ns715 0 -0.000721563408569
Gc6_716 0 n12 ns716 0 -0.00244155775542
Gc6_717 0 n12 ns717 0 0.000144229131908
Gc6_718 0 n12 ns718 0 -0.00167718932272
Gc6_719 0 n12 ns719 0 -0.000617010925003
Gc6_720 0 n12 ns720 0 -1.76323874204e-05
Gc6_721 0 n12 ns721 0 7.88685310723e-05
Gc6_722 0 n12 ns722 0 -1.62371166604e-07
Gc6_723 0 n12 ns723 0 -8.76513939473e-05
Gc6_724 0 n12 ns724 0 -5.37590581784e-05
Gc6_725 0 n12 ns725 0 9.16863623142e-05
Gc6_726 0 n12 ns726 0 0.00156893363013
Gc6_727 0 n12 ns727 0 9.70573696283e-05
Gc6_728 0 n12 ns728 0 0.000238086547884
Gc6_729 0 n12 ns729 0 5.91704447109e-06
Gc6_730 0 n12 ns730 0 -0.000231149017083
Gc6_731 0 n12 ns731 0 -0.000217309082218
Gc6_732 0 n12 ns732 0 0.000423573595793
Gc6_733 0 n12 ns733 0 -0.000104948107459
Gc6_734 0 n12 ns734 0 6.49082344578e-05
Gc6_735 0 n12 ns735 0 0.000608232729604
Gc6_736 0 n12 ns736 0 -0.00056789597651
Gc6_737 0 n12 ns737 0 -0.000459396741221
Gc6_738 0 n12 ns738 0 -0.000187757746382
Gc6_739 0 n12 ns739 0 0.00041157522262
Gc6_740 0 n12 ns740 0 -0.000339237539551
Gc6_741 0 n12 ns741 0 -6.40125379767e-05
Gc6_742 0 n12 ns742 0 -0.000493648038563
Gc6_743 0 n12 ns743 0 -0.000987387564304
Gc6_744 0 n12 ns744 0 0.00112640198801
Gc6_745 0 n12 ns745 0 -0.00259471785886
Gc6_746 0 n12 ns746 0 -0.00154134470222
Gc6_747 0 n12 ns747 0 -0.00237219368734
Gc6_748 0 n12 ns748 0 -0.00210183101396
Gc6_749 0 n12 ns749 0 0.0001181508899
Gc6_750 0 n12 ns750 0 0.000958873302351
Gc6_751 0 n12 ns751 0 0.000251442967375
Gc6_752 0 n12 ns752 0 -0.00132994294151
Gc6_753 0 n12 ns753 0 -0.000478205461112
Gc6_754 0 n12 ns754 0 -0.00300624006758
Gc6_755 0 n12 ns755 0 0.000918201072527
Gc6_756 0 n12 ns756 0 -0.00362547085595
Gc6_757 0 n12 ns757 0 -0.00165159496969
Gc6_758 0 n12 ns758 0 -2.41727212146e-05
Gc6_759 0 n12 ns759 0 0.000103871462244
Gc6_760 0 n12 ns760 0 -2.79205688047e-06
Gc6_761 0 n12 ns761 0 -0.000915918194392
Gc6_762 0 n12 ns762 0 -0.000237281009236
Gc6_763 0 n12 ns763 0 -0.00335155222299
Gc6_764 0 n12 ns764 0 -0.00121288180129
Gc6_765 0 n12 ns765 0 -0.0018976238887
Gc6_766 0 n12 ns766 0 0.00130937607206
Gc6_767 0 n12 ns767 0 0.000827731815948
Gc6_768 0 n12 ns768 0 -0.000570943643202
Gc6_769 0 n12 ns769 0 -0.000296658057248
Gc6_770 0 n12 ns770 0 0.000198385996326
Gc6_771 0 n12 ns771 0 -0.000162844413804
Gc6_772 0 n12 ns772 0 -8.93526156062e-06
Gc6_773 0 n12 ns773 0 0.000465080674856
Gc6_774 0 n12 ns774 0 -8.33697855376e-05
Gc6_775 0 n12 ns775 0 0.000785620767089
Gc6_776 0 n12 ns776 0 -0.00096266555636
Gc6_777 0 n12 ns777 0 0.00101646772587
Gc6_778 0 n12 ns778 0 -0.000312189198191
Gc6_779 0 n12 ns779 0 0.000875129761819
Gc6_780 0 n12 ns780 0 -0.000597285090295
Gc6_781 0 n12 ns781 0 -0.00210510737684
Gc6_782 0 n12 ns782 0 -0.000565169692916
Gc6_783 0 n12 ns783 0 -0.00606843379785
Gc6_784 0 n12 ns784 0 -0.00179497138689
Gc6_785 0 n12 ns785 0 -0.00479305724236
Gc6_786 0 n12 ns786 0 -0.00241364787919
Gc6_787 0 n12 ns787 0 0.00399240512787
Gc6_788 0 n12 ns788 0 0.00229513869518
Gc6_789 0 n12 ns789 0 0.00077588818549
Gc6_790 0 n12 ns790 0 -0.00123028145197
Gc6_791 0 n12 ns791 0 -0.00252012791171
Gc6_792 0 n12 ns792 0 -0.00324792600164
Gc6_793 0 n12 ns793 0 0.00231224003017
Gc6_794 0 n12 ns794 0 -0.00122881967695
Gc6_795 0 n12 ns795 0 -0.00332840541458
Gc6_796 0 n12 ns796 0 -4.50612442903e-05
Gc6_797 0 n12 ns797 0 0.00035993007314
Gc6_798 0 n12 ns798 0 -0.00017340004852
Gc6_799 0 n12 ns799 0 3.82917306453e-05
Gc6_800 0 n12 ns800 0 -0.000720006642153
Gc6_801 0 n12 ns801 0 0.0018957669604
Gc6_802 0 n12 ns802 0 0.00171395588503
Gc6_803 0 n12 ns803 0 0.00165420228493
Gc6_804 0 n12 ns804 0 -0.00118208892629
Gc6_805 0 n12 ns805 0 -0.000561338261708
Gc6_806 0 n12 ns806 0 0.000135547318503
Gc6_807 0 n12 ns807 0 6.00905245977e-05
Gc6_808 0 n12 ns808 0 -2.4878747651e-05
Gc6_809 0 n12 ns809 0 -0.00014185678948
Gc6_810 0 n12 ns810 0 3.83499066576e-05
Gc6_811 0 n12 ns811 0 0.00189404098511
Gc6_812 0 n12 ns812 0 -0.000665694370812
Gc6_813 0 n12 ns813 0 -0.00064692332823
Gc6_814 0 n12 ns814 0 0.00133430490801
Gc6_815 0 n12 ns815 0 -0.000520785500722
Gc6_816 0 n12 ns816 0 8.42637786665e-05
Gc6_817 0 n12 ns817 0 -0.00223157631846
Gc6_818 0 n12 ns818 0 -0.00117213782907
Gc6_819 0 n12 ns819 0 0.00293304707343
Gc6_820 0 n12 ns820 0 0.00367993717159
Gc6_821 0 n12 ns821 0 -0.0105683486148
Gc6_822 0 n12 ns822 0 0.000563608273994
Gc6_823 0 n12 ns823 0 -0.00812583824534
Gc6_824 0 n12 ns824 0 -0.000740106728079
Gc6_825 0 n12 ns825 0 -0.010612014655
Gc6_826 0 n12 ns826 0 -0.000233501065583
Gc6_827 0 n12 ns827 0 0.00141031570369
Gc6_828 0 n12 ns828 0 8.78253253902e-06
Gc6_829 0 n12 ns829 0 -0.00375329426666
Gc6_830 0 n12 ns830 0 0.00840954753066
Gc6_831 0 n12 ns831 0 -0.0143320208198
Gc6_832 0 n12 ns832 0 -0.00431559949291
Gc6_833 0 n12 ns833 0 -0.00628324248476
Gc6_834 0 n12 ns834 0 -5.4834372245e-05
Gc6_835 0 n12 ns835 0 -0.000361896087013
Gc6_836 0 n12 ns836 0 0.000584415651247
Gc6_837 0 n12 ns837 0 -0.0013626098358
Gc6_838 0 n12 ns838 0 -2.89343741907e-05
Gc6_839 0 n12 ns839 0 -0.00479917263822
Gc6_840 0 n12 ns840 0 -0.000447591609592
Gc6_841 0 n12 ns841 0 -0.00212494078363
Gc6_842 0 n12 ns842 0 0.00150570473231
Gc6_843 0 n12 ns843 0 0.000964425427456
Gc6_844 0 n12 ns844 0 -0.000687368590543
Gc6_845 0 n12 ns845 0 -0.000342229007557
Gc6_846 0 n12 ns846 0 0.000180289589269
Gc6_847 0 n12 ns847 0 -0.000160579714618
Gc6_848 0 n12 ns848 0 5.62309519967e-05
Gc6_849 0 n12 ns849 0 0.000854103207181
Gc6_850 0 n12 ns850 0 -6.87930123684e-05
Gc6_851 0 n12 ns851 0 0.00112804784949
Gc6_852 0 n12 ns852 0 -0.00104722665774
Gc6_853 0 n12 ns853 0 0.00116214812028
Gc6_854 0 n12 ns854 0 -0.000449585048039
Gc6_855 0 n12 ns855 0 0.00103234013476
Gc6_856 0 n12 ns856 0 -0.000719567653911
Gc6_857 0 n12 ns857 0 -0.00220170117706
Gc6_858 0 n12 ns858 0 -0.000829058652754
Gc6_859 0 n12 ns859 0 -0.00651754447673
Gc6_860 0 n12 ns860 0 -0.00316453084365
Gc6_861 0 n12 ns861 0 -0.00518226726071
Gc6_862 0 n12 ns862 0 -0.00357528462899
Gc6_863 0 n12 ns863 0 0.00338201033424
Gc6_864 0 n12 ns864 0 0.00223660675838
Gc6_865 0 n12 ns865 0 0.00085651898784
Gc6_866 0 n12 ns866 0 -0.00124080279273
Gc6_867 0 n12 ns867 0 -0.00204849875284
Gc6_868 0 n12 ns868 0 -0.0031387617347
Gc6_869 0 n12 ns869 0 0.0024825933331
Gc6_870 0 n12 ns870 0 -0.000726251915829
Gc6_871 0 n12 ns871 0 -0.00322956986254
Gc6_872 0 n12 ns872 0 -4.82425039689e-05
Gc6_873 0 n12 ns873 0 0.000378603286934
Gc6_874 0 n12 ns874 0 -0.00017578250458
Gc6_875 0 n12 ns875 0 -0.000430690045855
Gc6_876 0 n12 ns876 0 7.71244608022e-05
Gc6_877 0 n12 ns877 0 -0.000933372091712
Gc6_878 0 n12 ns878 0 0.00243216981895
Gc6_879 0 n12 ns879 0 -0.000130518019339
Gc6_880 0 n12 ns880 0 0.000404495179167
Gc6_881 0 n12 ns881 0 0.000189602384677
Gc6_882 0 n12 ns882 0 -0.00026705309571
Gc6_883 0 n12 ns883 0 1.42168890533e-05
Gc6_884 0 n12 ns884 0 0.000513493925755
Gc6_885 0 n12 ns885 0 -0.000173084279199
Gc6_886 0 n12 ns886 0 5.73101546697e-05
Gc6_887 0 n12 ns887 0 0.000647959713892
Gc6_888 0 n12 ns888 0 -0.00048848441253
Gc6_889 0 n12 ns889 0 2.46518855378e-05
Gc6_890 0 n12 ns890 0 -0.000125740002593
Gc6_891 0 n12 ns891 0 0.000810558231536
Gc6_892 0 n12 ns892 0 -0.000518173871085
Gc6_893 0 n12 ns893 0 0.000409765550622
Gc6_894 0 n12 ns894 0 -0.00075756722346
Gc6_895 0 n12 ns895 0 -0.000713511082724
Gc6_896 0 n12 ns896 0 0.000994062336823
Gc6_897 0 n12 ns897 0 -0.00182710156647
Gc6_898 0 n12 ns898 0 -0.00355287577561
Gc6_899 0 n12 ns899 0 -0.00174041420392
Gc6_900 0 n12 ns900 0 -0.00386421333476
Gc6_901 0 n12 ns901 0 -0.000584181194761
Gc6_902 0 n12 ns902 0 0.000812999647366
Gc6_903 0 n12 ns903 0 0.000374229694893
Gc6_904 0 n12 ns904 0 -0.00135999404541
Gc6_905 0 n12 ns905 0 0.000102307216043
Gc6_906 0 n12 ns906 0 -0.00297018905709
Gc6_907 0 n12 ns907 0 0.001091466953
Gc6_908 0 n12 ns908 0 -0.00331572068862
Gc6_909 0 n12 ns909 0 -0.00160281578481
Gc6_910 0 n12 ns910 0 -2.46194612595e-05
Gc6_911 0 n12 ns911 0 8.0143637788e-05
Gc6_912 0 n12 ns912 0 8.60038511861e-06
Gc6_913 0 n12 ns913 0 -0.000156677420978
Gc6_914 0 n12 ns914 0 -0.000403841351035
Gc6_915 0 n12 ns915 0 -0.000503439439889
Gc6_916 0 n12 ns916 0 0.00058615992291
Gc6_917 0 n12 ns917 0 -0.000196731202707
Gc6_918 0 n12 ns918 0 -3.10579649648e-05
Gc6_919 0 n12 ns919 0 -7.18859598626e-05
Gc6_920 0 n12 ns920 0 0.000117149157577
Gc6_921 0 n12 ns921 0 0.000368110491521
Gc6_922 0 n12 ns922 0 0.000684157876913
Gc6_923 0 n12 ns923 0 -0.000117332277093
Gc6_924 0 n12 ns924 0 -2.74194620933e-05
Gc6_925 0 n12 ns925 0 -0.000358012492596
Gc6_926 0 n12 ns926 0 -0.000373054832814
Gc6_927 0 n12 ns927 0 0.000383592370942
Gc6_928 0 n12 ns928 0 0.00115832536362
Gc6_929 0 n12 ns929 0 0.000849892458811
Gc6_930 0 n12 ns930 0 -1.64026517239e-05
Gc6_931 0 n12 ns931 0 0.000651727492294
Gc6_932 0 n12 ns932 0 0.000153974924841
Gc6_933 0 n12 ns933 0 0.000399382287299
Gc6_934 0 n12 ns934 0 0.000196829366416
Gc6_935 0 n12 ns935 0 -0.000937603462755
Gc6_936 0 n12 ns936 0 -0.00617966398206
Gc6_937 0 n12 ns937 0 -0.00115712017637
Gc6_938 0 n12 ns938 0 -0.00565965892118
Gc6_939 0 n12 ns939 0 -0.00143389444402
Gc6_940 0 n12 ns940 0 0.00104468156218
Gc6_941 0 n12 ns941 0 2.74674933857e-05
Gc6_942 0 n12 ns942 0 -0.000880653894056
Gc6_943 0 n12 ns943 0 0.00014846731248
Gc6_944 0 n12 ns944 0 -0.00200756471784
Gc6_945 0 n12 ns945 0 0.000365566889897
Gc6_946 0 n12 ns946 0 -0.00111727460956
Gc6_947 0 n12 ns947 0 -0.000526143237366
Gc6_948 0 n12 ns948 0 -9.06485690203e-06
Gc6_949 0 n12 ns949 0 7.49640606939e-05
Gc6_950 0 n12 ns950 0 9.07859773984e-07
Gc6_951 0 n12 ns951 0 -0.000101367170815
Gc6_952 0 n12 ns952 0 -0.000129845203435
Gc6_953 0 n12 ns953 0 -0.000251293955022
Gc6_954 0 n12 ns954 0 0.000259480719271
Gc6_955 0 n12 ns955 0 -4.31795095469e-05
Gc6_956 0 n12 ns956 0 0.000124188199634
Gc6_957 0 n12 ns957 0 -5.26231123188e-05
Gc6_958 0 n12 ns958 0 -9.24812604972e-06
Gc6_959 0 n12 ns959 0 0.000293214678205
Gc6_960 0 n12 ns960 0 -4.43394729201e-05
Gc6_961 0 n12 ns961 0 -6.65624887615e-05
Gc6_962 0 n12 ns962 0 0.000141212600073
Gc6_963 0 n12 ns963 0 -1.23490432286e-06
Gc6_964 0 n12 ns964 0 9.31008356417e-05
Gc6_965 0 n12 ns965 0 0.000638612058609
Gc6_966 0 n12 ns966 0 0.000298012297245
Gc6_967 0 n12 ns967 0 0.000292337198641
Gc6_968 0 n12 ns968 0 -0.000471684139627
Gc6_969 0 n12 ns969 0 0.000102415176909
Gc6_970 0 n12 ns970 0 -0.00028148311904
Gc6_971 0 n12 ns971 0 -4.01483734805e-05
Gc6_972 0 n12 ns972 0 -0.000362174260196
Gc6_973 0 n12 ns973 0 -0.00484267318977
Gc6_974 0 n12 ns974 0 -0.00425279790487
Gc6_975 0 n12 ns975 0 -0.00448132311968
Gc6_976 0 n12 ns976 0 -0.0037521089271
Gc6_977 0 n12 ns977 0 -0.000373401658022
Gc6_978 0 n12 ns978 0 0.00186404884336
Gc6_979 0 n12 ns979 0 -0.000289282137828
Gc6_980 0 n12 ns980 0 -0.000743366605587
Gc6_981 0 n12 ns981 0 -0.000900624914432
Gc6_982 0 n12 ns982 0 -0.00206800319121
Gc6_983 0 n12 ns983 0 1.90385271065e-05
Gc6_984 0 n12 ns984 0 -0.00125058213422
Gc6_985 0 n12 ns985 0 -0.000439342331122
Gc6_986 0 n12 ns986 0 -1.18913144472e-05
Gc6_987 0 n12 ns987 0 4.30629898775e-05
Gc6_988 0 n12 ns988 0 1.31904702048e-05
Gc6_989 0 n12 ns989 0 0.000288593906758
Gc6_990 0 n12 ns990 0 -0.000724806957334
Gc6_991 0 n12 ns991 0 0.00089174655591
Gc6_992 0 n12 ns992 0 6.83001053556e-05
Gc6_993 0 n12 ns993 0 4.70642088387e-05
Gc6_994 0 n12 ns994 0 -0.000293730915619
Gc6_995 0 n12 ns995 0 -7.89290502957e-05
Gc6_996 0 n12 ns996 0 2.61711868949e-05
Gc6_997 0 n12 ns997 0 -0.000168628482725
Gc6_998 0 n12 ns998 0 0.00030651724777
Gc6_999 0 n12 ns999 0 -9.99876775952e-05
Gc6_1000 0 n12 ns1000 0 0.000121349237508
Gc6_1001 0 n12 ns1001 0 0.000421958220076
Gc6_1002 0 n12 ns1002 0 -0.00035781998061
Gc6_1003 0 n12 ns1003 0 -0.000387804258068
Gc6_1004 0 n12 ns1004 0 0.000397579560602
Gc6_1005 0 n12 ns1005 0 0.00028029031369
Gc6_1006 0 n12 ns1006 0 -0.000169938055852
Gc6_1007 0 n12 ns1007 0 -0.000230430553421
Gc6_1008 0 n12 ns1008 0 -8.39962775368e-05
Gc6_1009 0 n12 ns1009 0 -0.000445269722529
Gc6_1010 0 n12 ns1010 0 0.000715617430042
Gc6_1011 0 n12 ns1011 0 -0.00227722257879
Gc6_1012 0 n12 ns1012 0 -0.00321914423488
Gc6_1013 0 n12 ns1013 0 -0.00223564028598
Gc6_1014 0 n12 ns1014 0 -0.00332684021309
Gc6_1015 0 n12 ns1015 0 -0.000681040805654
Gc6_1016 0 n12 ns1016 0 0.00118045143935
Gc6_1017 0 n12 ns1017 0 7.92556616939e-05
Gc6_1018 0 n12 ns1018 0 -0.00120836363885
Gc6_1019 0 n12 ns1019 0 -0.0003220547885
Gc6_1020 0 n12 ns1020 0 -0.00284856636192
Gc6_1021 0 n12 ns1021 0 0.000546254593527
Gc6_1022 0 n12 ns1022 0 -0.00281225070929
Gc6_1023 0 n12 ns1023 0 -0.00114702847332
Gc6_1024 0 n12 ns1024 0 -3.32845628686e-05
Gc6_1025 0 n12 ns1025 0 9.46443132005e-05
Gc6_1026 0 n12 ns1026 0 -1.32154115742e-06
Gc6_1027 0 n12 ns1027 0 -0.000965544352184
Gc6_1028 0 n12 ns1028 0 0.000373423580977
Gc6_1029 0 n12 ns1029 0 -0.00259009939816
Gc6_1030 0 n12 ns1030 0 0.00160097233057
Gc6_1031 0 n12 ns1031 0 -0.000328703477558
Gc6_1032 0 n12 ns1032 0 0.00121103547
Gc6_1033 0 n12 ns1033 0 0.000245805411848
Gc6_1034 0 n12 ns1034 0 -0.000509653654257
Gc6_1035 0 n12 ns1035 0 -0.000217457345954
Gc6_1036 0 n12 ns1036 0 0.000292985641548
Gc6_1037 0 n12 ns1037 0 -0.000153328750842
Gc6_1038 0 n12 ns1038 0 1.56832116161e-05
Gc6_1039 0 n12 ns1039 0 0.000624896891347
Gc6_1040 0 n12 ns1040 0 -8.00397481481e-05
Gc6_1041 0 n12 ns1041 0 0.000186396808512
Gc6_1042 0 n12 ns1042 0 -0.00084803891127
Gc6_1043 0 n12 ns1043 0 0.000748708444208
Gc6_1044 0 n12 ns1044 0 -0.000445922114756
Gc6_1045 0 n12 ns1045 0 0.000511445401804
Gc6_1046 0 n12 ns1046 0 -0.000836042201122
Gc6_1047 0 n12 ns1047 0 -0.00222816842638
Gc6_1048 0 n12 ns1048 0 0.00030206252358
Gc6_1049 0 n12 ns1049 0 -0.00575894455626
Gc6_1050 0 n12 ns1050 0 -0.000852779332514
Gc6_1051 0 n12 ns1051 0 -0.00467058309343
Gc6_1052 0 n12 ns1052 0 -0.00162896941387
Gc6_1053 0 n12 ns1053 0 0.00229713116257
Gc6_1054 0 n12 ns1054 0 0.000403552875065
Gc6_1055 0 n12 ns1055 0 0.000708325570478
Gc6_1056 0 n12 ns1056 0 -0.00120949603217
Gc6_1057 0 n12 ns1057 0 -0.00095506545841
Gc6_1058 0 n12 ns1058 0 -0.00222064213883
Gc6_1059 0 n12 ns1059 0 0.00224305902696
Gc6_1060 0 n12 ns1060 0 -0.00327556609893
Gc6_1061 0 n12 ns1061 0 -0.002669720531
Gc6_1062 0 n12 ns1062 0 -6.68507780773e-06
Gc6_1063 0 n12 ns1063 0 0.000188079990454
Gc6_1064 0 n12 ns1064 0 -6.10689699912e-05
Gc6_1065 0 n12 ns1065 0 0.00273663049442
Gc6_1066 0 n12 ns1066 0 -0.00385943547304
Gc6_1067 0 n12 ns1067 0 0.00629786122398
Gc6_1068 0 n12 ns1068 0 -0.00783696332637
Gc6_1069 0 n12 ns1069 0 -0.00298701234375
Gc6_1070 0 n12 ns1070 0 -0.00265388759271
Gc6_1071 0 n12 ns1071 0 0.000901739411587
Gc6_1072 0 n12 ns1072 0 0.000851141825261
Gc6_1073 0 n12 ns1073 0 -0.000515185479494
Gc6_1074 0 n12 ns1074 0 -0.00066546240833
Gc6_1075 0 n12 ns1075 0 -0.000244651028136
Gc6_1076 0 n12 ns1076 0 4.92445793861e-06
Gc6_1077 0 n12 ns1077 0 -0.000563395951477
Gc6_1078 0 n12 ns1078 0 -0.000228198950321
Gc6_1079 0 n12 ns1079 0 0.000966477662576
Gc6_1080 0 n12 ns1080 0 0.000167919094325
Gc6_1081 0 n12 ns1081 0 0.000685886407629
Gc6_1082 0 n12 ns1082 0 0.00045679797181
Gc6_1083 0 n12 ns1083 0 -2.37536481178e-05
Gc6_1084 0 n12 ns1084 0 0.000714196288418
Gc6_1085 0 n12 ns1085 0 0.000767444110907
Gc6_1086 0 n12 ns1086 0 -0.00302005881348
Gc6_1087 0 n12 ns1087 0 -0.00233244983695
Gc6_1088 0 n12 ns1088 0 -0.00681304709095
Gc6_1089 0 n12 ns1089 0 -0.00163706988953
Gc6_1090 0 n12 ns1090 0 -0.00645429474071
Gc6_1091 0 n12 ns1091 0 0.0058386642817
Gc6_1092 0 n12 ns1092 0 0.00788710916913
Gc6_1093 0 n12 ns1093 0 0.000749893132743
Gc6_1094 0 n12 ns1094 0 -0.0011579942332
Gc6_1095 0 n12 ns1095 0 -0.00559855896315
Gc6_1096 0 n12 ns1096 0 -0.00572972052096
Gc6_1097 0 n12 ns1097 0 0.00136699501538
Gc6_1098 0 n12 ns1098 0 0.00536118278362
Gc6_1099 0 n12 ns1099 0 -0.00426046871073
Gc6_1100 0 n12 ns1100 0 -2.0719553562e-06
Gc6_1101 0 n12 ns1101 0 0.000417866285689
Gc6_1102 0 n12 ns1102 0 -0.00023023043767
Gc6_1103 0 n12 ns1103 0 0.000915005951455
Gc6_1104 0 n12 ns1104 0 -0.00222921048173
Gc6_1105 0 n12 ns1105 0 0.00143429140868
Gc6_1106 0 n12 ns1106 0 -0.00419391476555
Gc6_1107 0 n12 ns1107 0 -0.00247737098385
Gc6_1108 0 n12 ns1108 0 -0.00108773442763
Gc6_1109 0 n12 ns1109 0 0.000889608888604
Gc6_1110 0 n12 ns1110 0 0.00032224545569
Gc6_1111 0 n12 ns1111 0 -0.000476046629699
Gc6_1112 0 n12 ns1112 0 -0.000407544689458
Gc6_1113 0 n12 ns1113 0 -0.000207927461079
Gc6_1114 0 n12 ns1114 0 4.39382397556e-05
Gc6_1115 0 n12 ns1115 0 0.000245397094987
Gc6_1116 0 n12 ns1116 0 2.03352267298e-06
Gc6_1117 0 n12 ns1117 0 0.00127277016129
Gc6_1118 0 n12 ns1118 0 -0.000517943970954
Gc6_1119 0 n12 ns1119 0 0.000934861184176
Gc6_1120 0 n12 ns1120 0 -2.30521406507e-05
Gc6_1121 0 n12 ns1121 0 0.000443194609224
Gc6_1122 0 n12 ns1122 0 -0.000107466061782
Gc6_1123 0 n12 ns1123 0 -0.000941478326735
Gc6_1124 0 n12 ns1124 0 -0.00215854790643
Gc6_1125 0 n12 ns1125 0 -0.00583267865312
Gc6_1126 0 n12 ns1126 0 -0.00436696278923
Gc6_1127 0 n12 ns1127 0 -0.00453741691147
Gc6_1128 0 n12 ns1128 0 -0.00456588572779
Gc6_1129 0 n12 ns1129 0 0.00441768441759
Gc6_1130 0 n12 ns1130 0 0.00415677710953
Gc6_1131 0 n12 ns1131 0 0.000937129008047
Gc6_1132 0 n12 ns1132 0 -0.00114541422085
Gc6_1133 0 n12 ns1133 0 -0.00313519546313
Gc6_1134 0 n12 ns1134 0 -0.00339376118292
Gc6_1135 0 n12 ns1135 0 0.00222023075044
Gc6_1136 0 n12 ns1136 0 0.0015206005526
Gc6_1137 0 n12 ns1137 0 -0.00374543048143
Gc6_1138 0 n12 ns1138 0 -1.93350295843e-06
Gc6_1139 0 n12 ns1139 0 0.000321914866712
Gc6_1140 0 n12 ns1140 0 -0.000144176873089
Gc6_1141 0 n12 ns1141 0 -0.000886635830016
Gc6_1142 0 n12 ns1142 0 0.000125080761083
Gc6_1143 0 n12 ns1143 0 -0.002493910482
Gc6_1144 0 n12 ns1144 0 0.00214383634647
Gc6_1145 0 n12 ns1145 0 -0.000486949722146
Gc6_1146 0 n12 ns1146 0 0.000894038173744
Gc6_1147 0 n12 ns1147 0 0.000417529130414
Gc6_1148 0 n12 ns1148 0 -0.00047680180417
Gc6_1149 0 n12 ns1149 0 -0.000259038790252
Gc6_1150 0 n12 ns1150 0 0.000330263266029
Gc6_1151 0 n12 ns1151 0 -0.000174839233179
Gc6_1152 0 n12 ns1152 0 9.33554127933e-05
Gc6_1153 0 n12 ns1153 0 0.00106043628305
Gc6_1154 0 n12 ns1154 0 -0.000283216931828
Gc6_1155 0 n12 ns1155 0 0.000165888916074
Gc6_1156 0 n12 ns1156 0 -0.000676723714535
Gc6_1157 0 n12 ns1157 0 0.00084980965652
Gc6_1158 0 n12 ns1158 0 -0.000567684203464
Gc6_1159 0 n12 ns1159 0 0.000473299255993
Gc6_1160 0 n12 ns1160 0 -0.000901222437825
Gc6_1161 0 n12 ns1161 0 -0.00155473376873
Gc6_1162 0 n12 ns1162 0 0.000687264658672
Gc6_1163 0 n12 ns1163 0 -0.0037131171093
Gc6_1164 0 n12 ns1164 0 -0.00270335689296
Gc6_1165 0 n12 ns1165 0 -0.00315568321484
Gc6_1166 0 n12 ns1166 0 -0.00324909390775
Gc6_1167 0 n12 ns1167 0 0.000451732990177
Gc6_1168 0 n12 ns1168 0 0.000801335687122
Gc6_1169 0 n12 ns1169 0 0.000576539577559
Gc6_1170 0 n12 ns1170 0 -0.00139699947421
Gc6_1171 0 n12 ns1171 0 -0.000188205971045
Gc6_1172 0 n12 ns1172 0 -0.00290043441403
Gc6_1173 0 n12 ns1173 0 0.00165473693139
Gc6_1174 0 n12 ns1174 0 -0.00345106608287
Gc6_1175 0 n12 ns1175 0 -0.00215827292964
Gc6_1176 0 n12 ns1176 0 -2.50961408689e-05
Gc6_1177 0 n12 ns1177 0 0.000136198164317
Gc6_1178 0 n12 ns1178 0 -2.0321279138e-05
Gc6_1179 0 n12 ns1179 0 9.03799541461e-05
Gc6_1180 0 n12 ns1180 0 -0.000884712385959
Gc6_1181 0 n12 ns1181 0 0.000160481260719
Gc6_1182 0 n12 ns1182 0 0.000287591549182
Gc6_1183 0 n12 ns1183 0 -7.53063758614e-05
Gc6_1184 0 n12 ns1184 0 -0.000234398037857
Gc6_1185 0 n12 ns1185 0 -9.00239662888e-05
Gc6_1186 0 n12 ns1186 0 0.000141082605248
Gc6_1187 0 n12 ns1187 0 0.000205454100182
Gc6_1188 0 n12 ns1188 0 0.000593620104456
Gc6_1189 0 n12 ns1189 0 -0.000174022886524
Gc6_1190 0 n12 ns1190 0 2.67325374871e-05
Gc6_1191 0 n12 ns1191 0 -9.70963990194e-05
Gc6_1192 0 n12 ns1192 0 -0.000254014430791
Gc6_1193 0 n12 ns1193 0 0.000150940147544
Gc6_1194 0 n12 ns1194 0 0.00109348020611
Gc6_1195 0 n12 ns1195 0 0.000847893605443
Gc6_1196 0 n12 ns1196 0 -7.61361024821e-05
Gc6_1197 0 n12 ns1197 0 0.000478963738777
Gc6_1198 0 n12 ns1198 0 3.11020944782e-05
Gc6_1199 0 n12 ns1199 0 0.000250032745859
Gc6_1200 0 n12 ns1200 0 0.000348403102462
Gc6_1201 0 n12 ns1201 0 -0.000903764910023
Gc6_1202 0 n12 ns1202 0 -0.00654767133872
Gc6_1203 0 n12 ns1203 0 -0.00114985433319
Gc6_1204 0 n12 ns1204 0 -0.00612965961867
Gc6_1205 0 n12 ns1205 0 -0.00154092071817
Gc6_1206 0 n12 ns1206 0 0.000996214280129
Gc6_1207 0 n12 ns1207 0 0.000110136222886
Gc6_1208 0 n12 ns1208 0 -0.00108270771137
Gc6_1209 0 n12 ns1209 0 0.000232110191902
Gc6_1210 0 n12 ns1210 0 -0.00238601419191
Gc6_1211 0 n12 ns1211 0 0.000555601616534
Gc6_1212 0 n12 ns1212 0 -0.00168150308595
Gc6_1213 0 n12 ns1213 0 -0.000788198945043
Gc6_1214 0 n12 ns1214 0 -1.19766815558e-05
Gc6_1215 0 n12 ns1215 0 6.06370495814e-05
Gc6_1216 0 n12 ns1216 0 3.30442820099e-06
Gd6_1 0 n12 ni1 0 0.000225589300604
Gd6_2 0 n12 ni2 0 0.000278025182669
Gd6_3 0 n12 ni3 0 0.000420595440091
Gd6_4 0 n12 ni4 0 -0.000237536947197
Gd6_5 0 n12 ni5 0 -0.00141419617936
Gd6_6 0 n12 ni6 0 0.00102194644741
Gd6_7 0 n12 ni7 0 -0.00183681437331
Gd6_8 0 n12 ni8 0 -0.000616697233918
Gd6_9 0 n12 ni9 0 -4.63735919882e-05
Gd6_10 0 n12 ni10 0 0.000236379606774
Gd6_11 0 n12 ni11 0 0.000552371679097
Gd6_12 0 n12 ni12 0 -0.00136824293286
Gd6_13 0 n12 ni13 0 -0.000269976036377
Gd6_14 0 n12 ni14 0 -0.0029086200121
Gd6_15 0 n12 ni15 0 -0.00159917275217
Gd6_16 0 n12 ni16 0 0.000108839626291
Gd6_17 0 n12 ni17 0 0.000541841470357
Gd6_18 0 n12 ni18 0 0.000233639849467
Gd6_19 0 n12 ni19 0 -8.50205641218e-05
Gd6_20 0 n12 ni20 0 9.33066743097e-05
Gd6_21 0 n12 ni21 0 -1.61030373076e-05
Gd6_22 0 n12 ni22 0 -0.000386502092619
Gd6_23 0 n12 ni23 0 0.000576099158723
Gd6_24 0 n12 ni24 0 0.000573067820268
Gd6_25 0 n12 ni25 0 2.15213479982e-05
Gd6_26 0 n12 ni26 0 1.56824983129e-05
Gd6_27 0 n12 ni27 0 -0.00059000490967
Gd6_28 0 n12 ni28 0 0.000681823062058
Gd6_29 0 n12 ni29 0 -0.00397472912353
Gd6_30 0 n12 ni30 0 -0.00182033486556
Gd6_31 0 n12 ni31 0 0.000719841056073
Gd6_32 0 n12 ni32 0 -0.000438678419898
Gc7_1 0 n14 ns1 0 0.000436149144582
Gc7_2 0 n14 ns2 0 1.73120610369e-05
Gc7_3 0 n14 ns3 0 0.00139803729024
Gc7_4 0 n14 ns4 0 -0.000144587006562
Gc7_5 0 n14 ns5 0 9.64790481309e-05
Gc7_6 0 n14 ns6 0 -8.73360647508e-05
Gc7_7 0 n14 ns7 0 -2.60094783035e-05
Gc7_8 0 n14 ns8 0 0.000116762448531
Gc7_9 0 n14 ns9 0 0.000254263950264
Gc7_10 0 n14 ns10 0 0.000161760277583
Gc7_11 0 n14 ns11 0 -6.11883887532e-05
Gc7_12 0 n14 ns12 0 -6.43279821983e-05
Gc7_13 0 n14 ns13 0 -0.000298169014676
Gc7_14 0 n14 ns14 0 -0.000202618902587
Gc7_15 0 n14 ns15 0 -0.000289598011079
Gc7_16 0 n14 ns16 0 -0.000656533917271
Gc7_17 0 n14 ns17 0 -0.000386772967411
Gc7_18 0 n14 ns18 0 -0.000366159867897
Gc7_19 0 n14 ns19 0 -0.000390504670047
Gc7_20 0 n14 ns20 0 -0.000521899292212
Gc7_21 0 n14 ns21 0 0.000709586201441
Gc7_22 0 n14 ns22 0 0.00022350804727
Gc7_23 0 n14 ns23 0 0.00275041975697
Gc7_24 0 n14 ns24 0 -0.000657383856526
Gc7_25 0 n14 ns25 0 0.00237041065625
Gc7_26 0 n14 ns26 0 -0.000664273823923
Gc7_27 0 n14 ns27 0 0.00050542093486
Gc7_28 0 n14 ns28 0 0.0002731278238
Gc7_29 0 n14 ns29 0 -0.000187006348328
Gc7_30 0 n14 ns30 0 -0.000119141318788
Gc7_31 0 n14 ns31 0 -0.000810595063437
Gc7_32 0 n14 ns32 0 -0.000297388797887
Gc7_33 0 n14 ns33 0 -0.000337863240282
Gc7_34 0 n14 ns34 0 -0.000165610643163
Gc7_35 0 n14 ns35 0 5.22678951586e-05
Gc7_36 0 n14 ns36 0 1.62152739295e-05
Gc7_37 0 n14 ns37 0 -5.60723953368e-05
Gc7_38 0 n14 ns38 0 1.59207831589e-05
Gc7_39 0 n14 ns39 0 0.000149141375717
Gc7_40 0 n14 ns40 0 0.000337007943876
Gc7_41 0 n14 ns41 0 0.000691261394888
Gc7_42 0 n14 ns42 0 0.000344104822687
Gc7_43 0 n14 ns43 0 -3.78040574337e-05
Gc7_44 0 n14 ns44 0 9.07879601936e-05
Gc7_45 0 n14 ns45 0 9.3563364117e-06
Gc7_46 0 n14 ns46 0 1.12106763582e-05
Gc7_47 0 n14 ns47 0 0.000217561637372
Gc7_48 0 n14 ns48 0 0.000312208860902
Gc7_49 0 n14 ns49 0 -4.10047339537e-05
Gc7_50 0 n14 ns50 0 -9.05953148975e-05
Gc7_51 0 n14 ns51 0 -0.00017958511977
Gc7_52 0 n14 ns52 0 -0.000344339153057
Gc7_53 0 n14 ns53 0 -4.9947774505e-05
Gc7_54 0 n14 ns54 0 -0.000799925557456
Gc7_55 0 n14 ns55 0 -0.000315778281205
Gc7_56 0 n14 ns56 0 -0.000500961407192
Gc7_57 0 n14 ns57 0 -0.000261119974871
Gc7_58 0 n14 ns58 0 -0.000622937494098
Gc7_59 0 n14 ns59 0 0.000643945404804
Gc7_60 0 n14 ns60 0 0.000444930008071
Gc7_61 0 n14 ns61 0 0.00315980729919
Gc7_62 0 n14 ns62 0 -0.000187363432381
Gc7_63 0 n14 ns63 0 0.00276530982194
Gc7_64 0 n14 ns64 0 -0.000285458341641
Gc7_65 0 n14 ns65 0 0.00058052345906
Gc7_66 0 n14 ns66 0 0.000499054785393
Gc7_67 0 n14 ns67 0 -0.000239809394907
Gc7_68 0 n14 ns68 0 -0.000176703469771
Gc7_69 0 n14 ns69 0 -0.000987776045123
Gc7_70 0 n14 ns70 0 -0.000490684441257
Gc7_71 0 n14 ns71 0 -0.00040542656766
Gc7_72 0 n14 ns72 0 -0.000245508502566
Gc7_73 0 n14 ns73 0 4.93680338524e-05
Gc7_74 0 n14 ns74 0 1.23571775576e-05
Gc7_75 0 n14 ns75 0 -1.23583865387e-05
Gc7_76 0 n14 ns76 0 -1.11022643803e-05
Gc7_77 0 n14 ns77 0 -0.000347254169428
Gc7_78 0 n14 ns78 0 0.000598229113309
Gc7_79 0 n14 ns79 0 -0.00073757366094
Gc7_80 0 n14 ns80 0 0.00141762134229
Gc7_81 0 n14 ns81 0 -0.000225816188435
Gc7_82 0 n14 ns82 0 0.000335653233946
Gc7_83 0 n14 ns83 0 9.34835595156e-05
Gc7_84 0 n14 ns84 0 -0.00024256608795
Gc7_85 0 n14 ns85 0 -0.000141848702737
Gc7_86 0 n14 ns86 0 0.000442509732354
Gc7_87 0 n14 ns87 0 7.39931020281e-05
Gc7_88 0 n14 ns88 0 -0.000154190155283
Gc7_89 0 n14 ns89 0 5.93926435625e-05
Gc7_90 0 n14 ns90 0 -0.000459767143831
Gc7_91 0 n14 ns91 0 0.000822031145782
Gc7_92 0 n14 ns92 0 -0.000467166562339
Gc7_93 0 n14 ns93 0 0.000207964449659
Gc7_94 0 n14 ns94 0 -0.000672388155418
Gc7_95 0 n14 ns95 0 0.000308743429018
Gc7_96 0 n14 ns96 0 -0.000579045202274
Gc7_97 0 n14 ns97 0 -0.000117368550931
Gc7_98 0 n14 ns98 0 0.000927191767004
Gc7_99 0 n14 ns99 0 0.00327029183627
Gc7_100 0 n14 ns100 0 0.00249542664405
Gc7_101 0 n14 ns101 0 0.00307505900103
Gc7_102 0 n14 ns102 0 0.00205360960218
Gc7_103 0 n14 ns103 0 0.000373244825192
Gc7_104 0 n14 ns104 0 0.00136373028255
Gc7_105 0 n14 ns105 0 -0.000346094530282
Gc7_106 0 n14 ns106 0 -0.000466745446148
Gc7_107 0 n14 ns107 0 -0.00127520011598
Gc7_108 0 n14 ns108 0 -0.00137315179526
Gc7_109 0 n14 ns109 0 -0.000550516516414
Gc7_110 0 n14 ns110 0 -0.000508308377561
Gc7_111 0 n14 ns111 0 4.28552298963e-05
Gc7_112 0 n14 ns112 0 2.1648036074e-06
Gc7_113 0 n14 ns113 0 -1.58891711146e-06
Gc7_114 0 n14 ns114 0 -4.07211004667e-05
Gc7_115 0 n14 ns115 0 -0.000140559921261
Gc7_116 0 n14 ns116 0 0.000126062165615
Gc7_117 0 n14 ns117 0 -2.71938208115e-05
Gc7_118 0 n14 ns118 0 0.000999133820647
Gc7_119 0 n14 ns119 0 2.27829986488e-05
Gc7_120 0 n14 ns120 0 0.000173423142614
Gc7_121 0 n14 ns121 0 0.000153419180332
Gc7_122 0 n14 ns122 0 -8.32666267863e-05
Gc7_123 0 n14 ns123 0 -0.000134814887548
Gc7_124 0 n14 ns124 0 -7.06162740617e-05
Gc7_125 0 n14 ns125 0 0.000141366728961
Gc7_126 0 n14 ns126 0 -0.000142124436238
Gc7_127 0 n14 ns127 0 -0.000282411842347
Gc7_128 0 n14 ns128 0 -0.000355418900004
Gc7_129 0 n14 ns129 0 0.00018439008302
Gc7_130 0 n14 ns130 0 0.000499902524503
Gc7_131 0 n14 ns131 0 0.000300618908271
Gc7_132 0 n14 ns132 0 -0.000425928850212
Gc7_133 0 n14 ns133 0 -7.96449684076e-05
Gc7_134 0 n14 ns134 0 -0.000374145124686
Gc7_135 0 n14 ns135 0 -0.000494853139913
Gc7_136 0 n14 ns136 0 -0.000256560277454
Gc7_137 0 n14 ns137 0 0.00207558134751
Gc7_138 0 n14 ns138 0 0.00335624835438
Gc7_139 0 n14 ns139 0 0.00218337451178
Gc7_140 0 n14 ns140 0 0.00315789815065
Gc7_141 0 n14 ns141 0 -0.00113527050939
Gc7_142 0 n14 ns142 0 0.00096616509659
Gc7_143 0 n14 ns143 0 -0.000154848547578
Gc7_144 0 n14 ns144 0 -0.000834958238038
Gc7_145 0 n14 ns145 0 -0.000502455492025
Gc7_146 0 n14 ns146 0 -0.00165127114172
Gc7_147 0 n14 ns147 0 -0.000635790407923
Gc7_148 0 n14 ns148 0 0.00057747638444
Gc7_149 0 n14 ns149 0 0.000457204363968
Gc7_150 0 n14 ns150 0 2.45340585805e-05
Gc7_151 0 n14 ns151 0 -0.00013884641086
Gc7_152 0 n14 ns152 0 1.71582351481e-05
Gc7_153 0 n14 ns153 0 2.15417402964e-05
Gc7_154 0 n14 ns154 0 -0.00053679043587
Gc7_155 0 n14 ns155 0 0.000196889155257
Gc7_156 0 n14 ns156 0 -0.000191591034448
Gc7_157 0 n14 ns157 0 -0.000350336454191
Gc7_158 0 n14 ns158 0 0.000385090909091
Gc7_159 0 n14 ns159 0 2.12380789327e-05
Gc7_160 0 n14 ns160 0 -0.000118240914565
Gc7_161 0 n14 ns161 0 0.000305038867882
Gc7_162 0 n14 ns162 0 -0.000142178213289
Gc7_163 0 n14 ns163 0 0.000178361019425
Gc7_164 0 n14 ns164 0 -6.6323946176e-05
Gc7_165 0 n14 ns165 0 6.76229824509e-05
Gc7_166 0 n14 ns166 0 -0.000258054102077
Gc7_167 0 n14 ns167 0 -0.000764376993511
Gc7_168 0 n14 ns168 0 -0.00028562591093
Gc7_169 0 n14 ns169 0 0.000258006082148
Gc7_170 0 n14 ns170 0 -0.000508003096815
Gc7_171 0 n14 ns171 0 -0.000261896560282
Gc7_172 0 n14 ns172 0 -0.000877810830126
Gc7_173 0 n14 ns173 0 0.00115552858724
Gc7_174 0 n14 ns174 0 -0.000806187840252
Gc7_175 0 n14 ns175 0 0.00196511894475
Gc7_176 0 n14 ns176 0 0.00271503249185
Gc7_177 0 n14 ns177 0 0.00182353161206
Gc7_178 0 n14 ns178 0 0.00305070672494
Gc7_179 0 n14 ns179 0 -0.00145703221065
Gc7_180 0 n14 ns180 0 -0.00162490855939
Gc7_181 0 n14 ns181 0 0.000439362824496
Gc7_182 0 n14 ns182 0 -0.00101700655942
Gc7_183 0 n14 ns183 0 0.000388698505441
Gc7_184 0 n14 ns184 0 -0.000536933985149
Gc7_185 0 n14 ns185 0 -0.00138032393919
Gc7_186 0 n14 ns186 0 0.00288911064628
Gc7_187 0 n14 ns187 0 0.00157508909681
Gc7_188 0 n14 ns188 0 1.67292484757e-05
Gc7_189 0 n14 ns189 0 -0.000189844200799
Gc7_190 0 n14 ns190 0 5.71630328949e-05
Gc7_191 0 n14 ns191 0 0.000534714816461
Gc7_192 0 n14 ns192 0 -0.00219706338715
Gc7_193 0 n14 ns193 0 0.00111545260384
Gc7_194 0 n14 ns194 0 -0.000584314349578
Gc7_195 0 n14 ns195 0 -0.000723940834749
Gc7_196 0 n14 ns196 0 0.000222140557202
Gc7_197 0 n14 ns197 0 0.000235680052402
Gc7_198 0 n14 ns198 0 -0.000418662878719
Gc7_199 0 n14 ns199 0 0.000272943213753
Gc7_200 0 n14 ns200 0 0.000420281719301
Gc7_201 0 n14 ns201 0 0.00025260697837
Gc7_202 0 n14 ns202 0 -5.39600544247e-05
Gc7_203 0 n14 ns203 0 -0.000421364803035
Gc7_204 0 n14 ns204 0 -6.54522571982e-06
Gc7_205 0 n14 ns205 0 0.000728424869997
Gc7_206 0 n14 ns206 0 -0.00102226877588
Gc7_207 0 n14 ns207 0 0.00086308378775
Gc7_208 0 n14 ns208 0 -0.000552019107075
Gc7_209 0 n14 ns209 0 0.000462475527648
Gc7_210 0 n14 ns210 0 -0.00107288421078
Gc7_211 0 n14 ns211 0 0.00103734319596
Gc7_212 0 n14 ns212 0 0.00227131535509
Gc7_213 0 n14 ns213 0 0.00334993064509
Gc7_214 0 n14 ns214 0 0.00494827303082
Gc7_215 0 n14 ns215 0 0.00260343470958
Gc7_216 0 n14 ns216 0 0.00505726889296
Gc7_217 0 n14 ns217 0 0.00367443710556
Gc7_218 0 n14 ns218 0 0.000380570849305
Gc7_219 0 n14 ns219 0 0.000889354761433
Gc7_220 0 n14 ns220 0 -0.000978988872776
Gc7_221 0 n14 ns221 0 -0.00194932637177
Gc7_222 0 n14 ns222 0 -0.00131254052747
Gc7_223 0 n14 ns223 0 -0.00393098864319
Gc7_224 0 n14 ns224 0 -0.00032334131313
Gc7_225 0 n14 ns225 0 0.00308169547355
Gc7_226 0 n14 ns226 0 5.01279010787e-05
Gc7_227 0 n14 ns227 0 -0.000187137152742
Gc7_228 0 n14 ns228 0 5.83769487741e-05
Gc7_229 0 n14 ns229 0 0.00033615482627
Gc7_230 0 n14 ns230 0 -0.00261180293489
Gc7_231 0 n14 ns231 0 -0.00188738669799
Gc7_232 0 n14 ns232 0 -0.000280137185614
Gc7_233 0 n14 ns233 0 -0.000658065380509
Gc7_234 0 n14 ns234 0 7.21542605965e-05
Gc7_235 0 n14 ns235 0 0.000348528280593
Gc7_236 0 n14 ns236 0 -0.000219136944822
Gc7_237 0 n14 ns237 0 -0.00021352294896
Gc7_238 0 n14 ns238 0 0.000288041113867
Gc7_239 0 n14 ns239 0 0.000310976056082
Gc7_240 0 n14 ns240 0 4.12643727186e-05
Gc7_241 0 n14 ns241 0 -0.000366837426418
Gc7_242 0 n14 ns242 0 -0.000275988375222
Gc7_243 0 n14 ns243 0 0.000671856748109
Gc7_244 0 n14 ns244 0 0.000448076774038
Gc7_245 0 n14 ns245 0 0.000661281194025
Gc7_246 0 n14 ns246 0 -0.000130019121339
Gc7_247 0 n14 ns247 0 -0.000127391972218
Gc7_248 0 n14 ns248 0 -0.000918911182026
Gc7_249 0 n14 ns249 0 -0.00101326317508
Gc7_250 0 n14 ns250 0 0.000363814643447
Gc7_251 0 n14 ns251 0 0.00644884042359
Gc7_252 0 n14 ns252 0 0.00633034196932
Gc7_253 0 n14 ns253 0 0.00483371491702
Gc7_254 0 n14 ns254 0 0.00625966893371
Gc7_255 0 n14 ns255 0 0.000774295215181
Gc7_256 0 n14 ns256 0 0.00551319745216
Gc7_257 0 n14 ns257 0 0.000961719066041
Gc7_258 0 n14 ns258 0 -0.000851681972829
Gc7_259 0 n14 ns259 0 -0.00584104066672
Gc7_260 0 n14 ns260 0 -0.00164812567038
Gc7_261 0 n14 ns261 0 0.00284351027769
Gc7_262 0 n14 ns262 0 -0.00450297965302
Gc7_263 0 n14 ns263 0 0.00470134979063
Gc7_264 0 n14 ns264 0 -3.34554996267e-06
Gc7_265 0 n14 ns265 0 0.000109215317115
Gc7_266 0 n14 ns266 0 -0.000158851324958
Gc7_267 0 n14 ns267 0 0.000328938205425
Gc7_268 0 n14 ns268 0 -0.00258343227588
Gc7_269 0 n14 ns269 0 0.000214377650002
Gc7_270 0 n14 ns270 0 -0.00146455682804
Gc7_271 0 n14 ns271 0 -0.000868583841574
Gc7_272 0 n14 ns272 0 5.07429205468e-05
Gc7_273 0 n14 ns273 0 0.000400414581074
Gc7_274 0 n14 ns274 0 -0.000401288832572
Gc7_275 0 n14 ns275 0 0.000134621131758
Gc7_276 0 n14 ns276 0 -1.67659758717e-05
Gc7_277 0 n14 ns277 0 0.000266014561295
Gc7_278 0 n14 ns278 0 8.21433385564e-05
Gc7_279 0 n14 ns279 0 -0.000268207640411
Gc7_280 0 n14 ns280 0 0.000481267310865
Gc7_281 0 n14 ns281 0 0.000585451380786
Gc7_282 0 n14 ns282 0 4.82711924792e-05
Gc7_283 0 n14 ns283 0 0.00109008561112
Gc7_284 0 n14 ns284 0 0.000164769380667
Gc7_285 0 n14 ns285 0 0.000547372631917
Gc7_286 0 n14 ns286 0 -0.000157985458602
Gc7_287 0 n14 ns287 0 0.000181085208482
Gc7_288 0 n14 ns288 0 0.00154059851711
Gc7_289 0 n14 ns289 0 -0.000106083806611
Gc7_290 0 n14 ns290 0 0.00470693482602
Gc7_291 0 n14 ns291 0 -0.000373200010756
Gc7_292 0 n14 ns292 0 0.00501685424282
Gc7_293 0 n14 ns293 0 0.00269210676775
Gc7_294 0 n14 ns294 0 8.61832193831e-05
Gc7_295 0 n14 ns295 0 0.00111605562877
Gc7_296 0 n14 ns296 0 -0.000981348390723
Gc7_297 0 n14 ns297 0 -0.000960426112386
Gc7_298 0 n14 ns298 0 -0.00114754594994
Gc7_299 0 n14 ns299 0 -0.00363613250412
Gc7_300 0 n14 ns300 0 0.000174280333877
Gc7_301 0 n14 ns301 0 0.00316618898994
Gc7_302 0 n14 ns302 0 1.74247093075e-05
Gc7_303 0 n14 ns303 0 -0.000152567956476
Gc7_304 0 n14 ns304 0 1.62612854325e-05
Gc7_305 0 n14 ns305 0 0.000350789928729
Gc7_306 0 n14 ns306 0 -0.000542506319473
Gc7_307 0 n14 ns307 0 0.00101628012956
Gc7_308 0 n14 ns308 0 0.000405731563775
Gc7_309 0 n14 ns309 0 -0.000166343585561
Gc7_310 0 n14 ns310 0 0.000384303311903
Gc7_311 0 n14 ns311 0 -5.79894708374e-05
Gc7_312 0 n14 ns312 0 3.13524033456e-05
Gc7_313 0 n14 ns313 0 0.000651763848368
Gc7_314 0 n14 ns314 0 -0.000262368351583
Gc7_315 0 n14 ns315 0 0.000170987215435
Gc7_316 0 n14 ns316 0 3.99433830351e-05
Gc7_317 0 n14 ns317 0 4.8058521226e-06
Gc7_318 0 n14 ns318 0 -0.000470921626548
Gc7_319 0 n14 ns319 0 -0.00155128564832
Gc7_320 0 n14 ns320 0 -0.000299776398165
Gc7_321 0 n14 ns321 0 0.000217363758027
Gc7_322 0 n14 ns322 0 -0.000101915429615
Gc7_323 0 n14 ns323 0 -0.000238490369084
Gc7_324 0 n14 ns324 0 -0.000747248296691
Gc7_325 0 n14 ns325 0 0.00142384575746
Gc7_326 0 n14 ns326 0 -0.00130473462135
Gc7_327 0 n14 ns327 0 -0.00129850589181
Gc7_328 0 n14 ns328 0 0.0020654270739
Gc7_329 0 n14 ns329 0 -0.00120235584629
Gc7_330 0 n14 ns330 0 0.00263101813658
Gc7_331 0 n14 ns331 0 -0.00156812090186
Gc7_332 0 n14 ns332 0 -0.00229477918947
Gc7_333 0 n14 ns333 0 0.000746970540024
Gc7_334 0 n14 ns334 0 -0.000915534679456
Gc7_335 0 n14 ns335 0 0.00116680413537
Gc7_336 0 n14 ns336 0 -0.000279143841488
Gc7_337 0 n14 ns337 0 -0.00123081141284
Gc7_338 0 n14 ns338 0 0.00247440422776
Gc7_339 0 n14 ns339 0 0.00148710802199
Gc7_340 0 n14 ns340 0 3.92089340569e-05
Gc7_341 0 n14 ns341 0 -0.00034070177428
Gc7_342 0 n14 ns342 0 0.000138389204668
Gc7_343 0 n14 ns343 0 2.39531448383e-05
Gc7_344 0 n14 ns344 0 0.000340604093819
Gc7_345 0 n14 ns345 0 0.000157457341037
Gc7_346 0 n14 ns346 0 0.000531029752705
Gc7_347 0 n14 ns347 0 -4.67123203308e-05
Gc7_348 0 n14 ns348 0 3.84207029243e-05
Gc7_349 0 n14 ns349 0 -2.95809902888e-05
Gc7_350 0 n14 ns350 0 -2.09392961412e-05
Gc7_351 0 n14 ns351 0 -3.29829968938e-05
Gc7_352 0 n14 ns352 0 0.000361516058014
Gc7_353 0 n14 ns353 0 -4.25934304731e-06
Gc7_354 0 n14 ns354 0 -0.000120721514128
Gc7_355 0 n14 ns355 0 -2.08819481854e-05
Gc7_356 0 n14 ns356 0 -0.000232368750278
Gc7_357 0 n14 ns357 0 0.000440586639164
Gc7_358 0 n14 ns358 0 -0.000605604881961
Gc7_359 0 n14 ns359 0 -7.94589326673e-05
Gc7_360 0 n14 ns360 0 -0.000571474114803
Gc7_361 0 n14 ns361 0 -1.42780533469e-05
Gc7_362 0 n14 ns362 0 -0.000540671987029
Gc7_363 0 n14 ns363 0 0.000245208173303
Gc7_364 0 n14 ns364 0 0.000685560677018
Gc7_365 0 n14 ns365 0 0.00352809992352
Gc7_366 0 n14 ns366 0 0.00100669800447
Gc7_367 0 n14 ns367 0 0.00320002708257
Gc7_368 0 n14 ns368 0 0.000749828477031
Gc7_369 0 n14 ns369 0 0.000419678309961
Gc7_370 0 n14 ns370 0 0.000931767092785
Gc7_371 0 n14 ns371 0 -0.000309903695796
Gc7_372 0 n14 ns372 0 -0.000336843965547
Gc7_373 0 n14 ns373 0 -0.00118280766399
Gc7_374 0 n14 ns374 0 -0.000902858766413
Gc7_375 0 n14 ns375 0 -0.00049372451303
Gc7_376 0 n14 ns376 0 -0.000156625061033
Gc7_377 0 n14 ns377 0 0.000108676368349
Gc7_378 0 n14 ns378 0 1.81991568117e-05
Gc7_379 0 n14 ns379 0 -2.66016559501e-05
Gc7_380 0 n14 ns380 0 -1.49623500297e-05
Gc7_381 0 n14 ns381 0 -0.000114287279238
Gc7_382 0 n14 ns382 0 0.000156296893137
Gc7_383 0 n14 ns383 0 -8.30346566462e-06
Gc7_384 0 n14 ns384 0 0.00104629532845
Gc7_385 0 n14 ns385 0 1.35394159839e-06
Gc7_386 0 n14 ns386 0 0.000146198325062
Gc7_387 0 n14 ns387 0 0.000113416990558
Gc7_388 0 n14 ns388 0 -0.000149700870085
Gc7_389 0 n14 ns389 0 -0.000191549275814
Gc7_390 0 n14 ns390 0 0.000107816191154
Gc7_391 0 n14 ns391 0 0.000101386168957
Gc7_392 0 n14 ns392 0 -0.000157833209731
Gc7_393 0 n14 ns393 0 -0.000247658844003
Gc7_394 0 n14 ns394 0 -0.000283472623272
Gc7_395 0 n14 ns395 0 0.000551177821309
Gc7_396 0 n14 ns396 0 0.000237658836891
Gc7_397 0 n14 ns397 0 0.000283932407251
Gc7_398 0 n14 ns398 0 -0.000499231226771
Gc7_399 0 n14 ns399 0 8.63361486007e-05
Gc7_400 0 n14 ns400 0 -0.000383394881209
Gc7_401 0 n14 ns401 0 -0.000498361630326
Gc7_402 0 n14 ns402 0 0.000281692818174
Gc7_403 0 n14 ns403 0 0.00260054177503
Gc7_404 0 n14 ns404 0 0.00322580149896
Gc7_405 0 n14 ns405 0 0.00260422945222
Gc7_406 0 n14 ns406 0 0.00287602477117
Gc7_407 0 n14 ns407 0 -0.000513009437565
Gc7_408 0 n14 ns408 0 0.00132230254882
Gc7_409 0 n14 ns409 0 -0.000265686086667
Gc7_410 0 n14 ns410 0 -0.000696638018213
Gc7_411 0 n14 ns411 0 -0.000881242801632
Gc7_412 0 n14 ns412 0 -0.00166953488305
Gc7_413 0 n14 ns413 0 -0.000592790835397
Gc7_414 0 n14 ns414 0 -1.55839773314e-05
Gc7_415 0 n14 ns415 0 0.000235375691678
Gc7_416 0 n14 ns416 0 1.15375088229e-05
Gc7_417 0 n14 ns417 0 -7.75177084309e-05
Gc7_418 0 n14 ns418 0 -6.87653907303e-06
Gc7_419 0 n14 ns419 0 -0.000320611598225
Gc7_420 0 n14 ns420 0 0.000134474477006
Gc7_421 0 n14 ns421 0 -0.000641678308413
Gc7_422 0 n14 ns422 0 0.00052921405704
Gc7_423 0 n14 ns423 0 -0.000100797297853
Gc7_424 0 n14 ns424 0 0.00043589618877
Gc7_425 0 n14 ns425 0 4.36842453636e-05
Gc7_426 0 n14 ns426 0 -8.44467453519e-05
Gc7_427 0 n14 ns427 0 9.47741533802e-05
Gc7_428 0 n14 ns428 0 -0.000246135065788
Gc7_429 0 n14 ns429 0 0.000150831716452
Gc7_430 0 n14 ns430 0 -7.48410584044e-05
Gc7_431 0 n14 ns431 0 1.72470605405e-05
Gc7_432 0 n14 ns432 0 -0.000341642462113
Gc7_433 0 n14 ns433 0 -0.000579957965176
Gc7_434 0 n14 ns434 0 0.000308556591388
Gc7_435 0 n14 ns435 0 0.000201124731651
Gc7_436 0 n14 ns436 0 -0.000340720103715
Gc7_437 0 n14 ns437 0 -0.000328292700094
Gc7_438 0 n14 ns438 0 -0.000508705358877
Gc7_439 0 n14 ns439 0 0.000278475491948
Gc7_440 0 n14 ns440 0 -0.00113603446334
Gc7_441 0 n14 ns441 0 0.0013919096419
Gc7_442 0 n14 ns442 0 0.0023812388816
Gc7_443 0 n14 ns443 0 0.00146559798761
Gc7_444 0 n14 ns444 0 0.00263674346332
Gc7_445 0 n14 ns445 0 -0.00214695430976
Gc7_446 0 n14 ns446 0 -0.00070640983092
Gc7_447 0 n14 ns447 0 0.000234777377983
Gc7_448 0 n14 ns448 0 -0.000980096177746
Gc7_449 0 n14 ns449 0 0.000489003772471
Gc7_450 0 n14 ns450 0 -0.000920725711849
Gc7_451 0 n14 ns451 0 -0.000834095208254
Gc7_452 0 n14 ns452 0 0.00242725789605
Gc7_453 0 n14 ns453 0 0.0011380035456
Gc7_454 0 n14 ns454 0 1.90971445786e-05
Gc7_455 0 n14 ns455 0 -0.000180184795278
Gc7_456 0 n14 ns456 0 5.40814505402e-05
Gc7_457 0 n14 ns457 0 0.000455086048131
Gc7_458 0 n14 ns458 0 -0.00182188103591
Gc7_459 0 n14 ns459 0 0.00109551450277
Gc7_460 0 n14 ns460 0 -0.00147478478939
Gc7_461 0 n14 ns461 0 -0.000773671149025
Gc7_462 0 n14 ns462 0 -5.92086579411e-05
Gc7_463 0 n14 ns463 0 0.000159302295481
Gc7_464 0 n14 ns464 0 -0.000222492640851
Gc7_465 0 n14 ns465 0 0.000269399123324
Gc7_466 0 n14 ns466 0 0.000156679960537
Gc7_467 0 n14 ns467 0 0.000195224411781
Gc7_468 0 n14 ns468 0 -2.90500971732e-05
Gc7_469 0 n14 ns469 0 4.98317618401e-05
Gc7_470 0 n14 ns470 0 0.000396483579835
Gc7_471 0 n14 ns471 0 0.000163024832115
Gc7_472 0 n14 ns472 0 -0.000916212545149
Gc7_473 0 n14 ns473 0 0.000685135415135
Gc7_474 0 n14 ns474 0 -0.000488899228756
Gc7_475 0 n14 ns475 0 0.000333729501242
Gc7_476 0 n14 ns476 0 -0.000806598925386
Gc7_477 0 n14 ns477 0 0.00163058382008
Gc7_478 0 n14 ns478 0 0.00115612538566
Gc7_479 0 n14 ns479 0 0.00240295607739
Gc7_480 0 n14 ns480 0 0.00381053882011
Gc7_481 0 n14 ns481 0 0.00193739251345
Gc7_482 0 n14 ns482 0 0.00404101469822
Gc7_483 0 n14 ns483 0 0.00147964465831
Gc7_484 0 n14 ns484 0 -0.00201256728509
Gc7_485 0 n14 ns485 0 0.000856958839393
Gc7_486 0 n14 ns486 0 -0.000923787824545
Gc7_487 0 n14 ns487 0 -0.000379504915176
Gc7_488 0 n14 ns488 0 -0.000272300948566
Gc7_489 0 n14 ns489 0 -0.00322603581936
Gc7_490 0 n14 ns490 0 0.00258876932785
Gc7_491 0 n14 ns491 0 0.00268397504898
Gc7_492 0 n14 ns492 0 2.32856349e-05
Gc7_493 0 n14 ns493 0 -0.000129758783692
Gc7_494 0 n14 ns494 0 2.59005262649e-05
Gc7_495 0 n14 ns495 0 0.000943738579916
Gc7_496 0 n14 ns496 0 -0.00391391374685
Gc7_497 0 n14 ns497 0 -0.000576849221335
Gc7_498 0 n14 ns498 0 -0.0013238202186
Gc7_499 0 n14 ns499 0 -0.000947503521078
Gc7_500 0 n14 ns500 0 -8.4234184953e-05
Gc7_501 0 n14 ns501 0 0.000468686735438
Gc7_502 0 n14 ns502 0 -0.000162149633628
Gc7_503 0 n14 ns503 0 -3.06020859288e-05
Gc7_504 0 n14 ns504 0 0.000440744163937
Gc7_505 0 n14 ns505 0 0.00029473588466
Gc7_506 0 n14 ns506 0 -1.43924580042e-05
Gc7_507 0 n14 ns507 0 -0.00036855512232
Gc7_508 0 n14 ns508 0 -0.000351056504363
Gc7_509 0 n14 ns509 0 0.000360663859622
Gc7_510 0 n14 ns510 0 -8.67641345506e-05
Gc7_511 0 n14 ns511 0 0.000560573399241
Gc7_512 0 n14 ns512 0 -0.000429137594928
Gc7_513 0 n14 ns513 0 -9.90004932198e-05
Gc7_514 0 n14 ns514 0 -0.00133950500322
Gc7_515 0 n14 ns515 0 -0.000275429481179
Gc7_516 0 n14 ns516 0 0.000389542735234
Gc7_517 0 n14 ns517 0 0.00685686082683
Gc7_518 0 n14 ns518 0 0.00739346346126
Gc7_519 0 n14 ns519 0 0.00518695351582
Gc7_520 0 n14 ns520 0 0.00707601097208
Gc7_521 0 n14 ns521 0 0.000693142439947
Gc7_522 0 n14 ns522 0 0.00529217796924
Gc7_523 0 n14 ns523 0 0.000858564513254
Gc7_524 0 n14 ns524 0 -0.000924256770926
Gc7_525 0 n14 ns525 0 -0.00633610519737
Gc7_526 0 n14 ns526 0 -0.00199068680561
Gc7_527 0 n14 ns527 0 0.00324901166967
Gc7_528 0 n14 ns528 0 -0.00528665494417
Gc7_529 0 n14 ns529 0 0.00454956269141
Gc7_530 0 n14 ns530 0 -4.31885662184e-06
Gc7_531 0 n14 ns531 0 -2.33495960213e-05
Gc7_532 0 n14 ns532 0 -3.89519568606e-05
Gc7_533 0 n14 ns533 0 0.00107527691263
Gc7_534 0 n14 ns534 0 -0.00477851936748
Gc7_535 0 n14 ns535 0 0.000813184344724
Gc7_536 0 n14 ns536 0 -0.0035006276361
Gc7_537 0 n14 ns537 0 -0.00117421719617
Gc7_538 0 n14 ns538 0 -0.000660919512411
Gc7_539 0 n14 ns539 0 0.000609085143368
Gc7_540 0 n14 ns540 0 -0.000145976222607
Gc7_541 0 n14 ns541 0 -9.9143941393e-05
Gc7_542 0 n14 ns542 0 0.000224949281387
Gc7_543 0 n14 ns543 0 0.000286744644495
Gc7_544 0 n14 ns544 0 4.86479859462e-05
Gc7_545 0 n14 ns545 0 -0.000366872684414
Gc7_546 0 n14 ns546 0 0.000595268888569
Gc7_547 0 n14 ns547 0 0.000706022681708
Gc7_548 0 n14 ns548 0 -2.66783076496e-05
Gc7_549 0 n14 ns549 0 0.00096169146367
Gc7_550 0 n14 ns550 0 -6.96117595777e-05
Gc7_551 0 n14 ns551 0 0.000356202354667
Gc7_552 0 n14 ns552 0 -0.000612783969647
Gc7_553 0 n14 ns553 0 0.000296636494464
Gc7_554 0 n14 ns554 0 0.00136517076749
Gc7_555 0 n14 ns555 0 0.00354788318233
Gc7_556 0 n14 ns556 0 0.00644143694199
Gc7_557 0 n14 ns557 0 0.00251258374315
Gc7_558 0 n14 ns558 0 0.0064096042496
Gc7_559 0 n14 ns559 0 0.00211225726892
Gc7_560 0 n14 ns560 0 0.00178777750695
Gc7_561 0 n14 ns561 0 0.00107071126093
Gc7_562 0 n14 ns562 0 -0.000943072005008
Gc7_563 0 n14 ns563 0 -0.00350540708603
Gc7_564 0 n14 ns564 0 -0.0011720505744
Gc7_565 0 n14 ns565 0 -0.000479136389829
Gc7_566 0 n14 ns566 0 -0.00201400575251
Gc7_567 0 n14 ns567 0 0.00383288210391
Gc7_568 0 n14 ns568 0 -5.29106247334e-06
Gc7_569 0 n14 ns569 0 -0.000115974186642
Gc7_570 0 n14 ns570 0 2.72384386936e-06
Gc7_571 0 n14 ns571 0 0.000764109707009
Gc7_572 0 n14 ns572 0 -0.0021416639848
Gc7_573 0 n14 ns573 0 0.00192466124624
Gc7_574 0 n14 ns574 0 -0.00158697497759
Gc7_575 0 n14 ns575 0 -0.000386627125799
Gc7_576 0 n14 ns576 0 -5.93244163442e-05
Gc7_577 0 n14 ns577 0 4.36304338411e-05
Gc7_578 0 n14 ns578 0 2.24231245675e-05
Gc7_579 0 n14 ns579 0 0.000555260769338
Gc7_580 0 n14 ns580 0 -0.000349135414095
Gc7_581 0 n14 ns581 0 0.000176332920662
Gc7_582 0 n14 ns582 0 7.48489323764e-05
Gc7_583 0 n14 ns583 0 -0.000128182807738
Gc7_584 0 n14 ns584 0 0.000193038276975
Gc7_585 0 n14 ns585 0 -0.00129859634229
Gc7_586 0 n14 ns586 0 -0.000261118972003
Gc7_587 0 n14 ns587 0 0.000378374983365
Gc7_588 0 n14 ns588 0 -1.40513022963e-05
Gc7_589 0 n14 ns589 0 -0.000238260686434
Gc7_590 0 n14 ns590 0 -0.000634423703396
Gc7_591 0 n14 ns591 0 0.00162061849185
Gc7_592 0 n14 ns592 0 -0.000908029704879
Gc7_593 0 n14 ns593 0 -0.00072805736888
Gc7_594 0 n14 ns594 0 0.00218775224019
Gc7_595 0 n14 ns595 0 -0.000789585721768
Gc7_596 0 n14 ns596 0 0.00288484087156
Gc7_597 0 n14 ns597 0 -0.000924921604076
Gc7_598 0 n14 ns598 0 -0.00260130168513
Gc7_599 0 n14 ns599 0 0.000977755238726
Gc7_600 0 n14 ns600 0 -0.000996124884389
Gc7_601 0 n14 ns601 0 0.00110959761753
Gc7_602 0 n14 ns602 0 -0.000197506041496
Gc7_603 0 n14 ns603 0 -0.00195969465975
Gc7_604 0 n14 ns604 0 0.00267878005592
Gc7_605 0 n14 ns605 0 0.00207492230009
Gc7_606 0 n14 ns606 0 1.28591002976e-05
Gc7_607 0 n14 ns607 0 -0.000278488650922
Gc7_608 0 n14 ns608 0 0.000109684007671
Gc7_609 0 n14 ns609 0 -0.000489599603673
Gc7_610 0 n14 ns610 0 0.000961527444084
Gc7_611 0 n14 ns611 0 -0.00133582398857
Gc7_612 0 n14 ns612 0 0.00133699419541
Gc7_613 0 n14 ns613 0 -0.000129241288839
Gc7_614 0 n14 ns614 0 0.00045719568877
Gc7_615 0 n14 ns615 0 4.78300865649e-05
Gc7_616 0 n14 ns616 0 -0.000303076691576
Gc7_617 0 n14 ns617 0 -0.000219307514076
Gc7_618 0 n14 ns618 0 1.11785933725e-05
Gc7_619 0 n14 ns619 0 0.000129014495956
Gc7_620 0 n14 ns620 0 7.12978282452e-05
Gc7_621 0 n14 ns621 0 0.000502808421063
Gc7_622 0 n14 ns622 0 -0.000451574608105
Gc7_623 0 n14 ns623 0 4.78851273791e-05
Gc7_624 0 n14 ns624 0 -0.000566765778742
Gc7_625 0 n14 ns625 0 -0.00028041111344
Gc7_626 0 n14 ns626 0 -0.000244312036909
Gc7_627 0 n14 ns627 0 -0.000289685771516
Gc7_628 0 n14 ns628 0 -0.000167605755361
Gc7_629 0 n14 ns629 0 -0.000569321511495
Gc7_630 0 n14 ns630 0 -7.79500676561e-05
Gc7_631 0 n14 ns631 0 -0.00323181266501
Gc7_632 0 n14 ns632 0 0.00104308777621
Gc7_633 0 n14 ns633 0 -0.00278507253649
Gc7_634 0 n14 ns634 0 0.000964595836391
Gc7_635 0 n14 ns635 0 0.000407046513839
Gc7_636 0 n14 ns636 0 0.000945698571002
Gc7_637 0 n14 ns637 0 -0.00020555683347
Gc7_638 0 n14 ns638 0 -0.000188383803023
Gc7_639 0 n14 ns639 0 -0.000715241551982
Gc7_640 0 n14 ns640 0 -0.000705164693039
Gc7_641 0 n14 ns641 0 -7.99715095944e-05
Gc7_642 0 n14 ns642 0 -0.000435757830817
Gc7_643 0 n14 ns643 0 -0.000146413735424
Gc7_644 0 n14 ns644 0 -1.45518055632e-05
Gc7_645 0 n14 ns645 0 4.72602168563e-05
Gc7_646 0 n14 ns646 0 3.10430157882e-06
Gc7_647 0 n14 ns647 0 -0.000238614723642
Gc7_648 0 n14 ns648 0 0.000665544561633
Gc7_649 0 n14 ns649 0 -0.000542105354563
Gc7_650 0 n14 ns650 0 0.0010649341126
Gc7_651 0 n14 ns651 0 -9.38954819794e-06
Gc7_652 0 n14 ns652 0 0.000366020058933
Gc7_653 0 n14 ns653 0 1.72883040639e-05
Gc7_654 0 n14 ns654 0 -0.000256103998133
Gc7_655 0 n14 ns655 0 -0.000152429602237
Gc7_656 0 n14 ns656 0 -0.000144942607494
Gc7_657 0 n14 ns657 0 0.000102276055841
Gc7_658 0 n14 ns658 0 9.52903992495e-05
Gc7_659 0 n14 ns659 0 0.000423757879612
Gc7_660 0 n14 ns660 0 -0.000290751910062
Gc7_661 0 n14 ns661 0 9.86669212162e-05
Gc7_662 0 n14 ns662 0 -0.000656539097319
Gc7_663 0 n14 ns663 0 -0.000318158305408
Gc7_664 0 n14 ns664 0 -0.000373831940442
Gc7_665 0 n14 ns665 0 -0.000344611115446
Gc7_666 0 n14 ns666 0 -0.000321695695676
Gc7_667 0 n14 ns667 0 -0.000505216406935
Gc7_668 0 n14 ns668 0 -0.000102381488123
Gc7_669 0 n14 ns669 0 -0.00385878634535
Gc7_670 0 n14 ns670 0 0.00103544913521
Gc7_671 0 n14 ns671 0 -0.00336088386352
Gc7_672 0 n14 ns672 0 0.000961558069213
Gc7_673 0 n14 ns673 0 0.00066522216328
Gc7_674 0 n14 ns674 0 0.00123127219076
Gc7_675 0 n14 ns675 0 -0.000285431821053
Gc7_676 0 n14 ns676 0 -0.000250591552376
Gc7_677 0 n14 ns677 0 -0.00105271595698
Gc7_678 0 n14 ns678 0 -0.000970642685916
Gc7_679 0 n14 ns679 0 -0.000166748667928
Gc7_680 0 n14 ns680 0 -0.000757265754092
Gc7_681 0 n14 ns681 0 -0.000219919885104
Gc7_682 0 n14 ns682 0 2.00084022092e-07
Gc7_683 0 n14 ns683 0 1.50842957588e-05
Gc7_684 0 n14 ns684 0 2.63928072013e-05
Gc7_685 0 n14 ns685 0 0.000334053353056
Gc7_686 0 n14 ns686 0 -0.00017872816468
Gc7_687 0 n14 ns687 0 0.00123685963041
Gc7_688 0 n14 ns688 0 -0.000399559289227
Gc7_689 0 n14 ns689 0 0.000230161092907
Gc7_690 0 n14 ns690 0 -3.13223163333e-05
Gc7_691 0 n14 ns691 0 -7.56394342627e-05
Gc7_692 0 n14 ns692 0 5.67760250528e-05
Gc7_693 0 n14 ns693 0 0.000299510657554
Gc7_694 0 n14 ns694 0 -0.000387395316541
Gc7_695 0 n14 ns695 0 -7.20515115449e-05
Gc7_696 0 n14 ns696 0 0.000110395098754
Gc7_697 0 n14 ns697 0 -0.000176285348207
Gc7_698 0 n14 ns698 0 0.000396767076671
Gc7_699 0 n14 ns699 0 0.000417318064164
Gc7_700 0 n14 ns700 0 -0.000204668423556
Gc7_701 0 n14 ns701 0 -7.69513505957e-05
Gc7_702 0 n14 ns702 0 -0.000560220431402
Gc7_703 0 n14 ns703 0 -0.000211783577692
Gc7_704 0 n14 ns704 0 -0.000510253327016
Gc7_705 0 n14 ns705 0 -4.97553997761e-05
Gc7_706 0 n14 ns706 0 -0.000362414898269
Gc7_707 0 n14 ns707 0 -0.00475944918569
Gc7_708 0 n14 ns708 0 -0.00140016706202
Gc7_709 0 n14 ns709 0 -0.00431424695275
Gc7_710 0 n14 ns710 0 -0.001176437777
Gc7_711 0 n14 ns711 0 0.000609215988706
Gc7_712 0 n14 ns712 0 0.00170759821614
Gc7_713 0 n14 ns713 0 -0.000386615127628
Gc7_714 0 n14 ns714 0 -0.000492564308642
Gc7_715 0 n14 ns715 0 -0.00142492280856
Gc7_716 0 n14 ns716 0 -0.0016286336222
Gc7_717 0 n14 ns717 0 -0.000235804679992
Gc7_718 0 n14 ns718 0 -0.00132783671748
Gc7_719 0 n14 ns719 0 -0.000380159645533
Gc7_720 0 n14 ns720 0 -3.49195600287e-06
Gc7_721 0 n14 ns721 0 2.85980975406e-05
Gc7_722 0 n14 ns722 0 2.60033440231e-05
Gc7_723 0 n14 ns723 0 -0.000128297022137
Gc7_724 0 n14 ns724 0 0.000128641283991
Gc7_725 0 n14 ns725 0 -7.90604594257e-05
Gc7_726 0 n14 ns726 0 0.000560316750273
Gc7_727 0 n14 ns727 0 -0.000176863360319
Gc7_728 0 n14 ns728 0 0.000193679224625
Gc7_729 0 n14 ns729 0 -1.41898190304e-05
Gc7_730 0 n14 ns730 0 -8.68585661376e-05
Gc7_731 0 n14 ns731 0 0.000344447535772
Gc7_732 0 n14 ns732 0 0.000361128990567
Gc7_733 0 n14 ns733 0 -6.83348839801e-05
Gc7_734 0 n14 ns734 0 6.0099420922e-05
Gc7_735 0 n14 ns735 0 -0.000177104006801
Gc7_736 0 n14 ns736 0 -0.000393288601162
Gc7_737 0 n14 ns737 0 0.000304755916121
Gc7_738 0 n14 ns738 0 0.000524814939917
Gc7_739 0 n14 ns739 0 0.000414850996164
Gc7_740 0 n14 ns740 0 -0.000312977518123
Gc7_741 0 n14 ns741 0 0.00018540227916
Gc7_742 0 n14 ns742 0 -0.000116540165947
Gc7_743 0 n14 ns743 0 -2.6633828072e-05
Gc7_744 0 n14 ns744 0 0.000264978299453
Gc7_745 0 n14 ns745 0 -0.00393534075357
Gc7_746 0 n14 ns746 0 -0.00366417119839
Gc7_747 0 n14 ns747 0 -0.00373189448896
Gc7_748 0 n14 ns748 0 -0.00341536990619
Gc7_749 0 n14 ns749 0 -0.000238982749365
Gc7_750 0 n14 ns750 0 0.00204481484384
Gc7_751 0 n14 ns751 0 -0.00026253027331
Gc7_752 0 n14 ns752 0 -0.000955116109084
Gc7_753 0 n14 ns753 0 -0.00104211131961
Gc7_754 0 n14 ns754 0 -0.00270593192903
Gc7_755 0 n14 ns755 0 3.12481817982e-05
Gc7_756 0 n14 ns756 0 -0.00224472256264
Gc7_757 0 n14 ns757 0 -0.000746270110422
Gc7_758 0 n14 ns758 0 -1.73251018385e-05
Gc7_759 0 n14 ns759 0 8.23926904654e-05
Gc7_760 0 n14 ns760 0 -1.22811520819e-05
Gc7_761 0 n14 ns761 0 7.14939792855e-05
Gc7_762 0 n14 ns762 0 -0.000552956672564
Gc7_763 0 n14 ns763 0 0.000347649589362
Gc7_764 0 n14 ns764 0 0.00101609339268
Gc7_765 0 n14 ns765 0 0.000192733957385
Gc7_766 0 n14 ns766 0 5.35674543229e-05
Gc7_767 0 n14 ns767 0 -7.06816647088e-05
Gc7_768 0 n14 ns768 0 -0.000154702370359
Gc7_769 0 n14 ns769 0 -0.000339086870565
Gc7_770 0 n14 ns770 0 0.000272435086148
Gc7_771 0 n14 ns771 0 -0.00011792829876
Gc7_772 0 n14 ns772 0 0.000114207239698
Gc7_773 0 n14 ns773 0 0.000727150476984
Gc7_774 0 n14 ns774 0 -0.000342200136807
Gc7_775 0 n14 ns775 0 -0.00048323613375
Gc7_776 0 n14 ns776 0 -0.000110923731486
Gc7_777 0 n14 ns777 0 0.000352585627998
Gc7_778 0 n14 ns778 0 -0.000308979157798
Gc7_779 0 n14 ns779 0 -0.000193844761092
Gc7_780 0 n14 ns780 0 -0.000436162230021
Gc7_781 0 n14 ns781 0 -0.00101010064114
Gc7_782 0 n14 ns782 0 0.000880592191948
Gc7_783 0 n14 ns783 0 -0.00268805798778
Gc7_784 0 n14 ns784 0 -0.00225951676918
Gc7_785 0 n14 ns785 0 -0.00245878983298
Gc7_786 0 n14 ns786 0 -0.00269861199226
Gc7_787 0 n14 ns787 0 -0.000158021742121
Gc7_788 0 n14 ns788 0 0.000745428640036
Gc7_789 0 n14 ns789 0 0.000290218731174
Gc7_790 0 n14 ns790 0 -0.00130040679434
Gc7_791 0 n14 ns791 0 -0.000253903090339
Gc7_792 0 n14 ns792 0 -0.00276813867099
Gc7_793 0 n14 ns793 0 0.00100005374209
Gc7_794 0 n14 ns794 0 -0.00320823148511
Gc7_795 0 n14 ns795 0 -0.00155749363116
Gc7_796 0 n14 ns796 0 -2.40505670151e-05
Gc7_797 0 n14 ns797 0 0.000102672943068
Gc7_798 0 n14 ns798 0 2.60173310375e-06
Gc7_799 0 n14 ns799 0 -0.0013590854792
Gc7_800 0 n14 ns800 0 -4.86214886052e-05
Gc7_801 0 n14 ns801 0 -0.00479587540754
Gc7_802 0 n14 ns802 0 -0.000499406554826
Gc7_803 0 n14 ns803 0 -0.00212889892857
Gc7_804 0 n14 ns804 0 0.00149165582724
Gc7_805 0 n14 ns805 0 0.000966714597851
Gc7_806 0 n14 ns806 0 -0.000681049479275
Gc7_807 0 n14 ns807 0 -0.000347617120111
Gc7_808 0 n14 ns808 0 0.000175560759066
Gc7_809 0 n14 ns809 0 -0.000161664830467
Gc7_810 0 n14 ns810 0 5.81429888827e-05
Gc7_811 0 n14 ns811 0 0.000859047545509
Gc7_812 0 n14 ns812 0 -5.69522856451e-05
Gc7_813 0 n14 ns813 0 0.00112439154836
Gc7_814 0 n14 ns814 0 -0.00103768140169
Gc7_815 0 n14 ns815 0 0.001159135771
Gc7_816 0 n14 ns816 0 -0.000443484602675
Gc7_817 0 n14 ns817 0 0.00102578677519
Gc7_818 0 n14 ns818 0 -0.000709815371604
Gc7_819 0 n14 ns819 0 -0.0022030388631
Gc7_820 0 n14 ns820 0 -0.000839760075738
Gc7_821 0 n14 ns821 0 -0.00651802914509
Gc7_822 0 n14 ns822 0 -0.00319458925164
Gc7_823 0 n14 ns823 0 -0.0051831736052
Gc7_824 0 n14 ns824 0 -0.00359971281171
Gc7_825 0 n14 ns825 0 0.00337158228794
Gc7_826 0 n14 ns826 0 0.00222971544826
Gc7_827 0 n14 ns827 0 0.000857471246807
Gc7_828 0 n14 ns828 0 -0.00123957196823
Gc7_829 0 n14 ns829 0 -0.00204186598413
Gc7_830 0 n14 ns830 0 -0.00313020828928
Gc7_831 0 n14 ns831 0 0.00248341304774
Gc7_832 0 n14 ns832 0 -0.000706912596802
Gc7_833 0 n14 ns833 0 -0.00322430938722
Gc7_834 0 n14 ns834 0 -4.72079123046e-05
Gc7_835 0 n14 ns835 0 0.000381669986613
Gc7_836 0 n14 ns836 0 -0.000177241438672
Gc7_837 0 n14 ns837 0 -0.000519164979153
Gc7_838 0 n14 ns838 0 -0.000136576131467
Gc7_839 0 n14 ns839 0 0.000429733171713
Gc7_840 0 n14 ns840 0 0.00310217057037
Gc7_841 0 n14 ns841 0 0.00130712794942
Gc7_842 0 n14 ns842 0 -0.000834454876545
Gc7_843 0 n14 ns843 0 -0.000288136020783
Gc7_844 0 n14 ns844 0 2.94770435455e-05
Gc7_845 0 n14 ns845 0 0.00040081237591
Gc7_846 0 n14 ns846 0 0.000225839195067
Gc7_847 0 n14 ns847 0 -0.00019303603233
Gc7_848 0 n14 ns848 0 -1.83716886853e-05
Gc7_849 0 n14 ns849 0 0.00182715343912
Gc7_850 0 n14 ns850 0 -0.000792221979923
Gc7_851 0 n14 ns851 0 -0.000163337418346
Gc7_852 0 n14 ns852 0 0.00134768744773
Gc7_853 0 n14 ns853 0 -9.48783078778e-05
Gc7_854 0 n14 ns854 0 -9.93284264296e-05
Gc7_855 0 n14 ns855 0 -0.00167376906864
Gc7_856 0 n14 ns856 0 -0.00144848767955
Gc7_857 0 n14 ns857 0 0.00321748104577
Gc7_858 0 n14 ns858 0 0.00371650428197
Gc7_859 0 n14 ns859 0 -0.0095336435015
Gc7_860 0 n14 ns860 0 -0.00095339103985
Gc7_861 0 n14 ns861 0 -0.00725472026978
Gc7_862 0 n14 ns862 0 -0.00208033148521
Gc7_863 0 n14 ns863 0 -0.011185370985
Gc7_864 0 n14 ns864 0 -0.000335566715218
Gc7_865 0 n14 ns865 0 0.00151900891924
Gc7_866 0 n14 ns866 0 -2.19826806833e-05
Gc7_867 0 n14 ns867 0 -0.00327588247526
Gc7_868 0 n14 ns868 0 0.00837412241689
Gc7_869 0 n14 ns869 0 -0.0141833225585
Gc7_870 0 n14 ns870 0 -0.00409268297011
Gc7_871 0 n14 ns871 0 -0.00625668578626
Gc7_872 0 n14 ns872 0 -6.2400884845e-05
Gc7_873 0 n14 ns873 0 -0.000392202523491
Gc7_874 0 n14 ns874 0 0.000610691734779
Gc7_875 0 n14 ns875 0 -0.000747675285117
Gc7_876 0 n14 ns876 0 -0.000910147251806
Gc7_877 0 n14 ns877 0 -0.00327341743727
Gc7_878 0 n14 ns878 0 -0.00148994575409
Gc7_879 0 n14 ns879 0 -0.0018288691676
Gc7_880 0 n14 ns880 0 0.00103659728046
Gc7_881 0 n14 ns881 0 0.000719625893357
Gc7_882 0 n14 ns882 0 -0.000357509796547
Gc7_883 0 n14 ns883 0 -0.000282964334257
Gc7_884 0 n14 ns884 0 0.000447839566107
Gc7_885 0 n14 ns885 0 -0.000214711821645
Gc7_886 0 n14 ns886 0 -0.000100185863898
Gc7_887 0 n14 ns887 0 0.000209169635746
Gc7_888 0 n14 ns888 0 -1.06973770051e-06
Gc7_889 0 n14 ns889 0 0.000768922965375
Gc7_890 0 n14 ns890 0 -0.000356098648945
Gc7_891 0 n14 ns891 0 0.00138380533904
Gc7_892 0 n14 ns892 0 -4.07955300841e-06
Gc7_893 0 n14 ns893 0 0.00126254679117
Gc7_894 0 n14 ns894 0 -0.00034204945307
Gc7_895 0 n14 ns895 0 -0.00160098265224
Gc7_896 0 n14 ns896 0 -0.000630422642994
Gc7_897 0 n14 ns897 0 -0.00274054699101
Gc7_898 0 n14 ns898 0 -0.00418203122862
Gc7_899 0 n14 ns899 0 -0.0019278364864
Gc7_900 0 n14 ns900 0 -0.00454800932141
Gc7_901 0 n14 ns901 0 0.00283661264242
Gc7_902 0 n14 ns902 0 0.00125639669944
Gc7_903 0 n14 ns903 0 0.00106285982512
Gc7_904 0 n14 ns904 0 -0.00115766368652
Gc7_905 0 n14 ns905 0 -0.00135775750734
Gc7_906 0 n14 ns906 0 -0.00256147013553
Gc7_907 0 n14 ns907 0 0.00266327404964
Gc7_908 0 n14 ns908 0 -0.000281024374708
Gc7_909 0 n14 ns909 0 -0.00315740623045
Gc7_910 0 n14 ns910 0 -3.04071916356e-05
Gc7_911 0 n14 ns911 0 0.000274662440461
Gc7_912 0 n14 ns912 0 -0.000131600724043
Gc7_913 0 n14 ns913 0 -0.000380522674571
Gc7_914 0 n14 ns914 0 8.89007241105e-05
Gc7_915 0 n14 ns915 0 -0.00109727020464
Gc7_916 0 n14 ns916 0 0.00149737718768
Gc7_917 0 n14 ns917 0 -6.47584985474e-05
Gc7_918 0 n14 ns918 0 0.000123535634519
Gc7_919 0 n14 ns919 0 7.48181168624e-05
Gc7_920 0 n14 ns920 0 -0.00026352214409
Gc7_921 0 n14 ns921 0 -0.000692523261478
Gc7_922 0 n14 ns922 0 0.000655439248516
Gc7_923 0 n14 ns923 0 -4.11464017238e-05
Gc7_924 0 n14 ns924 0 -1.36437043389e-05
Gc7_925 0 n14 ns925 0 0.000967058974329
Gc7_926 0 n14 ns926 0 -0.000778614163745
Gc7_927 0 n14 ns927 0 -0.00102329166096
Gc7_928 0 n14 ns928 0 8.06320143974e-05
Gc7_929 0 n14 ns929 0 0.000442430643767
Gc7_930 0 n14 ns930 0 0.00028850811026
Gc7_931 0 n14 ns931 0 -7.12161975908e-07
Gc7_932 0 n14 ns932 0 8.37334625864e-05
Gc7_933 0 n14 ns933 0 -0.000965269089061
Gc7_934 0 n14 ns934 0 0.00135704206744
Gc7_935 0 n14 ns935 0 0.00216240571155
Gc7_936 0 n14 ns936 0 -0.00149943952339
Gc7_937 0 n14 ns937 0 0.00189497820705
Gc7_938 0 n14 ns938 0 -0.00217399636213
Gc7_939 0 n14 ns939 0 -0.000904626756029
Gc7_940 0 n14 ns940 0 -0.00086611229028
Gc7_941 0 n14 ns941 0 0.000706093549094
Gc7_942 0 n14 ns942 0 -0.00107548109263
Gc7_943 0 n14 ns943 0 0.00107571222343
Gc7_944 0 n14 ns944 0 -0.001624299096
Gc7_945 0 n14 ns945 0 0.00138372091878
Gc7_946 0 n14 ns946 0 -0.00216593124682
Gc7_947 0 n14 ns947 0 -0.00140572932342
Gc7_948 0 n14 ns948 0 -3.24102859673e-05
Gc7_949 0 n14 ns949 0 0.000129475309555
Gc7_950 0 n14 ns950 0 -1.01308513141e-05
Gc7_951 0 n14 ns951 0 0.000426614603617
Gc7_952 0 n14 ns952 0 -0.000183088907206
Gc7_953 0 n14 ns953 0 0.00131705468825
Gc7_954 0 n14 ns954 0 -0.000458625626047
Gc7_955 0 n14 ns955 0 0.000354918815224
Gc7_956 0 n14 ns956 0 -6.54822312501e-05
Gc7_957 0 n14 ns957 0 -0.000152911649288
Gc7_958 0 n14 ns958 0 1.4158406702e-05
Gc7_959 0 n14 ns959 0 4.80854849154e-05
Gc7_960 0 n14 ns960 0 -0.000508420065249
Gc7_961 0 n14 ns961 0 -2.60445303129e-05
Gc7_962 0 n14 ns962 0 0.000129333829048
Gc7_963 0 n14 ns963 0 4.22750434754e-05
Gc7_964 0 n14 ns964 0 0.00040195921302
Gc7_965 0 n14 ns965 0 0.000194487394636
Gc7_966 0 n14 ns966 0 -0.00039403941507
Gc7_967 0 n14 ns967 0 -0.000290651139887
Gc7_968 0 n14 ns968 0 -0.000475803014486
Gc7_969 0 n14 ns969 0 -0.000436100283939
Gc7_970 0 n14 ns970 0 -0.000440846971574
Gc7_971 0 n14 ns971 0 -0.00020024553429
Gc7_972 0 n14 ns972 0 -0.00042100274742
Gc7_973 0 n14 ns973 0 -0.00444991491082
Gc7_974 0 n14 ns974 0 -0.000486291808071
Gc7_975 0 n14 ns975 0 -0.00397725920571
Gc7_976 0 n14 ns976 0 -0.000348201995804
Gc7_977 0 n14 ns977 0 0.000705667600207
Gc7_978 0 n14 ns978 0 0.00135613887177
Gc7_979 0 n14 ns979 0 -0.000358655242332
Gc7_980 0 n14 ns980 0 -0.000356484018134
Gc7_981 0 n14 ns981 0 -0.00134810415892
Gc7_982 0 n14 ns982 0 -0.00115953827437
Gc7_983 0 n14 ns983 0 -0.000229876495265
Gc7_984 0 n14 ns984 0 -0.000822037016833
Gc7_985 0 n14 ns985 0 -0.000239614971018
Gc7_986 0 n14 ns986 0 -7.55840715859e-06
Gc7_987 0 n14 ns987 0 -1.69438933515e-05
Gc7_988 0 n14 ns988 0 5.40847253939e-05
Gc7_989 0 n14 ns989 0 -2.16630393598e-05
Gc7_990 0 n14 ns990 0 0.000209560208617
Gc7_991 0 n14 ns991 0 0.000244917507998
Gc7_992 0 n14 ns992 0 0.000336274572142
Gc7_993 0 n14 ns993 0 -2.43883174169e-05
Gc7_994 0 n14 ns994 0 0.000203114492919
Gc7_995 0 n14 ns995 0 -4.3745853692e-05
Gc7_996 0 n14 ns996 0 -2.6507911747e-05
Gc7_997 0 n14 ns997 0 0.000449682937262
Gc7_998 0 n14 ns998 0 9.51523102325e-05
Gc7_999 0 n14 ns999 0 -6.49001659332e-05
Gc7_1000 0 n14 ns1000 0 6.02669316847e-05
Gc7_1001 0 n14 ns1001 0 -0.00033114360278
Gc7_1002 0 n14 ns1002 0 -9.19960768477e-05
Gc7_1003 0 n14 ns1003 0 0.000488030238359
Gc7_1004 0 n14 ns1004 0 0.000283567107503
Gc7_1005 0 n14 ns1005 0 0.000277729046697
Gc7_1006 0 n14 ns1006 0 -0.000431620985808
Gc7_1007 0 n14 ns1007 0 0.000139686218922
Gc7_1008 0 n14 ns1008 0 -0.000280341444489
Gc7_1009 0 n14 ns1009 0 5.314982872e-05
Gc7_1010 0 n14 ns1010 0 -3.16794567267e-05
Gc7_1011 0 n14 ns1011 0 -0.00444626075711
Gc7_1012 0 n14 ns1012 0 -0.00303058564273
Gc7_1013 0 n14 ns1013 0 -0.00413529932193
Gc7_1014 0 n14 ns1014 0 -0.00272868012741
Gc7_1015 0 n14 ns1015 0 0.000146499379316
Gc7_1016 0 n14 ns1016 0 0.00204165727472
Gc7_1017 0 n14 ns1017 0 -0.000356763522344
Gc7_1018 0 n14 ns1018 0 -0.000759906467514
Gc7_1019 0 n14 ns1019 0 -0.00130278121097
Gc7_1020 0 n14 ns1020 0 -0.0022999947598
Gc7_1021 0 n14 ns1021 0 -0.000118280147164
Gc7_1022 0 n14 ns1022 0 -0.00185403475059
Gc7_1023 0 n14 ns1023 0 -0.000574421453536
Gc7_1024 0 n14 ns1024 0 -1.13790867784e-05
Gc7_1025 0 n14 ns1025 0 3.87449756308e-05
Gc7_1026 0 n14 ns1026 0 1.099993617e-05
Gc7_1027 0 n14 ns1027 0 0.000287619893045
Gc7_1028 0 n14 ns1028 0 -0.000724723816007
Gc7_1029 0 n14 ns1029 0 0.000893716015198
Gc7_1030 0 n14 ns1030 0 7.09077135148e-05
Gc7_1031 0 n14 ns1031 0 4.71351931924e-05
Gc7_1032 0 n14 ns1032 0 -0.000291823306171
Gc7_1033 0 n14 ns1033 0 -7.95351661418e-05
Gc7_1034 0 n14 ns1034 0 2.55699351996e-05
Gc7_1035 0 n14 ns1035 0 -0.000165341440802
Gc7_1036 0 n14 ns1036 0 0.0003086440215
Gc7_1037 0 n14 ns1037 0 -0.000100555136842
Gc7_1038 0 n14 ns1038 0 0.000120705504068
Gc7_1039 0 n14 ns1039 0 0.000417586067458
Gc7_1040 0 n14 ns1040 0 -0.00035924750044
Gc7_1041 0 n14 ns1041 0 -0.000388386096715
Gc7_1042 0 n14 ns1042 0 0.000399796013491
Gc7_1043 0 n14 ns1043 0 0.000281303254459
Gc7_1044 0 n14 ns1044 0 -0.000170613040373
Gc7_1045 0 n14 ns1045 0 -0.000230362005883
Gc7_1046 0 n14 ns1046 0 -8.48876360195e-05
Gc7_1047 0 n14 ns1047 0 -0.000442843486689
Gc7_1048 0 n14 ns1048 0 0.00071700136832
Gc7_1049 0 n14 ns1049 0 -0.0022732266171
Gc7_1050 0 n14 ns1050 0 -0.00322475263815
Gc7_1051 0 n14 ns1051 0 -0.00223313604021
Gc7_1052 0 n14 ns1052 0 -0.00333238858339
Gc7_1053 0 n14 ns1053 0 -0.000681147539538
Gc7_1054 0 n14 ns1054 0 0.00117738919649
Gc7_1055 0 n14 ns1055 0 7.87487491259e-05
Gc7_1056 0 n14 ns1056 0 -0.00120905482035
Gc7_1057 0 n14 ns1057 0 -0.000324173562851
Gc7_1058 0 n14 ns1058 0 -0.00284704482367
Gc7_1059 0 n14 ns1059 0 0.000544657579336
Gc7_1060 0 n14 ns1060 0 -0.00280639591013
Gc7_1061 0 n14 ns1061 0 -0.00114443724774
Gc7_1062 0 n14 ns1062 0 -3.3837465594e-05
Gc7_1063 0 n14 ns1063 0 9.50097158651e-05
Gc7_1064 0 n14 ns1064 0 -1.0982407942e-06
Gc7_1065 0 n14 ns1065 0 -0.00105576581272
Gc7_1066 0 n14 ns1066 0 5.94428106508e-05
Gc7_1067 0 n14 ns1067 0 -0.003132516382
Gc7_1068 0 n14 ns1068 0 0.00153569763159
Gc7_1069 0 n14 ns1069 0 -0.000339376370067
Gc7_1070 0 n14 ns1070 0 0.00114123448279
Gc7_1071 0 n14 ns1071 0 0.000228979594835
Gc7_1072 0 n14 ns1072 0 -0.000495544974438
Gc7_1073 0 n14 ns1073 0 -0.000374176364427
Gc7_1074 0 n14 ns1074 0 0.000152428677739
Gc7_1075 0 n14 ns1075 0 -0.00015524034957
Gc7_1076 0 n14 ns1076 0 9.57719779705e-05
Gc7_1077 0 n14 ns1077 0 0.000951848142615
Gc7_1078 0 n14 ns1078 0 0.000111341901209
Gc7_1079 0 n14 ns1079 0 0.000332665865083
Gc7_1080 0 n14 ns1080 0 -0.000826700846193
Gc7_1081 0 n14 ns1081 0 0.000758769519846
Gc7_1082 0 n14 ns1082 0 -0.000480976345235
Gc7_1083 0 n14 ns1083 0 0.000465891636812
Gc7_1084 0 n14 ns1084 0 -0.000832395581078
Gc7_1085 0 n14 ns1085 0 -0.00231590041602
Gc7_1086 0 n14 ns1086 0 -5.62840834078e-05
Gc7_1087 0 n14 ns1087 0 -0.0061025894052
Gc7_1088 0 n14 ns1088 0 -0.00215750416892
Gc7_1089 0 n14 ns1089 0 -0.00496969500836
Gc7_1090 0 n14 ns1090 0 -0.00272002275236
Gc7_1091 0 n14 ns1091 0 0.00173607301765
Gc7_1092 0 n14 ns1092 0 0.00017829973572
Gc7_1093 0 n14 ns1093 0 0.000783798348811
Gc7_1094 0 n14 ns1094 0 -0.00118442707679
Gc7_1095 0 n14 ns1095 0 -0.00051178631632
Gc7_1096 0 n14 ns1096 0 -0.00193599198497
Gc7_1097 0 n14 ns1097 0 0.00240504604794
Gc7_1098 0 n14 ns1098 0 -0.00261257318381
Gc7_1099 0 n14 ns1099 0 -0.00252567619347
Gc7_1100 0 n14 ns1100 0 -8.95932552718e-06
Gc7_1101 0 n14 ns1101 0 0.000197014717027
Gc7_1102 0 n14 ns1102 0 -5.19548394362e-05
Gc7_1103 0 n14 ns1103 0 0.00216302194091
Gc7_1104 0 n14 ns1104 0 -0.00322850718523
Gc7_1105 0 n14 ns1105 0 0.00475010698127
Gc7_1106 0 n14 ns1106 0 -0.00642015803856
Gc7_1107 0 n14 ns1107 0 -0.00337006839977
Gc7_1108 0 n14 ns1108 0 -0.00225769326921
Gc7_1109 0 n14 ns1109 0 0.00119353046856
Gc7_1110 0 n14 ns1110 0 0.000655869456408
Gc7_1111 0 n14 ns1111 0 -0.000275532577328
Gc7_1112 0 n14 ns1112 0 -0.000539090172656
Gc7_1113 0 n14 ns1113 0 -0.000276316370728
Gc7_1114 0 n14 ns1114 0 4.89647298644e-06
Gc7_1115 0 n14 ns1115 0 -0.00041067170063
Gc7_1116 0 n14 ns1116 0 -0.000356111806955
Gc7_1117 0 n14 ns1117 0 0.00147790666049
Gc7_1118 0 n14 ns1118 0 2.44295756533e-05
Gc7_1119 0 n14 ns1119 0 0.00103065827554
Gc7_1120 0 n14 ns1120 0 0.000204329718712
Gc7_1121 0 n14 ns1121 0 0.000430960045049
Gc7_1122 0 n14 ns1122 0 0.000387007712733
Gc7_1123 0 n14 ns1123 0 0.000883029011485
Gc7_1124 0 n14 ns1124 0 -0.00303070413705
Gc7_1125 0 n14 ns1125 0 -0.00227297001573
Gc7_1126 0 n14 ns1126 0 -0.0080284553763
Gc7_1127 0 n14 ns1127 0 -0.00159861805883
Gc7_1128 0 n14 ns1128 0 -0.007525825247
Gc7_1129 0 n14 ns1129 0 0.00539644836991
Gc7_1130 0 n14 ns1130 0 0.00811256005096
Gc7_1131 0 n14 ns1131 0 0.000817655599313
Gc7_1132 0 n14 ns1132 0 -0.00123151463349
Gc7_1133 0 n14 ns1133 0 -0.00526545332886
Gc7_1134 0 n14 ns1134 0 -0.00600770422443
Gc7_1135 0 n14 ns1135 0 0.00145772030173
Gc7_1136 0 n14 ns1136 0 0.00524583390108
Gc7_1137 0 n14 ns1137 0 -0.00431089669607
Gc7_1138 0 n14 ns1138 0 2.3847394547e-06
Gc7_1139 0 n14 ns1139 0 0.000421236251669
Gc7_1140 0 n14 ns1140 0 -0.000231688438035
Gc7_1141 0 n14 ns1141 0 0.00125608997731
Gc7_1142 0 n14 ns1142 0 -0.00278421855194
Gc7_1143 0 n14 ns1143 0 0.00234272674396
Gc7_1144 0 n14 ns1144 0 -0.00460274971841
Gc7_1145 0 n14 ns1145 0 -0.00238499558345
Gc7_1146 0 n14 ns1146 0 -0.00136150830566
Gc7_1147 0 n14 ns1147 0 0.000847743482031
Gc7_1148 0 n14 ns1148 0 0.000567050070177
Gc7_1149 0 n14 ns1149 0 -0.00019915164781
Gc7_1150 0 n14 ns1150 0 -0.000192793536796
Gc7_1151 0 n14 ns1151 0 -0.000296914557669
Gc7_1152 0 n14 ns1152 0 -8.0470639952e-05
Gc7_1153 0 n14 ns1153 0 -0.000323008893344
Gc7_1154 0 n14 ns1154 0 0.000130870989086
Gc7_1155 0 n14 ns1155 0 0.00129527458634
Gc7_1156 0 n14 ns1156 0 -3.67525870821e-05
Gc7_1157 0 n14 ns1157 0 0.00127809884823
Gc7_1158 0 n14 ns1158 0 0.00014030055957
Gc7_1159 0 n14 ns1159 0 0.00084447738975
Gc7_1160 0 n14 ns1160 0 -4.5062342236e-05
Gc7_1161 0 n14 ns1161 0 -0.000345175338082
Gc7_1162 0 n14 ns1162 0 -0.00203277519231
Gc7_1163 0 n14 ns1163 0 -0.00309232826826
Gc7_1164 0 n14 ns1164 0 -0.00574457349995
Gc7_1165 0 n14 ns1165 0 -0.00220323752859
Gc7_1166 0 n14 ns1166 0 -0.00582531430083
Gc7_1167 0 n14 ns1167 0 0.00393267398365
Gc7_1168 0 n14 ns1168 0 0.00361223703807
Gc7_1169 0 n14 ns1169 0 0.00108674675095
Gc7_1170 0 n14 ns1170 0 -0.00112287010668
Gc7_1171 0 n14 ns1171 0 -0.0026153022561
Gc7_1172 0 n14 ns1172 0 -0.0031681008543
Gc7_1173 0 n14 ns1173 0 0.00234212754206
Gc7_1174 0 n14 ns1174 0 0.00170032056637
Gc7_1175 0 n14 ns1175 0 -0.00372905114282
Gc7_1176 0 n14 ns1176 0 1.22310147009e-05
Gc7_1177 0 n14 ns1177 0 0.000245295170071
Gc7_1178 0 n14 ns1178 0 -0.000119082229834
Gc7_1179 0 n14 ns1179 0 -0.000769129270262
Gc7_1180 0 n14 ns1180 0 -4.60920988303e-05
Gc7_1181 0 n14 ns1181 0 -0.00247357437853
Gc7_1182 0 n14 ns1182 0 0.00145848746029
Gc7_1183 0 n14 ns1183 0 -0.000419624767362
Gc7_1184 0 n14 ns1184 0 0.000649085314035
Gc7_1185 0 n14 ns1185 0 0.000245040414047
Gc7_1186 0 n14 ns1186 0 -0.000390743373584
Gc7_1187 0 n14 ns1187 0 -0.000658534555307
Gc7_1188 0 n14 ns1188 0 0.000705496146444
Gc7_1189 0 n14 ns1189 0 -9.41069773324e-05
Gc7_1190 0 n14 ns1190 0 -3.97102226981e-05
Gc7_1191 0 n14 ns1191 0 0.000961350705085
Gc7_1192 0 n14 ns1192 0 -0.00064541161604
Gc7_1193 0 n14 ns1193 0 -0.000650616127473
Gc7_1194 0 n14 ns1194 0 -0.000146674102353
Gc7_1195 0 n14 ns1195 0 0.000758373356474
Gc7_1196 0 n14 ns1196 0 0.00019687356681
Gc7_1197 0 n14 ns1197 0 0.000372056363718
Gc7_1198 0 n14 ns1198 0 -9.57354210533e-05
Gc7_1199 0 n14 ns1199 0 -0.00147226702441
Gc7_1200 0 n14 ns1200 0 0.00108531698204
Gc7_1201 0 n14 ns1201 0 0.000592363506948
Gc7_1202 0 n14 ns1202 0 -0.00193181975309
Gc7_1203 0 n14 ns1203 0 0.000675738832618
Gc7_1204 0 n14 ns1204 0 -0.00268655339258
Gc7_1205 0 n14 ns1205 0 -0.000169042587333
Gc7_1206 0 n14 ns1206 0 -0.000702648516764
Gc7_1207 0 n14 ns1207 0 0.00089701021069
Gc7_1208 0 n14 ns1208 0 -0.00120577318527
Gc7_1209 0 n14 ns1209 0 0.000851041266651
Gc7_1210 0 n14 ns1210 0 -0.0018389100447
Gc7_1211 0 n14 ns1211 0 0.00198437963407
Gc7_1212 0 n14 ns1212 0 -0.00255178896014
Gc7_1213 0 n14 ns1213 0 -0.00202021159154
Gc7_1214 0 n14 ns1214 0 -2.58732227164e-05
Gc7_1215 0 n14 ns1215 0 0.000115406591847
Gc7_1216 0 n14 ns1216 0 -1.22620742556e-05
Gd7_1 0 n14 ni1 0 -0.00038909981452
Gd7_2 0 n14 ni2 0 1.56788979044e-05
Gd7_3 0 n14 ni3 0 0.0007220662014
Gd7_4 0 n14 ni4 0 0.000484721032423
Gd7_5 0 n14 ni5 0 -0.000228037809852
Gd7_6 0 n14 ni6 0 -0.00183681421854
Gd7_7 0 n14 ni7 0 0.000759209451873
Gd7_8 0 n14 ni8 0 -0.00189024838388
Gd7_9 0 n14 ni9 0 -0.000258780440249
Gd7_10 0 n14 ni10 0 0.000215472822646
Gd7_11 0 n14 ni11 0 0.000428540447445
Gd7_12 0 n14 ni12 0 0.000540331741996
Gd7_13 0 n14 ni13 0 -0.00152139365108
Gd7_14 0 n14 ni14 0 -0.0006919249272
Gd7_15 0 n14 ni15 0 -0.00302038282614
Gd7_16 0 n14 ni16 0 -0.00179373210104
Gd7_17 0 n14 ni17 0 0.00100251206757
Gd7_18 0 n14 ni18 0 0.000624394355892
Gd7_19 0 n14 ni19 0 -0.000450569340639
Gd7_20 0 n14 ni20 0 0.000136596944195
Gd7_21 0 n14 ni21 0 -0.000298047333752
Gd7_22 0 n14 ni22 0 0.000556882817819
Gd7_23 0 n14 ni23 0 0.000509180783915
Gd7_24 0 n14 ni24 0 -0.000394081365767
Gd7_25 0 n14 ni25 0 0.00047577887146
Gd7_26 0 n14 ni26 0 -0.000479459101783
Gd7_27 0 n14 ni27 0 6.17137252877e-05
Gd7_28 0 n14 ni28 0 -0.000589454631635
Gd7_29 0 n14 ni29 0 0.000662966336658
Gd7_30 0 n14 ni30 0 -0.00304384469146
Gd7_31 0 n14 ni31 0 -0.0023719924121
Gd7_32 0 n14 ni32 0 0.000509679926502
Gc8_1 0 n16 ns1 0 -6.98156617704e-09
Gc8_2 0 n16 ns2 0 0.000114514857897
Gc8_3 0 n16 ns3 0 -1.09312995341e-05
Gc8_4 0 n16 ns4 0 -0.000839413350558
Gc8_5 0 n16 ns5 0 -0.000107341142592
Gc8_6 0 n16 ns6 0 -9.3716047187e-05
Gc8_7 0 n16 ns7 0 9.79020778266e-05
Gc8_8 0 n16 ns8 0 2.58687528809e-05
Gc8_9 0 n16 ns9 0 7.94090941762e-05
Gc8_10 0 n16 ns10 0 -0.000125087187709
Gc8_11 0 n16 ns11 0 -4.54225452862e-05
Gc8_12 0 n16 ns12 0 3.43438707754e-05
Gc8_13 0 n16 ns13 0 -6.8431944151e-05
Gc8_14 0 n16 ns14 0 0.000191801296928
Gc8_15 0 n16 ns15 0 -0.00032411624502
Gc8_16 0 n16 ns16 0 0.000136673133613
Gc8_17 0 n16 ns17 0 -0.000243988063932
Gc8_18 0 n16 ns18 0 0.000206359957544
Gc8_19 0 n16 ns19 0 -0.000332785313636
Gc8_20 0 n16 ns20 0 0.000270628548771
Gc8_21 0 n16 ns21 0 3.57582114655e-05
Gc8_22 0 n16 ns22 0 -0.000351167799885
Gc8_23 0 n16 ns23 0 5.11020530775e-05
Gc8_24 0 n16 ns24 0 -0.00169241703242
Gc8_25 0 n16 ns25 0 3.84006960671e-05
Gc8_26 0 n16 ns26 0 -0.00146476179973
Gc8_27 0 n16 ns27 0 -0.000123300386126
Gc8_28 0 n16 ns28 0 8.99422631139e-05
Gc8_29 0 n16 ns29 0 -6.52485693033e-05
Gc8_30 0 n16 ns30 0 -3.85156899878e-05
Gc8_31 0 n16 ns31 0 -0.000146317809841
Gc8_32 0 n16 ns32 0 4.27578488466e-05
Gc8_33 0 n16 ns33 0 -5.91058400377e-05
Gc8_34 0 n16 ns34 0 0.000385858420873
Gc8_35 0 n16 ns35 0 0.000139382674051
Gc8_36 0 n16 ns36 0 -1.68047450743e-06
Gc8_37 0 n16 ns37 0 4.99859132977e-05
Gc8_38 0 n16 ns38 0 -4.43647860554e-05
Gc8_39 0 n16 ns39 0 0.000103257091293
Gc8_40 0 n16 ns40 0 0.000229176962328
Gc8_41 0 n16 ns41 0 0.00048595018825
Gc8_42 0 n16 ns42 0 -0.000448776627933
Gc8_43 0 n16 ns43 0 -5.4499780082e-05
Gc8_44 0 n16 ns44 0 2.17365027254e-06
Gc8_45 0 n16 ns45 0 8.50636897591e-05
Gc8_46 0 n16 ns46 0 -5.13462387123e-06
Gc8_47 0 n16 ns47 0 0.000205707127744
Gc8_48 0 n16 ns48 0 -4.26872516076e-05
Gc8_49 0 n16 ns49 0 -5.13967458395e-05
Gc8_50 0 n16 ns50 0 -1.47205002761e-06
Gc8_51 0 n16 ns51 0 -0.000218316866695
Gc8_52 0 n16 ns52 0 1.08814838795e-05
Gc8_53 0 n16 ns53 0 -0.000386685737949
Gc8_54 0 n16 ns54 0 -0.000123193856936
Gc8_55 0 n16 ns55 0 -0.00030859858903
Gc8_56 0 n16 ns56 0 4.78199322077e-05
Gc8_57 0 n16 ns57 0 -0.000362189199091
Gc8_58 0 n16 ns58 0 2.38747013606e-05
Gc8_59 0 n16 ns59 0 0.000266153625455
Gc8_60 0 n16 ns60 0 -0.000172137151047
Gc8_61 0 n16 ns61 0 0.000704034040801
Gc8_62 0 n16 ns62 0 -0.00147016188103
Gc8_63 0 n16 ns63 0 0.000595165536014
Gc8_64 0 n16 ns64 0 -0.00130829466498
Gc8_65 0 n16 ns65 0 0.000175307588561
Gc8_66 0 n16 ns66 0 0.000268055322031
Gc8_67 0 n16 ns67 0 -0.000125578457816
Gc8_68 0 n16 ns68 0 -7.71737888873e-05
Gc8_69 0 n16 ns69 0 -0.000451401526282
Gc8_70 0 n16 ns70 0 -0.000170262208552
Gc8_71 0 n16 ns71 0 -0.000181570200736
Gc8_72 0 n16 ns72 0 5.17933806584e-05
Gc8_73 0 n16 ns73 0 7.41509949744e-05
Gc8_74 0 n16 ns74 0 1.02050314763e-05
Gc8_75 0 n16 ns75 0 1.77120409557e-05
Gc8_76 0 n16 ns76 0 -3.25480971636e-05
Gc8_77 0 n16 ns77 0 0.000201834895828
Gc8_78 0 n16 ns78 0 0.000457888687114
Gc8_79 0 n16 ns79 0 0.000924600505324
Gc8_80 0 n16 ns80 0 0.000776583405371
Gc8_81 0 n16 ns81 0 3.01229538795e-05
Gc8_82 0 n16 ns82 0 0.000197569489781
Gc8_83 0 n16 ns83 0 -1.44175103006e-05
Gc8_84 0 n16 ns84 0 -5.89968124814e-05
Gc8_85 0 n16 ns85 0 0.000260328759902
Gc8_86 0 n16 ns86 0 0.000303776499796
Gc8_87 0 n16 ns87 0 -3.09115205239e-05
Gc8_88 0 n16 ns88 0 -9.88176958042e-05
Gc8_89 0 n16 ns89 0 -0.000246026175935
Gc8_90 0 n16 ns90 0 -0.000432202529014
Gc8_91 0 n16 ns91 0 -3.68632059227e-05
Gc8_92 0 n16 ns92 0 -0.000842872187159
Gc8_93 0 n16 ns93 0 -0.000263246530209
Gc8_94 0 n16 ns94 0 -0.0005258818445
Gc8_95 0 n16 ns95 0 -0.000162992478675
Gc8_96 0 n16 ns96 0 -0.000686854395413
Gc8_97 0 n16 ns97 0 0.000669461730001
Gc8_98 0 n16 ns98 0 0.000543527688379
Gc8_99 0 n16 ns99 0 0.00297025194216
Gc8_100 0 n16 ns100 0 -4.21428293527e-05
Gc8_101 0 n16 ns101 0 0.00259828172092
Gc8_102 0 n16 ns102 0 -0.000174295693503
Gc8_103 0 n16 ns103 0 0.000741705308918
Gc8_104 0 n16 ns104 0 0.000761770982904
Gc8_105 0 n16 ns105 0 -0.000272118738122
Gc8_106 0 n16 ns106 0 -0.000215915471622
Gc8_107 0 n16 ns107 0 -0.00113969716351
Gc8_108 0 n16 ns108 0 -0.000757461772686
Gc8_109 0 n16 ns109 0 -0.000456139432814
Gc8_110 0 n16 ns110 0 -0.000638547884457
Gc8_111 0 n16 ns111 0 -4.64944816791e-05
Gc8_112 0 n16 ns112 0 3.06880955765e-05
Gc8_113 0 n16 ns113 0 -5.49248528956e-05
Gc8_114 0 n16 ns114 0 1.06944669296e-05
Gc8_115 0 n16 ns115 0 -0.000452902135832
Gc8_116 0 n16 ns116 0 0.000560278535243
Gc8_117 0 n16 ns117 0 -0.00112071601436
Gc8_118 0 n16 ns118 0 0.00119590895387
Gc8_119 0 n16 ns119 0 -0.000306919176901
Gc8_120 0 n16 ns120 0 0.000260159367287
Gc8_121 0 n16 ns121 0 0.000132183806814
Gc8_122 0 n16 ns122 0 -0.000182602016515
Gc8_123 0 n16 ns123 0 -0.000179194613695
Gc8_124 0 n16 ns124 0 0.000476022433541
Gc8_125 0 n16 ns125 0 7.22805400998e-05
Gc8_126 0 n16 ns126 0 -0.000148915803874
Gc8_127 0 n16 ns127 0 0.000134656728691
Gc8_128 0 n16 ns128 0 -0.000419690994531
Gc8_129 0 n16 ns129 0 0.000821777255471
Gc8_130 0 n16 ns130 0 -0.000420477879679
Gc8_131 0 n16 ns131 0 0.000173233341743
Gc8_132 0 n16 ns132 0 -0.000636831721695
Gc8_133 0 n16 ns133 0 0.000240551571465
Gc8_134 0 n16 ns134 0 -0.000500670503655
Gc8_135 0 n16 ns135 0 -0.000173115376799
Gc8_136 0 n16 ns136 0 0.000827233582363
Gc8_137 0 n16 ns137 0 0.00331859961922
Gc8_138 0 n16 ns138 0 0.00229857938607
Gc8_139 0 n16 ns139 0 0.00312145804922
Gc8_140 0 n16 ns140 0 0.00189826996434
Gc8_141 0 n16 ns141 0 0.000197219539419
Gc8_142 0 n16 ns142 0 0.0011430385069
Gc8_143 0 n16 ns143 0 -0.000317344799419
Gc8_144 0 n16 ns144 0 -0.000430127692918
Gc8_145 0 n16 ns145 0 -0.00111778573071
Gc8_146 0 n16 ns146 0 -0.0011243679396
Gc8_147 0 n16 ns147 0 -0.000491895124333
Gc8_148 0 n16 ns148 0 -0.000110304977734
Gc8_149 0 n16 ns149 0 0.000137835967219
Gc8_150 0 n16 ns150 0 -1.38161407271e-05
Gc8_151 0 n16 ns151 0 1.93070353432e-05
Gc8_152 0 n16 ns152 0 -4.79680863473e-05
Gc8_153 0 n16 ns153 0 9.17939501755e-05
Gc8_154 0 n16 ns154 0 -0.000227532211319
Gc8_155 0 n16 ns155 0 0.000511089281767
Gc8_156 0 n16 ns156 0 0.000492911947359
Gc8_157 0 n16 ns157 0 0.000191856275086
Gc8_158 0 n16 ns158 0 -2.12983120576e-05
Gc8_159 0 n16 ns159 0 1.28797637892e-05
Gc8_160 0 n16 ns160 0 3.93780380258e-05
Gc8_161 0 n16 ns161 0 -0.000236187718551
Gc8_162 0 n16 ns162 0 -0.000102581169294
Gc8_163 0 n16 ns163 0 0.00013207244285
Gc8_164 0 n16 ns164 0 -0.00014319304108
Gc8_165 0 n16 ns165 0 -0.000259129672097
Gc8_166 0 n16 ns166 0 -0.000227161837229
Gc8_167 0 n16 ns167 0 0.000246237327614
Gc8_168 0 n16 ns168 0 0.000448598998777
Gc8_169 0 n16 ns169 0 0.000299378204642
Gc8_170 0 n16 ns170 0 -0.000532677487911
Gc8_171 0 n16 ns171 0 -0.000111154876356
Gc8_172 0 n16 ns172 0 -0.000506472554101
Gc8_173 0 n16 ns173 0 -0.000375275039011
Gc8_174 0 n16 ns174 0 -0.000190718005564
Gc8_175 0 n16 ns175 0 0.00280607007203
Gc8_176 0 n16 ns176 0 0.00386811302547
Gc8_177 0 n16 ns177 0 0.00281319632892
Gc8_178 0 n16 ns178 0 0.00360363682402
Gc8_179 0 n16 ns179 0 -0.00113449270214
Gc8_180 0 n16 ns180 0 0.000669004442292
Gc8_181 0 n16 ns181 0 -0.000128390498214
Gc8_182 0 n16 ns182 0 -0.000804347449173
Gc8_183 0 n16 ns183 0 -0.000461452693656
Gc8_184 0 n16 ns184 0 -0.00144632941129
Gc8_185 0 n16 ns185 0 -0.000663632216499
Gc8_186 0 n16 ns186 0 0.00081335838574
Gc8_187 0 n16 ns187 0 0.000532839189028
Gc8_188 0 n16 ns188 0 1.94332056037e-05
Gc8_189 0 n16 ns189 0 -0.000143823593641
Gc8_190 0 n16 ns190 0 2.71870743652e-05
Gc8_191 0 n16 ns191 0 0.000253637054594
Gc8_192 0 n16 ns192 0 -0.00101143080517
Gc8_193 0 n16 ns193 0 0.000658014361153
Gc8_194 0 n16 ns194 0 -0.000455957592086
Gc8_195 0 n16 ns195 0 -0.000102439604423
Gc8_196 0 n16 ns196 0 0.00026781688351
Gc8_197 0 n16 ns197 0 -0.00018224441874
Gc8_198 0 n16 ns198 0 -0.000122457369249
Gc8_199 0 n16 ns199 0 3.61978352613e-05
Gc8_200 0 n16 ns200 0 -0.000339822048113
Gc8_201 0 n16 ns201 0 0.000209639192599
Gc8_202 0 n16 ns202 0 -2.98101483971e-05
Gc8_203 0 n16 ns203 0 0.000229133150065
Gc8_204 0 n16 ns204 0 -3.4735626411e-06
Gc8_205 0 n16 ns205 0 -0.000386000915567
Gc8_206 0 n16 ns206 0 -4.04209205347e-05
Gc8_207 0 n16 ns207 0 0.00059464601913
Gc8_208 0 n16 ns208 0 -0.000517892982814
Gc8_209 0 n16 ns209 0 0.00011664958663
Gc8_210 0 n16 ns210 0 -0.00086489046524
Gc8_211 0 n16 ns211 0 0.000926639808721
Gc8_212 0 n16 ns212 0 -0.000561587895962
Gc8_213 0 n16 ns213 0 0.00161553612645
Gc8_214 0 n16 ns214 0 0.00436020926934
Gc8_215 0 n16 ns215 0 0.00155435650984
Gc8_216 0 n16 ns216 0 0.00449478573682
Gc8_217 0 n16 ns217 0 -0.00146630075829
Gc8_218 0 n16 ns218 0 -0.00154345194764
Gc8_219 0 n16 ns219 0 0.000486905970805
Gc8_220 0 n16 ns220 0 -0.00106817286821
Gc8_221 0 n16 ns221 0 0.000473253944813
Gc8_222 0 n16 ns222 0 -0.000793229610511
Gc8_223 0 n16 ns223 0 -0.00141606734495
Gc8_224 0 n16 ns224 0 0.00254684022295
Gc8_225 0 n16 ns225 0 0.00150769007882
Gc8_226 0 n16 ns226 0 2.10671426749e-05
Gc8_227 0 n16 ns227 0 -0.000228580953087
Gc8_228 0 n16 ns228 0 7.5049459017e-05
Gc8_229 0 n16 ns229 0 0.000328938231857
Gc8_230 0 n16 ns230 0 -0.00258343231928
Gc8_231 0 n16 ns231 0 0.000214377689523
Gc8_232 0 n16 ns232 0 -0.00146455675192
Gc8_233 0 n16 ns233 0 -0.00086858382478
Gc8_234 0 n16 ns234 0 5.07429121585e-05
Gc8_235 0 n16 ns235 0 0.000400414571728
Gc8_236 0 n16 ns236 0 -0.000401288818115
Gc8_237 0 n16 ns237 0 0.000134621127757
Gc8_238 0 n16 ns238 0 -1.67659610846e-05
Gc8_239 0 n16 ns239 0 0.000266014565761
Gc8_240 0 n16 ns240 0 8.21433362249e-05
Gc8_241 0 n16 ns241 0 -0.000268207638048
Gc8_242 0 n16 ns242 0 0.000481267284426
Gc8_243 0 n16 ns243 0 0.000585451387836
Gc8_244 0 n16 ns244 0 4.82711719927e-05
Gc8_245 0 n16 ns245 0 0.00109008561734
Gc8_246 0 n16 ns246 0 0.0001647693666
Gc8_247 0 n16 ns247 0 0.000547372645724
Gc8_248 0 n16 ns248 0 -0.000157985480231
Gc8_249 0 n16 ns249 0 0.000181085227685
Gc8_250 0 n16 ns250 0 0.00154059854072
Gc8_251 0 n16 ns251 0 -0.000106083724669
Gc8_252 0 n16 ns252 0 0.00470693489453
Gc8_253 0 n16 ns253 0 -0.000373199940967
Gc8_254 0 n16 ns254 0 0.00501685430002
Gc8_255 0 n16 ns255 0 0.00269210678951
Gc8_256 0 n16 ns256 0 8.61831812475e-05
Gc8_257 0 n16 ns257 0 0.00111605562462
Gc8_258 0 n16 ns258 0 -0.000981348383626
Gc8_259 0 n16 ns259 0 -0.00096042613586
Gc8_260 0 n16 ns260 0 -0.00114754590455
Gc8_261 0 n16 ns261 0 -0.00363613253223
Gc8_262 0 n16 ns262 0 0.00017428044376
Gc8_263 0 n16 ns263 0 0.00316618903387
Gc8_264 0 n16 ns264 0 1.74246910019e-05
Gc8_265 0 n16 ns265 0 -0.000152567975518
Gc8_266 0 n16 ns266 0 1.6261314963e-05
Gc8_267 0 n16 ns267 0 0.000489599261472
Gc8_268 0 n16 ns268 0 -0.00220782922069
Gc8_269 0 n16 ns269 0 -0.0013118478914
Gc8_270 0 n16 ns270 0 0.00024963540067
Gc8_271 0 n16 ns271 0 -0.000589453183694
Gc8_272 0 n16 ns272 0 0.000253140283809
Gc8_273 0 n16 ns273 0 0.000383295821958
Gc8_274 0 n16 ns274 0 -0.000152212317214
Gc8_275 0 n16 ns275 0 0.000428384808386
Gc8_276 0 n16 ns276 0 0.000215384946227
Gc8_277 0 n16 ns277 0 0.00022312930578
Gc8_278 0 n16 ns278 0 0.00012299269288
Gc8_279 0 n16 ns279 0 -0.000692795385511
Gc8_280 0 n16 ns280 0 -0.000510290986818
Gc8_281 0 n16 ns281 0 -0.000552674116328
Gc8_282 0 n16 ns282 0 0.00028577927245
Gc8_283 0 n16 ns283 0 0.000210123997977
Gc8_284 0 n16 ns284 0 0.000360929892249
Gc8_285 0 n16 ns285 0 -0.000587102446668
Gc8_286 0 n16 ns286 0 -0.000699732824339
Gc8_287 0 n16 ns287 0 -0.000480303738504
Gc8_288 0 n16 ns288 0 -0.000489207903591
Gc8_289 0 n16 ns289 0 0.00353294672445
Gc8_290 0 n16 ns290 0 0.00369192413948
Gc8_291 0 n16 ns291 0 0.00205102696805
Gc8_292 0 n16 ns292 0 0.00409634319208
Gc8_293 0 n16 ns293 0 0.000564949487832
Gc8_294 0 n16 ns294 0 0.00447484121255
Gc8_295 0 n16 ns295 0 0.00125629412618
Gc8_296 0 n16 ns296 0 -0.000686974393223
Gc8_297 0 n16 ns297 0 -0.0050823423741
Gc8_298 0 n16 ns298 0 -0.000954144598953
Gc8_299 0 n16 ns299 0 0.00290586518381
Gc8_300 0 n16 ns300 0 -0.00396410143742
Gc8_301 0 n16 ns301 0 0.00488648619319
Gc8_302 0 n16 ns302 0 -3.40685555834e-05
Gc8_303 0 n16 ns303 0 -1.30237228375e-05
Gc8_304 0 n16 ns304 0 -4.09753548973e-05
Gc8_305 0 n16 ns305 0 0.000742507268186
Gc8_306 0 n16 ns306 0 -0.00247513327544
Gc8_307 0 n16 ns307 0 0.00117822420973
Gc8_308 0 n16 ns308 0 -0.00174421865199
Gc8_309 0 n16 ns309 0 -0.00106128404931
Gc8_310 0 n16 ns310 0 -0.000184343301618
Gc8_311 0 n16 ns311 0 0.000334508966664
Gc8_312 0 n16 ns312 0 -0.000330353426178
Gc8_313 0 n16 ns313 0 0.000364964848937
Gc8_314 0 n16 ns314 0 0.000669517558087
Gc8_315 0 n16 ns315 0 0.000112633917252
Gc8_316 0 n16 ns316 0 9.25620864137e-05
Gc8_317 0 n16 ns317 0 -0.000122004386595
Gc8_318 0 n16 ns318 0 0.000373435922091
Gc8_319 0 n16 ns319 0 0.000672942550779
Gc8_320 0 n16 ns320 0 -0.00160009095586
Gc8_321 0 n16 ns321 0 0.000640281161839
Gc8_322 0 n16 ns322 0 -4.4820236717e-05
Gc8_323 0 n16 ns323 0 0.000656067521671
Gc8_324 0 n16 ns324 0 -0.00060216936429
Gc8_325 0 n16 ns325 0 0.0015371935165
Gc8_326 0 n16 ns326 0 0.00268466513011
Gc8_327 0 n16 ns327 0 0.000649045805521
Gc8_328 0 n16 ns328 0 0.00184259278804
Gc8_329 0 n16 ns329 0 -0.000143802273069
Gc8_330 0 n16 ns330 0 0.00223858824272
Gc8_331 0 n16 ns331 0 0.0050461024781
Gc8_332 0 n16 ns332 0 -0.000416737426141
Gc8_333 0 n16 ns333 0 0.00116334445937
Gc8_334 0 n16 ns334 0 -0.000447551628365
Gc8_335 0 n16 ns335 0 -0.00165934130158
Gc8_336 0 n16 ns336 0 -0.000127431713172
Gc8_337 0 n16 ns337 0 -0.00373685663722
Gc8_338 0 n16 ns338 0 -0.00107662427629
Gc8_339 0 n16 ns339 0 0.00295498568929
Gc8_340 0 n16 ns340 0 2.58447998153e-05
Gc8_341 0 n16 ns341 0 -0.000183977757365
Gc8_342 0 n16 ns342 0 3.92526294848e-05
Gc8_343 0 n16 ns343 0 0.00034125671403
Gc8_344 0 n16 ns344 0 0.000262052134632
Gc8_345 0 n16 ns345 0 0.00128351059597
Gc8_346 0 n16 ns346 0 0.000167693262984
Gc8_347 0 n16 ns347 0 7.1808679525e-05
Gc8_348 0 n16 ns348 0 4.67056830274e-05
Gc8_349 0 n16 ns349 0 9.82453114604e-06
Gc8_350 0 n16 ns350 0 1.98072382647e-05
Gc8_351 0 n16 ns351 0 0.00030104686771
Gc8_352 0 n16 ns352 0 0.000139401920849
Gc8_353 0 n16 ns353 0 -5.21727539372e-05
Gc8_354 0 n16 ns354 0 -6.26435079106e-05
Gc8_355 0 n16 ns355 0 -0.000336874742496
Gc8_356 0 n16 ns356 0 -0.00025934322444
Gc8_357 0 n16 ns357 0 -0.00029681912186
Gc8_358 0 n16 ns358 0 -0.000613410439328
Gc8_359 0 n16 ns359 0 -0.000338098374327
Gc8_360 0 n16 ns360 0 -0.000315014649895
Gc8_361 0 n16 ns361 0 -0.000307756016139
Gc8_362 0 n16 ns362 0 -0.000475814080868
Gc8_363 0 n16 ns363 0 0.000654142420974
Gc8_364 0 n16 ns364 0 0.000242873490363
Gc8_365 0 n16 ns365 0 0.00227000415931
Gc8_366 0 n16 ns366 0 -0.000747889993291
Gc8_367 0 n16 ns367 0 0.00195449521594
Gc8_368 0 n16 ns368 0 -0.000748899177292
Gc8_369 0 n16 ns369 0 0.00058990971106
Gc8_370 0 n16 ns370 0 0.000555526283785
Gc8_371 0 n16 ns371 0 -0.000216582103022
Gc8_372 0 n16 ns372 0 -0.000159454612653
Gc8_373 0 n16 ns373 0 -0.000910431364308
Gc8_374 0 n16 ns374 0 -0.000556917065969
Gc8_375 0 n16 ns375 0 -0.000366426978937
Gc8_376 0 n16 ns376 0 -0.000510217034625
Gc8_377 0 n16 ns377 0 -3.80987694786e-05
Gc8_378 0 n16 ns378 0 2.89375821049e-05
Gc8_379 0 n16 ns379 0 -3.87084411156e-05
Gc8_380 0 n16 ns380 0 9.04676006768e-06
Gc8_381 0 n16 ns381 0 6.34959283086e-05
Gc8_382 0 n16 ns382 0 0.0003242130625
Gc8_383 0 n16 ns383 0 0.000264684023124
Gc8_384 0 n16 ns384 0 0.000567988235359
Gc8_385 0 n16 ns385 0 -2.26430668744e-05
Gc8_386 0 n16 ns386 0 3.89603352948e-05
Gc8_387 0 n16 ns387 0 -4.10965702489e-05
Gc8_388 0 n16 ns388 0 -2.04442250247e-05
Gc8_389 0 n16 ns389 0 -2.54957182889e-05
Gc8_390 0 n16 ns390 0 0.000359033929394
Gc8_391 0 n16 ns391 0 -4.39511057938e-06
Gc8_392 0 n16 ns392 0 -0.000123482176235
Gc8_393 0 n16 ns393 0 -4.10125099293e-05
Gc8_394 0 n16 ns394 0 -0.000240625095009
Gc8_395 0 n16 ns395 0 0.000434782828372
Gc8_396 0 n16 ns396 0 -0.00061936974851
Gc8_397 0 n16 ns397 0 -7.98879125953e-05
Gc8_398 0 n16 ns398 0 -0.000582526247003
Gc8_399 0 n16 ns399 0 -1.22873528405e-05
Gc8_400 0 n16 ns400 0 -0.000560606121284
Gc8_401 0 n16 ns401 0 0.000260419221134
Gc8_402 0 n16 ns402 0 0.0007044314174
Gc8_403 0 n16 ns403 0 0.00354977209254
Gc8_404 0 n16 ns404 0 0.00106571820472
Gc8_405 0 n16 ns405 0 0.00321786339567
Gc8_406 0 n16 ns406 0 0.000798464714307
Gc8_407 0 n16 ns407 0 0.000470280746917
Gc8_408 0 n16 ns408 0 0.000955008631506
Gc8_409 0 n16 ns409 0 -0.000321409355416
Gc8_410 0 n16 ns410 0 -0.00034466908654
Gc8_411 0 n16 ns411 0 -0.00125097768047
Gc8_412 0 n16 ns412 0 -0.000923473030828
Gc8_413 0 n16 ns413 0 -0.000515387897152
Gc8_414 0 n16 ns414 0 -0.000138322110947
Gc8_415 0 n16 ns415 0 0.000115232724256
Gc8_416 0 n16 ns416 0 1.05711525061e-05
Gc8_417 0 n16 ns417 0 -3.98991402681e-05
Gc8_418 0 n16 ns418 0 -1.57125023187e-05
Gc8_419 0 n16 ns419 0 -7.37781512843e-05
Gc8_420 0 n16 ns420 0 -2.38015466068e-05
Gc8_421 0 n16 ns421 0 1.29286173731e-05
Gc8_422 0 n16 ns422 0 0.000562969117057
Gc8_423 0 n16 ns423 0 2.96975420157e-05
Gc8_424 0 n16 ns424 0 2.47476133905e-06
Gc8_425 0 n16 ns425 0 6.86126817688e-05
Gc8_426 0 n16 ns426 0 -5.1071340493e-05
Gc8_427 0 n16 ns427 0 -0.00025377872625
Gc8_428 0 n16 ns428 0 0.000105567412438
Gc8_429 0 n16 ns429 0 8.87017380998e-05
Gc8_430 0 n16 ns430 0 -0.000154460924018
Gc8_431 0 n16 ns431 0 -0.000200135170803
Gc8_432 0 n16 ns432 0 -0.000174491040424
Gc8_433 0 n16 ns433 0 0.00055479641617
Gc8_434 0 n16 ns434 0 0.000238905508314
Gc8_435 0 n16 ns435 0 0.000233022341848
Gc8_436 0 n16 ns436 0 -0.000527963340495
Gc8_437 0 n16 ns437 0 -1.34064744412e-05
Gc8_438 0 n16 ns438 0 -0.000395646860198
Gc8_439 0 n16 ns439 0 -0.00045430075817
Gc8_440 0 n16 ns440 0 0.000228646344701
Gc8_441 0 n16 ns441 0 0.00309176594059
Gc8_442 0 n16 ns442 0 0.00329439383045
Gc8_443 0 n16 ns443 0 0.00302920593682
Gc8_444 0 n16 ns444 0 0.0029470733492
Gc8_445 0 n16 ns445 0 -0.000632073251671
Gc8_446 0 n16 ns446 0 0.000973803890091
Gc8_447 0 n16 ns447 0 -0.000233277640409
Gc8_448 0 n16 ns448 0 -0.000648301509837
Gc8_449 0 n16 ns449 0 -0.000754991947528
Gc8_450 0 n16 ns450 0 -0.00134640591164
Gc8_451 0 n16 ns451 0 -0.000567372429927
Gc8_452 0 n16 ns452 0 0.000434421238945
Gc8_453 0 n16 ns453 0 0.000354060104002
Gc8_454 0 n16 ns454 0 -3.26023714998e-06
Gc8_455 0 n16 ns455 0 -5.48584462824e-05
Gc8_456 0 n16 ns456 0 -1.8299213819e-05
Gc8_457 0 n16 ns457 0 -1.83095052354e-05
Gc8_458 0 n16 ns458 0 -0.000254369875599
Gc8_459 0 n16 ns459 0 0.000100289974535
Gc8_460 0 n16 ns460 0 0.000425441601886
Gc8_461 0 n16 ns461 0 0.000196348684385
Gc8_462 0 n16 ns462 0 0.000319639320912
Gc8_463 0 n16 ns463 0 -0.000189812744789
Gc8_464 0 n16 ns464 0 -3.9656458561e-05
Gc8_465 0 n16 ns465 0 -8.55901175192e-05
Gc8_466 0 n16 ns466 0 -0.000332046934165
Gc8_467 0 n16 ns467 0 0.000166116729729
Gc8_468 0 n16 ns468 0 -7.10338843036e-05
Gc8_469 0 n16 ns469 0 8.77861673826e-05
Gc8_470 0 n16 ns470 0 -0.000213172367167
Gc8_471 0 n16 ns471 0 -0.000295215365001
Gc8_472 0 n16 ns472 0 0.00029971072616
Gc8_473 0 n16 ns473 0 0.000409319422224
Gc8_474 0 n16 ns474 0 -0.000485328432911
Gc8_475 0 n16 ns475 0 -7.32283325022e-05
Gc8_476 0 n16 ns476 0 -0.000692339557502
Gc8_477 0 n16 ns477 0 0.000294621045082
Gc8_478 0 n16 ns478 0 -0.00082914343106
Gc8_479 0 n16 ns479 0 0.00179934791668
Gc8_480 0 n16 ns480 0 0.00385027123154
Gc8_481 0 n16 ns481 0 0.00183193807789
Gc8_482 0 n16 ns482 0 0.00390236562095
Gc8_483 0 n16 ns483 0 -0.00200564364631
Gc8_484 0 n16 ns484 0 -0.000723080841057
Gc8_485 0 n16 ns485 0 0.00025667538587
Gc8_486 0 n16 ns486 0 -0.00100763358379
Gc8_487 0 n16 ns487 0 0.000439222967436
Gc8_488 0 n16 ns488 0 -0.00107493954175
Gc8_489 0 n16 ns489 0 -0.000919728079869
Gc8_490 0 n16 ns490 0 0.0021563348773
Gc8_491 0 n16 ns491 0 0.00109798963798
Gc8_492 0 n16 ns492 0 2.72225147425e-05
Gc8_493 0 n16 ns493 0 -0.000239915351312
Gc8_494 0 n16 ns494 0 8.87064154011e-05
Gc8_495 0 n16 ns495 0 0.000375062292251
Gc8_496 0 n16 ns496 0 -0.00233876427883
Gc8_497 0 n16 ns497 0 0.00052306595033
Gc8_498 0 n16 ns498 0 -0.00216804780959
Gc8_499 0 n16 ns499 0 -0.000779275755427
Gc8_500 0 n16 ns500 0 -0.000222734385804
Gc8_501 0 n16 ns501 0 0.000166603061486
Gc8_502 0 n16 ns502 0 -0.000240594661772
Gc8_503 0 n16 ns503 0 -1.78922464631e-05
Gc8_504 0 n16 ns504 0 -0.000203008648941
Gc8_505 0 n16 ns505 0 0.000230291521868
Gc8_506 0 n16 ns506 0 7.07510193756e-05
Gc8_507 0 n16 ns507 0 0.000281077326973
Gc8_508 0 n16 ns508 0 0.000864504922038
Gc8_509 0 n16 ns509 0 0.000366200078366
Gc8_510 0 n16 ns510 0 -7.61330088572e-05
Gc8_511 0 n16 ns511 0 0.00103393905263
Gc8_512 0 n16 ns512 0 -4.38054183485e-05
Gc8_513 0 n16 ns513 0 0.000612619205016
Gc8_514 0 n16 ns514 0 -0.000180947874767
Gc8_515 0 n16 ns515 0 0.00088772646774
Gc8_516 0 n16 ns516 0 0.000837102106317
Gc8_517 0 n16 ns517 0 6.02573667353e-05
Gc8_518 0 n16 ns518 0 0.00450451399823
Gc8_519 0 n16 ns519 0 -4.51617509125e-05
Gc8_520 0 n16 ns520 0 0.0047557957216
Gc8_521 0 n16 ns521 0 0.000816858301761
Gc8_522 0 n16 ns522 0 -0.00211610103346
Gc8_523 0 n16 ns523 0 0.00100837174464
Gc8_524 0 n16 ns524 0 -0.000952915374744
Gc8_525 0 n16 ns525 0 0.000276547092802
Gc8_526 0 n16 ns526 0 -0.000276134395575
Gc8_527 0 n16 ns527 0 -0.00303533528233
Gc8_528 0 n16 ns528 0 0.0028282320696
Gc8_529 0 n16 ns529 0 0.00272311193564
Gc8_530 0 n16 ns530 0 -4.90084365949e-06
Gc8_531 0 n16 ns531 0 -0.000124993087996
Gc8_532 0 n16 ns532 0 2.6578709321e-06
Gc8_533 0 n16 ns533 0 0.00105389927989
Gc8_534 0 n16 ns534 0 -0.00413160518092
Gc8_535 0 n16 ns535 0 -0.000329760538197
Gc8_536 0 n16 ns536 0 -0.00186250893005
Gc8_537 0 n16 ns537 0 -0.000942772151902
Gc8_538 0 n16 ns538 0 -0.000180598083406
Gc8_539 0 n16 ns539 0 0.000606318606346
Gc8_540 0 n16 ns540 0 -4.31749570747e-05
Gc8_541 0 n16 ns541 0 0.000293777785562
Gc8_542 0 n16 ns542 0 5.31422633225e-05
Gc8_543 0 n16 ns543 0 0.000238398626612
Gc8_544 0 n16 ns544 0 0.000115055283471
Gc8_545 0 n16 ns545 0 -0.00057495919004
Gc8_546 0 n16 ns546 0 -0.000161559831695
Gc8_547 0 n16 ns547 0 -0.000619509380727
Gc8_548 0 n16 ns548 0 0.000528716396911
Gc8_549 0 n16 ns549 0 0.000324378570739
Gc8_550 0 n16 ns550 0 0.00029934476083
Gc8_551 0 n16 ns551 0 -0.000506976261147
Gc8_552 0 n16 ns552 0 -0.00066730097896
Gc8_553 0 n16 ns553 0 -0.000460881655094
Gc8_554 0 n16 ns554 0 -0.000758131558259
Gc8_555 0 n16 ns555 0 0.00312787173865
Gc8_556 0 n16 ns556 0 0.00527807043967
Gc8_557 0 n16 ns557 0 0.00182497084106
Gc8_558 0 n16 ns558 0 0.00543127791548
Gc8_559 0 n16 ns559 0 -0.000136134600479
Gc8_560 0 n16 ns560 0 0.00455287949428
Gc8_561 0 n16 ns561 0 0.00115515692577
Gc8_562 0 n16 ns562 0 -0.000841883382615
Gc8_563 0 n16 ns563 0 -0.00525726050761
Gc8_564 0 n16 ns564 0 -0.00151994289152
Gc8_565 0 n16 ns565 0 0.00348602883279
Gc8_566 0 n16 ns566 0 -0.00472688923247
Gc8_567 0 n16 ns567 0 0.00467215533512
Gc8_568 0 n16 ns568 0 -1.54563207725e-05
Gc8_569 0 n16 ns569 0 -7.89566986829e-05
Gc8_570 0 n16 ns570 0 -1.07992767516e-05
Gc8_571 0 n16 ns571 0 0.00139312037015
Gc8_572 0 n16 ns572 0 -0.00457156842908
Gc8_573 0 n16 ns573 0 0.00163821038308
Gc8_574 0 n16 ns574 0 -0.00357033154217
Gc8_575 0 n16 ns575 0 -0.001356577623
Gc8_576 0 n16 ns576 0 -0.000731666636543
Gc8_577 0 n16 ns577 0 0.000581179634787
Gc8_578 0 n16 ns578 0 -3.14104748893e-05
Gc8_579 0 n16 ns579 0 0.000386512826599
Gc8_580 0 n16 ns580 0 0.000609326942927
Gc8_581 0 n16 ns581 0 0.000148488770832
Gc8_582 0 n16 ns582 0 0.000113648805254
Gc8_583 0 n16 ns583 0 -0.000249483496317
Gc8_584 0 n16 ns584 0 0.000412662253449
Gc8_585 0 n16 ns585 0 0.000113779530494
Gc8_586 0 n16 ns586 0 -0.00128101935478
Gc8_587 0 n16 ns587 0 0.000466065116236
Gc8_588 0 n16 ns588 0 -1.51371403272e-05
Gc8_589 0 n16 ns589 0 0.000247647024879
Gc8_590 0 n16 ns590 0 -0.000860973787337
Gc8_591 0 n16 ns591 0 0.00160159638942
Gc8_592 0 n16 ns592 0 0.00165559385673
Gc8_593 0 n16 ns593 0 0.00259851100068
Gc8_594 0 n16 ns594 0 0.00325151257015
Gc8_595 0 n16 ns595 0 0.00128102578139
Gc8_596 0 n16 ns596 0 0.00352740244551
Gc8_597 0 n16 ns597 0 0.00346038575457
Gc8_598 0 n16 ns598 0 0.000716494141805
Gc8_599 0 n16 ns599 0 0.00128617537805
Gc8_600 0 n16 ns600 0 -0.000545264818934
Gc8_601 0 n16 ns601 0 -0.00348859135411
Gc8_602 0 n16 ns602 0 -0.00013756011124
Gc8_603 0 n16 ns603 0 -0.000594426782848
Gc8_604 0 n16 ns604 0 -0.00233170240929
Gc8_605 0 n16 ns605 0 0.00383983361091
Gc8_606 0 n16 ns606 0 8.77556015293e-06
Gc8_607 0 n16 ns607 0 -0.000162565426253
Gc8_608 0 n16 ns608 0 4.97980175604e-05
Gc8_609 0 n16 ns609 0 0.000339874127514
Gc8_610 0 n16 ns610 0 -0.00022556120351
Gc8_611 0 n16 ns611 0 0.000885966382614
Gc8_612 0 n16 ns612 0 -0.000488391549774
Gc8_613 0 n16 ns613 0 0.000165990096813
Gc8_614 0 n16 ns614 0 -0.00023725379725
Gc8_615 0 n16 ns615 0 -0.000131125358472
Gc8_616 0 n16 ns616 0 0.000152259832937
Gc8_617 0 n16 ns617 0 -0.00013886685583
Gc8_618 0 n16 ns618 0 9.77970873208e-05
Gc8_619 0 n16 ns619 0 6.05022889102e-05
Gc8_620 0 n16 ns620 0 -4.21813126753e-05
Gc8_621 0 n16 ns621 0 -0.000136572571546
Gc8_622 0 n16 ns622 0 -0.000178735022549
Gc8_623 0 n16 ns623 0 -0.000360964715147
Gc8_624 0 n16 ns624 0 -2.36150539894e-05
Gc8_625 0 n16 ns625 0 -0.00026272211053
Gc8_626 0 n16 ns626 0 0.000131160585777
Gc8_627 0 n16 ns627 0 -0.000308746252699
Gc8_628 0 n16 ns628 0 0.00018134292939
Gc8_629 0 n16 ns629 0 -0.000185270377077
Gc8_630 0 n16 ns630 0 0.000116852335222
Gc8_631 0 n16 ns631 0 -0.000657480619516
Gc8_632 0 n16 ns632 0 0.00148535002665
Gc8_633 0 n16 ns633 0 -0.000554305413701
Gc8_634 0 n16 ns634 0 0.00130168966613
Gc8_635 0 n16 ns635 0 0.000487507391912
Gc8_636 0 n16 ns636 0 0.000214772917368
Gc8_637 0 n16 ns637 0 -0.000126610781503
Gc8_638 0 n16 ns638 0 -4.84595426013e-05
Gc8_639 0 n16 ns639 0 -0.000543221073488
Gc8_640 0 n16 ns640 0 -0.000160930857039
Gc8_641 0 n16 ns641 0 -7.42735569898e-05
Gc8_642 0 n16 ns642 0 -0.000234935571975
Gc8_643 0 n16 ns643 0 -9.17306255039e-05
Gc8_644 0 n16 ns644 0 -8.5344582482e-06
Gc8_645 0 n16 ns645 0 7.64037860564e-06
Gc8_646 0 n16 ns646 0 5.14791961713e-06
Gc8_647 0 n16 ns647 0 0.000108585199993
Gc8_648 0 n16 ns648 0 0.000194172316448
Gc8_649 0 n16 ns649 0 0.000395867229719
Gc8_650 0 n16 ns650 0 0.00010411459113
Gc8_651 0 n16 ns651 0 4.29655536066e-05
Gc8_652 0 n16 ns652 0 8.6293539952e-07
Gc8_653 0 n16 ns653 0 -5.7421104537e-05
Gc8_654 0 n16 ns654 0 1.46612939505e-06
Gc8_655 0 n16 ns655 0 -0.000131660879387
Gc8_656 0 n16 ns656 0 0.00016351569515
Gc8_657 0 n16 ns657 0 9.84200222425e-05
Gc8_658 0 n16 ns658 0 -4.3443839798e-05
Gc8_659 0 n16 ns659 0 -5.25115841498e-05
Gc8_660 0 n16 ns660 0 -0.000402094205223
Gc8_661 0 n16 ns661 0 -0.000325818531596
Gc8_662 0 n16 ns662 0 -0.000208766297053
Gc8_663 0 n16 ns663 0 -0.000290854164305
Gc8_664 0 n16 ns664 0 5.09312040667e-05
Gc8_665 0 n16 ns665 0 -0.000297526410582
Gc8_666 0 n16 ns666 0 0.000101472735271
Gc8_667 0 n16 ns667 0 -0.00029754957101
Gc8_668 0 n16 ns668 0 0.000230693650351
Gc8_669 0 n16 ns669 0 -0.00131950733076
Gc8_670 0 n16 ns670 0 0.00205219913527
Gc8_671 0 n16 ns671 0 -0.00112121375249
Gc8_672 0 n16 ns672 0 0.00179046305537
Gc8_673 0 n16 ns673 0 0.000722706176625
Gc8_674 0 n16 ns674 0 0.000520070179679
Gc8_675 0 n16 ns675 0 -0.000186195716888
Gc8_676 0 n16 ns676 0 -9.4766639736e-05
Gc8_677 0 n16 ns677 0 -0.000796432506058
Gc8_678 0 n16 ns678 0 -0.000418806394182
Gc8_679 0 n16 ns679 0 -0.000139638606611
Gc8_680 0 n16 ns680 0 -0.000546864728919
Gc8_681 0 n16 ns681 0 -0.000161762972646
Gc8_682 0 n16 ns682 0 -1.12980650301e-05
Gc8_683 0 n16 ns683 0 1.08742357641e-05
Gc8_684 0 n16 ns684 0 1.17637430139e-06
Gc8_685 0 n16 ns685 0 -0.000309645756097
Gc8_686 0 n16 ns686 0 0.00104939079272
Gc8_687 0 n16 ns687 0 -0.000518464289148
Gc8_688 0 n16 ns688 0 0.00130020981135
Gc8_689 0 n16 ns689 0 -0.000100416204138
Gc8_690 0 n16 ns690 0 0.000502219936245
Gc8_691 0 n16 ns691 0 9.4038934259e-05
Gc8_692 0 n16 ns692 0 -0.000316032747287
Gc8_693 0 n16 ns693 0 -6.49201299791e-06
Gc8_694 0 n16 ns694 0 -1.47945153047e-05
Gc8_695 0 n16 ns695 0 0.000102895420304
Gc8_696 0 n16 ns696 0 3.68032435009e-05
Gc8_697 0 n16 ns697 0 0.000220808321159
Gc8_698 0 n16 ns698 0 -0.000460301794488
Gc8_699 0 n16 ns699 0 5.70121650488e-05
Gc8_700 0 n16 ns700 0 -0.000685231640579
Gc8_701 0 n16 ns701 0 -0.000286531082479
Gc8_702 0 n16 ns702 0 -0.000365967407647
Gc8_703 0 n16 ns703 0 -0.000256022785064
Gc8_704 0 n16 ns704 0 -0.000340176796804
Gc8_705 0 n16 ns705 0 -0.00045856445532
Gc8_706 0 n16 ns706 0 0.000160931431638
Gc8_707 0 n16 ns707 0 -0.00364436858384
Gc8_708 0 n16 ns708 0 0.00191942678858
Gc8_709 0 n16 ns709 0 -0.00317126488814
Gc8_710 0 n16 ns710 0 0.00169926945834
Gc8_711 0 n16 ns711 0 0.00102939776042
Gc8_712 0 n16 ns712 0 0.00139813329889
Gc8_713 0 n16 ns713 0 -0.000336127507536
Gc8_714 0 n16 ns714 0 -0.000269965530495
Gc8_715 0 n16 ns715 0 -0.00134465367221
Gc8_716 0 n16 ns716 0 -0.0011676845307
Gc8_717 0 n16 ns717 0 -0.000268918817291
Gc8_718 0 n16 ns718 0 -0.00119237177019
Gc8_719 0 n16 ns719 0 -0.000312961446798
Gc8_720 0 n16 ns720 0 -6.98090765827e-06
Gc8_721 0 n16 ns721 0 1.5729915231e-05
Gc8_722 0 n16 ns722 0 1.64313436152e-05
Gc8_723 0 n16 ns723 0 0.000488215690009
Gc8_724 0 n16 ns724 0 -0.000685417370032
Gc8_725 0 n16 ns725 0 0.00149508776148
Gc8_726 0 n16 ns726 0 -0.000962338399945
Gc8_727 0 n16 ns727 0 0.000307626185351
Gc8_728 0 n16 ns728 0 -0.00022314881067
Gc8_729 0 n16 ns729 0 -0.000137317790787
Gc8_730 0 n16 ns730 0 0.0001363963065
Gc8_731 0 n16 ns731 0 0.000179442298025
Gc8_732 0 n16 ns732 0 -0.000532171927999
Gc8_733 0 n16 ns733 0 -8.42899396877e-05
Gc8_734 0 n16 ns734 0 0.000159626007482
Gc8_735 0 n16 ns735 0 -5.31554809836e-05
Gc8_736 0 n16 ns736 0 0.000613864477379
Gc8_737 0 n16 ns737 0 0.000399081272949
Gc8_738 0 n16 ns738 0 -0.0001330403344
Gc8_739 0 n16 ns739 0 -0.0001309189935
Gc8_740 0 n16 ns740 0 -0.000532596952652
Gc8_741 0 n16 ns741 0 -0.000331557458143
Gc8_742 0 n16 ns742 0 -0.000455872754232
Gc8_743 0 n16 ns743 0 -7.49397861838e-05
Gc8_744 0 n16 ns744 0 -0.000592384107714
Gc8_745 0 n16 ns745 0 -0.00487894036605
Gc8_746 0 n16 ns746 0 -0.00207523971498
Gc8_747 0 n16 ns747 0 -0.00442309939474
Gc8_748 0 n16 ns748 0 -0.00173761382462
Gc8_749 0 n16 ns749 0 0.000357589735458
Gc8_750 0 n16 ns750 0 0.00152690591307
Gc8_751 0 n16 ns751 0 -0.000350710279113
Gc8_752 0 n16 ns752 0 -0.000467406326551
Gc8_753 0 n16 ns753 0 -0.00121995044378
Gc8_754 0 n16 ns754 0 -0.00142605051837
Gc8_755 0 n16 ns755 0 -0.000164128320365
Gc8_756 0 n16 ns756 0 -0.000962237918476
Gc8_757 0 n16 ns757 0 -0.000297879011076
Gc8_758 0 n16 ns758 0 -5.46233197747e-06
Gc8_759 0 n16 ns759 0 2.75477371383e-05
Gc8_760 0 n16 ns760 0 2.93176383896e-05
Gc8_761 0 n16 ns761 0 -0.000571102139118
Gc8_762 0 n16 ns762 0 0.000326627119998
Gc8_763 0 n16 ns763 0 -0.00150028812482
Gc8_764 0 n16 ns764 0 0.0013138876896
Gc8_765 0 n16 ns765 0 -0.000417114622769
Gc8_766 0 n16 ns766 0 0.000378784619702
Gc8_767 0 n16 ns767 0 0.000133910639961
Gc8_768 0 n16 ns768 0 -0.000197623273316
Gc8_769 0 n16 ns769 0 0.000303018781128
Gc8_770 0 n16 ns770 0 0.000350300994123
Gc8_771 0 n16 ns771 0 -6.4990626828e-05
Gc8_772 0 n16 ns772 0 0.000124296983459
Gc8_773 0 n16 ns773 0 0.000211491369981
Gc8_774 0 n16 ns774 0 -0.00038982102647
Gc8_775 0 n16 ns775 0 0.000651944550493
Gc8_776 0 n16 ns776 0 0.000434496129858
Gc8_777 0 n16 ns777 0 0.000565583739023
Gc8_778 0 n16 ns778 0 -0.000455041721836
Gc8_779 0 n16 ns779 0 0.000354369114919
Gc8_780 0 n16 ns780 0 -0.000246329264025
Gc8_781 0 n16 ns781 0 -0.000113885252794
Gc8_782 0 n16 ns782 0 2.62077782572e-05
Gc8_783 0 n16 ns783 0 -0.00437529139622
Gc8_784 0 n16 ns784 0 -0.00497169656349
Gc8_785 0 n16 ns785 0 -0.00411395900548
Gc8_786 0 n16 ns786 0 -0.00452537711666
Gc8_787 0 n16 ns787 0 -0.000811437939593
Gc8_788 0 n16 ns788 0 0.0020001678759
Gc8_789 0 n16 ns789 0 -0.000188166986599
Gc8_790 0 n16 ns790 0 -0.000966006876076
Gc8_791 0 n16 ns791 0 -0.000603898653783
Gc8_792 0 n16 ns792 0 -0.00261180305234
Gc8_793 0 n16 ns793 0 0.000178485427481
Gc8_794 0 n16 ns794 0 -0.00176010259431
Gc8_795 0 n16 ns795 0 -0.000642340124405
Gc8_796 0 n16 ns796 0 -2.04910390296e-05
Gc8_797 0 n16 ns797 0 9.93429774242e-05
Gc8_798 0 n16 ns798 0 -2.21203249685e-05
Gc8_799 0 n16 ns799 0 -0.000439977186523
Gc8_800 0 n16 ns800 0 0.000100318801306
Gc8_801 0 n16 ns801 0 -0.000959039383612
Gc8_802 0 n16 ns802 0 0.00246121043713
Gc8_803 0 n16 ns803 0 -0.00013714232758
Gc8_804 0 n16 ns804 0 0.000414580234829
Gc8_805 0 n16 ns805 0 0.000193709678712
Gc8_806 0 n16 ns806 0 -0.000271990411177
Gc8_807 0 n16 ns807 0 1.77136054771e-05
Gc8_808 0 n16 ns808 0 0.000519398896903
Gc8_809 0 n16 ns809 0 -0.000171951620689
Gc8_810 0 n16 ns810 0 5.61484000395e-05
Gc8_811 0 n16 ns811 0 0.000648114849442
Gc8_812 0 n16 ns812 0 -0.000498358428919
Gc8_813 0 n16 ns813 0 2.94120563832e-05
Gc8_814 0 n16 ns814 0 -0.000131339341514
Gc8_815 0 n16 ns815 0 0.000813877871534
Gc8_816 0 n16 ns816 0 -0.000521382037082
Gc8_817 0 n16 ns817 0 0.000416475545357
Gc8_818 0 n16 ns818 0 -0.000762068214598
Gc8_819 0 n16 ns819 0 -0.000714579365363
Gc8_820 0 n16 ns820 0 0.00100179599931
Gc8_821 0 n16 ns821 0 -0.0018314526066
Gc8_822 0 n16 ns822 0 -0.00352970266381
Gc8_823 0 n16 ns823 0 -0.00174363037722
Gc8_824 0 n16 ns824 0 -0.00384488052601
Gc8_825 0 n16 ns825 0 -0.000574614434758
Gc8_826 0 n16 ns826 0 0.000819826467252
Gc8_827 0 n16 ns827 0 0.0003729159818
Gc8_828 0 n16 ns828 0 -0.00136069668028
Gc8_829 0 n16 ns829 0 9.44841637385e-05
Gc8_830 0 n16 ns830 0 -0.00297631587195
Gc8_831 0 n16 ns831 0 0.00108867309856
Gc8_832 0 n16 ns832 0 -0.00332326076905
Gc8_833 0 n16 ns833 0 -0.00160435748215
Gc8_834 0 n16 ns834 0 -2.36199404689e-05
Gc8_835 0 n16 ns835 0 8.28671450619e-05
Gc8_836 0 n16 ns836 0 5.3386502656e-06
Gc8_837 0 n16 ns837 0 -0.000741815749944
Gc8_838 0 n16 ns838 0 -0.000917455698829
Gc8_839 0 n16 ns839 0 -0.00326553412338
Gc8_840 0 n16 ns840 0 -0.00150342635183
Gc8_841 0 n16 ns841 0 -0.00182754269757
Gc8_842 0 n16 ns842 0 0.00103113401941
Gc8_843 0 n16 ns843 0 0.000718925776402
Gc8_844 0 n16 ns844 0 -0.000353998969304
Gc8_845 0 n16 ns845 0 -0.000284699813504
Gc8_846 0 n16 ns846 0 0.000446973417405
Gc8_847 0 n16 ns847 0 -0.000214832407108
Gc8_848 0 n16 ns848 0 -0.000100000771367
Gc8_849 0 n16 ns849 0 0.000209172137799
Gc8_850 0 n16 ns850 0 1.7108921407e-06
Gc8_851 0 n16 ns851 0 0.000767339958756
Gc8_852 0 n16 ns852 0 -0.000354909374506
Gc8_853 0 n16 ns853 0 0.0013828488494
Gc8_854 0 n16 ns854 0 -3.52426491133e-06
Gc8_855 0 n16 ns855 0 0.00126068119596
Gc8_856 0 n16 ns856 0 -0.000341491494201
Gc8_857 0 n16 ns857 0 -0.00159859662984
Gc8_858 0 n16 ns858 0 -0.000633281337296
Gc8_859 0 n16 ns859 0 -0.00273093612357
Gc8_860 0 n16 ns860 0 -0.00418985047579
Gc8_861 0 n16 ns861 0 -0.00191993711918
Gc8_862 0 n16 ns862 0 -0.00455443241018
Gc8_863 0 n16 ns863 0 0.00283621946188
Gc8_864 0 n16 ns864 0 0.00124910942333
Gc8_865 0 n16 ns865 0 0.00106265522543
Gc8_866 0 n16 ns866 0 -0.00115619039952
Gc8_867 0 n16 ns867 0 -0.00135817427635
Gc8_868 0 n16 ns868 0 -0.00255240608544
Gc8_869 0 n16 ns869 0 0.00266213922093
Gc8_870 0 n16 ns870 0 -0.000264712475534
Gc8_871 0 n16 ns871 0 -0.00315253749224
Gc8_872 0 n16 ns872 0 -3.14562942129e-05
Gc8_873 0 n16 ns873 0 0.000273284564036
Gc8_874 0 n16 ns874 0 -0.00013075955848
Gc8_875 0 n16 ns875 0 -0.000440545733582
Gc8_876 0 n16 ns876 0 -0.000130006732141
Gc8_877 0 n16 ns877 0 0.000291055687951
Gc8_878 0 n16 ns878 0 0.00236931807944
Gc8_879 0 n16 ns879 0 0.0012114819811
Gc8_880 0 n16 ns880 0 -0.00106305814421
Gc8_881 0 n16 ns881 0 -0.000288316592618
Gc8_882 0 n16 ns882 0 3.74741955125e-06
Gc8_883 0 n16 ns883 0 -0.000246036223983
Gc8_884 0 n16 ns884 0 0.000438315711001
Gc8_885 0 n16 ns885 0 -4.03268852889e-05
Gc8_886 0 n16 ns886 0 -0.000104578759085
Gc8_887 0 n16 ns887 0 0.00213411152709
Gc8_888 0 n16 ns888 0 -0.00122379909818
Gc8_889 0 n16 ns889 0 -0.00111060385669
Gc8_890 0 n16 ns890 0 0.00144807252864
Gc8_891 0 n16 ns891 0 -0.000411182293111
Gc8_892 0 n16 ns892 0 0.000659898418784
Gc8_893 0 n16 ns893 0 -0.0019464685629
Gc8_894 0 n16 ns894 0 -0.000672391850682
Gc8_895 0 n16 ns895 0 0.00290227853425
Gc8_896 0 n16 ns896 0 0.00430355646557
Gc8_897 0 n16 ns897 0 -0.00588217404697
Gc8_898 0 n16 ns898 0 0.00197949808084
Gc8_899 0 n16 ns899 0 -0.0038853985074
Gc8_900 0 n16 ns900 0 0.000358828795822
Gc8_901 0 n16 ns901 0 -0.0111822045703
Gc8_902 0 n16 ns902 0 -0.00171080403854
Gc8_903 0 n16 ns903 0 0.00180736680089
Gc8_904 0 n16 ns904 0 0.000212219399037
Gc8_905 0 n16 ns905 0 -0.00257381102816
Gc8_906 0 n16 ns906 0 0.00937612914572
Gc8_907 0 n16 ns907 0 -0.0139775336671
Gc8_908 0 n16 ns908 0 -0.00350659964543
Gc8_909 0 n16 ns909 0 -0.00617595947766
Gc8_910 0 n16 ns910 0 -5.56980611826e-05
Gc8_911 0 n16 ns911 0 -0.00042982804987
Gc8_912 0 n16 ns912 0 0.000593881242952
Gc8_913 0 n16 ns913 0 -0.00103540376209
Gc8_914 0 n16 ns914 0 -0.000303833756502
Gc8_915 0 n16 ns915 0 -0.00419603692882
Gc8_916 0 n16 ns916 0 -0.00173479833106
Gc8_917 0 n16 ns917 0 -0.00180608384707
Gc8_918 0 n16 ns918 0 0.00120316233805
Gc8_919 0 n16 ns919 0 0.000893483669925
Gc8_920 0 n16 ns920 0 -0.000415282247713
Gc8_921 0 n16 ns921 0 -0.000665322859023
Gc8_922 0 n16 ns922 0 -0.000250600552285
Gc8_923 0 n16 ns923 0 -8.64214384022e-05
Gc8_924 0 n16 ns924 0 -5.41318550702e-05
Gc8_925 0 n16 ns925 0 0.000738352281713
Gc8_926 0 n16 ns926 0 0.000527762226605
Gc8_927 0 n16 ns927 0 0.000658510044449
Gc8_928 0 n16 ns928 0 -0.00145934141866
Gc8_929 0 n16 ns929 0 0.000689307863534
Gc8_930 0 n16 ns930 0 9.43710717135e-05
Gc8_931 0 n16 ns931 0 0.00079611719257
Gc8_932 0 n16 ns932 0 -0.000335048342139
Gc8_933 0 n16 ns933 0 -0.00249795959488
Gc8_934 0 n16 ns934 0 -0.00106307520096
Gc8_935 0 n16 ns935 0 -0.00285875126163
Gc8_936 0 n16 ns936 0 0.000783158697159
Gc8_937 0 n16 ns937 0 -0.00162683857527
Gc8_938 0 n16 ns938 0 -4.42166289982e-05
Gc8_939 0 n16 ns939 0 0.00415186974936
Gc8_940 0 n16 ns940 0 0.000143476765727
Gc8_941 0 n16 ns941 0 0.00123096985394
Gc8_942 0 n16 ns942 0 -0.000539655024363
Gc8_943 0 n16 ns943 0 -0.001349516952
Gc8_944 0 n16 ns944 0 -0.000724918922058
Gc8_945 0 n16 ns945 0 0.00270725195232
Gc8_946 0 n16 ns946 0 0.00135617213958
Gc8_947 0 n16 ns947 0 -0.00286031773115
Gc8_948 0 n16 ns948 0 -3.87301326724e-05
Gc8_949 0 n16 ns949 0 0.000369392585985
Gc8_950 0 n16 ns950 0 -0.000192001944608
Gc8_951 0 n16 ns951 0 -0.000450702016649
Gc8_952 0 n16 ns952 0 0.00127564552589
Gc8_953 0 n16 ns953 0 -0.00093537353082
Gc8_954 0 n16 ns954 0 0.00159222030053
Gc8_955 0 n16 ns955 0 -0.000181875747494
Gc8_956 0 n16 ns956 0 0.000559699077247
Gc8_957 0 n16 ns957 0 0.000106342425683
Gc8_958 0 n16 ns958 0 -0.00032713601058
Gc8_959 0 n16 ns959 0 -4.10698949449e-05
Gc8_960 0 n16 ns960 0 0.000209729066399
Gc8_961 0 n16 ns961 0 0.000138227827947
Gc8_962 0 n16 ns962 0 -2.01175309856e-05
Gc8_963 0 n16 ns963 0 0.000175708605268
Gc8_964 0 n16 ns964 0 -0.000712771272308
Gc8_965 0 n16 ns965 0 -6.15313492142e-05
Gc8_966 0 n16 ns966 0 -0.000609866339127
Gc8_967 0 n16 ns967 0 -0.000256116836367
Gc8_968 0 n16 ns968 0 -0.000225551782816
Gc8_969 0 n16 ns969 0 -0.000186618090945
Gc8_970 0 n16 ns970 0 -0.000197080929218
Gc8_971 0 n16 ns971 0 -0.000466052063343
Gc8_972 0 n16 ns972 0 0.000320819278694
Gc8_973 0 n16 ns973 0 -0.00278010579884
Gc8_974 0 n16 ns974 0 0.00239695176124
Gc8_975 0 n16 ns975 0 -0.0023901754077
Gc8_976 0 n16 ns976 0 0.00209395890502
Gc8_977 0 n16 ns977 0 0.000967007244738
Gc8_978 0 n16 ns978 0 0.00114461536412
Gc8_979 0 n16 ns979 0 -0.000282678967816
Gc8_980 0 n16 ns980 0 -0.000205761263228
Gc8_981 0 n16 ns981 0 -0.00115463576403
Gc8_982 0 n16 ns982 0 -0.000946321727064
Gc8_983 0 n16 ns983 0 -0.000220408500385
Gc8_984 0 n16 ns984 0 -0.0010605753697
Gc8_985 0 n16 ns985 0 -0.000283495522124
Gc8_986 0 n16 ns986 0 -2.04613169234e-05
Gc8_987 0 n16 ns987 0 2.10886644725e-05
Gc8_988 0 n16 ns988 0 6.13873311487e-06
Gc8_989 0 n16 ns989 0 0.000425702128024
Gc8_990 0 n16 ns990 0 -0.000184556361503
Gc8_991 0 n16 ns991 0 0.00132063881367
Gc8_992 0 n16 ns992 0 -0.000460241915533
Gc8_993 0 n16 ns993 0 0.000356055719575
Gc8_994 0 n16 ns994 0 -6.50969188697e-05
Gc8_995 0 n16 ns995 0 -0.00015369936397
Gc8_996 0 n16 ns996 0 1.4216891468e-05
Gc8_997 0 n16 ns997 0 4.96874987827e-05
Gc8_998 0 n16 ns998 0 -0.000508122477359
Gc8_999 0 n16 ns999 0 -2.65938443441e-05
Gc8_1000 0 n16 ns1000 0 0.000128808754673
Gc8_1001 0 n16 ns1001 0 3.92033595557e-05
Gc8_1002 0 n16 ns1002 0 0.000402928045745
Gc8_1003 0 n16 ns1003 0 0.000193660449069
Gc8_1004 0 n16 ns1004 0 -0.000391609669067
Gc8_1005 0 n16 ns1005 0 -0.000289771009952
Gc8_1006 0 n16 ns1006 0 -0.000474374337462
Gc8_1007 0 n16 ns1007 0 -0.00043508989003
Gc8_1008 0 n16 ns1008 0 -0.000439486779323
Gc8_1009 0 n16 ns1009 0 -0.00019868647588
Gc8_1010 0 n16 ns1010 0 -0.000419371001785
Gc8_1011 0 n16 ns1011 0 -0.00443894360377
Gc8_1012 0 n16 ns1012 0 -0.000482926748906
Gc8_1013 0 n16 ns1013 0 -0.00396781289184
Gc8_1014 0 n16 ns1014 0 -0.000345616581676
Gc8_1015 0 n16 ns1015 0 0.000706124668336
Gc8_1016 0 n16 ns1016 0 0.0013502291364
Gc8_1017 0 n16 ns1017 0 -0.00035795677451
Gc8_1018 0 n16 ns1018 0 -0.000355071779035
Gc8_1019 0 n16 ns1019 0 -0.0013453562055
Gc8_1020 0 n16 ns1020 0 -0.00115403757716
Gc8_1021 0 n16 ns1021 0 -0.000228941447567
Gc8_1022 0 n16 ns1022 0 -0.00082113711655
Gc8_1023 0 n16 ns1023 0 -0.000239346340416
Gc8_1024 0 n16 ns1024 0 -7.03720032836e-06
Gc8_1025 0 n16 ns1025 0 -1.66091056707e-05
Gc8_1026 0 n16 ns1026 0 5.38455272295e-05
Gc8_1027 0 n16 ns1027 0 -0.000105155796323
Gc8_1028 0 n16 ns1028 0 -0.000130616098372
Gc8_1029 0 n16 ns1029 0 -0.000258520141175
Gc8_1030 0 n16 ns1030 0 0.000249820595878
Gc8_1031 0 n16 ns1031 0 -4.47026697165e-05
Gc8_1032 0 n16 ns1032 0 0.000123700737622
Gc8_1033 0 n16 ns1033 0 -5.18755967162e-05
Gc8_1034 0 n16 ns1034 0 -9.63332569966e-06
Gc8_1035 0 n16 ns1035 0 0.000292865703908
Gc8_1036 0 n16 ns1036 0 -4.61612841783e-05
Gc8_1037 0 n16 ns1037 0 -6.72621140379e-05
Gc8_1038 0 n16 ns1038 0 0.000141836330609
Gc8_1039 0 n16 ns1039 0 2.74737726405e-07
Gc8_1040 0 n16 ns1040 0 9.70061927879e-05
Gc8_1041 0 n16 ns1041 0 0.000638386160611
Gc8_1042 0 n16 ns1042 0 0.000300311045882
Gc8_1043 0 n16 ns1043 0 0.000291980262073
Gc8_1044 0 n16 ns1044 0 -0.0004707982431
Gc8_1045 0 n16 ns1045 0 0.000100658811724
Gc8_1046 0 n16 ns1046 0 -0.000280174191032
Gc8_1047 0 n16 ns1047 0 -4.02336665249e-05
Gc8_1048 0 n16 ns1048 0 -0.000366947141962
Gc8_1049 0 n16 ns1049 0 -0.00484158219724
Gc8_1050 0 n16 ns1050 0 -0.00426862871161
Gc8_1051 0 n16 ns1051 0 -0.00448050687996
Gc8_1052 0 n16 ns1052 0 -0.00376543250415
Gc8_1053 0 n16 ns1053 0 -0.000377425823462
Gc8_1054 0 n16 ns1054 0 0.00185828606665
Gc8_1055 0 n16 ns1055 0 -0.000288754420901
Gc8_1056 0 n16 ns1056 0 -0.000742482728732
Gc8_1057 0 n16 ns1057 0 -0.00089810180121
Gc8_1058 0 n16 ns1058 0 -0.00206135866268
Gc8_1059 0 n16 ns1059 0 1.75537892314e-05
Gc8_1060 0 n16 ns1060 0 -0.00123475363781
Gc8_1061 0 n16 ns1061 0 -0.000433759398927
Gc8_1062 0 n16 ns1062 0 -1.30604968255e-05
Gc8_1063 0 n16 ns1063 0 4.25598172959e-05
Gc8_1064 0 n16 ns1064 0 1.34139273063e-05
Gc8_1065 0 n16 ns1065 0 -0.000309043253874
Gc8_1066 0 n16 ns1066 0 -0.0001179154322
Gc8_1067 0 n16 ns1067 0 -0.000714970467473
Gc8_1068 0 n16 ns1068 0 0.00141514605913
Gc8_1069 0 n16 ns1069 0 -0.000344359115992
Gc8_1070 0 n16 ns1070 0 0.000100606889612
Gc8_1071 0 n16 ns1071 0 0.000214579310859
Gc8_1072 0 n16 ns1072 0 -0.000165717637895
Gc8_1073 0 n16 ns1073 0 6.20172759353e-05
Gc8_1074 0 n16 ns1074 0 0.000429281684864
Gc8_1075 0 n16 ns1075 0 -0.000132972706535
Gc8_1076 0 n16 ns1076 0 0.00012499516759
Gc8_1077 0 n16 ns1077 0 0.000588827591727
Gc8_1078 0 n16 ns1078 0 -0.000466213072057
Gc8_1079 0 n16 ns1079 0 0.000125545354882
Gc8_1080 0 n16 ns1080 0 0.000272068515968
Gc8_1081 0 n16 ns1081 0 0.000630406908691
Gc8_1082 0 n16 ns1082 0 -0.000412287175837
Gc8_1083 0 n16 ns1083 0 0.000230115310693
Gc8_1084 0 n16 ns1084 0 -0.000396271005529
Gc8_1085 0 n16 ns1085 0 -0.000335723671223
Gc8_1086 0 n16 ns1086 0 0.000700827266316
Gc8_1087 0 n16 ns1087 0 -0.00219552958922
Gc8_1088 0 n16 ns1088 0 -0.00447655886818
Gc8_1089 0 n16 ns1089 0 -0.00217874038549
Gc8_1090 0 n16 ns1090 0 -0.00443346575511
Gc8_1091 0 n16 ns1091 0 -0.00112308270638
Gc8_1092 0 n16 ns1092 0 0.00134279658249
Gc8_1093 0 n16 ns1093 0 0.000147033692729
Gc8_1094 0 n16 ns1094 0 -0.00126974331665
Gc8_1095 0 n16 ns1095 0 1.40913409284e-05
Gc8_1096 0 n16 ns1096 0 -0.00306171685588
Gc8_1097 0 n16 ns1097 0 0.000639920383293
Gc8_1098 0 n16 ns1098 0 -0.00282988051899
Gc8_1099 0 n16 ns1099 0 -0.001166390329
Gc8_1100 0 n16 ns1100 0 -3.8730617165e-05
Gc8_1101 0 n16 ns1101 0 0.000102765843648
Gc8_1102 0 n16 ns1102 0 -1.11745216046e-05
Gc8_1103 0 n16 ns1103 0 -0.000729872521454
Gc8_1104 0 n16 ns1104 0 -0.000497024546825
Gc8_1105 0 n16 ns1105 0 -0.00229655639078
Gc8_1106 0 n16 ns1106 0 0.00106942742409
Gc8_1107 0 n16 ns1107 0 -0.000232825544391
Gc8_1108 0 n16 ns1108 0 0.00086953119792
Gc8_1109 0 n16 ns1109 0 0.000168807100721
Gc8_1110 0 n16 ns1110 0 -0.000246533472157
Gc8_1111 0 n16 ns1111 0 -0.000119016308833
Gc8_1112 0 n16 ns1112 0 0.000351504153829
Gc8_1113 0 n16 ns1113 0 -0.000249178393041
Gc8_1114 0 n16 ns1114 0 -2.27333403168e-05
Gc8_1115 0 n16 ns1115 0 0.00040771447793
Gc8_1116 0 n16 ns1116 0 0.000271693031297
Gc8_1117 0 n16 ns1117 0 0.000353425649629
Gc8_1118 0 n16 ns1118 0 -0.000329724418325
Gc8_1119 0 n16 ns1119 0 0.00110501458963
Gc8_1120 0 n16 ns1120 0 -0.00030786035637
Gc8_1121 0 n16 ns1121 0 0.000853968278126
Gc8_1122 0 n16 ns1122 0 -0.000753547662814
Gc8_1123 0 n16 ns1123 0 -0.00174049010143
Gc8_1124 0 n16 ns1124 0 3.75573960367e-05
Gc8_1125 0 n16 ns1125 0 -0.00340167282781
Gc8_1126 0 n16 ns1126 0 -0.00364079078885
Gc8_1127 0 n16 ns1127 0 -0.00267244404692
Gc8_1128 0 n16 ns1128 0 -0.00407543406636
Gc8_1129 0 n16 ns1129 0 0.00120483540259
Gc8_1130 0 n16 ns1130 0 -0.000415088208341
Gc8_1131 0 n16 ns1131 0 0.000937987455234
Gc8_1132 0 n16 ns1132 0 -0.00116204477434
Gc8_1133 0 n16 ns1133 0 4.36469439822e-05
Gc8_1134 0 n16 ns1134 0 -0.00165401079917
Gc8_1135 0 n16 ns1135 0 0.00254072606233
Gc8_1136 0 n16 ns1136 0 -0.00235160883603
Gc8_1137 0 n16 ns1137 0 -0.00248861229616
Gc8_1138 0 n16 ns1138 0 2.07517037665e-06
Gc8_1139 0 n16 ns1139 0 0.000131300400821
Gc8_1140 0 n16 ns1140 0 -2.93206451706e-05
Gc8_1141 0 n16 ns1141 0 0.00227640868846
Gc8_1142 0 n16 ns1142 0 -0.00344456648495
Gc8_1143 0 n16 ns1143 0 0.0047771949892
Gc8_1144 0 n16 ns1144 0 -0.00707884512365
Gc8_1145 0 n16 ns1145 0 -0.00337545555117
Gc8_1146 0 n16 ns1146 0 -0.00251234765028
Gc8_1147 0 n16 ns1147 0 0.00107643145987
Gc8_1148 0 n16 ns1148 0 0.000740786389905
Gc8_1149 0 n16 ns1149 0 -0.000651357491209
Gc8_1150 0 n16 ns1150 0 -0.000127287675962
Gc8_1151 0 n16 ns1151 0 -0.000190020440996
Gc8_1152 0 n16 ns1152 0 -0.000135602317309
Gc8_1153 0 n16 ns1153 0 -0.000524551511742
Gc8_1154 0 n16 ns1154 0 -0.000766025626622
Gc8_1155 0 n16 ns1155 0 0.000679739021809
Gc8_1156 0 n16 ns1156 0 0.0005496651948
Gc8_1157 0 n16 ns1157 0 0.000951238834645
Gc8_1158 0 n16 ns1158 0 0.000963381880605
Gc8_1159 0 n16 ns1159 0 0.00036106095798
Gc8_1160 0 n16 ns1160 0 0.00118993931282
Gc8_1161 0 n16 ns1161 0 0.000973173231558
Gc8_1162 0 n16 ns1162 0 -0.00257482259115
Gc8_1163 0 n16 ns1163 0 0.00201748139166
Gc8_1164 0 n16 ns1164 0 -0.00705085824683
Gc8_1165 0 n16 ns1165 0 0.002219212924
Gc8_1166 0 n16 ns1166 0 -0.00678262379684
Gc8_1167 0 n16 ns1167 0 0.00480286689798
Gc8_1168 0 n16 ns1168 0 0.00665700577971
Gc8_1169 0 n16 ns1169 0 0.00113343731111
Gc8_1170 0 n16 ns1170 0 -0.00104892953115
Gc8_1171 0 n16 ns1171 0 -0.00425427363134
Gc8_1172 0 n16 ns1172 0 -0.005022143895
Gc8_1173 0 n16 ns1173 0 0.00175475418059
Gc8_1174 0 n16 ns1174 0 0.00605748062911
Gc8_1175 0 n16 ns1175 0 -0.00417977510632
Gc8_1176 0 n16 ns1176 0 -1.02124905917e-05
Gc8_1177 0 n16 ns1177 0 0.000369170971126
Gc8_1178 0 n16 ns1178 0 -0.000218449956968
Gc8_1179 0 n16 ns1179 0 0.000941894582467
Gc8_1180 0 n16 ns1180 0 -0.00215546993214
Gc8_1181 0 n16 ns1181 0 0.00136726308016
Gc8_1182 0 n16 ns1182 0 -0.00438640420793
Gc8_1183 0 n16 ns1183 0 -0.00242258120453
Gc8_1184 0 n16 ns1184 0 -0.00129736571696
Gc8_1185 0 n16 ns1185 0 0.00100958489801
Gc8_1186 0 n16 ns1186 0 0.000435130415743
Gc8_1187 0 n16 ns1187 0 -0.000787342693723
Gc8_1188 0 n16 ns1188 0 -0.000482789044317
Gc8_1189 0 n16 ns1189 0 -0.000134096759471
Gc8_1190 0 n16 ns1190 0 -8.7330589149e-05
Gc8_1191 0 n16 ns1191 0 0.00034743431666
Gc8_1192 0 n16 ns1192 0 0.000123714090513
Gc8_1193 0 n16 ns1193 0 0.000722152637232
Gc8_1194 0 n16 ns1194 0 -0.000854573347288
Gc8_1195 0 n16 ns1195 0 0.00065281696918
Gc8_1196 0 n16 ns1196 0 0.000479712671391
Gc8_1197 0 n16 ns1197 0 0.000351794005593
Gc8_1198 0 n16 ns1198 0 0.00019965242906
Gc8_1199 0 n16 ns1199 0 -0.00119745927579
Gc8_1200 0 n16 ns1200 0 -0.00190539039426
Gc8_1201 0 n16 ns1201 0 -0.00145084046771
Gc8_1202 0 n16 ns1202 0 -0.000857782413232
Gc8_1203 0 n16 ns1203 0 -0.000411701568851
Gc8_1204 0 n16 ns1204 0 -0.00154414947222
Gc8_1205 0 n16 ns1205 0 0.00461639117142
Gc8_1206 0 n16 ns1206 0 0.00201081248828
Gc8_1207 0 n16 ns1207 0 0.00139254050146
Gc8_1208 0 n16 ns1208 0 -0.000647655429989
Gc8_1209 0 n16 ns1209 0 -0.00207258491176
Gc8_1210 0 n16 ns1210 0 -0.00148237318601
Gc8_1211 0 n16 ns1211 0 0.00261039049428
Gc8_1212 0 n16 ns1212 0 0.00292504739498
Gc8_1213 0 n16 ns1213 0 -0.00354824111689
Gc8_1214 0 n16 ns1214 0 -9.9645724243e-06
Gc8_1215 0 n16 ns1215 0 0.000290836656289
Gc8_1216 0 n16 ns1216 0 -0.000151789216891
Gd8_1 0 n16 ni1 0 -6.00320487197e-05
Gd8_2 0 n16 ni2 0 -5.68299918703e-05
Gd8_3 0 n16 ni3 0 0.000105761638196
Gd8_4 0 n16 ni4 0 0.000748269223215
Gd8_5 0 n16 ni5 0 7.37972247511e-05
Gd8_6 0 n16 ni6 0 -0.00061669712865
Gd8_7 0 n16 ni7 0 -0.00189024840863
Gd8_8 0 n16 ni8 0 0.000977162417913
Gd8_9 0 n16 ni9 0 -0.0023212862845
Gd8_10 0 n16 ni10 0 -0.000161581299637
Gd8_11 0 n16 ni11 0 0.000186496331977
Gd8_12 0 n16 ni12 0 0.000238204334992
Gd8_13 0 n16 ni13 0 0.000143015181471
Gd8_14 0 n16 ni14 0 -0.0017123859239
Gd8_15 0 n16 ni15 0 -0.00085859995726
Gd8_16 0 n16 ni16 0 -0.00323659187357
Gd8_17 0 n16 ni17 0 -0.000440885478895
Gd8_18 0 n16 ni18 0 -1.86301726095e-05
Gd8_19 0 n16 ni19 0 0.00083372267476
Gd8_20 0 n16 ni20 0 -0.000848707913596
Gd8_21 0 n16 ni21 0 0.000713002338929
Gd8_22 0 n16 ni22 0 0.000593669710446
Gd8_23 0 n16 ni23 0 -0.00040322528085
Gd8_24 0 n16 ni24 0 0.000365745386694
Gd8_25 0 n16 ni25 0 0.000105159556926
Gd8_26 0 n16 ni26 0 0.00108702505595
Gd8_27 0 n16 ni27 0 -0.00047998743184
Gd8_28 0 n16 ni28 0 1.6694805124e-05
Gd8_29 0 n16 ni29 0 0.000331413631316
Gd8_30 0 n16 ni30 0 0.000117054204764
Gd8_31 0 n16 ni31 0 -0.00328123167792
Gd8_32 0 n16 ni32 0 -0.00175881818516
Gc9_1 0 n18 ns1 0 0.000355758834563
Gc9_2 0 n18 ns2 0 -0.000159187510689
Gc9_3 0 n18 ns3 0 0.00102162330449
Gc9_4 0 n18 ns4 0 -0.000260041237001
Gc9_5 0 n18 ns5 0 0.000190121043613
Gc9_6 0 n18 ns6 0 -7.68814554771e-05
Gc9_7 0 n18 ns7 0 -8.50911932013e-05
Gc9_8 0 n18 ns8 0 -2.89954910691e-06
Gc9_9 0 n18 ns9 0 2.47108750281e-05
Gc9_10 0 n18 ns10 0 -0.000168243732651
Gc9_11 0 n18 ns11 0 -2.03959985154e-05
Gc9_12 0 n18 ns12 0 1.80769058089e-05
Gc9_13 0 n18 ns13 0 -0.000129875180735
Gc9_14 0 n18 ns14 0 0.000126205469091
Gc9_15 0 n18 ns15 0 -0.000108265068293
Gc9_16 0 n18 ns16 0 4.5284516887e-05
Gc9_17 0 n18 ns17 0 -1.44583460838e-05
Gc9_18 0 n18 ns18 0 4.81740809241e-05
Gc9_19 0 n18 ns19 0 -2.06107140421e-06
Gc9_20 0 n18 ns20 0 1.08658034232e-05
Gc9_21 0 n18 ns21 0 9.11689553945e-05
Gc9_22 0 n18 ns22 0 9.08109255613e-06
Gc9_23 0 n18 ns23 0 -0.000128892758895
Gc9_24 0 n18 ns24 0 -0.00035988859514
Gc9_25 0 n18 ns25 0 -0.000121440008516
Gc9_26 0 n18 ns26 0 -0.000332894311545
Gc9_27 0 n18 ns27 0 0.000242799608841
Gc9_28 0 n18 ns28 0 0.000420318676168
Gc9_29 0 n18 ns29 0 -7.03769960383e-05
Gc9_30 0 n18 ns30 0 -8.9390488579e-05
Gc9_31 0 n18 ns31 0 -0.000343344001362
Gc9_32 0 n18 ns32 0 -0.000429597243267
Gc9_33 0 n18 ns33 0 -0.000169624955425
Gc9_34 0 n18 ns34 0 -0.000468137707341
Gc9_35 0 n18 ns35 0 -5.34790438463e-05
Gc9_36 0 n18 ns36 0 3.02186537236e-05
Gc9_37 0 n18 ns37 0 -6.73404776799e-05
Gc9_38 0 n18 ns38 0 3.5588566395e-05
Gc9_39 0 n18 ns39 0 0.000175635126175
Gc9_40 0 n18 ns40 0 4.90065907523e-05
Gc9_41 0 n18 ns41 0 0.000589869630683
Gc9_42 0 n18 ns42 0 -0.000187194107865
Gc9_43 0 n18 ns43 0 6.11739605681e-05
Gc9_44 0 n18 ns44 0 7.02045032028e-06
Gc9_45 0 n18 ns45 0 3.35389992127e-07
Gc9_46 0 n18 ns46 0 -4.82245554318e-05
Gc9_47 0 n18 ns47 0 6.93578063431e-05
Gc9_48 0 n18 ns48 0 -0.000130197919933
Gc9_49 0 n18 ns49 0 -1.93687389774e-05
Gc9_50 0 n18 ns50 0 1.77897719474e-05
Gc9_51 0 n18 ns51 0 -0.000118037449001
Gc9_52 0 n18 ns52 0 7.13245507654e-05
Gc9_53 0 n18 ns53 0 -0.000149695825159
Gc9_54 0 n18 ns54 0 4.32152829097e-05
Gc9_55 0 n18 ns55 0 -5.3737412536e-05
Gc9_56 0 n18 ns56 0 7.99212305961e-05
Gc9_57 0 n18 ns57 0 -4.77789475067e-05
Gc9_58 0 n18 ns58 0 6.19882843721e-05
Gc9_59 0 n18 ns59 0 6.19739491875e-05
Gc9_60 0 n18 ns60 0 -4.51514191047e-05
Gc9_61 0 n18 ns61 0 -0.000203089812133
Gc9_62 0 n18 ns62 0 -0.000646728647135
Gc9_63 0 n18 ns63 0 -0.000182911605175
Gc9_64 0 n18 ns64 0 -0.000580961316508
Gc9_65 0 n18 ns65 0 0.000195131085502
Gc9_66 0 n18 ns66 0 0.00044032614047
Gc9_67 0 n18 ns67 0 -7.70603397704e-05
Gc9_68 0 n18 ns68 0 -9.26055782739e-05
Gc9_69 0 n18 ns69 0 -0.000338369927696
Gc9_70 0 n18 ns70 0 -0.000416797504776
Gc9_71 0 n18 ns71 0 -0.000171860253097
Gc9_72 0 n18 ns72 0 -0.000360774181028
Gc9_73 0 n18 ns73 0 -2.65921328912e-05
Gc9_74 0 n18 ns74 0 1.88023984789e-05
Gc9_75 0 n18 ns75 0 -3.58522515979e-05
Gc9_76 0 n18 ns76 0 1.11826881005e-05
Gc9_77 0 n18 ns77 0 4.84318944427e-05
Gc9_78 0 n18 ns78 0 0.00019838887547
Gc9_79 0 n18 ns79 0 0.000205688884447
Gc9_80 0 n18 ns80 0 -0.000587119326461
Gc9_81 0 n18 ns81 0 -0.000105539734588
Gc9_82 0 n18 ns82 0 -4.77316057191e-05
Gc9_83 0 n18 ns83 0 0.000108322953388
Gc9_84 0 n18 ns84 0 3.89568320689e-05
Gc9_85 0 n18 ns85 0 0.000188373238208
Gc9_86 0 n18 ns86 0 -1.8770612185e-05
Gc9_87 0 n18 ns87 0 -5.66466579928e-05
Gc9_88 0 n18 ns88 0 1.09147345968e-06
Gc9_89 0 n18 ns89 0 -0.000173585633275
Gc9_90 0 n18 ns90 0 4.54494492304e-05
Gc9_91 0 n18 ns91 0 -0.000406075346738
Gc9_92 0 n18 ns92 0 -9.27942793376e-05
Gc9_93 0 n18 ns93 0 -0.000355958437076
Gc9_94 0 n18 ns94 0 7.58144380559e-05
Gc9_95 0 n18 ns95 0 -0.000443676618868
Gc9_96 0 n18 ns96 0 8.65480356281e-05
Gc9_97 0 n18 ns97 0 0.000231126554189
Gc9_98 0 n18 ns98 0 -0.000274716164373
Gc9_99 0 n18 ns99 0 0.000787719743408
Gc9_100 0 n18 ns100 0 -0.00172317209996
Gc9_101 0 n18 ns101 0 0.000670484636828
Gc9_102 0 n18 ns102 0 -0.00151388885499
Gc9_103 0 n18 ns103 0 4.26599515839e-06
Gc9_104 0 n18 ns104 0 7.06072605198e-05
Gc9_105 0 n18 ns105 0 -9.84949584017e-05
Gc9_106 0 n18 ns106 0 -4.43004332372e-05
Gc9_107 0 n18 ns107 0 -0.000303232778211
Gc9_108 0 n18 ns108 0 5.55116403363e-05
Gc9_109 0 n18 ns109 0 -0.000110886940352
Gc9_110 0 n18 ns110 0 0.00039921524992
Gc9_111 0 n18 ns111 0 0.000150025288043
Gc9_112 0 n18 ns112 0 -6.5714730427e-06
Gc9_113 0 n18 ns113 0 1.66671155084e-05
Gc9_114 0 n18 ns114 0 -3.04989151554e-05
Gc9_115 0 n18 ns115 0 0.000576736657266
Gc9_116 0 n18 ns116 0 -4.79590473156e-05
Gc9_117 0 n18 ns117 0 0.00180828729651
Gc9_118 0 n18 ns118 0 0.000361223822488
Gc9_119 0 n18 ns119 0 0.000271019017436
Gc9_120 0 n18 ns120 0 1.14914670654e-06
Gc9_121 0 n18 ns121 0 -0.000194867118135
Gc9_122 0 n18 ns122 0 5.83973121867e-05
Gc9_123 0 n18 ns123 0 0.000176827042445
Gc9_124 0 n18 ns124 0 0.000249470210256
Gc9_125 0 n18 ns125 0 -4.68648489934e-05
Gc9_126 0 n18 ns126 0 -0.000103439728231
Gc9_127 0 n18 ns127 0 -0.000270812595699
Gc9_128 0 n18 ns128 0 -0.00029855101864
Gc9_129 0 n18 ns129 0 4.14765727985e-06
Gc9_130 0 n18 ns130 0 -0.000929174386094
Gc9_131 0 n18 ns131 0 -0.000281877275406
Gc9_132 0 n18 ns132 0 -0.000656521335289
Gc9_133 0 n18 ns133 0 -0.000210907561734
Gc9_134 0 n18 ns134 0 -0.000858052775771
Gc9_135 0 n18 ns135 0 0.000823540109838
Gc9_136 0 n18 ns136 0 0.000630707625763
Gc9_137 0 n18 ns137 0 0.0037639126601
Gc9_138 0 n18 ns138 0 0.000494408024285
Gc9_139 0 n18 ns139 0 0.00328090840682
Gc9_140 0 n18 ns140 0 0.000288207541048
Gc9_141 0 n18 ns141 0 0.000791029399327
Gc9_142 0 n18 ns142 0 0.000494238446072
Gc9_143 0 n18 ns143 0 -0.000247952236457
Gc9_144 0 n18 ns144 0 -0.000186619839476
Gc9_145 0 n18 ns145 0 -0.00112990574832
Gc9_146 0 n18 ns146 0 -0.000583812411954
Gc9_147 0 n18 ns147 0 -0.000484414921708
Gc9_148 0 n18 ns148 0 -0.000489376561576
Gc9_149 0 n18 ns149 0 7.4385222052e-06
Gc9_150 0 n18 ns150 0 3.23883743741e-05
Gc9_151 0 n18 ns151 0 -0.000119443378029
Gc9_152 0 n18 ns152 0 4.59559821154e-05
Gc9_153 0 n18 ns153 0 1.79449312343e-06
Gc9_154 0 n18 ns154 0 -1.57605788001e-05
Gc9_155 0 n18 ns155 0 -3.92867151959e-05
Gc9_156 0 n18 ns156 0 0.00100971201186
Gc9_157 0 n18 ns157 0 0.000120593699687
Gc9_158 0 n18 ns158 0 0.00013306025953
Gc9_159 0 n18 ns159 0 -0.000176943286736
Gc9_160 0 n18 ns160 0 -0.000185648147639
Gc9_161 0 n18 ns161 0 -0.000435604424576
Gc9_162 0 n18 ns162 0 0.000232994049221
Gc9_163 0 n18 ns163 0 9.50378969868e-05
Gc9_164 0 n18 ns164 0 -0.000123464807679
Gc9_165 0 n18 ns165 0 0.000196163653739
Gc9_166 0 n18 ns166 0 -0.000146531891931
Gc9_167 0 n18 ns167 0 0.00117511232578
Gc9_168 0 n18 ns168 0 -0.000242672441997
Gc9_169 0 n18 ns169 0 0.000486321569355
Gc9_170 0 n18 ns170 0 -0.000715084494996
Gc9_171 0 n18 ns171 0 0.000592741065886
Gc9_172 0 n18 ns172 0 -0.000595185174826
Gc9_173 0 n18 ns173 0 -0.000296109163224
Gc9_174 0 n18 ns174 0 0.00112700105767
Gc9_175 0 n18 ns175 0 0.00323579828075
Gc9_176 0 n18 ns176 0 0.00405519435239
Gc9_177 0 n18 ns177 0 0.00307685521394
Gc9_178 0 n18 ns178 0 0.00342710568529
Gc9_179 0 n18 ns179 0 0.0003403445291
Gc9_180 0 n18 ns180 0 0.00122868492989
Gc9_181 0 n18 ns181 0 -0.000283599413176
Gc9_182 0 n18 ns182 0 -0.000471052848441
Gc9_183 0 n18 ns183 0 -0.00113529817548
Gc9_184 0 n18 ns184 0 -0.00138392008727
Gc9_185 0 n18 ns185 0 -0.00055208492548
Gc9_186 0 n18 ns186 0 -0.00058350981285
Gc9_187 0 n18 ns187 0 4.39691074577e-05
Gc9_188 0 n18 ns188 0 2.05498004093e-06
Gc9_189 0 n18 ns189 0 -9.35071827159e-05
Gc9_190 0 n18 ns190 0 1.2050211519e-06
Gc9_191 0 n18 ns191 0 1.96191056884e-05
Gc9_192 0 n18 ns192 0 -0.000646383419642
Gc9_193 0 n18 ns193 0 1.0766035829e-05
Gc9_194 0 n18 ns194 0 -0.000252130659442
Gc9_195 0 n18 ns195 0 0.000126430209352
Gc9_196 0 n18 ns196 0 -0.000216998758802
Gc9_197 0 n18 ns197 0 0.000144952911231
Gc9_198 0 n18 ns198 0 7.73659215792e-05
Gc9_199 0 n18 ns199 0 -0.000381405440719
Gc9_200 0 n18 ns200 0 -0.000544946245934
Gc9_201 0 n18 ns201 0 0.000162533877768
Gc9_202 0 n18 ns202 0 -1.83116583677e-05
Gc9_203 0 n18 ns203 0 -0.000151107003053
Gc9_204 0 n18 ns204 0 0.00019831335501
Gc9_205 0 n18 ns205 0 0.000113398294607
Gc9_206 0 n18 ns206 0 0.00146563927658
Gc9_207 0 n18 ns207 0 0.000550943934557
Gc9_208 0 n18 ns208 0 0.000109094429288
Gc9_209 0 n18 ns209 0 4.89017110234e-07
Gc9_210 0 n18 ns210 0 0.000303132403823
Gc9_211 0 n18 ns211 0 -0.00118319185713
Gc9_212 0 n18 ns212 0 -0.000823238081279
Gc9_213 0 n18 ns213 0 -0.000482454596044
Gc9_214 0 n18 ns214 0 0.00391087721254
Gc9_215 0 n18 ns215 0 -8.15807295134e-06
Gc9_216 0 n18 ns216 0 0.00379975812667
Gc9_217 0 n18 ns217 0 -0.00189674396615
Gc9_218 0 n18 ns218 0 0.000506170856763
Gc9_219 0 n18 ns219 0 6.56919003016e-05
Gc9_220 0 n18 ns220 0 -0.000804750130557
Gc9_221 0 n18 ns221 0 0.00036425726468
Gc9_222 0 n18 ns222 0 -0.00136250407889
Gc9_223 0 n18 ns223 0 -0.000385539686834
Gc9_224 0 n18 ns224 0 0.00101241247391
Gc9_225 0 n18 ns225 0 0.000550383667375
Gc9_226 0 n18 ns226 0 -7.12002474543e-06
Gc9_227 0 n18 ns227 0 -0.00014975614395
Gc9_228 0 n18 ns228 0 1.00361089642e-05
Gc9_229 0 n18 ns229 0 0.000350790166408
Gc9_230 0 n18 ns230 0 -0.000542506314286
Gc9_231 0 n18 ns231 0 0.00101628086348
Gc9_232 0 n18 ns232 0 0.000405731872132
Gc9_233 0 n18 ns233 0 -0.000166343393536
Gc9_234 0 n18 ns234 0 0.000384303411879
Gc9_235 0 n18 ns235 0 -5.7989578455e-05
Gc9_236 0 n18 ns236 0 3.13523427775e-05
Gc9_237 0 n18 ns237 0 0.000651763925962
Gc9_238 0 n18 ns238 0 -0.000262368385068
Gc9_239 0 n18 ns239 0 0.000170987210158
Gc9_240 0 n18 ns240 0 3.99433623863e-05
Gc9_241 0 n18 ns241 0 4.80568242157e-06
Gc9_242 0 n18 ns242 0 -0.000470921693686
Gc9_243 0 n18 ns243 0 -0.00155128571041
Gc9_244 0 n18 ns244 0 -0.000299776533321
Gc9_245 0 n18 ns245 0 0.000217363733545
Gc9_246 0 n18 ns246 0 -0.000101915534893
Gc9_247 0 n18 ns247 0 -0.000238490382776
Gc9_248 0 n18 ns248 0 -0.000747248482029
Gc9_249 0 n18 ns249 0 0.00142384591458
Gc9_250 0 n18 ns250 0 -0.00130473450821
Gc9_251 0 n18 ns251 0 -0.0012985056172
Gc9_252 0 n18 ns252 0 0.00206542736011
Gc9_253 0 n18 ns253 0 -0.00120235561988
Gc9_254 0 n18 ns254 0 0.00263101836653
Gc9_255 0 n18 ns255 0 -0.00156812068123
Gc9_256 0 n18 ns256 0 -0.00229477905807
Gc9_257 0 n18 ns257 0 0.000746970517733
Gc9_258 0 n18 ns258 0 -0.000915534699845
Gc9_259 0 n18 ns259 0 0.0011668039805
Gc9_260 0 n18 ns260 0 -0.000279144031607
Gc9_261 0 n18 ns261 0 -0.0012308114633
Gc9_262 0 n18 ns262 0 0.00247440377566
Gc9_263 0 n18 ns263 0 0.00148710791057
Gc9_264 0 n18 ns264 0 3.92089089636e-05
Gc9_265 0 n18 ns265 0 -0.000340701855198
Gc9_266 0 n18 ns266 0 0.00013838920698
Gc9_267 0 n18 ns267 0 0.000742507215641
Gc9_268 0 n18 ns268 0 -0.00247513325807
Gc9_269 0 n18 ns269 0 0.00117822412753
Gc9_270 0 n18 ns270 0 -0.00174421865247
Gc9_271 0 n18 ns271 0 -0.001061284118
Gc9_272 0 n18 ns272 0 -0.000184343280501
Gc9_273 0 n18 ns273 0 0.000334509015889
Gc9_274 0 n18 ns274 0 -0.000330353444772
Gc9_275 0 n18 ns275 0 0.00036496486901
Gc9_276 0 n18 ns276 0 0.000669517577682
Gc9_277 0 n18 ns277 0 0.000112633918406
Gc9_278 0 n18 ns278 0 9.25620826145e-05
Gc9_279 0 n18 ns279 0 -0.000122004391601
Gc9_280 0 n18 ns280 0 0.000373435895724
Gc9_281 0 n18 ns281 0 0.000672942554605
Gc9_282 0 n18 ns282 0 -0.00160009096641
Gc9_283 0 n18 ns283 0 0.000640281165435
Gc9_284 0 n18 ns284 0 -4.48202419147e-05
Gc9_285 0 n18 ns285 0 0.000656067530417
Gc9_286 0 n18 ns286 0 -0.000602169371418
Gc9_287 0 n18 ns287 0 0.00153719351295
Gc9_288 0 n18 ns288 0 0.00268466515047
Gc9_289 0 n18 ns289 0 0.000649045769861
Gc9_290 0 n18 ns290 0 0.00184259286793
Gc9_291 0 n18 ns291 0 -0.000143802303927
Gc9_292 0 n18 ns292 0 0.00223858830956
Gc9_293 0 n18 ns293 0 0.00504610253661
Gc9_294 0 n18 ns294 0 -0.000416737414739
Gc9_295 0 n18 ns295 0 0.00116334444834
Gc9_296 0 n18 ns296 0 -0.000447551629212
Gc9_297 0 n18 ns297 0 -0.00165934136511
Gc9_298 0 n18 ns298 0 -0.000127431715889
Gc9_299 0 n18 ns299 0 -0.00373685668169
Gc9_300 0 n18 ns300 0 -0.00107662421752
Gc9_301 0 n18 ns301 0 0.00295498572023
Gc9_302 0 n18 ns302 0 2.58447927156e-05
Gc9_303 0 n18 ns303 0 -0.000183977733968
Gc9_304 0 n18 ns304 0 3.92526122568e-05
Gc9_305 0 n18 ns305 0 0.00152950806139
Gc9_306 0 n18 ns306 0 -0.00498296780095
Gc9_307 0 n18 ns307 0 0.000664570489934
Gc9_308 0 n18 ns308 0 -0.00379929833929
Gc9_309 0 n18 ns309 0 -0.0003572267903
Gc9_310 0 n18 ns310 0 -0.000449950796674
Gc9_311 0 n18 ns311 0 0.000459028567835
Gc9_312 0 n18 ns312 0 -4.48903144639e-05
Gc9_313 0 n18 ns313 0 -0.000167401091997
Gc9_314 0 n18 ns314 0 0.000264417295195
Gc9_315 0 n18 ns315 0 1.15928827027e-05
Gc9_316 0 n18 ns316 0 3.52548539366e-05
Gc9_317 0 n18 ns317 0 -0.00128357173542
Gc9_318 0 n18 ns318 0 4.49495933463e-05
Gc9_319 0 n18 ns319 0 0.000455190066269
Gc9_320 0 n18 ns320 0 0.000396983181469
Gc9_321 0 n18 ns321 0 -0.000259666542204
Gc9_322 0 n18 ns322 0 0.000160790425752
Gc9_323 0 n18 ns323 0 -0.000768304430611
Gc9_324 0 n18 ns324 0 -0.000677140057411
Gc9_325 0 n18 ns325 0 -0.000883353785482
Gc9_326 0 n18 ns326 0 0.000837256132454
Gc9_327 0 n18 ns327 0 0.00775118077209
Gc9_328 0 n18 ns328 0 0.00337046351154
Gc9_329 0 n18 ns329 0 0.00556693273616
Gc9_330 0 n18 ns330 0 0.00308657494293
Gc9_331 0 n18 ns331 0 0.00323272041157
Gc9_332 0 n18 ns332 0 0.00673159836634
Gc9_333 0 n18 ns333 0 0.000480448904077
Gc9_334 0 n18 ns334 0 6.78413699046e-06
Gc9_335 0 n18 ns335 0 -0.0080605334339
Gc9_336 0 n18 ns336 0 -0.000487255468096
Gc9_337 0 n18 ns337 0 0.00464380763757
Gc9_338 0 n18 ns338 0 -0.00744594388326
Gc9_339 0 n18 ns339 0 0.00365719766226
Gc9_340 0 n18 ns340 0 -2.89946710206e-05
Gc9_341 0 n18 ns341 0 -0.000100712168545
Gc9_342 0 n18 ns342 0 1.31820349077e-05
Gc9_343 0 n18 ns343 0 1.99662623345e-05
Gc9_344 0 n18 ns344 0 0.000102387985275
Gc9_345 0 n18 ns345 0 4.56874453243e-05
Gc9_346 0 n18 ns346 0 -0.000814219892709
Gc9_347 0 n18 ns347 0 -9.24624817692e-05
Gc9_348 0 n18 ns348 0 -8.98612679715e-05
Gc9_349 0 n18 ns349 0 8.96095315879e-05
Gc9_350 0 n18 ns350 0 2.37244784751e-05
Gc9_351 0 n18 ns351 0 8.3555448214e-05
Gc9_352 0 n18 ns352 0 -0.000127539836064
Gc9_353 0 n18 ns353 0 -4.57627606266e-05
Gc9_354 0 n18 ns354 0 3.31099565035e-05
Gc9_355 0 n18 ns355 0 -7.88533172824e-05
Gc9_356 0 n18 ns356 0 0.000188068469493
Gc9_357 0 n18 ns357 0 -0.000327031169509
Gc9_358 0 n18 ns358 0 0.00012864763476
Gc9_359 0 n18 ns359 0 -0.000244628930031
Gc9_360 0 n18 ns360 0 0.000200096039488
Gc9_361 0 n18 ns361 0 -0.000332166361371
Gc9_362 0 n18 ns362 0 0.000259694441045
Gc9_363 0 n18 ns363 0 4.4646462705e-05
Gc9_364 0 n18 ns364 0 -0.000342176000651
Gc9_365 0 n18 ns365 0 6.9506277488e-05
Gc9_366 0 n18 ns366 0 -0.00166821767238
Gc9_367 0 n18 ns367 0 5.38385936497e-05
Gc9_368 0 n18 ns368 0 -0.00144503629228
Gc9_369 0 n18 ns369 0 -0.000109333809832
Gc9_370 0 n18 ns370 0 9.73219137365e-05
Gc9_371 0 n18 ns371 0 -6.61288685904e-05
Gc9_372 0 n18 ns372 0 -4.00086655067e-05
Gc9_373 0 n18 ns373 0 -0.000157020555185
Gc9_374 0 n18 ns374 0 3.12207254844e-05
Gc9_375 0 n18 ns375 0 -6.16615742248e-05
Gc9_376 0 n18 ns376 0 0.000364522731836
Gc9_377 0 n18 ns377 0 0.000132972387642
Gc9_378 0 n18 ns378 0 -6.34834283606e-07
Gc9_379 0 n18 ns379 0 4.45385308561e-05
Gc9_380 0 n18 ns380 0 -4.29801965152e-05
Gc9_381 0 n18 ns381 0 0.000442035800648
Gc9_382 0 n18 ns382 0 1.19538958026e-05
Gc9_383 0 n18 ns383 0 0.00141574518673
Gc9_384 0 n18 ns384 0 -0.000146458004186
Gc9_385 0 n18 ns385 0 0.000105256789227
Gc9_386 0 n18 ns386 0 -8.71464803505e-05
Gc9_387 0 n18 ns387 0 -3.21547073615e-05
Gc9_388 0 n18 ns388 0 0.000116463934491
Gc9_389 0 n18 ns389 0 0.000253675693731
Gc9_390 0 n18 ns390 0 0.000158165497464
Gc9_391 0 n18 ns391 0 -6.17069445163e-05
Gc9_392 0 n18 ns392 0 -6.43880227676e-05
Gc9_393 0 n18 ns393 0 -0.000301452652225
Gc9_394 0 n18 ns394 0 -0.000198325116374
Gc9_395 0 n18 ns395 0 -0.000290822747543
Gc9_396 0 n18 ns396 0 -0.00065452785783
Gc9_397 0 n18 ns397 0 -0.00038705863483
Gc9_398 0 n18 ns398 0 -0.000365772598964
Gc9_399 0 n18 ns399 0 -0.000391694787472
Gc9_400 0 n18 ns400 0 -0.00052182771891
Gc9_401 0 n18 ns401 0 0.000711103773989
Gc9_402 0 n18 ns402 0 0.00022276622691
Gc9_403 0 n18 ns403 0 0.00275771652554
Gc9_404 0 n18 ns404 0 -0.000653761588833
Gc9_405 0 n18 ns405 0 0.00237656301207
Gc9_406 0 n18 ns406 0 -0.00066084249464
Gc9_407 0 n18 ns407 0 0.000503231791129
Gc9_408 0 n18 ns408 0 0.000268932799171
Gc9_409 0 n18 ns409 0 -0.000186138516278
Gc9_410 0 n18 ns410 0 -0.000118898497365
Gc9_411 0 n18 ns411 0 -0.000807923931862
Gc9_412 0 n18 ns412 0 -0.000295165885016
Gc9_413 0 n18 ns413 0 -0.000336726927784
Gc9_414 0 n18 ns414 0 -0.000164231827663
Gc9_415 0 n18 ns415 0 5.20833982052e-05
Gc9_416 0 n18 ns416 0 1.70583912845e-05
Gc9_417 0 n18 ns417 0 -5.7124560319e-05
Gc9_418 0 n18 ns418 0 1.64733740283e-05
Gc9_419 0 n18 ns419 0 -1.16474304467e-05
Gc9_420 0 n18 ns420 0 0.000242389664238
Gc9_421 0 n18 ns421 0 -4.92125420021e-05
Gc9_422 0 n18 ns422 0 0.000781370838412
Gc9_423 0 n18 ns423 0 3.17332134769e-05
Gc9_424 0 n18 ns424 0 -5.33274791725e-05
Gc9_425 0 n18 ns425 0 -0.000146924670718
Gc9_426 0 n18 ns426 0 4.16672912737e-05
Gc9_427 0 n18 ns427 0 -0.000306449630721
Gc9_428 0 n18 ns428 0 0.000441410068451
Gc9_429 0 n18 ns429 0 5.76170188086e-05
Gc9_430 0 n18 ns430 0 -0.000112481727748
Gc9_431 0 n18 ns431 0 0.000291222332768
Gc9_432 0 n18 ns432 0 -0.00029853227078
Gc9_433 0 n18 ns433 0 0.000920995103772
Gc9_434 0 n18 ns434 0 -0.000674521201413
Gc9_435 0 n18 ns435 0 0.000239915970742
Gc9_436 0 n18 ns436 0 -0.000747386599521
Gc9_437 0 n18 ns437 0 0.00042620217821
Gc9_438 0 n18 ns438 0 -0.000719319668053
Gc9_439 0 n18 ns439 0 0.000128236688967
Gc9_440 0 n18 ns440 0 0.00114162779988
Gc9_441 0 n18 ns441 0 0.00363087865742
Gc9_442 0 n18 ns442 0 0.0028543335182
Gc9_443 0 n18 ns443 0 0.00332066195811
Gc9_444 0 n18 ns444 0 0.00233032357898
Gc9_445 0 n18 ns445 0 0.000740189622373
Gc9_446 0 n18 ns446 0 0.000991897470116
Gc9_447 0 n18 ns447 0 -0.000342339640106
Gc9_448 0 n18 ns448 0 -0.000354894998129
Gc9_449 0 n18 ns449 0 -0.00144460108057
Gc9_450 0 n18 ns450 0 -0.000972329661088
Gc9_451 0 n18 ns451 0 -0.000550762768507
Gc9_452 0 n18 ns452 0 -0.000241964058738
Gc9_453 0 n18 ns453 0 9.90270613378e-05
Gc9_454 0 n18 ns454 0 1.14552146646e-05
Gc9_455 0 n18 ns455 0 -6.4733399915e-05
Gc9_456 0 n18 ns456 0 -1.06100926724e-05
Gc9_457 0 n18 ns457 0 -1.36204602613e-05
Gc9_458 0 n18 ns458 0 -0.00049631126496
Gc9_459 0 n18 ns459 0 -0.000128311547376
Gc9_460 0 n18 ns460 0 4.10069177058e-05
Gc9_461 0 n18 ns461 0 0.000175427681949
Gc9_462 0 n18 ns462 0 -0.000136919318019
Gc9_463 0 n18 ns463 0 -1.14817924116e-05
Gc9_464 0 n18 ns464 0 -8.26038108465e-05
Gc9_465 0 n18 ns465 0 -0.000543812719692
Gc9_466 0 n18 ns466 0 -0.000292784186188
Gc9_467 0 n18 ns467 0 0.000127848511163
Gc9_468 0 n18 ns468 0 -6.2281114172e-05
Gc9_469 0 n18 ns469 0 -3.23120237868e-05
Gc9_470 0 n18 ns470 0 0.000273206205124
Gc9_471 0 n18 ns471 0 0.000762620786664
Gc9_472 0 n18 ns472 0 0.00102952861
Gc9_473 0 n18 ns473 0 0.000587880198694
Gc9_474 0 n18 ns474 0 -0.000146179534185
Gc9_475 0 n18 ns475 0 0.00027646321623
Gc9_476 0 n18 ns476 0 0.000139630949745
Gc9_477 0 n18 ns477 0 -0.00114967952319
Gc9_478 0 n18 ns478 0 -4.56581690099e-06
Gc9_479 0 n18 ns479 0 0.00086025666294
Gc9_480 0 n18 ns480 0 0.00420713855542
Gc9_481 0 n18 ns481 0 0.00114602324806
Gc9_482 0 n18 ns482 0 0.00383771777304
Gc9_483 0 n18 ns483 0 -0.0010843469867
Gc9_484 0 n18 ns484 0 0.000971410997582
Gc9_485 0 n18 ns485 0 -0.000106120518874
Gc9_486 0 n18 ns486 0 -0.00067152142692
Gc9_487 0 n18 ns487 0 -0.000244354139772
Gc9_488 0 n18 ns488 0 -0.00141932867317
Gc9_489 0 n18 ns489 0 -0.00040796097741
Gc9_490 0 n18 ns490 0 0.000428935394346
Gc9_491 0 n18 ns491 0 0.00034039600612
Gc9_492 0 n18 ns492 0 -1.97309488208e-05
Gc9_493 0 n18 ns493 0 -0.000100602316114
Gc9_494 0 n18 ns494 0 -9.98797091588e-06
Gc9_495 0 n18 ns495 0 0.00011079307276
Gc9_496 0 n18 ns496 0 -0.000370985845416
Gc9_497 0 n18 ns497 0 0.000389873243174
Gc9_498 0 n18 ns498 0 0.000418773601075
Gc9_499 0 n18 ns499 0 0.000149870907122
Gc9_500 0 n18 ns500 0 0.000233364522137
Gc9_501 0 n18 ns501 0 2.01058304071e-06
Gc9_502 0 n18 ns502 0 0.000113879003272
Gc9_503 0 n18 ns503 0 0.000248276707028
Gc9_504 0 n18 ns504 0 -0.000592683448564
Gc9_505 0 n18 ns505 0 0.000158213372189
Gc9_506 0 n18 ns506 0 3.41538091432e-05
Gc9_507 0 n18 ns507 0 -0.00011104718526
Gc9_508 0 n18 ns508 0 -0.000280321247579
Gc9_509 0 n18 ns509 0 -0.00122190217188
Gc9_510 0 n18 ns510 0 0.00078056504582
Gc9_511 0 n18 ns511 0 0.000249639683109
Gc9_512 0 n18 ns512 0 0.000128134944404
Gc9_513 0 n18 ns513 0 -0.000369409084383
Gc9_514 0 n18 ns514 0 -0.000184187724611
Gc9_515 0 n18 ns515 0 0.000148321283748
Gc9_516 0 n18 ns516 0 -0.00179081817555
Gc9_517 0 n18 ns517 0 -0.00174349623092
Gc9_518 0 n18 ns518 0 0.00227671497553
Gc9_519 0 n18 ns519 0 -0.00134921421188
Gc9_520 0 n18 ns520 0 0.00271946860317
Gc9_521 0 n18 ns521 0 -0.0025941033892
Gc9_522 0 n18 ns522 0 -0.00123394006199
Gc9_523 0 n18 ns523 0 0.000509755805637
Gc9_524 0 n18 ns524 0 -0.000940301203814
Gc9_525 0 n18 ns525 0 0.00132195795867
Gc9_526 0 n18 ns526 0 -0.000765979561029
Gc9_527 0 n18 ns527 0 -0.000663633137067
Gc9_528 0 n18 ns528 0 0.00227342571784
Gc9_529 0 n18 ns529 0 0.00110661842801
Gc9_530 0 n18 ns530 0 2.87359261522e-05
Gc9_531 0 n18 ns531 0 -0.000339027811749
Gc9_532 0 n18 ns532 0 0.000139126814011
Gc9_533 0 n18 ns533 0 0.00067346772189
Gc9_534 0 n18 ns534 0 -0.0018049508815
Gc9_535 0 n18 ns535 0 0.00136378337308
Gc9_536 0 n18 ns536 0 -0.00150698332561
Gc9_537 0 n18 ns537 0 -0.00097474473691
Gc9_538 0 n18 ns538 0 -0.000166122128929
Gc9_539 0 n18 ns539 0 0.000142058667718
Gc9_540 0 n18 ns540 0 -0.000156223292433
Gc9_541 0 n18 ns541 0 0.000532814087033
Gc9_542 0 n18 ns542 0 0.000338561765918
Gc9_543 0 n18 ns543 0 0.000135631440695
Gc9_544 0 n18 ns544 0 0.000101072285941
Gc9_545 0 n18 ns545 0 0.000357971912377
Gc9_546 0 n18 ns546 0 0.000374177222122
Gc9_547 0 n18 ns547 0 -0.000230181920535
Gc9_548 0 n18 ns548 0 -0.00154998521968
Gc9_549 0 n18 ns549 0 0.000583802715866
Gc9_550 0 n18 ns550 0 -0.000137560841584
Gc9_551 0 n18 ns551 0 0.000589110954099
Gc9_552 0 n18 ns552 0 -0.000667256585024
Gc9_553 0 n18 ns553 0 0.00230561153216
Gc9_554 0 n18 ns554 0 0.00129520853855
Gc9_555 0 n18 ns555 0 -0.000589198325688
Gc9_556 0 n18 ns556 0 0.00189889358802
Gc9_557 0 n18 ns557 0 -0.00100452489664
Gc9_558 0 n18 ns558 0 0.00237337481102
Gc9_559 0 n18 ns559 0 0.00238012386731
Gc9_560 0 n18 ns560 0 -0.00296029362889
Gc9_561 0 n18 ns561 0 0.00116445465316
Gc9_562 0 n18 ns562 0 -0.000574741873426
Gc9_563 0 n18 ns563 0 7.38727757893e-05
Gc9_564 0 n18 ns564 0 0.000576386986877
Gc9_565 0 n18 ns565 0 -0.00312822752934
Gc9_566 0 n18 ns566 0 0.00205321615512
Gc9_567 0 n18 ns567 0 0.0026016306555
Gc9_568 0 n18 ns568 0 1.72596707323e-05
Gc9_569 0 n18 ns569 0 -0.0002062413453
Gc9_570 0 n18 ns570 0 5.32121718326e-05
Gc9_571 0 n18 ns571 0 0.00199734108707
Gc9_572 0 n18 ns572 0 -0.00554541485308
Gc9_573 0 n18 ns573 0 0.00165721575712
Gc9_574 0 n18 ns574 0 -0.00411598353016
Gc9_575 0 n18 ns575 0 -0.000822899704178
Gc9_576 0 n18 ns576 0 -0.000934566788997
Gc9_577 0 n18 ns577 0 0.000607845299257
Gc9_578 0 n18 ns578 0 0.000118968075357
Gc9_579 0 n18 ns579 0 -0.000110318316178
Gc9_580 0 n18 ns580 0 0.000431487394289
Gc9_581 0 n18 ns581 0 4.36512287247e-05
Gc9_582 0 n18 ns582 0 7.88315492496e-05
Gc9_583 0 n18 ns583 0 -0.00089695391276
Gc9_584 0 n18 ns584 0 0.000270259308976
Gc9_585 0 n18 ns585 0 0.000469228654417
Gc9_586 0 n18 ns586 0 -3.38600354824e-05
Gc9_587 0 n18 ns587 0 -4.39499320148e-05
Gc9_588 0 n18 ns588 0 0.000171984698617
Gc9_589 0 n18 ns589 0 -0.000449182388236
Gc9_590 0 n18 ns590 0 -0.000638768358789
Gc9_591 0 n18 ns591 0 -0.000529072877409
Gc9_592 0 n18 ns592 0 0.00114090721668
Gc9_593 0 n18 ns593 0 0.00596296121251
Gc9_594 0 n18 ns594 0 0.00370090648371
Gc9_595 0 n18 ns595 0 0.00401962060791
Gc9_596 0 n18 ns596 0 0.00346785975019
Gc9_597 0 n18 ns597 0 0.00338581960672
Gc9_598 0 n18 ns598 0 0.00627101707087
Gc9_599 0 n18 ns599 0 0.000735223825876
Gc9_600 0 n18 ns600 0 -0.000161172329896
Gc9_601 0 n18 ns601 0 -0.00746567089562
Gc9_602 0 n18 ns602 0 -0.0010028699377
Gc9_603 0 n18 ns603 0 0.00385873431542
Gc9_604 0 n18 ns604 0 -0.00795709628322
Gc9_605 0 n18 ns605 0 0.00388652898124
Gc9_606 0 n18 ns606 0 4.70375813501e-06
Gc9_607 0 n18 ns607 0 -0.0001334506006
Gc9_608 0 n18 ns608 0 2.30673147423e-05
Gc9_609 0 n18 ns609 0 -0.000226229077419
Gc9_610 0 n18 ns610 0 0.000873045155504
Gc9_611 0 n18 ns611 0 -0.00030267129846
Gc9_612 0 n18 ns612 0 0.000707223320046
Gc9_613 0 n18 ns613 0 -0.000189182800472
Gc9_614 0 n18 ns614 0 0.000304000093787
Gc9_615 0 n18 ns615 0 0.000138500485772
Gc9_616 0 n18 ns616 0 -0.000130214891684
Gc9_617 0 n18 ns617 0 0.000214836474473
Gc9_618 0 n18 ns618 0 0.000283979242921
Gc9_619 0 n18 ns619 0 2.7128010122e-05
Gc9_620 0 n18 ns620 0 -0.000100395066574
Gc9_621 0 n18 ns621 0 -0.000270409375978
Gc9_622 0 n18 ns622 0 -0.000414410650918
Gc9_623 0 n18 ns623 0 -5.84690500895e-05
Gc9_624 0 n18 ns624 0 -0.000132527507361
Gc9_625 0 n18 ns625 0 2.86705893207e-05
Gc9_626 0 n18 ns626 0 -2.25676286982e-05
Gc9_627 0 n18 ns627 0 0.00012856533247
Gc9_628 0 n18 ns628 0 -6.0172994332e-05
Gc9_629 0 n18 ns629 0 -2.83049246822e-06
Gc9_630 0 n18 ns630 0 0.000453282434825
Gc9_631 0 n18 ns631 0 5.44003524126e-05
Gc9_632 0 n18 ns632 0 0.00170759643657
Gc9_633 0 n18 ns633 0 6.18737856615e-05
Gc9_634 0 n18 ns634 0 0.00144097613668
Gc9_635 0 n18 ns635 0 0.000624604504125
Gc9_636 0 n18 ns636 0 0.000407714523295
Gc9_637 0 n18 ns637 0 -0.000112959458957
Gc9_638 0 n18 ns638 0 -7.30435109823e-05
Gc9_639 0 n18 ns639 0 -0.000577799645181
Gc9_640 0 n18 ns640 0 -0.000443801246302
Gc9_641 0 n18 ns641 0 -0.000133680403049
Gc9_642 0 n18 ns642 0 -0.000756879261819
Gc9_643 0 n18 ns643 0 -0.000211629506822
Gc9_644 0 n18 ns644 0 -1.03290156584e-05
Gc9_645 0 n18 ns645 0 4.57321680582e-05
Gc9_646 0 n18 ns646 0 -3.13840042379e-05
Gc9_647 0 n18 ns647 0 0.000109125591035
Gc9_648 0 n18 ns648 0 0.000546506249887
Gc9_649 0 n18 ns649 0 0.000638584308898
Gc9_650 0 n18 ns650 0 0.000759692202046
Gc9_651 0 n18 ns651 0 5.53594673757e-05
Gc9_652 0 n18 ns652 0 0.000250317404908
Gc9_653 0 n18 ns653 0 -1.56046319808e-05
Gc9_654 0 n18 ns654 0 -9.84596529942e-05
Gc9_655 0 n18 ns655 0 0.000197269462797
Gc9_656 0 n18 ns656 0 0.000248351592296
Gc9_657 0 n18 ns657 0 3.85736004758e-05
Gc9_658 0 n18 ns658 0 -0.000114333595021
Gc9_659 0 n18 ns659 0 -0.000403554906947
Gc9_660 0 n18 ns660 0 -0.000460831843557
Gc9_661 0 n18 ns661 0 -0.000194697865219
Gc9_662 0 n18 ns662 0 -0.000201164084171
Gc9_663 0 n18 ns663 0 -5.15504018576e-05
Gc9_664 0 n18 ns664 0 -4.19450375748e-05
Gc9_665 0 n18 ns665 0 4.12806441614e-05
Gc9_666 0 n18 ns666 0 -0.000115280716747
Gc9_667 0 n18 ns667 0 5.59193523831e-05
Gc9_668 0 n18 ns668 0 0.000538717688218
Gc9_669 0 n18 ns669 0 8.37219472e-05
Gc9_670 0 n18 ns670 0 0.00219736124082
Gc9_671 0 n18 ns671 0 8.15706125649e-05
Gc9_672 0 n18 ns672 0 0.00185770512405
Gc9_673 0 n18 ns673 0 0.000872340294096
Gc9_674 0 n18 ns674 0 0.000465395423321
Gc9_675 0 n18 ns675 0 -0.000151432757612
Gc9_676 0 n18 ns676 0 -8.23181955101e-05
Gc9_677 0 n18 ns677 0 -0.000805432485187
Gc9_678 0 n18 ns678 0 -0.000516437340253
Gc9_679 0 n18 ns679 0 -0.000209623608704
Gc9_680 0 n18 ns680 0 -0.000866836027408
Gc9_681 0 n18 ns681 0 -0.000229589157242
Gc9_682 0 n18 ns682 0 1.0951853472e-05
Gc9_683 0 n18 ns683 0 -3.46502798526e-05
Gc9_684 0 n18 ns684 0 1.95327110258e-05
Gc9_685 0 n18 ns685 0 0.00030129489624
Gc9_686 0 n18 ns686 0 -0.000318109836297
Gc9_687 0 n18 ns687 0 0.000714639641605
Gc9_688 0 n18 ns688 0 -0.000495668720402
Gc9_689 0 n18 ns689 0 0.000169100813788
Gc9_690 0 n18 ns690 0 -0.000214806618181
Gc9_691 0 n18 ns691 0 -0.000149776781244
Gc9_692 0 n18 ns692 0 9.74068033404e-05
Gc9_693 0 n18 ns693 0 -0.000266092604359
Gc9_694 0 n18 ns694 0 -1.74520183268e-06
Gc9_695 0 n18 ns695 0 8.48722463067e-05
Gc9_696 0 n18 ns696 0 8.96505987783e-06
Gc9_697 0 n18 ns697 0 6.78954876236e-05
Gc9_698 0 n18 ns698 0 -0.000158075288817
Gc9_699 0 n18 ns699 0 -0.000367805369488
Gc9_700 0 n18 ns700 0 -0.00012235382769
Gc9_701 0 n18 ns701 0 -0.000366966036355
Gc9_702 0 n18 ns702 0 9.23917959761e-05
Gc9_703 0 n18 ns703 0 -0.000453237683088
Gc9_704 0 n18 ns704 0 0.000177299724728
Gc9_705 0 n18 ns705 0 -0.000338003591794
Gc9_706 0 n18 ns706 0 -3.57112005555e-05
Gc9_707 0 n18 ns707 0 -0.00148778806356
Gc9_708 0 n18 ns708 0 0.00131549171389
Gc9_709 0 n18 ns709 0 -0.00127170214137
Gc9_710 0 n18 ns710 0 0.00118131469767
Gc9_711 0 n18 ns711 0 0.000437385240867
Gc9_712 0 n18 ns712 0 0.000336383954444
Gc9_713 0 n18 ns713 0 -0.000146086705307
Gc9_714 0 n18 ns714 0 -7.28751679112e-05
Gc9_715 0 n18 ns715 0 -0.000572688816051
Gc9_716 0 n18 ns716 0 -0.000216949456261
Gc9_717 0 n18 ns717 0 -7.24364098804e-05
Gc9_718 0 n18 ns718 0 -0.000137171165054
Gc9_719 0 n18 ns719 0 -6.65932964391e-05
Gc9_720 0 n18 ns720 0 -1.23309288727e-05
Gc9_721 0 n18 ns721 0 1.74662026147e-05
Gc9_722 0 n18 ns722 0 9.54274163143e-06
Gc9_723 0 n18 ns723 0 -0.000705209105005
Gc9_724 0 n18 ns724 0 0.00129933823823
Gc9_725 0 n18 ns725 0 -0.00180610899669
Gc9_726 0 n18 ns726 0 0.00186563950919
Gc9_727 0 n18 ns727 0 -0.000240935752353
Gc9_728 0 n18 ns728 0 0.000688275081041
Gc9_729 0 n18 ns729 0 0.000171369330511
Gc9_730 0 n18 ns730 0 -0.000437936529708
Gc9_731 0 n18 ns731 0 -5.93260613835e-05
Gc9_732 0 n18 ns732 0 -0.000110462406583
Gc9_733 0 n18 ns733 0 9.34226175162e-05
Gc9_734 0 n18 ns734 0 0.000114173352022
Gc9_735 0 n18 ns735 0 0.00058942724804
Gc9_736 0 n18 ns736 0 -0.000354565555117
Gc9_737 0 n18 ns737 0 0.000350928182211
Gc9_738 0 n18 ns738 0 -0.000741602093822
Gc9_739 0 n18 ns739 0 -0.000189245064613
Gc9_740 0 n18 ns740 0 -0.000485474889082
Gc9_741 0 n18 ns741 0 -0.000176327165139
Gc9_742 0 n18 ns742 0 -0.000434946863019
Gc9_743 0 n18 ns743 0 -0.000556563613811
Gc9_744 0 n18 ns744 0 -0.000162633551144
Gc9_745 0 n18 ns745 0 -0.00416975355022
Gc9_746 0 n18 ns746 0 0.000452068311124
Gc9_747 0 n18 ns747 0 -0.00362969249318
Gc9_748 0 n18 ns748 0 0.000460396283841
Gc9_749 0 n18 ns749 0 0.00042381919513
Gc9_750 0 n18 ns750 0 0.00131862749841
Gc9_751 0 n18 ns751 0 -0.000252501919216
Gc9_752 0 n18 ns752 0 -0.0002756866998
Gc9_753 0 n18 ns753 0 -0.000871297832414
Gc9_754 0 n18 ns754 0 -0.00104650668947
Gc9_755 0 n18 ns755 0 -0.00012015128231
Gc9_756 0 n18 ns756 0 -0.000665934872239
Gc9_757 0 n18 ns757 0 -0.00020259357868
Gc9_758 0 n18 ns758 0 1.89934590896e-06
Gc9_759 0 n18 ns759 0 6.49159719759e-05
Gc9_760 0 n18 ns760 0 -6.63420544621e-06
Gc9_761 0 n18 ns761 0 -7.62044035861e-05
Gc9_762 0 n18 ns762 0 -5.21471076391e-06
Gc9_763 0 n18 ns763 0 2.63582549849e-05
Gc9_764 0 n18 ns764 0 0.000341822186764
Gc9_765 0 n18 ns765 0 -3.04492990854e-05
Gc9_766 0 n18 ns766 0 0.000126958407837
Gc9_767 0 n18 ns767 0 0.000126405658795
Gc9_768 0 n18 ns768 0 2.01234343089e-05
Gc9_769 0 n18 ns769 0 0.00052898453286
Gc9_770 0 n18 ns770 0 -0.000332187447413
Gc9_771 0 n18 ns771 0 -0.000149494330835
Gc9_772 0 n18 ns772 0 0.000117954385299
Gc9_773 0 n18 ns773 0 -9.7644332383e-05
Gc9_774 0 n18 ns774 0 0.000549083386752
Gc9_775 0 n18 ns775 0 0.000924618474935
Gc9_776 0 n18 ns776 0 -9.92521597395e-05
Gc9_777 0 n18 ns777 0 0.000310904705668
Gc9_778 0 n18 ns778 0 -0.000718933654268
Gc9_779 0 n18 ns779 0 0.000232732873817
Gc9_780 0 n18 ns780 0 -0.000721818421361
Gc9_781 0 n18 ns781 0 0.000155154975769
Gc9_782 0 n18 ns782 0 -0.000567966946553
Gc9_783 0 n18 ns783 0 -0.00426431287082
Gc9_784 0 n18 ns784 0 -0.00355017346577
Gc9_785 0 n18 ns785 0 -0.00391711552558
Gc9_786 0 n18 ns786 0 -0.00304678859654
Gc9_787 0 n18 ns787 0 -0.000153189362908
Gc9_788 0 n18 ns788 0 0.00155196294081
Gc9_789 0 n18 ns789 0 -0.000248431933913
Gc9_790 0 n18 ns790 0 -0.000517905598099
Gc9_791 0 n18 ns791 0 -0.000778656826766
Gc9_792 0 n18 ns792 0 -0.00157316885209
Gc9_793 0 n18 ns793 0 -5.74533076439e-05
Gc9_794 0 n18 ns794 0 -0.000934783526103
Gc9_795 0 n18 ns795 0 -0.000312982089254
Gc9_796 0 n18 ns796 0 -1.94389456351e-07
Gc9_797 0 n18 ns797 0 6.67458609292e-05
Gc9_798 0 n18 ns798 0 8.81947500395e-06
Gc9_799 0 n18 ns799 0 -0.000163340795199
Gc9_800 0 n18 ns800 0 -0.000385223193648
Gc9_801 0 n18 ns801 0 -0.000520156741678
Gc9_802 0 n18 ns802 0 0.00059207316679
Gc9_803 0 n18 ns803 0 -0.000203308762778
Gc9_804 0 n18 ns804 0 -2.53700145139e-05
Gc9_805 0 n18 ns805 0 -6.78219766255e-05
Gc9_806 0 n18 ns806 0 0.000113315932569
Gc9_807 0 n18 ns807 0 0.000369775344259
Gc9_808 0 n18 ns808 0 0.00068612228568
Gc9_809 0 n18 ns809 0 -0.000116975086826
Gc9_810 0 n18 ns810 0 -2.7597937992e-05
Gc9_811 0 n18 ns811 0 -0.000356571907503
Gc9_812 0 n18 ns812 0 -0.000376819736179
Gc9_813 0 n18 ns813 0 0.000385956639531
Gc9_814 0 n18 ns814 0 0.00115638347429
Gc9_815 0 n18 ns815 0 0.000851428543159
Gc9_816 0 n18 ns816 0 -1.68521607576e-05
Gc9_817 0 n18 ns817 0 0.000655083595777
Gc9_818 0 n18 ns818 0 0.000153825054479
Gc9_819 0 n18 ns819 0 0.000395800216961
Gc9_820 0 n18 ns820 0 0.000202141374861
Gc9_821 0 n18 ns821 0 -0.000950007416906
Gc9_822 0 n18 ns822 0 -0.00616390328746
Gc9_823 0 n18 ns823 0 -0.00116719564356
Gc9_824 0 n18 ns824 0 -0.00564652006197
Gc9_825 0 n18 ns825 0 -0.00142930365328
Gc9_826 0 n18 ns826 0 0.00105942745387
Gc9_827 0 n18 ns827 0 2.73083561343e-05
Gc9_828 0 n18 ns828 0 -0.000882955563294
Gc9_829 0 n18 ns829 0 0.000146844005136
Gc9_830 0 n18 ns830 0 -0.0020248769373
Gc9_831 0 n18 ns831 0 0.000368432395671
Gc9_832 0 n18 ns832 0 -0.0011521975541
Gc9_833 0 n18 ns833 0 -0.000538059698461
Gc9_834 0 n18 ns834 0 -5.83906702635e-06
Gc9_835 0 n18 ns835 0 7.69941992265e-05
Gc9_836 0 n18 ns836 0 -1.60330370836e-06
Gc9_837 0 n18 ns837 0 -0.000396080590255
Gc9_838 0 n18 ns838 0 0.00011189344449
Gc9_839 0 n18 ns839 0 -0.00114177226192
Gc9_840 0 n18 ns840 0 0.00150497401874
Gc9_841 0 n18 ns841 0 -7.60714586447e-05
Gc9_842 0 n18 ns842 0 0.000130037870541
Gc9_843 0 n18 ns843 0 8.09155740628e-05
Gc9_844 0 n18 ns844 0 -0.000267473394751
Gc9_845 0 n18 ns845 0 -0.000692475019728
Gc9_846 0 n18 ns846 0 0.000660455501718
Gc9_847 0 n18 ns847 0 -4.01932621818e-05
Gc9_848 0 n18 ns848 0 -1.36135457886e-05
Gc9_849 0 n18 ns849 0 0.00097200297925
Gc9_850 0 n18 ns850 0 -0.000784199114428
Gc9_851 0 n18 ns851 0 -0.00101917604191
Gc9_852 0 n18 ns852 0 8.15630265017e-05
Gc9_853 0 n18 ns853 0 0.000445035092703
Gc9_854 0 n18 ns854 0 0.000289299911087
Gc9_855 0 n18 ns855 0 3.63125350721e-06
Gc9_856 0 n18 ns856 0 8.62566063269e-05
Gc9_857 0 n18 ns857 0 -0.000968417851964
Gc9_858 0 n18 ns858 0 0.00135836353932
Gc9_859 0 n18 ns859 0 0.00215463816231
Gc9_860 0 n18 ns860 0 -0.0014946276657
Gc9_861 0 n18 ns861 0 0.00188837028172
Gc9_862 0 n18 ns862 0 -0.00216959822191
Gc9_863 0 n18 ns863 0 -0.000900426920728
Gc9_864 0 n18 ns864 0 -0.000868386187674
Gc9_865 0 n18 ns865 0 0.000704656669864
Gc9_866 0 n18 ns866 0 -0.00107456217007
Gc9_867 0 n18 ns867 0 0.00106932565002
Gc9_868 0 n18 ns868 0 -0.0016178931822
Gc9_869 0 n18 ns869 0 0.00137646981879
Gc9_870 0 n18 ns870 0 -0.00214082922157
Gc9_871 0 n18 ns871 0 -0.0013956319453
Gc9_872 0 n18 ns872 0 -3.08638217789e-05
Gc9_873 0 n18 ns873 0 0.000130917106344
Gc9_874 0 n18 ns874 0 -1.1095874208e-05
Gc9_875 0 n18 ns875 0 -0.00104001666584
Gc9_876 0 n18 ns876 0 -0.000302675954038
Gc9_877 0 n18 ns877 0 -0.00421431461277
Gc9_878 0 n18 ns878 0 -0.00176758961425
Gc9_879 0 n18 ns879 0 -0.00180913000228
Gc9_880 0 n18 ns880 0 0.00119766679446
Gc9_881 0 n18 ns881 0 0.000894256427421
Gc9_882 0 n18 ns882 0 -0.000413023637844
Gc9_883 0 n18 ns883 0 -0.000669286745146
Gc9_884 0 n18 ns884 0 -0.000253653974006
Gc9_885 0 n18 ns885 0 -8.70998098711e-05
Gc9_886 0 n18 ns886 0 -5.26182238982e-05
Gc9_887 0 n18 ns887 0 0.000742891496412
Gc9_888 0 n18 ns888 0 0.000536694529637
Gc9_889 0 n18 ns889 0 0.000656649705117
Gc9_890 0 n18 ns890 0 -0.00145175286365
Gc9_891 0 n18 ns891 0 0.000687129058187
Gc9_892 0 n18 ns892 0 9.90617789273e-05
Gc9_893 0 n18 ns893 0 0.00079100754501
Gc9_894 0 n18 ns894 0 -0.000327279894547
Gc9_895 0 n18 ns895 0 -0.00249962821394
Gc9_896 0 n18 ns896 0 -0.00107302186695
Gc9_897 0 n18 ns897 0 -0.00285649997022
Gc9_898 0 n18 ns898 0 0.00075996108754
Gc9_899 0 n18 ns899 0 -0.00162544151421
Gc9_900 0 n18 ns900 0 -6.30287495414e-05
Gc9_901 0 n18 ns901 0 0.00414507422311
Gc9_902 0 n18 ns902 0 0.000126849503071
Gc9_903 0 n18 ns903 0 0.00123071140634
Gc9_904 0 n18 ns904 0 -0.000537019801761
Gc9_905 0 n18 ns905 0 -0.00134857733216
Gc9_906 0 n18 ns906 0 -0.000704056516368
Gc9_907 0 n18 ns907 0 0.00270010235784
Gc9_908 0 n18 ns908 0 0.0014074514839
Gc9_909 0 n18 ns909 0 -0.00284197899406
Gc9_910 0 n18 ns910 0 -4.07041763902e-05
Gc9_911 0 n18 ns911 0 0.000368920717462
Gc9_912 0 n18 ns912 0 -0.00018754350965
Gc9_913 0 n18 ns913 0 0.000121966279301
Gc9_914 0 n18 ns914 0 0.000229600484173
Gc9_915 0 n18 ns915 0 0.00240523494294
Gc9_916 0 n18 ns916 0 0.0022267927759
Gc9_917 0 n18 ns917 0 0.000984848535316
Gc9_918 0 n18 ns918 0 -0.00205265558868
Gc9_919 0 n18 ns919 0 -0.00026357898423
Gc9_920 0 n18 ns920 0 0.000518733961132
Gc9_921 0 n18 ns921 0 0.000582191231581
Gc9_922 0 n18 ns922 0 -9.63807502144e-05
Gc9_923 0 n18 ns923 0 4.18493958639e-05
Gc9_924 0 n18 ns924 0 -0.000117667740339
Gc9_925 0 n18 ns925 0 0.00108138393693
Gc9_926 0 n18 ns926 0 -0.00104277696232
Gc9_927 0 n18 ns927 0 0.000240986993005
Gc9_928 0 n18 ns928 0 0.00161226395851
Gc9_929 0 n18 ns929 0 -0.000719048180635
Gc9_930 0 n18 ns930 0 0.000570654751896
Gc9_931 0 n18 ns931 0 -0.00191393015333
Gc9_932 0 n18 ns932 0 -0.000391902881495
Gc9_933 0 n18 ns933 0 0.00408806118606
Gc9_934 0 n18 ns934 0 0.00260921095885
Gc9_935 0 n18 ns935 0 -0.00833105481029
Gc9_936 0 n18 ns936 0 0.00311839909917
Gc9_937 0 n18 ns937 0 -0.00597758254711
Gc9_938 0 n18 ns938 0 0.00203286155577
Gc9_939 0 n18 ns939 0 -0.0103197009458
Gc9_940 0 n18 ns940 0 4.64689610645e-05
Gc9_941 0 n18 ns941 0 0.00129064307063
Gc9_942 0 n18 ns942 0 0.000991310826497
Gc9_943 0 n18 ns943 0 -0.00360295059837
Gc9_944 0 n18 ns944 0 0.0108451761748
Gc9_945 0 n18 ns945 0 -0.0155892398406
Gc9_946 0 n18 ns946 0 -0.000688582903554
Gc9_947 0 n18 ns947 0 -0.00491304676768
Gc9_948 0 n18 ns948 0 -4.74693731389e-05
Gc9_949 0 n18 ns949 0 -0.000370471690536
Gc9_950 0 n18 ns950 0 0.000563148999432
Gc9_951 0 n18 ns951 0 0.000346422446421
Gc9_952 0 n18 ns952 0 -0.000221564364125
Gc9_953 0 n18 ns953 0 0.000912116765228
Gc9_954 0 n18 ns954 0 -0.000456156442869
Gc9_955 0 n18 ns955 0 0.000171963399175
Gc9_956 0 n18 ns956 0 -0.000227492409452
Gc9_957 0 n18 ns957 0 -0.000133844393096
Gc9_958 0 n18 ns958 0 0.000147025454321
Gc9_959 0 n18 ns959 0 -0.000132490101526
Gc9_960 0 n18 ns960 0 9.94524282679e-05
Gc9_961 0 n18 ns961 0 6.06267272619e-05
Gc9_962 0 n18 ns962 0 -4.39712763076e-05
Gc9_963 0 n18 ns963 0 -0.000145937593062
Gc9_964 0 n18 ns964 0 -0.000187606492827
Gc9_965 0 n18 ns965 0 -0.000363057020167
Gc9_966 0 n18 ns966 0 -3.37024730366e-05
Gc9_967 0 n18 ns967 0 -0.000263299082227
Gc9_968 0 n18 ns968 0 0.00012356575247
Gc9_969 0 n18 ns969 0 -0.000308045651461
Gc9_970 0 n18 ns970 0 0.000168698522001
Gc9_971 0 n18 ns971 0 -0.000175948583531
Gc9_972 0 n18 ns972 0 0.000124241282921
Gc9_973 0 n18 ns973 0 -0.000640802855373
Gc9_974 0 n18 ns974 0 0.00150416614334
Gc9_975 0 n18 ns975 0 -0.000540618747284
Gc9_976 0 n18 ns976 0 0.00131689695369
Gc9_977 0 n18 ns977 0 0.000501426676962
Gc9_978 0 n18 ns978 0 0.000217484948348
Gc9_979 0 n18 ns979 0 -0.000128138770318
Gc9_980 0 n18 ns980 0 -4.88760031345e-05
Gc9_981 0 n18 ns981 0 -0.000554842278102
Gc9_982 0 n18 ns982 0 -0.000165484437489
Gc9_983 0 n18 ns983 0 -7.87831001955e-05
Gc9_984 0 n18 ns984 0 -0.00024263221749
Gc9_985 0 n18 ns985 0 -9.30919204076e-05
Gc9_986 0 n18 ns986 0 -9.82185203687e-06
Gc9_987 0 n18 ns987 0 2.91578879696e-06
Gc9_988 0 n18 ns988 0 8.22018134654e-06
Gc9_989 0 n18 ns989 0 -0.000499230282643
Gc9_990 0 n18 ns990 0 0.00096137781426
Gc9_991 0 n18 ns991 0 -0.00136535424799
Gc9_992 0 n18 ns992 0 0.00134964219654
Gc9_993 0 n18 ns993 0 -0.000133791399434
Gc9_994 0 n18 ns994 0 0.000457203696439
Gc9_995 0 n18 ns995 0 5.05155643387e-05
Gc9_996 0 n18 ns996 0 -0.000302027831497
Gc9_997 0 n18 ns997 0 -0.000220388661819
Gc9_998 0 n18 ns998 0 1.35467259476e-05
Gc9_999 0 n18 ns999 0 0.00012917250978
Gc9_1000 0 n18 ns1000 0 7.17708367177e-05
Gc9_1001 0 n18 ns1001 0 0.000508727630535
Gc9_1002 0 n18 ns1002 0 -0.000451700148563
Gc9_1003 0 n18 ns1003 0 5.35042944249e-05
Gc9_1004 0 n18 ns1004 0 -0.000564353749355
Gc9_1005 0 n18 ns1005 0 -0.000277007988947
Gc9_1006 0 n18 ns1006 0 -0.000243651545058
Gc9_1007 0 n18 ns1007 0 -0.000285973391789
Gc9_1008 0 n18 ns1008 0 -0.000165509066086
Gc9_1009 0 n18 ns1009 0 -0.000572872875638
Gc9_1010 0 n18 ns1010 0 -8.28250614144e-05
Gc9_1011 0 n18 ns1011 0 -0.0032383335703
Gc9_1012 0 n18 ns1012 0 0.00101799397795
Gc9_1013 0 n18 ns1013 0 -0.00279049942609
Gc9_1014 0 n18 ns1014 0 0.000943378967175
Gc9_1015 0 n18 ns1015 0 0.000393598429367
Gc9_1016 0 n18 ns1016 0 0.000941006871207
Gc9_1017 0 n18 ns1017 0 -0.000203776163463
Gc9_1018 0 n18 ns1018 0 -0.000187775970249
Gc9_1019 0 n18 ns1019 0 -0.000704568638068
Gc9_1020 0 n18 ns1020 0 -0.000698772259437
Gc9_1021 0 n18 ns1021 0 -7.75042910732e-05
Gc9_1022 0 n18 ns1022 0 -0.0004166451571
Gc9_1023 0 n18 ns1023 0 -0.000141284788251
Gc9_1024 0 n18 ns1024 0 -1.49165171824e-05
Gc9_1025 0 n18 ns1025 0 4.74660216629e-05
Gc9_1026 0 n18 ns1026 0 2.40894887335e-06
Gc9_1027 0 n18 ns1027 0 -0.000268036708419
Gc9_1028 0 n18 ns1028 0 0.000516124182853
Gc9_1029 0 n18 ns1029 0 -0.000536513755094
Gc9_1030 0 n18 ns1030 0 0.000819473527757
Gc9_1031 0 n18 ns1031 0 -7.32147410412e-05
Gc9_1032 0 n18 ns1032 0 0.00035006084964
Gc9_1033 0 n18 ns1033 0 0.000159330102838
Gc9_1034 0 n18 ns1034 0 -0.000192885884007
Gc9_1035 0 n18 ns1035 0 0.000273704123869
Gc9_1036 0 n18 ns1036 0 -0.000410865413745
Gc9_1037 0 n18 ns1037 0 -6.39187373097e-05
Gc9_1038 0 n18 ns1038 0 0.000146868594264
Gc9_1039 0 n18 ns1039 0 0.000259022248925
Gc9_1040 0 n18 ns1040 0 0.000339530243492
Gc9_1041 0 n18 ns1041 0 0.000742807492604
Gc9_1042 0 n18 ns1042 0 -0.000501457807385
Gc9_1043 0 n18 ns1043 0 6.27283853426e-05
Gc9_1044 0 n18 ns1044 0 -0.000713110973748
Gc9_1045 0 n18 ns1045 0 2.31926517913e-05
Gc9_1046 0 n18 ns1046 0 -0.000728882452335
Gc9_1047 0 n18 ns1047 0 -0.000117519801393
Gc9_1048 0 n18 ns1048 0 -0.000471711187327
Gc9_1049 0 n18 ns1049 0 -0.00444476039501
Gc9_1050 0 n18 ns1050 0 -0.00179539366924
Gc9_1051 0 n18 ns1051 0 -0.00398782594458
Gc9_1052 0 n18 ns1052 0 -0.00149184772376
Gc9_1053 0 n18 ns1053 0 0.00022199716633
Gc9_1054 0 n18 ns1054 0 0.00145264104568
Gc9_1055 0 n18 ns1055 0 -0.000284012592188
Gc9_1056 0 n18 ns1056 0 -0.000407621572055
Gc9_1057 0 n18 ns1057 0 -0.000976239561997
Gc9_1058 0 n18 ns1058 0 -0.00129065617048
Gc9_1059 0 n18 ns1059 0 -0.000109808714043
Gc9_1060 0 n18 ns1060 0 -0.000702305345481
Gc9_1061 0 n18 ns1061 0 -0.000237088081093
Gc9_1062 0 n18 ns1062 0 3.53656779177e-07
Gc9_1063 0 n18 ns1063 0 4.33967681877e-05
Gc9_1064 0 n18 ns1064 0 1.85438223213e-05
Gc9_1065 0 n18 ns1065 0 8.56642737999e-05
Gc9_1066 0 n18 ns1066 0 -0.000582105347382
Gc9_1067 0 n18 ns1067 0 0.000223283307611
Gc9_1068 0 n18 ns1068 0 -2.67603470281e-05
Gc9_1069 0 n18 ns1069 0 -3.50277752589e-06
Gc9_1070 0 n18 ns1070 0 -0.000105590803915
Gc9_1071 0 n18 ns1071 0 -7.5943599491e-05
Gc9_1072 0 n18 ns1072 0 0.000223165165577
Gc9_1073 0 n18 ns1073 0 0.000563896329273
Gc9_1074 0 n18 ns1074 0 0.000186351388967
Gc9_1075 0 n18 ns1075 0 -0.000161203935797
Gc9_1076 0 n18 ns1076 0 2.82336713294e-05
Gc9_1077 0 n18 ns1077 0 -0.000499174093173
Gc9_1078 0 n18 ns1078 0 0.00023707789546
Gc9_1079 0 n18 ns1079 0 0.000729464963887
Gc9_1080 0 n18 ns1080 0 0.00082309193863
Gc9_1081 0 n18 ns1081 0 0.000675010240109
Gc9_1082 0 n18 ns1082 0 -0.000300405040445
Gc9_1083 0 n18 ns1083 0 0.000531551394634
Gc9_1084 0 n18 ns1084 0 -0.000179242922147
Gc9_1085 0 n18 ns1085 0 0.000468322695648
Gc9_1086 0 n18 ns1086 0 -0.000298652620877
Gc9_1087 0 n18 ns1087 0 -0.00241121241169
Gc9_1088 0 n18 ns1088 0 -0.00585587135067
Gc9_1089 0 n18 ns1089 0 -0.00241652752469
Gc9_1090 0 n18 ns1090 0 -0.00520370072643
Gc9_1091 0 n18 ns1091 0 -0.000958942917154
Gc9_1092 0 n18 ns1092 0 0.00128030522394
Gc9_1093 0 n18 ns1093 0 -0.000119731395197
Gc9_1094 0 n18 ns1094 0 -0.000716127917133
Gc9_1095 0 n18 ns1095 0 -0.000282549549495
Gc9_1096 0 n18 ns1096 0 -0.0017698571844
Gc9_1097 0 n18 ns1097 0 0.000165995194755
Gc9_1098 0 n18 ns1098 0 -0.000876075855252
Gc9_1099 0 n18 ns1099 0 -0.000381062217294
Gc9_1100 0 n18 ns1100 0 4.99978389241e-07
Gc9_1101 0 n18 ns1101 0 4.23553387353e-05
Gc9_1102 0 n18 ns1102 0 1.98254818123e-05
Gc9_1103 0 n18 ns1103 0 -0.000316675463142
Gc9_1104 0 n18 ns1104 0 -0.000190953857329
Gc9_1105 0 n18 ns1105 0 -0.00100109191998
Gc9_1106 0 n18 ns1106 0 0.000809640502954
Gc9_1107 0 n18 ns1107 0 -0.000336896999738
Gc9_1108 0 n18 ns1108 0 -0.000142423663378
Gc9_1109 0 n18 ns1109 0 7.04972876024e-05
Gc9_1110 0 n18 ns1110 0 -8.18575198042e-05
Gc9_1111 0 n18 ns1111 0 -0.000351496866968
Gc9_1112 0 n18 ns1112 0 0.000855783841165
Gc9_1113 0 n18 ns1113 0 -5.36612137205e-05
Gc9_1114 0 n18 ns1114 0 -2.69261102906e-06
Gc9_1115 0 n18 ns1115 0 0.000546931734628
Gc9_1116 0 n18 ns1116 0 -0.000858674032314
Gc9_1117 0 n18 ns1117 0 -0.000646447564652
Gc9_1118 0 n18 ns1118 0 0.000858818346171
Gc9_1119 0 n18 ns1119 0 0.000590108482685
Gc9_1120 0 n18 ns1120 0 0.000357340113153
Gc9_1121 0 n18 ns1121 0 0.00017424550798
Gc9_1122 0 n18 ns1122 0 0.000437918959894
Gc9_1123 0 n18 ns1123 0 -0.000291752103474
Gc9_1124 0 n18 ns1124 0 0.00107802456107
Gc9_1125 0 n18 ns1125 0 0.0018544177833
Gc9_1126 0 n18 ns1126 0 -0.00391134551225
Gc9_1127 0 n18 ns1127 0 0.00141802796359
Gc9_1128 0 n18 ns1128 0 -0.00404906712137
Gc9_1129 0 n18 ns1129 0 -0.00177172895714
Gc9_1130 0 n18 ns1130 0 -0.000114899155116
Gc9_1131 0 n18 ns1131 0 0.000458636043991
Gc9_1132 0 n18 ns1132 0 -0.00108056130933
Gc9_1133 0 n18 ns1133 0 0.00104878963447
Gc9_1134 0 n18 ns1134 0 -0.00199671581786
Gc9_1135 0 n18 ns1135 0 0.000934382900773
Gc9_1136 0 n18 ns1136 0 -0.00178116770259
Gc9_1137 0 n18 ns1137 0 -0.000977748986853
Gc9_1138 0 n18 ns1138 0 -3.59567644151e-05
Gc9_1139 0 n18 ns1139 0 0.000151001630998
Gc9_1140 0 n18 ns1140 0 -2.98443818078e-05
Gc9_1141 0 n18 ns1141 0 -0.00096935169567
Gc9_1142 0 n18 ns1142 0 0.000214299218361
Gc9_1143 0 n18 ns1143 0 -0.00297389288665
Gc9_1144 0 n18 ns1144 0 0.00109164302679
Gc9_1145 0 n18 ns1145 0 -0.000115959696261
Gc9_1146 0 n18 ns1146 0 0.000951231388413
Gc9_1147 0 n18 ns1147 0 0.000235869464195
Gc9_1148 0 n18 ns1148 0 -0.000401366618227
Gc9_1149 0 n18 ns1149 0 -0.000734764134814
Gc9_1150 0 n18 ns1150 0 -2.06706156122e-05
Gc9_1151 0 n18 ns1151 0 -0.000104529504615
Gc9_1152 0 n18 ns1152 0 -2.38661790988e-05
Gc9_1153 0 n18 ns1153 0 0.00104242825827
Gc9_1154 0 n18 ns1154 0 0.000354353671736
Gc9_1155 0 n18 ns1155 0 -0.000320728835074
Gc9_1156 0 n18 ns1156 0 -0.00114559881671
Gc9_1157 0 n18 ns1157 0 0.000448526402869
Gc9_1158 0 n18 ns1158 0 2.87332460712e-05
Gc9_1159 0 n18 ns1159 0 0.000283778276432
Gc9_1160 0 n18 ns1160 0 -0.000533329228914
Gc9_1161 0 n18 ns1161 0 -0.00252101157371
Gc9_1162 0 n18 ns1162 0 0.000146923879659
Gc9_1163 0 n18 ns1163 0 -0.00160261903919
Gc9_1164 0 n18 ns1164 0 0.00110189932033
Gc9_1165 0 n18 ns1165 0 -0.000771679124611
Gc9_1166 0 n18 ns1166 0 6.58393059292e-05
Gc9_1167 0 n18 ns1167 0 0.00195542214782
Gc9_1168 0 n18 ns1168 0 -0.00199354404561
Gc9_1169 0 n18 ns1169 0 0.001209720718
Gc9_1170 0 n18 ns1170 0 -0.000680817258316
Gc9_1171 0 n18 ns1171 0 0.00048940074801
Gc9_1172 0 n18 ns1172 0 4.665412844e-05
Gc9_1173 0 n18 ns1173 0 0.00271477281466
Gc9_1174 0 n18 ns1174 0 -0.00105273557234
Gc9_1175 0 n18 ns1175 0 -0.00226442059045
Gc9_1176 0 n18 ns1176 0 -1.09376981549e-05
Gc9_1177 0 n18 ns1177 0 0.000218018835723
Gc9_1178 0 n18 ns1178 0 -7.04332629229e-05
Gc9_1179 0 n18 ns1179 0 0.0024411345872
Gc9_1180 0 n18 ns1180 0 -0.00366290096724
Gc9_1181 0 n18 ns1181 0 0.0048101909553
Gc9_1182 0 n18 ns1182 0 -0.00873260275562
Gc9_1183 0 n18 ns1183 0 -0.00380763561089
Gc9_1184 0 n18 ns1184 0 -0.00259723049824
Gc9_1185 0 n18 ns1185 0 0.00129374045528
Gc9_1186 0 n18 ns1186 0 0.00097640730797
Gc9_1187 0 n18 ns1187 0 -0.000368550806094
Gc9_1188 0 n18 ns1188 0 -0.000866648510798
Gc9_1189 0 n18 ns1189 0 -0.000111061994795
Gc9_1190 0 n18 ns1190 0 -0.000104710189288
Gc9_1191 0 n18 ns1191 0 -0.000968855375553
Gc9_1192 0 n18 ns1192 0 5.98177671592e-05
Gc9_1193 0 n18 ns1193 0 0.00168075385596
Gc9_1194 0 n18 ns1194 0 -3.24629414084e-05
Gc9_1195 0 n18 ns1195 0 0.000574177935419
Gc9_1196 0 n18 ns1196 0 0.000821561097953
Gc9_1197 0 n18 ns1197 0 0.000430739839062
Gc9_1198 0 n18 ns1198 0 0.0011731018628
Gc9_1199 0 n18 ns1199 0 0.000954386679587
Gc9_1200 0 n18 ns1200 0 -0.00413595229229
Gc9_1201 0 n18 ns1201 0 -0.000462541202507
Gc9_1202 0 n18 ns1202 0 -0.00484071133687
Gc9_1203 0 n18 ns1203 0 0.000331578277808
Gc9_1204 0 n18 ns1204 0 -0.00428864515544
Gc9_1205 0 n18 ns1205 0 0.00671820971283
Gc9_1206 0 n18 ns1206 0 0.00738952626274
Gc9_1207 0 n18 ns1207 0 0.00089209306941
Gc9_1208 0 n18 ns1208 0 -0.000279065352788
Gc9_1209 0 n18 ns1209 0 -0.00547798486662
Gc9_1210 0 n18 ns1210 0 -0.00358152297735
Gc9_1211 0 n18 ns1211 0 0.00104995479341
Gc9_1212 0 n18 ns1212 0 0.00889943300782
Gc9_1213 0 n18 ns1213 0 -0.00349950965914
Gc9_1214 0 n18 ns1214 0 7.35745079825e-06
Gc9_1215 0 n18 ns1215 0 0.000474271444508
Gc9_1216 0 n18 ns1216 0 -0.000314587237879
Gd9_1 0 n18 ni1 0 -0.000329954129577
Gd9_2 0 n18 ni2 0 -0.000110991032171
Gd9_3 0 n18 ni3 0 -4.20587763399e-05
Gd9_4 0 n18 ni4 0 -0.000450578489223
Gd9_5 0 n18 ni5 0 0.000185509129375
Gd9_6 0 n18 ni6 0 -4.63734151961e-05
Gd9_7 0 n18 ni7 0 -0.000258780575124
Gd9_8 0 n18 ni8 0 -0.00232128625232
Gd9_9 0 n18 ni9 0 -0.00264233945176
Gd9_10 0 n18 ni10 0 -7.6129801414e-05
Gd9_11 0 n18 ni11 0 -0.000395357816304
Gd9_12 0 n18 ni12 0 0.000243899761587
Gd9_13 0 n18 ni13 0 1.80629494547e-05
Gd9_14 0 n18 ni14 0 0.000112417177943
Gd9_15 0 n18 ni15 0 -0.00163078358763
Gd9_16 0 n18 ni16 0 -0.00292891917575
Gd9_17 0 n18 ni17 0 0.000582430089958
Gd9_18 0 n18 ni18 0 0.000205167601032
Gd9_19 0 n18 ni19 0 -0.000443720728977
Gd9_20 0 n18 ni20 0 0.00138121032681
Gd9_21 0 n18 ni21 0 8.44032702999e-05
Gd9_22 0 n18 ni22 0 3.44750767975e-05
Gd9_23 0 n18 ni23 0 0.000498068557351
Gd9_24 0 n18 ni24 0 0.000105205625222
Gd9_25 0 n18 ni25 0 0.000749992412317
Gd9_26 0 n18 ni26 0 -0.00043991133207
Gd9_27 0 n18 ni27 0 0.00101283560352
Gd9_28 0 n18 ni28 0 0.000538823683828
Gd9_29 0 n18 ni29 0 -0.00034285746636
Gd9_30 0 n18 ni30 0 0.000281204753647
Gd9_31 0 n18 ni31 0 0.000688621873472
Gd9_32 0 n18 ni32 0 -0.00359116907361
Gc10_1 0 n20 ns1 0 0.000739158716487
Gc10_2 0 n20 ns2 0 -0.00251819446566
Gc10_3 0 n20 ns3 0 0.00115754679303
Gc10_4 0 n20 ns4 0 -0.00181502150817
Gc10_5 0 n20 ns5 0 -0.00107593165858
Gc10_6 0 n20 ns6 0 -0.00020870979044
Gc10_7 0 n20 ns7 0 0.000343483283934
Gc10_8 0 n20 ns8 0 -0.000316861636858
Gc10_9 0 n20 ns9 0 0.000355496106432
Gc10_10 0 n20 ns10 0 0.000670979049539
Gc10_11 0 n20 ns11 0 0.000114174969954
Gc10_12 0 n20 ns12 0 9.43075187813e-05
Gc10_13 0 n20 ns13 0 -0.000111185463976
Gc10_14 0 n20 ns14 0 0.000383772692901
Gc10_15 0 n20 ns15 0 0.000673383840105
Gc10_16 0 n20 ns16 0 -0.00158876417896
Gc10_17 0 n20 ns17 0 0.000641965574232
Gc10_18 0 n20 ns18 0 -3.8613724272e-05
Gc10_19 0 n20 ns19 0 0.000651854850625
Gc10_20 0 n20 ns20 0 -0.000591772969501
Gc10_21 0 n20 ns21 0 0.00153141439229
Gc10_22 0 n20 ns22 0 0.00267152895928
Gc10_23 0 n20 ns23 0 0.000647851827563
Gc10_24 0 n20 ns24 0 0.00181646046445
Gc10_25 0 n20 ns25 0 -0.000142931081916
Gc10_26 0 n20 ns26 0 0.00221984319325
Gc10_27 0 n20 ns27 0 0.00502618973812
Gc10_28 0 n20 ns28 0 -0.000423061556364
Gc10_29 0 n20 ns29 0 0.00116474674816
Gc10_30 0 n20 ns30 0 -0.000449206294893
Gc10_31 0 n20 ns31 0 -0.00164609621853
Gc10_32 0 n20 ns32 0 -0.000120404695713
Gc10_33 0 n20 ns33 0 -0.00372765414405
Gc10_34 0 n20 ns34 0 -0.00106767035144
Gc10_35 0 n20 ns35 0 0.00295501792037
Gc10_36 0 n20 ns36 0 2.6072201055e-05
Gc10_37 0 n20 ns37 0 -0.000178170494791
Gc10_38 0 n20 ns38 0 3.55321550008e-05
Gc10_39 0 n20 ns39 0 0.00138043506423
Gc10_40 0 n20 ns40 0 -0.00457258972213
Gc10_41 0 n20 ns41 0 0.00159545873045
Gc10_42 0 n20 ns42 0 -0.00358036764397
Gc10_43 0 n20 ns43 0 -0.00135429019224
Gc10_44 0 n20 ns44 0 -0.00073643993781
Gc10_45 0 n20 ns45 0 0.000578962842616
Gc10_46 0 n20 ns46 0 -2.67496643033e-05
Gc10_47 0 n20 ns47 0 0.000376539696425
Gc10_48 0 n20 ns48 0 0.000603240336194
Gc10_49 0 n20 ns49 0 0.000148540412551
Gc10_50 0 n20 ns50 0 0.000115575260163
Gc10_51 0 n20 ns51 0 -0.000237236919829
Gc10_52 0 n20 ns52 0 0.000422215223086
Gc10_53 0 n20 ns53 0 0.000118795128122
Gc10_54 0 n20 ns54 0 -0.00126188876612
Gc10_55 0 n20 ns55 0 0.000467991203433
Gc10_56 0 n20 ns56 0 -5.86801126837e-06
Gc10_57 0 n20 ns57 0 0.000247243960251
Gc10_58 0 n20 ns58 0 -0.000843540736003
Gc10_59 0 n20 ns59 0 0.00158095508328
Gc10_60 0 n20 ns60 0 0.00164070364891
Gc10_61 0 n20 ns61 0 0.00257041009555
Gc10_62 0 n20 ns62 0 0.00322769985761
Gc10_63 0 n20 ns63 0 0.00125896118871
Gc10_64 0 n20 ns64 0 0.0035075373398
Gc10_65 0 n20 ns65 0 0.00343242372138
Gc10_66 0 n20 ns66 0 0.000715014965516
Gc10_67 0 n20 ns67 0 0.00128793387625
Gc10_68 0 n20 ns68 0 -0.000543398114523
Gc10_69 0 n20 ns69 0 -0.0034722181211
Gc10_70 0 n20 ns70 0 -0.000127755547115
Gc10_71 0 n20 ns71 0 -0.00058295230348
Gc10_72 0 n20 ns72 0 -0.00230507547533
Gc10_73 0 n20 ns73 0 0.00384634555387
Gc10_74 0 n20 ns74 0 9.46793060995e-06
Gc10_75 0 n20 ns75 0 -0.000158856281498
Gc10_76 0 n20 ns76 0 4.75640352307e-05
Gc10_77 0 n20 ns77 0 0.00101857471779
Gc10_78 0 n20 ns78 0 -0.00417064586365
Gc10_79 0 n20 ns79 0 -0.000450601153026
Gc10_80 0 n20 ns80 0 -0.00198287495233
Gc10_81 0 n20 ns81 0 -0.000982384724625
Gc10_82 0 n20 ns82 0 -0.000226853105994
Gc10_83 0 n20 ns83 0 0.000628779993795
Gc10_84 0 n20 ns84 0 -1.76215041164e-05
Gc10_85 0 n20 ns85 0 0.000271642525285
Gc10_86 0 n20 ns86 0 5.94069639034e-05
Gc10_87 0 n20 ns87 0 0.00024104339454
Gc10_88 0 n20 ns88 0 0.000120225410394
Gc10_89 0 n20 ns89 0 -0.000536511856483
Gc10_90 0 n20 ns90 0 -0.000135044418851
Gc10_91 0 n20 ns91 0 -0.000609932400056
Gc10_92 0 n20 ns92 0 0.000553805506261
Gc10_93 0 n20 ns93 0 0.000332055960717
Gc10_94 0 n20 ns94 0 0.000318182708398
Gc10_95 0 n20 ns95 0 -0.000505571006398
Gc10_96 0 n20 ns96 0 -0.000634154702674
Gc10_97 0 n20 ns97 0 -0.000470809700679
Gc10_98 0 n20 ns98 0 -0.000794050744229
Gc10_99 0 n20 ns99 0 0.00311150793559
Gc10_100 0 n20 ns100 0 0.00520471319886
Gc10_101 0 n20 ns101 0 0.00181245545889
Gc10_102 0 n20 ns102 0 0.00537506074348
Gc10_103 0 n20 ns103 0 -0.000229227163799
Gc10_104 0 n20 ns104 0 0.00450554528845
Gc10_105 0 n20 ns105 0 0.00116554411279
Gc10_106 0 n20 ns106 0 -0.000843870849461
Gc10_107 0 n20 ns107 0 -0.00520255237023
Gc10_108 0 n20 ns108 0 -0.00148637502482
Gc10_109 0 n20 ns109 0 0.0035390201031
Gc10_110 0 n20 ns110 0 -0.00466151262517
Gc10_111 0 n20 ns111 0 0.00467939923322
Gc10_112 0 n20 ns112 0 -1.86083544318e-05
Gc10_113 0 n20 ns113 0 -6.60298583606e-05
Gc10_114 0 n20 ns114 0 -1.85228937547e-05
Gc10_115 0 n20 ns115 0 0.000387322020182
Gc10_116 0 n20 ns116 0 -0.00231280698376
Gc10_117 0 n20 ns117 0 0.000562280226986
Gc10_118 0 n20 ns118 0 -0.00215317944973
Gc10_119 0 n20 ns119 0 -0.000759136083286
Gc10_120 0 n20 ns120 0 -0.000213825588291
Gc10_121 0 n20 ns121 0 0.000154045100374
Gc10_122 0 n20 ns122 0 -0.000245320777188
Gc10_123 0 n20 ns123 0 -1.28527109852e-05
Gc10_124 0 n20 ns124 0 -0.000210645664058
Gc10_125 0 n20 ns125 0 0.00022816844748
Gc10_126 0 n20 ns126 0 7.0816802098e-05
Gc10_127 0 n20 ns127 0 0.000269260673585
Gc10_128 0 n20 ns128 0 0.000867728401698
Gc10_129 0 n20 ns129 0 0.000359773456979
Gc10_130 0 n20 ns130 0 -7.73889793319e-05
Gc10_131 0 n20 ns131 0 0.00102970590279
Gc10_132 0 n20 ns132 0 -4.27924697852e-05
Gc10_133 0 n20 ns133 0 0.000609308041083
Gc10_134 0 n20 ns134 0 -0.000182824860713
Gc10_135 0 n20 ns135 0 0.000892379125485
Gc10_136 0 n20 ns136 0 0.000842692698195
Gc10_137 0 n20 ns137 0 5.92414222817e-05
Gc10_138 0 n20 ns138 0 0.00451506662921
Gc10_139 0 n20 ns139 0 -4.87191617235e-05
Gc10_140 0 n20 ns140 0 0.00476286260807
Gc10_141 0 n20 ns141 0 0.00083654625527
Gc10_142 0 n20 ns142 0 -0.00212025987853
Gc10_143 0 n20 ns143 0 0.00100892518121
Gc10_144 0 n20 ns144 0 -0.000949082732106
Gc10_145 0 n20 ns145 0 0.000268503615652
Gc10_146 0 n20 ns146 0 -0.000271188396742
Gc10_147 0 n20 ns147 0 -0.00304201469353
Gc10_148 0 n20 ns148 0 0.00282365833185
Gc10_149 0 n20 ns149 0 0.00272431414082
Gc10_150 0 n20 ns150 0 -3.37699239931e-06
Gc10_151 0 n20 ns151 0 -0.000128177143003
Gc10_152 0 n20 ns152 0 3.64030060383e-06
Gc10_153 0 n20 ns153 0 -1.75599039573e-05
Gc10_154 0 n20 ns154 0 -0.000245031383303
Gc10_155 0 n20 ns155 0 0.000105582770832
Gc10_156 0 n20 ns156 0 0.000415080204071
Gc10_157 0 n20 ns157 0 0.000196188021597
Gc10_158 0 n20 ns158 0 0.000321949349466
Gc10_159 0 n20 ns159 0 -0.000189608258719
Gc10_160 0 n20 ns160 0 -4.16669920448e-05
Gc10_161 0 n20 ns161 0 -8.28031245802e-05
Gc10_162 0 n20 ns162 0 -0.000334486068838
Gc10_163 0 n20 ns163 0 0.000165510022413
Gc10_164 0 n20 ns164 0 -7.0689513787e-05
Gc10_165 0 n20 ns165 0 8.47428660813e-05
Gc10_166 0 n20 ns166 0 -0.00021147920701
Gc10_167 0 n20 ns167 0 -0.000299509207535
Gc10_168 0 n20 ns168 0 0.00029993933606
Gc10_169 0 n20 ns169 0 0.000408378101915
Gc10_170 0 n20 ns170 0 -0.000483997202131
Gc10_171 0 n20 ns171 0 -7.43797020167e-05
Gc10_172 0 n20 ns172 0 -0.000692757856848
Gc10_173 0 n20 ns173 0 0.00029834062409
Gc10_174 0 n20 ns174 0 -0.000830052320181
Gc10_175 0 n20 ns175 0 0.00179635396533
Gc10_176 0 n20 ns176 0 0.0038558756725
Gc10_177 0 n20 ns177 0 0.00182831221779
Gc10_178 0 n20 ns178 0 0.00390762066931
Gc10_179 0 n20 ns179 0 -0.00200222640734
Gc10_180 0 n20 ns180 0 -0.000726473598828
Gc10_181 0 n20 ns181 0 0.000256952763971
Gc10_182 0 n20 ns182 0 -0.00100760597103
Gc10_183 0 n20 ns183 0 0.000437374108427
Gc10_184 0 n20 ns184 0 -0.00107483364044
Gc10_185 0 n20 ns185 0 -0.000921402904961
Gc10_186 0 n20 ns186 0 0.00215389385317
Gc10_187 0 n20 ns187 0 0.0010976009618
Gc10_188 0 n20 ns188 0 2.73487094228e-05
Gc10_189 0 n20 ns189 0 -0.000238513800725
Gc10_190 0 n20 ns190 0 8.75078212826e-05
Gc10_191 0 n20 ns191 0 -7.54364433259e-05
Gc10_192 0 n20 ns192 0 -2.14689354006e-05
Gc10_193 0 n20 ns193 0 5.77833705626e-06
Gc10_194 0 n20 ns194 0 0.00053573158586
Gc10_195 0 n20 ns195 0 2.71860139949e-05
Gc10_196 0 n20 ns196 0 -2.98319879524e-06
Gc10_197 0 n20 ns197 0 6.97590460382e-05
Gc10_198 0 n20 ns198 0 -4.86222109342e-05
Gc10_199 0 n20 ns199 0 -0.000256304562267
Gc10_200 0 n20 ns200 0 0.000103345952731
Gc10_201 0 n20 ns201 0 8.81134574651e-05
Gc10_202 0 n20 ns202 0 -0.000153555669006
Gc10_203 0 n20 ns203 0 -0.000197098219126
Gc10_204 0 n20 ns204 0 -0.000167992508678
Gc10_205 0 n20 ns205 0 0.000553818148873
Gc10_206 0 n20 ns206 0 0.000242988427302
Gc10_207 0 n20 ns207 0 0.000231469459469
Gc10_208 0 n20 ns208 0 -0.00052510453187
Gc10_209 0 n20 ns209 0 -1.65877012643e-05
Gc10_210 0 n20 ns210 0 -0.000391065060774
Gc10_211 0 n20 ns211 0 -0.000456125891215
Gc10_212 0 n20 ns212 0 0.000223005906467
Gc10_213 0 n20 ns213 0 0.00308683066783
Gc10_214 0 n20 ns214 0 0.00327782850712
Gc10_215 0 n20 ns215 0 0.00302496495158
Gc10_216 0 n20 ns216 0 0.00293324305333
Gc10_217 0 n20 ns217 0 -0.000637185333408
Gc10_218 0 n20 ns218 0 0.000972375159369
Gc10_219 0 n20 ns219 0 -0.000232719493973
Gc10_220 0 n20 ns220 0 -0.000647969911446
Gc10_221 0 n20 ns221 0 -0.000750278846178
Gc10_222 0 n20 ns222 0 -0.00134459878471
Gc10_223 0 n20 ns223 0 -0.000564285304702
Gc10_224 0 n20 ns224 0 0.000432110385165
Gc10_225 0 n20 ns225 0 0.00035240920382
Gc10_226 0 n20 ns226 0 -3.72200862569e-06
Gc10_227 0 n20 ns227 0 -5.24614527534e-05
Gc10_228 0 n20 ns228 0 -1.93674162615e-05
Gc10_229 0 n20 ns229 0 2.39534900608e-05
Gc10_230 0 n20 ns230 0 0.000340604035676
Gc10_231 0 n20 ns231 0 0.000157458366989
Gc10_232 0 n20 ns232 0 0.000531030192417
Gc10_233 0 n20 ns233 0 -4.67120191868e-05
Gc10_234 0 n20 ns234 0 3.84208012887e-05
Gc10_235 0 n20 ns235 0 -2.95811616212e-05
Gc10_236 0 n20 ns236 0 -2.09393434867e-05
Gc10_237 0 n20 ns237 0 -3.2982907748e-05
Gc10_238 0 n20 ns238 0 0.000361516016149
Gc10_239 0 n20 ns239 0 -4.25934826415e-06
Gc10_240 0 n20 ns240 0 -0.000120721542368
Gc10_241 0 n20 ns241 0 -2.0882174394e-05
Gc10_242 0 n20 ns242 0 -0.000232368836837
Gc10_243 0 n20 ns243 0 0.000440586548723
Gc10_244 0 n20 ns244 0 -0.000605605058824
Gc10_245 0 n20 ns245 0 -7.94589711624e-05
Gc10_246 0 n20 ns246 0 -0.000571474254256
Gc10_247 0 n20 ns247 0 -1.4278082563e-05
Gc10_248 0 n20 ns248 0 -0.000540672234432
Gc10_249 0 n20 ns249 0 0.000245208402204
Gc10_250 0 n20 ns250 0 0.000685560816647
Gc10_251 0 n20 ns251 0 0.00352810040051
Gc10_252 0 n20 ns252 0 0.00100669840269
Gc10_253 0 n20 ns253 0 0.00320002747703
Gc10_254 0 n20 ns254 0 0.000749828800317
Gc10_255 0 n20 ns255 0 0.000419678614857
Gc10_256 0 n20 ns256 0 0.000931767117262
Gc10_257 0 n20 ns257 0 -0.000309903731204
Gc10_258 0 n20 ns258 0 -0.00033684396505
Gc10_259 0 n20 ns259 0 -0.00118280789773
Gc10_260 0 n20 ns260 0 -0.00090285883425
Gc10_261 0 n20 ns261 0 -0.000493724626494
Gc10_262 0 n20 ns262 0 -0.000156625278835
Gc10_263 0 n20 ns263 0 0.000108676346907
Gc10_264 0 n20 ns264 0 1.81991567968e-05
Gc10_265 0 n20 ns265 0 -2.66017886199e-05
Gc10_266 0 n20 ns266 0 -1.49622957452e-05
Gc10_267 0 n20 ns267 0 0.00034125665354
Gc10_268 0 n20 ns268 0 0.000262052116346
Gc10_269 0 n20 ns269 0 0.00128351041973
Gc10_270 0 n20 ns270 0 0.000167693193973
Gc10_271 0 n20 ns271 0 7.18086251534e-05
Gc10_272 0 n20 ns272 0 4.67056613327e-05
Gc10_273 0 n20 ns273 0 9.82456791922e-06
Gc10_274 0 n20 ns274 0 1.98072514348e-05
Gc10_275 0 n20 ns275 0 0.000301046861009
Gc10_276 0 n20 ns276 0 0.000139401931349
Gc10_277 0 n20 ns277 0 -5.21727539524e-05
Gc10_278 0 n20 ns278 0 -6.26435061838e-05
Gc10_279 0 n20 ns279 0 -0.000336874718839
Gc10_280 0 n20 ns280 0 -0.000259343211354
Gc10_281 0 n20 ns281 0 -0.000296819121359
Gc10_282 0 n20 ns282 0 -0.000613410412842
Gc10_283 0 n20 ns283 0 -0.000338098380133
Gc10_284 0 n20 ns284 0 -0.000315014631664
Gc10_285 0 n20 ns285 0 -0.000307756033195
Gc10_286 0 n20 ns286 0 -0.000475814049995
Gc10_287 0 n20 ns287 0 0.000654142404678
Gc10_288 0 n20 ns288 0 0.00024287343902
Gc10_289 0 n20 ns289 0 0.00227000414141
Gc10_290 0 n20 ns290 0 -0.000747890116356
Gc10_291 0 n20 ns291 0 0.00195449519936
Gc10_292 0 n20 ns292 0 -0.000748899277188
Gc10_293 0 n20 ns293 0 0.000589909671047
Gc10_294 0 n20 ns294 0 0.000555526175246
Gc10_295 0 n20 ns295 0 -0.000216582103725
Gc10_296 0 n20 ns296 0 -0.000159454595283
Gc10_297 0 n20 ns297 0 -0.000910431361188
Gc10_298 0 n20 ns298 0 -0.000556916926409
Gc10_299 0 n20 ns299 0 -0.000366427027073
Gc10_300 0 n20 ns300 0 -0.000510216668791
Gc10_301 0 n20 ns301 0 -3.80986418453e-05
Gc10_302 0 n20 ns302 0 2.89375361598e-05
Gc10_303 0 n20 ns303 0 -3.87084379119e-05
Gc10_304 0 n20 ns304 0 9.04675218273e-06
Gc10_305 0 n20 ns305 0 1.99661544903e-05
Gc10_306 0 n20 ns306 0 0.000102388011573
Gc10_307 0 n20 ns307 0 4.56871618249e-05
Gc10_308 0 n20 ns308 0 -0.000814220029172
Gc10_309 0 n20 ns309 0 -9.24625704745e-05
Gc10_310 0 n20 ns310 0 -8.98612884369e-05
Gc10_311 0 n20 ns311 0 8.96095828838e-05
Gc10_312 0 n20 ns312 0 2.37244844419e-05
Gc10_313 0 n20 ns313 0 8.35554285036e-05
Gc10_314 0 n20 ns314 0 -0.000127539828247
Gc10_315 0 n20 ns315 0 -4.57627607648e-05
Gc10_316 0 n20 ns316 0 3.31099643532e-05
Gc10_317 0 n20 ns317 0 -7.88532596042e-05
Gc10_318 0 n20 ns318 0 0.00018806849796
Gc10_319 0 n20 ns319 0 -0.000327031147272
Gc10_320 0 n20 ns320 0 0.000128647685896
Gc10_321 0 n20 ns321 0 -0.000244628921003
Gc10_322 0 n20 ns322 0 0.000200096079896
Gc10_323 0 n20 ns323 0 -0.000332166355761
Gc10_324 0 n20 ns324 0 0.000259694511893
Gc10_325 0 n20 ns325 0 4.46463959578e-05
Gc10_326 0 n20 ns326 0 -0.000342176038314
Gc10_327 0 n20 ns327 0 6.95061209979e-05
Gc10_328 0 n20 ns328 0 -0.00166821776724
Gc10_329 0 n20 ns329 0 5.38384631899e-05
Gc10_330 0 n20 ns330 0 -0.00144503636858
Gc10_331 0 n20 ns331 0 -0.000109333882968
Gc10_332 0 n20 ns332 0 9.73219175075e-05
Gc10_333 0 n20 ns333 0 -6.61288605194e-05
Gc10_334 0 n20 ns334 0 -4.00086669847e-05
Gc10_335 0 n20 ns335 0 -0.0001570204997
Gc10_336 0 n20 ns336 0 3.12207335335e-05
Gc10_337 0 n20 ns337 0 -6.16615413023e-05
Gc10_338 0 n20 ns338 0 0.000364522768149
Gc10_339 0 n20 ns339 0 0.000132972382295
Gc10_340 0 n20 ns340 0 -6.34827659991e-07
Gc10_341 0 n20 ns341 0 4.45385653508e-05
Gc10_342 0 n20 ns342 0 -4.29802255112e-05
Gc10_343 0 n20 ns343 0 0.000550329633646
Gc10_344 0 n20 ns344 0 -0.00224872636093
Gc10_345 0 n20 ns345 0 -0.001144855541
Gc10_346 0 n20 ns346 0 0.000252515195129
Gc10_347 0 n20 ns347 0 -0.000556804967199
Gc10_348 0 n20 ns348 0 0.000266409926616
Gc10_349 0 n20 ns349 0 0.000362791569056
Gc10_350 0 n20 ns350 0 -0.000162304386472
Gc10_351 0 n20 ns351 0 0.000439934607075
Gc10_352 0 n20 ns352 0 0.000203492457917
Gc10_353 0 n20 ns353 0 0.000222662356236
Gc10_354 0 n20 ns354 0 0.000119868015209
Gc10_355 0 n20 ns355 0 -0.000725241823601
Gc10_356 0 n20 ns356 0 -0.000518402514015
Gc10_357 0 n20 ns357 0 -0.000568073256358
Gc10_358 0 n20 ns358 0 0.000263214359407
Gc10_359 0 n20 ns359 0 0.00020468702107
Gc10_360 0 n20 ns360 0 0.00033952622784
Gc10_361 0 n20 ns361 0 -0.000595506837986
Gc10_362 0 n20 ns362 0 -0.000739511401157
Gc10_363 0 n20 ns363 0 -0.000448503864223
Gc10_364 0 n20 ns364 0 -0.000467332752817
Gc10_365 0 n20 ns365 0 0.00360012816988
Gc10_366 0 n20 ns366 0 0.00375378795851
Gc10_367 0 n20 ns367 0 0.00210707101892
Gc10_368 0 n20 ns368 0 0.00414995530815
Gc10_369 0 n20 ns369 0 0.000641788763325
Gc10_370 0 n20 ns370 0 0.00448681324917
Gc10_371 0 n20 ns371 0 0.00124799818322
Gc10_372 0 n20 ns372 0 -0.000689162791921
Gc10_373 0 n20 ns373 0 -0.00512620351353
Gc10_374 0 n20 ns374 0 -0.000966253808642
Gc10_375 0 n20 ns375 0 0.00285911915994
Gc10_376 0 n20 ns376 0 -0.00400822295494
Gc10_377 0 n20 ns377 0 0.00488105135822
Gc10_378 0 n20 ns378 0 -3.2969292061e-05
Gc10_379 0 n20 ns379 0 -2.95632199905e-05
Gc10_380 0 n20 ns380 0 -2.74392003333e-05
Gc10_381 0 n20 ns381 0 0.000353913500265
Gc10_382 0 n20 ns382 0 -0.00259445631812
Gc10_383 0 n20 ns383 0 0.000287645370237
Gc10_384 0 n20 ns384 0 -0.0014755886619
Gc10_385 0 n20 ns385 0 -0.000860467450755
Gc10_386 0 n20 ns386 0 4.81344137579e-05
Gc10_387 0 n20 ns387 0 0.000395285938203
Gc10_388 0 n20 ns388 0 -0.000401867750552
Gc10_389 0 n20 ns389 0 0.000139305746714
Gc10_390 0 n20 ns390 0 -2.16727715207e-05
Gc10_391 0 n20 ns391 0 0.000265587110242
Gc10_392 0 n20 ns392 0 8.14442017097e-05
Gc10_393 0 n20 ns393 0 -0.000278554881187
Gc10_394 0 n20 ns394 0 0.000482022836899
Gc10_395 0 n20 ns395 0 0.000578503115062
Gc10_396 0 n20 ns396 0 4.07638830739e-05
Gc10_397 0 n20 ns397 0 0.0010884500017
Gc10_398 0 n20 ns398 0 0.00015903887886
Gc10_399 0 n20 ns399 0 0.000546027507825
Gc10_400 0 n20 ns400 0 -0.000169937925599
Gc10_401 0 n20 ns401 0 0.000194382935296
Gc10_402 0 n20 ns402 0 0.0015492151022
Gc10_403 0 n20 ns403 0 -8.89718968683e-05
Gc10_404 0 n20 ns404 0 0.00473409651174
Gc10_405 0 n20 ns405 0 -0.000360443136669
Gc10_406 0 n20 ns406 0 0.00503939240663
Gc10_407 0 n20 ns407 0 0.00271870331061
Gc10_408 0 n20 ns408 0 9.16074135928e-05
Gc10_409 0 n20 ns409 0 0.00111454090996
Gc10_410 0 n20 ns410 0 -0.000981631221903
Gc10_411 0 n20 ns411 0 -0.000979464769618
Gc10_412 0 n20 ns412 0 -0.00115494185966
Gc10_413 0 n20 ns413 0 -0.00364332007356
Gc10_414 0 n20 ns414 0 0.000148199921374
Gc10_415 0 n20 ns415 0 0.00316254245147
Gc10_416 0 n20 ns416 0 1.84522333056e-05
Gc10_417 0 n20 ns417 0 -0.000155628033127
Gc10_418 0 n20 ns418 0 1.67757503581e-05
Gc10_419 0 n20 ns419 0 0.000259579963507
Gc10_420 0 n20 ns420 0 -0.00100703626338
Gc10_421 0 n20 ns421 0 0.000677548209622
Gc10_422 0 n20 ns422 0 -0.000460030473501
Gc10_423 0 n20 ns423 0 -0.000101430326173
Gc10_424 0 n20 ns424 0 0.000269960091149
Gc10_425 0 n20 ns425 0 -0.000181769768469
Gc10_426 0 n20 ns426 0 -0.000124122065701
Gc10_427 0 n20 ns427 0 4.04982419749e-05
Gc10_428 0 n20 ns428 0 -0.000341087976974
Gc10_429 0 n20 ns429 0 0.000209071128768
Gc10_430 0 n20 ns430 0 -3.00063621958e-05
Gc10_431 0 n20 ns431 0 0.000222892523191
Gc10_432 0 n20 ns432 0 -4.89549037571e-06
Gc10_433 0 n20 ns433 0 -0.000390359925112
Gc10_434 0 n20 ns434 0 -4.33749990011e-05
Gc10_435 0 n20 ns435 0 0.000593499523298
Gc10_436 0 n20 ns436 0 -0.000518505759046
Gc10_437 0 n20 ns437 0 0.000116527582107
Gc10_438 0 n20 ns438 0 -0.00086889515431
Gc10_439 0 n20 ns439 0 0.000933307536202
Gc10_440 0 n20 ns440 0 -0.000558039593418
Gc10_441 0 n20 ns441 0 0.00161770084222
Gc10_442 0 n20 ns442 0 0.00437531857999
Gc10_443 0 n20 ns443 0 0.00155450467799
Gc10_444 0 n20 ns444 0 0.00450733457321
Gc10_445 0 n20 ns445 0 -0.00145565709059
Gc10_446 0 n20 ns446 0 -0.00154639753071
Gc10_447 0 n20 ns447 0 0.000486538114265
Gc10_448 0 n20 ns448 0 -0.0010677103662
Gc10_449 0 n20 ns449 0 0.000465943282445
Gc10_450 0 n20 ns450 0 -0.000793755046225
Gc10_451 0 n20 ns451 0 -0.00142111611524
Gc10_452 0 n20 ns452 0 0.00254421175714
Gc10_453 0 n20 ns453 0 0.00150827053297
Gc10_454 0 n20 ns454 0 2.0089593543e-05
Gc10_455 0 n20 ns455 0 -0.00022986416094
Gc10_456 0 n20 ns456 0 7.61244682023e-05
Gc10_457 0 n20 ns457 0 9.35806099671e-05
Gc10_458 0 n20 ns458 0 -0.000223330561665
Gc10_459 0 n20 ns459 0 0.000515290650659
Gc10_460 0 n20 ns460 0 0.000469838428344
Gc10_461 0 n20 ns461 0 0.000193722455353
Gc10_462 0 n20 ns462 0 -2.42500227556e-05
Gc10_463 0 n20 ns463 0 1.16108662243e-05
Gc10_464 0 n20 ns464 0 4.02368650507e-05
Gc10_465 0 n20 ns465 0 -0.000237352934052
Gc10_466 0 n20 ns466 0 -0.000107187284988
Gc10_467 0 n20 ns467 0 0.000131418958206
Gc10_468 0 n20 ns468 0 -0.000142435663146
Gc10_469 0 n20 ns469 0 -0.000259786807506
Gc10_470 0 n20 ns470 0 -0.000220320922426
Gc10_471 0 n20 ns471 0 0.000243309974791
Gc10_472 0 n20 ns472 0 0.000453810930765
Gc10_473 0 n20 ns473 0 0.00029805836147
Gc10_474 0 n20 ns474 0 -0.00052973860113
Gc10_475 0 n20 ns475 0 -0.000114556116751
Gc10_476 0 n20 ns476 0 -0.000502702383405
Gc10_477 0 n20 ns477 0 -0.000375900119546
Gc10_478 0 n20 ns478 0 -0.000195704979639
Gc10_479 0 n20 ns479 0 0.00280440747585
Gc10_480 0 n20 ns480 0 0.00386117896752
Gc10_481 0 n20 ns481 0 0.00281180351987
Gc10_482 0 n20 ns482 0 0.00359834647854
Gc10_483 0 n20 ns483 0 -0.00113811915313
Gc10_484 0 n20 ns484 0 0.000666996781991
Gc10_485 0 n20 ns485 0 -0.000127834205527
Gc10_486 0 n20 ns486 0 -0.000804511570087
Gc10_487 0 n20 ns487 0 -0.000458527668877
Gc10_488 0 n20 ns488 0 -0.00144586591503
Gc10_489 0 n20 ns489 0 -0.00066174570093
Gc10_490 0 n20 ns490 0 0.000810780630058
Gc10_491 0 n20 ns491 0 0.00053135019971
Gc10_492 0 n20 ns492 0 2.07177122406e-05
Gc10_493 0 n20 ns493 0 -0.000140486831832
Gc10_494 0 n20 ns494 0 2.44385729437e-05
Gc10_495 0 n20 ns495 0 -0.000455195229919
Gc10_496 0 n20 ns496 0 0.000574067629029
Gc10_497 0 n20 ns497 0 -0.0011190576664
Gc10_498 0 n20 ns498 0 0.00120038861698
Gc10_499 0 n20 ns499 0 -0.000304914984644
Gc10_500 0 n20 ns500 0 0.000262046419748
Gc10_501 0 n20 ns501 0 0.000130525483824
Gc10_502 0 n20 ns502 0 -0.000182556753229
Gc10_503 0 n20 ns503 0 -0.00017776097467
Gc10_504 0 n20 ns504 0 0.000479086134759
Gc10_505 0 n20 ns505 0 7.20697417193e-05
Gc10_506 0 n20 ns506 0 -0.000149981073671
Gc10_507 0 n20 ns507 0 0.000132510378274
Gc10_508 0 n20 ns508 0 -0.00042314210972
Gc10_509 0 n20 ns509 0 0.0008211847506
Gc10_510 0 n20 ns510 0 -0.000426731354243
Gc10_511 0 n20 ns511 0 0.000171160883124
Gc10_512 0 n20 ns512 0 -0.000640700340673
Gc10_513 0 n20 ns513 0 0.000239253515417
Gc10_514 0 n20 ns514 0 -0.000505976037517
Gc10_515 0 n20 ns515 0 -0.000167016513716
Gc10_516 0 n20 ns516 0 0.000831064389973
Gc10_517 0 n20 ns517 0 0.00334052177105
Gc10_518 0 n20 ns518 0 0.00229948231904
Gc10_519 0 n20 ns519 0 0.00314024255909
Gc10_520 0 n20 ns520 0 0.00189806011334
Gc10_521 0 n20 ns521 0 0.000204244960387
Gc10_522 0 n20 ns522 0 0.00114518696891
Gc10_523 0 n20 ns523 0 -0.000319285769926
Gc10_524 0 n20 ns524 0 -0.000430471897545
Gc10_525 0 n20 ns525 0 -0.00112573477654
Gc10_526 0 n20 ns526 0 -0.00112587594079
Gc10_527 0 n20 ns527 0 -0.000494085775238
Gc10_528 0 n20 ns528 0 -0.000114741386432
Gc10_529 0 n20 ns529 0 0.000136910850327
Gc10_530 0 n20 ns530 0 -1.25310768995e-05
Gc10_531 0 n20 ns531 0 2.29882949771e-05
Gc10_532 0 n20 ns532 0 -5.41579673375e-05
Gc10_533 0 n20 ns533 0 0.000203732169887
Gc10_534 0 n20 ns534 0 0.000451539414638
Gc10_535 0 n20 ns535 0 0.00093011947645
Gc10_536 0 n20 ns536 0 0.000758682654369
Gc10_537 0 n20 ns537 0 2.77476410429e-05
Gc10_538 0 n20 ns538 0 0.000193930002058
Gc10_539 0 n20 ns539 0 -1.24741140946e-05
Gc10_540 0 n20 ns540 0 -5.76503093271e-05
Gc10_541 0 n20 ns541 0 0.000260400222004
Gc10_542 0 n20 ns542 0 0.000302165838729
Gc10_543 0 n20 ns543 0 -3.13642045139e-05
Gc10_544 0 n20 ns544 0 -9.84956743883e-05
Gc10_545 0 n20 ns545 0 -0.000246722836302
Gc10_546 0 n20 ns546 0 -0.000428773557141
Gc10_547 0 n20 ns547 0 -3.83795880604e-05
Gc10_548 0 n20 ns548 0 -0.000840036223787
Gc10_549 0 n20 ns549 0 -0.000263584137722
Gc10_550 0 n20 ns550 0 -0.000524108841736
Gc10_551 0 n20 ns551 0 -0.000164108659436
Gc10_552 0 n20 ns552 0 -0.000684878416596
Gc10_553 0 n20 ns553 0 0.000669382362016
Gc10_554 0 n20 ns554 0 0.000542081455998
Gc10_555 0 n20 ns555 0 0.00296914220462
Gc10_556 0 n20 ns556 0 -4.03417016087e-05
Gc10_557 0 n20 ns557 0 0.00259717160978
Gc10_558 0 n20 ns558 0 -0.000172441907155
Gc10_559 0 n20 ns559 0 0.00074137661667
Gc10_560 0 n20 ns560 0 0.000759840464654
Gc10_561 0 n20 ns561 0 -0.000271847125113
Gc10_562 0 n20 ns562 0 -0.00021583333265
Gc10_563 0 n20 ns563 0 -0.00113893904448
Gc10_564 0 n20 ns564 0 -0.000756607607737
Gc10_565 0 n20 ns565 0 -0.000455857997462
Gc10_566 0 n20 ns566 0 -0.000639957292303
Gc10_567 0 n20 ns567 0 -4.69252021377e-05
Gc10_568 0 n20 ns568 0 3.11534012986e-05
Gc10_569 0 n20 ns569 0 -5.15759360647e-05
Gc10_570 0 n20 ns570 0 7.21183672957e-06
Gc10_571 0 n20 ns571 0 9.89783903483e-05
Gc10_572 0 n20 ns572 0 0.000227842853866
Gc10_573 0 n20 ns573 0 0.000473006945265
Gc10_574 0 n20 ns574 0 -0.000453104650141
Gc10_575 0 n20 ns575 0 -5.85249038389e-05
Gc10_576 0 n20 ns576 0 -3.16638510779e-07
Gc10_577 0 n20 ns577 0 8.7663282067e-05
Gc10_578 0 n20 ns578 0 -3.61052513929e-06
Gc10_579 0 n20 ns579 0 0.000204125598701
Gc10_580 0 n20 ns580 0 -4.20750828352e-05
Gc10_581 0 n20 ns581 0 -5.12246674092e-05
Gc10_582 0 n20 ns582 0 -8.76322510912e-07
Gc10_583 0 n20 ns583 0 -0.000214246024371
Gc10_584 0 n20 ns584 0 1.17314796765e-05
Gc10_585 0 n20 ns585 0 -0.000385009708478
Gc10_586 0 n20 ns586 0 -0.000120892474449
Gc10_587 0 n20 ns587 0 -0.000307677760452
Gc10_588 0 n20 ns588 0 4.99095752601e-05
Gc10_589 0 n20 ns589 0 -0.000361022321338
Gc10_590 0 n20 ns590 0 2.75338626918e-05
Gc10_591 0 n20 ns591 0 0.000262074429721
Gc10_592 0 n20 ns592 0 -0.000174060227653
Gc10_593 0 n20 ns593 0 0.000692003039267
Gc10_594 0 n20 ns594 0 -0.00147895404262
Gc10_595 0 n20 ns595 0 0.000585095795505
Gc10_596 0 n20 ns596 0 -0.00131567697467
Gc10_597 0 n20 ns597 0 0.000170285617413
Gc10_598 0 n20 ns598 0 0.000272165009182
Gc10_599 0 n20 ns599 0 -0.000124998509263
Gc10_600 0 n20 ns600 0 -7.7855608063e-05
Gc10_601 0 n20 ns601 0 -0.000447067571474
Gc10_602 0 n20 ns602 0 -0.000173929968183
Gc10_603 0 n20 ns603 0 -0.000178843003076
Gc10_604 0 n20 ns604 0 4.59815951135e-05
Gc10_605 0 n20 ns605 0 7.16067484978e-05
Gc10_606 0 n20 ns606 0 1.02512297832e-05
Gc10_607 0 n20 ns607 0 1.89842664731e-05
Gc10_608 0 n20 ns608 0 -3.36860834864e-05
Gc10_609 0 n20 ns609 0 -0.00105366522295
Gc10_610 0 n20 ns610 0 -0.000298833747251
Gc10_611 0 n20 ns611 0 -0.00425068719115
Gc10_612 0 n20 ns612 0 -0.00172289702857
Gc10_613 0 n20 ns613 0 -0.00182519164339
Gc10_614 0 n20 ns614 0 0.00121090062306
Gc10_615 0 n20 ns615 0 0.000904638882667
Gc10_616 0 n20 ns616 0 -0.000418463064183
Gc10_617 0 n20 ns617 0 -0.000666117446208
Gc10_618 0 n20 ns618 0 -0.000241045879814
Gc10_619 0 n20 ns619 0 -8.56109203559e-05
Gc10_620 0 n20 ns620 0 -5.44248951589e-05
Gc10_621 0 n20 ns621 0 0.000746115735809
Gc10_622 0 n20 ns622 0 0.000518664016618
Gc10_623 0 n20 ns623 0 0.000665953898006
Gc10_624 0 n20 ns624 0 -0.00146083958215
Gc10_625 0 n20 ns625 0 0.000697354852206
Gc10_626 0 n20 ns626 0 9.24982167537e-05
Gc10_627 0 n20 ns627 0 0.000805957531597
Gc10_628 0 n20 ns628 0 -0.00033646739391
Gc10_629 0 n20 ns629 0 -0.00250268658425
Gc10_630 0 n20 ns630 0 -0.00105989754475
Gc10_631 0 n20 ns631 0 -0.00287593766555
Gc10_632 0 n20 ns632 0 0.000773351983448
Gc10_633 0 n20 ns633 0 -0.00164275276657
Gc10_634 0 n20 ns634 0 -5.48012305459e-05
Gc10_635 0 n20 ns635 0 0.00415177311108
Gc10_636 0 n20 ns636 0 0.000145223462702
Gc10_637 0 n20 ns637 0 0.00122900059889
Gc10_638 0 n20 ns638 0 -0.000541604963113
Gc10_639 0 n20 ns639 0 -0.00135354722075
Gc10_640 0 n20 ns640 0 -0.000723115060325
Gc10_641 0 n20 ns641 0 0.00270387354768
Gc10_642 0 n20 ns642 0 0.00136876687013
Gc10_643 0 n20 ns643 0 -0.00285455833541
Gc10_644 0 n20 ns644 0 -3.82365505822e-05
Gc10_645 0 n20 ns645 0 0.00037198518823
Gc10_646 0 n20 ns646 0 -0.000193731447985
Gc10_647 0 n20 ns647 0 0.000945487362114
Gc10_648 0 n20 ns648 0 -0.00216341843129
Gc10_649 0 n20 ns649 0 0.00137879805802
Gc10_650 0 n20 ns650 0 -0.00440445241574
Gc10_651 0 n20 ns651 0 -0.00242289416591
Gc10_652 0 n20 ns652 0 -0.00130499646149
Gc10_653 0 n20 ns653 0 0.00100972774417
Gc10_654 0 n20 ns654 0 0.000438341954969
Gc10_655 0 n20 ns655 0 -0.000784680679149
Gc10_656 0 n20 ns656 0 -0.000483207073301
Gc10_657 0 n20 ns657 0 -0.000135388358978
Gc10_658 0 n20 ns658 0 -8.67628603867e-05
Gc10_659 0 n20 ns659 0 0.000344421460296
Gc10_660 0 n20 ns660 0 0.000128019426546
Gc10_661 0 n20 ns661 0 0.000723214986394
Gc10_662 0 n20 ns662 0 -0.000846667052952
Gc10_663 0 n20 ns663 0 0.000653558447365
Gc10_664 0 n20 ns664 0 0.000480704014173
Gc10_665 0 n20 ns665 0 0.000351450372473
Gc10_666 0 n20 ns666 0 0.000202204251254
Gc10_667 0 n20 ns667 0 -0.0011893209294
Gc10_668 0 n20 ns668 0 -0.00191112548754
Gc10_669 0 n20 ns669 0 -0.00144054923023
Gc10_670 0 n20 ns670 0 -0.000889562238589
Gc10_671 0 n20 ns671 0 -0.000404103201639
Gc10_672 0 n20 ns672 0 -0.00156992551511
Gc10_673 0 n20 ns673 0 0.00461293769977
Gc10_674 0 n20 ns674 0 0.00201239571275
Gc10_675 0 n20 ns675 0 0.00139176865144
Gc10_676 0 n20 ns676 0 -0.000646348490312
Gc10_677 0 n20 ns677 0 -0.00207448480598
Gc10_678 0 n20 ns678 0 -0.00147960347496
Gc10_679 0 n20 ns679 0 0.00260927270022
Gc10_680 0 n20 ns680 0 0.00294098407068
Gc10_681 0 n20 ns681 0 -0.00354481417412
Gc10_682 0 n20 ns682 0 -9.30796130524e-06
Gc10_683 0 n20 ns683 0 0.000292808657078
Gc10_684 0 n20 ns684 0 -0.000154818732666
Gc10_685 0 n20 ns685 0 0.00220558991396
Gc10_686 0 n20 ns686 0 -0.00343934847468
Gc10_687 0 n20 ns687 0 0.00454064743715
Gc10_688 0 n20 ns688 0 -0.0071134268397
Gc10_689 0 n20 ns689 0 -0.0034393845909
Gc10_690 0 n20 ns690 0 -0.00251444775983
Gc10_691 0 n20 ns691 0 0.00111245612316
Gc10_692 0 n20 ns692 0 0.000747167453742
Gc10_693 0 n20 ns693 0 -0.000671874608552
Gc10_694 0 n20 ns694 0 -0.000106899068852
Gc10_695 0 n20 ns695 0 -0.00018746433382
Gc10_696 0 n20 ns696 0 -0.00013091573288
Gc10_697 0 n20 ns697 0 -0.000471369868883
Gc10_698 0 n20 ns698 0 -0.000765159393815
Gc10_699 0 n20 ns699 0 0.000705105638095
Gc10_700 0 n20 ns700 0 0.000565530605584
Gc10_701 0 n20 ns701 0 0.000969211675333
Gc10_702 0 n20 ns702 0 0.000976837752604
Gc10_703 0 n20 ns703 0 0.000381623309151
Gc10_704 0 n20 ns704 0 0.00121757688388
Gc10_705 0 n20 ns705 0 0.000924115856417
Gc10_706 0 n20 ns706 0 -0.00258524689539
Gc10_707 0 n20 ns707 0 0.00192828314064
Gc10_708 0 n20 ns708 0 -0.00711105905241
Gc10_709 0 n20 ns709 0 0.00214479069735
Gc10_710 0 n20 ns710 0 -0.00683527654787
Gc10_711 0 n20 ns711 0 0.00475318002404
Gc10_712 0 n20 ns712 0 0.00662594364624
Gc10_713 0 n20 ns713 0 0.00113965946931
Gc10_714 0 n20 ns714 0 -0.00105012947839
Gc10_715 0 n20 ns715 0 -0.00421300114256
Gc10_716 0 n20 ns716 0 -0.00499470780932
Gc10_717 0 n20 ns717 0 0.00178036940682
Gc10_718 0 n20 ns718 0 0.00610570341879
Gc10_719 0 n20 ns719 0 -0.00416675675354
Gc10_720 0 n20 ns720 0 -1.03269075929e-05
Gc10_721 0 n20 ns721 0 0.000376696318625
Gc10_722 0 n20 ns722 0 -0.000225533909205
Gc10_723 0 n20 ns723 0 -0.000715358371751
Gc10_724 0 n20 ns724 0 -0.000520299790298
Gc10_725 0 n20 ns725 0 -0.00226711485779
Gc10_726 0 n20 ns726 0 0.00100894035001
Gc10_727 0 n20 ns727 0 -0.00022460578078
Gc10_728 0 n20 ns728 0 0.000848818183818
Gc10_729 0 n20 ns729 0 0.000163101180866
Gc10_730 0 n20 ns730 0 -0.000235777970845
Gc10_731 0 n20 ns731 0 -0.000126087089045
Gc10_732 0 n20 ns732 0 0.00034243180959
Gc10_733 0 n20 ns733 0 -0.00025039362277
Gc10_734 0 n20 ns734 0 -2.12920760274e-05
Gc10_735 0 n20 ns735 0 0.000408075317077
Gc10_736 0 n20 ns736 0 0.000290468565866
Gc10_737 0 n20 ns737 0 0.000348341118012
Gc10_738 0 n20 ns738 0 -0.00031806082759
Gc10_739 0 n20 ns739 0 0.00110028697001
Gc10_740 0 n20 ns740 0 -0.000298581515101
Gc10_741 0 n20 ns741 0 0.000846844630139
Gc10_742 0 n20 ns742 0 -0.000742062286152
Gc10_743 0 n20 ns743 0 -0.00173814021577
Gc10_744 0 n20 ns744 0 2.1376697001e-05
Gc10_745 0 n20 ns745 0 -0.00337479638379
Gc10_746 0 n20 ns746 0 -0.00367338679041
Gc10_747 0 n20 ns747 0 -0.00264746755801
Gc10_748 0 n20 ns748 0 -0.00410070722122
Gc10_749 0 n20 ns749 0 0.00119282645495
Gc10_750 0 n20 ns750 0 -0.000434195520669
Gc10_751 0 n20 ns751 0 0.000942938672242
Gc10_752 0 n20 ns752 0 -0.00115700694188
Gc10_753 0 n20 ns753 0 5.9825692793e-05
Gc10_754 0 n20 ns754 0 -0.00163420991127
Gc10_755 0 n20 ns755 0 0.00254738364482
Gc10_756 0 n20 ns756 0 -0.00232633938755
Gc10_757 0 n20 ns757 0 -0.00248459953851
Gc10_758 0 n20 ns758 0 3.42313820799e-06
Gc10_759 0 n20 ns759 0 0.000130216506809
Gc10_760 0 n20 ns760 0 -2.93420127023e-05
Gc10_761 0 n20 ns761 0 -0.000313124040736
Gc10_762 0 n20 ns762 0 -0.000111950204863
Gc10_763 0 n20 ns763 0 -0.000727634851358
Gc10_764 0 n20 ns764 0 0.00142939451511
Gc10_765 0 n20 ns765 0 -0.000347605786858
Gc10_766 0 n20 ns766 0 0.00010130336282
Gc10_767 0 n20 ns767 0 0.000216614121871
Gc10_768 0 n20 ns768 0 -0.00016492199276
Gc10_769 0 n20 ns769 0 6.12578112992e-05
Gc10_770 0 n20 ns770 0 0.000435393302543
Gc10_771 0 n20 ns771 0 -0.000131913434081
Gc10_772 0 n20 ns772 0 0.000123813032794
Gc10_773 0 n20 ns773 0 0.000589954622617
Gc10_774 0 n20 ns774 0 -0.000473516309521
Gc10_775 0 n20 ns775 0 0.000126842022156
Gc10_776 0 n20 ns776 0 0.000270781923058
Gc10_777 0 n20 ns777 0 0.000633408880091
Gc10_778 0 n20 ns778 0 -0.00041166491224
Gc10_779 0 n20 ns779 0 0.000235516726015
Gc10_780 0 n20 ns780 0 -0.0003964968946
Gc10_781 0 n20 ns781 0 -0.000334743851555
Gc10_782 0 n20 ns782 0 0.000706378550134
Gc10_783 0 n20 ns783 0 -0.0021778038245
Gc10_784 0 n20 ns784 0 -0.0044687816415
Gc10_785 0 n20 ns785 0 -0.0021627990412
Gc10_786 0 n20 ns786 0 -0.0044276163042
Gc10_787 0 n20 ns787 0 -0.00112441137365
Gc10_788 0 n20 ns788 0 0.00134241100791
Gc10_789 0 n20 ns789 0 0.000147753845345
Gc10_790 0 n20 ns790 0 -0.00127005998955
Gc10_791 0 n20 ns791 0 1.62538759445e-05
Gc10_792 0 n20 ns792 0 -0.00306323973002
Gc10_793 0 n20 ns793 0 0.000639583415135
Gc10_794 0 n20 ns794 0 -0.00283186846832
Gc10_795 0 n20 ns795 0 -0.00116635824511
Gc10_796 0 n20 ns796 0 -3.85005095748e-05
Gc10_797 0 n20 ns797 0 0.000100626082436
Gc10_798 0 n20 ns798 0 -1.00498288945e-05
Gc10_799 0 n20 ns799 0 -0.000105352121974
Gc10_800 0 n20 ns800 0 -0.000124621478799
Gc10_801 0 n20 ns801 0 -0.000258143123947
Gc10_802 0 n20 ns802 0 0.000260289478342
Gc10_803 0 n20 ns803 0 -4.63835133071e-05
Gc10_804 0 n20 ns804 0 0.000126606751832
Gc10_805 0 n20 ns805 0 -5.06460637382e-05
Gc10_806 0 n20 ns806 0 -1.10435215669e-05
Gc10_807 0 n20 ns807 0 0.000293942389861
Gc10_808 0 n20 ns808 0 -4.35597670001e-05
Gc10_809 0 n20 ns809 0 -6.64292241968e-05
Gc10_810 0 n20 ns810 0 0.000141118080226
Gc10_811 0 n20 ns811 0 -9.05180944736e-07
Gc10_812 0 n20 ns812 0 9.1423532044e-05
Gc10_813 0 n20 ns813 0 0.00063832678767
Gc10_814 0 n20 ns814 0 0.00029687245622
Gc10_815 0 n20 ns815 0 0.0002920337741
Gc10_816 0 n20 ns816 0 -0.000472021562646
Gc10_817 0 n20 ns817 0 0.000102221649766
Gc10_818 0 n20 ns818 0 -0.00028197354855
Gc10_819 0 n20 ns819 0 -4.09216577137e-05
Gc10_820 0 n20 ns820 0 -0.000361069119149
Gc10_821 0 n20 ns821 0 -0.00484488940127
Gc10_822 0 n20 ns822 0 -0.00424625162394
Gc10_823 0 n20 ns823 0 -0.00448309934214
Gc10_824 0 n20 ns824 0 -0.00374656050198
Gc10_825 0 n20 ns825 0 -0.000370161359969
Gc10_826 0 n20 ns826 0 0.0018643919836
Gc10_827 0 n20 ns827 0 -0.00028971849858
Gc10_828 0 n20 ns828 0 -0.000743194608986
Gc10_829 0 n20 ns829 0 -0.000902964950831
Gc10_830 0 n20 ns830 0 -0.002067850136
Gc10_831 0 n20 ns831 0 1.79491042737e-05
Gc10_832 0 n20 ns832 0 -0.00125137295312
Gc10_833 0 n20 ns833 0 -0.000439042571893
Gc10_834 0 n20 ns834 0 -1.07157386739e-05
Gc10_835 0 n20 ns835 0 4.19745528425e-05
Gc10_836 0 n20 ns836 0 1.39154648229e-05
Gc10_837 0 n20 ns837 0 0.000424983395993
Gc10_838 0 n20 ns838 0 -0.000177220561916
Gc10_839 0 n20 ns839 0 0.00131534567596
Gc10_840 0 n20 ns840 0 -0.00045337458744
Gc10_841 0 n20 ns841 0 0.000354455402922
Gc10_842 0 n20 ns842 0 -6.23166806482e-05
Gc10_843 0 n20 ns843 0 -0.000152674224986
Gc10_844 0 n20 ns844 0 1.22350318359e-05
Gc10_845 0 n20 ns845 0 4.94634382932e-05
Gc10_846 0 n20 ns846 0 -0.000507912145001
Gc10_847 0 n20 ns847 0 -2.60422927686e-05
Gc10_848 0 n20 ns848 0 0.000129045600682
Gc10_849 0 n20 ns849 0 4.09626712301e-05
Gc10_850 0 n20 ns850 0 0.000400307904887
Gc10_851 0 n20 ns851 0 0.000194480440344
Gc10_852 0 n20 ns852 0 -0.000395120442624
Gc10_853 0 n20 ns853 0 -0.000290406149588
Gc10_854 0 n20 ns854 0 -0.000476607420575
Gc10_855 0 n20 ns855 0 -0.000435525993304
Gc10_856 0 n20 ns856 0 -0.000442170142166
Gc10_857 0 n20 ns857 0 -0.000199513614337
Gc10_858 0 n20 ns858 0 -0.000419460660477
Gc10_859 0 n20 ns859 0 -0.00444876916982
Gc10_860 0 n20 ns860 0 -0.000482575033023
Gc10_861 0 n20 ns861 0 -0.00397629364119
Gc10_862 0 n20 ns862 0 -0.000345197555694
Gc10_863 0 n20 ns863 0 0.000707912715066
Gc10_864 0 n20 ns864 0 0.00135806917198
Gc10_865 0 n20 ns865 0 -0.000358903820145
Gc10_866 0 n20 ns866 0 -0.000356878729368
Gc10_867 0 n20 ns867 0 -0.00134992918552
Gc10_868 0 n20 ns868 0 -0.00116210885847
Gc10_869 0 n20 ns869 0 -0.000230675451238
Gc10_870 0 n20 ns870 0 -0.000826209024774
Gc10_871 0 n20 ns871 0 -0.000240624281716
Gc10_872 0 n20 ns872 0 -6.79837896451e-06
Gc10_873 0 n20 ns873 0 -1.63571295883e-05
Gc10_874 0 n20 ns874 0 5.30647414293e-05
Gc10_875 0 n20 ns875 0 -0.000451038766372
Gc10_876 0 n20 ns876 0 0.00127708171377
Gc10_877 0 n20 ns877 0 -0.000934111719011
Gc10_878 0 n20 ns878 0 0.00159115529668
Gc10_879 0 n20 ns879 0 -0.000181139922254
Gc10_880 0 n20 ns880 0 0.000559975602483
Gc10_881 0 n20 ns881 0 0.000105769912604
Gc10_882 0 n20 ns882 0 -0.000327273586387
Gc10_883 0 n20 ns883 0 -4.11117591976e-05
Gc10_884 0 n20 ns884 0 0.000209599337618
Gc10_885 0 n20 ns885 0 0.000138287656021
Gc10_886 0 n20 ns886 0 -2.01751547734e-05
Gc10_887 0 n20 ns887 0 0.000175183516495
Gc10_888 0 n20 ns888 0 -0.000712973244201
Gc10_889 0 n20 ns889 0 -6.224384934e-05
Gc10_890 0 n20 ns890 0 -0.000610336982859
Gc10_891 0 n20 ns891 0 -0.000256673372967
Gc10_892 0 n20 ns892 0 -0.000225898132495
Gc10_893 0 n20 ns893 0 -0.000187423722928
Gc10_894 0 n20 ns894 0 -0.000197723504755
Gc10_895 0 n20 ns895 0 -0.000465334847317
Gc10_896 0 n20 ns896 0 0.000320604288173
Gc10_897 0 n20 ns897 0 -0.00277885919672
Gc10_898 0 n20 ns898 0 0.00239753411135
Gc10_899 0 n20 ns899 0 -0.00238917809051
Gc10_900 0 n20 ns900 0 0.00209446187408
Gc10_901 0 n20 ns901 0 0.000968507849419
Gc10_902 0 n20 ns902 0 0.00114392642045
Gc10_903 0 n20 ns903 0 -0.000282961117962
Gc10_904 0 n20 ns904 0 -0.000205724827422
Gc10_905 0 n20 ns905 0 -0.00115656043904
Gc10_906 0 n20 ns906 0 -0.000945656755285
Gc10_907 0 n20 ns907 0 -0.000222394896971
Gc10_908 0 n20 ns908 0 -0.00105692650275
Gc10_909 0 n20 ns909 0 -0.000281602454065
Gc10_910 0 n20 ns910 0 -2.06172062778e-05
Gc10_911 0 n20 ns911 0 1.90165510323e-05
Gc10_912 0 n20 ns912 0 8.00426434545e-06
Gc10_913 0 n20 ns913 0 0.000347183727571
Gc10_914 0 n20 ns914 0 -0.000218877255325
Gc10_915 0 n20 ns915 0 0.000908841589157
Gc10_916 0 n20 ns916 0 -0.000473853476529
Gc10_917 0 n20 ns917 0 0.000171808666143
Gc10_918 0 n20 ns918 0 -0.000231436230054
Gc10_919 0 n20 ns919 0 -0.000134278575391
Gc10_920 0 n20 ns920 0 0.000148938592524
Gc10_921 0 n20 ns921 0 -0.000134893499914
Gc10_922 0 n20 ns922 0 9.74816932305e-05
Gc10_923 0 n20 ns923 0 6.03278926091e-05
Gc10_924 0 n20 ns924 0 -4.31998232471e-05
Gc10_925 0 n20 ns925 0 -0.000143424720464
Gc10_926 0 n20 ns926 0 -0.000182824341055
Gc10_927 0 n20 ns927 0 -0.000362931195083
Gc10_928 0 n20 ns928 0 -3.01306162371e-05
Gc10_929 0 n20 ns929 0 -0.000263386559037
Gc10_930 0 n20 ns930 0 0.000125947415128
Gc10_931 0 n20 ns931 0 -0.000308809097464
Gc10_932 0 n20 ns932 0 0.000172439492935
Gc10_933 0 n20 ns933 0 -0.000177761285483
Gc10_934 0 n20 ns934 0 0.000122090510341
Gc10_935 0 n20 ns935 0 -0.000643110004761
Gc10_936 0 n20 ns936 0 0.00149942597973
Gc10_937 0 n20 ns937 0 -0.000542482724845
Gc10_938 0 n20 ns938 0 0.00131305414131
Gc10_939 0 n20 ns939 0 0.000498175126124
Gc10_940 0 n20 ns940 0 0.000216860183762
Gc10_941 0 n20 ns941 0 -0.000127480980208
Gc10_942 0 n20 ns942 0 -4.88162600082e-05
Gc10_943 0 n20 ns943 0 -0.000551172650156
Gc10_944 0 n20 ns944 0 -0.000165416950295
Gc10_945 0 n20 ns945 0 -7.64631141019e-05
Gc10_946 0 n20 ns946 0 -0.000247072910234
Gc10_947 0 n20 ns947 0 -9.50775622925e-05
Gc10_948 0 n20 ns948 0 -8.46470672019e-06
Gc10_949 0 n20 ns949 0 4.16196555954e-06
Gc10_950 0 n20 ns950 0 7.18874438298e-06
Gc10_951 0 n20 ns951 0 -0.000370721829848
Gc10_952 0 n20 ns952 0 -0.000153730901554
Gc10_953 0 n20 ns953 0 0.000511655983679
Gc10_954 0 n20 ns954 0 0.00243896762258
Gc10_955 0 n20 ns955 0 0.00126591035203
Gc10_956 0 n20 ns956 0 -0.00105449227965
Gc10_957 0 n20 ns957 0 -0.000318268079933
Gc10_958 0 n20 ns958 0 -3.60787933974e-06
Gc10_959 0 n20 ns959 0 -0.000223771138077
Gc10_960 0 n20 ns960 0 0.000427333900474
Gc10_961 0 n20 ns961 0 -4.42431780282e-05
Gc10_962 0 n20 ns962 0 -0.000110912047026
Gc10_963 0 n20 ns963 0 0.00208341305797
Gc10_964 0 n20 ns964 0 -0.00123648780706
Gc10_965 0 n20 ns965 0 -0.00113486498832
Gc10_966 0 n20 ns966 0 0.00142186412263
Gc10_967 0 n20 ns967 0 -0.00042353357312
Gc10_968 0 n20 ns968 0 0.000637079301526
Gc10_969 0 n20 ns969 0 -0.0019668504934
Gc10_970 0 n20 ns970 0 -0.000714516484989
Gc10_971 0 n20 ns971 0 0.00295175709623
Gc10_972 0 n20 ns972 0 0.00431817420019
Gc10_973 0 n20 ns973 0 -0.00578613108429
Gc10_974 0 n20 ns974 0 0.00202211235492
Gc10_975 0 n20 ns975 0 -0.00380713780248
Gc10_976 0 n20 ns976 0 0.000389573321865
Gc10_977 0 n20 ns977 0 -0.0111491088348
Gc10_978 0 n20 ns978 0 -0.00170280909567
Gc10_979 0 n20 ns979 0 0.00180232324179
Gc10_980 0 n20 ns980 0 0.000208166520634
Gc10_981 0 n20 ns981 0 -0.00260370999161
Gc10_982 0 n20 ns982 0 0.00936586952761
Gc10_983 0 n20 ns983 0 -0.013998908619
Gc10_984 0 n20 ns984 0 -0.00354108441704
Gc10_985 0 n20 ns985 0 -0.00618380697207
Gc10_986 0 n20 ns986 0 -5.80470011631e-05
Gc10_987 0 n20 ns987 0 -0.000441189650715
Gc10_988 0 n20 ns988 0 0.000605873520598
Gc10_989 0 n20 ns989 0 -0.000751747948893
Gc10_990 0 n20 ns990 0 -0.000900895728238
Gc10_991 0 n20 ns991 0 -0.00328972541723
Gc10_992 0 n20 ns992 0 -0.00146073722782
Gc10_993 0 n20 ns993 0 -0.00183582937919
Gc10_994 0 n20 ns994 0 0.00104428875745
Gc10_995 0 n20 ns995 0 0.000725484359448
Gc10_996 0 n20 ns996 0 -0.000361039241214
Gc10_997 0 n20 ns997 0 -0.000280423702313
Gc10_998 0 n20 ns998 0 0.000455248668453
Gc10_999 0 n20 ns999 0 -0.000213990573567
Gc10_1000 0 n20 ns1000 0 -0.000102107231788
Gc10_1001 0 n20 ns1001 0 0.000208293947265
Gc10_1002 0 n20 ns1002 0 -1.16253958267e-05
Gc10_1003 0 n20 ns1003 0 0.000770674139423
Gc10_1004 0 n20 ns1004 0 -0.000363017420607
Gc10_1005 0 n20 ns1005 0 0.00138766005814
Gc10_1006 0 n20 ns1006 0 -7.473499227e-06
Gc10_1007 0 n20 ns1007 0 0.00126912241721
Gc10_1008 0 n20 ns1008 0 -0.000348474569161
Gc10_1009 0 n20 ns1009 0 -0.00159843282004
Gc10_1010 0 n20 ns1010 0 -0.000623915492817
Gc10_1011 0 n20 ns1011 0 -0.00271793039739
Gc10_1012 0 n20 ns1012 0 -0.00416974959702
Gc10_1013 0 n20 ns1013 0 -0.0019076208692
Gc10_1014 0 n20 ns1014 0 -0.00453853843309
Gc10_1015 0 n20 ns1015 0 0.00284176704271
Gc10_1016 0 n20 ns1016 0 0.00126103785619
Gc10_1017 0 n20 ns1017 0 0.00106409902344
Gc10_1018 0 n20 ns1018 0 -0.0011585946014
Gc10_1019 0 n20 ns1019 0 -0.00136113248574
Gc10_1020 0 n20 ns1020 0 -0.00256889005794
Gc10_1021 0 n20 ns1021 0 0.00266178019193
Gc10_1022 0 n20 ns1022 0 -0.000277312213372
Gc10_1023 0 n20 ns1023 0 -0.00315919949971
Gc10_1024 0 n20 ns1024 0 -3.04900550547e-05
Gc10_1025 0 n20 ns1025 0 0.00027227568327
Gc10_1026 0 n20 ns1026 0 -0.000131172641756
Gc10_1027 0 n20 ns1027 0 -0.000439619566235
Gc10_1028 0 n20 ns1028 0 9.61627733995e-05
Gc10_1029 0 n20 ns1029 0 -0.000962018654965
Gc10_1030 0 n20 ns1030 0 0.0024579098947
Gc10_1031 0 n20 ns1031 0 -0.000141149888927
Gc10_1032 0 n20 ns1032 0 0.000410658009428
Gc10_1033 0 n20 ns1033 0 0.000196283342831
Gc10_1034 0 n20 ns1034 0 -0.000269496881542
Gc10_1035 0 n20 ns1035 0 1.60029166436e-05
Gc10_1036 0 n20 ns1036 0 0.000523083198387
Gc10_1037 0 n20 ns1037 0 -0.000171317758739
Gc10_1038 0 n20 ns1038 0 5.53044701139e-05
Gc10_1039 0 n20 ns1039 0 0.000648946194761
Gc10_1040 0 n20 ns1040 0 -0.000501391341316
Gc10_1041 0 n20 ns1041 0 2.92196601579e-05
Gc10_1042 0 n20 ns1042 0 -0.000130415649643
Gc10_1043 0 n20 ns1043 0 0.000815351424041
Gc10_1044 0 n20 ns1044 0 -0.000519114679846
Gc10_1045 0 n20 ns1045 0 0.000419539689375
Gc10_1046 0 n20 ns1046 0 -0.000760224449875
Gc10_1047 0 n20 ns1047 0 -0.00071228858857
Gc10_1048 0 n20 ns1048 0 0.00100370941627
Gc10_1049 0 n20 ns1049 0 -0.00180801418443
Gc10_1050 0 n20 ns1050 0 -0.00352989137218
Gc10_1051 0 n20 ns1051 0 -0.00172261869446
Gc10_1052 0 n20 ns1052 0 -0.00384522343871
Gc10_1053 0 n20 ns1053 0 -0.000578915424616
Gc10_1054 0 n20 ns1054 0 0.000816979681509
Gc10_1055 0 n20 ns1055 0 0.000374311408555
Gc10_1056 0 n20 ns1056 0 -0.00136029299377
Gc10_1057 0 n20 ns1057 0 9.93417409056e-05
Gc10_1058 0 n20 ns1058 0 -0.00297535490261
Gc10_1059 0 n20 ns1059 0 0.00108845532803
Gc10_1060 0 n20 ns1060 0 -0.00332134270332
Gc10_1061 0 n20 ns1061 0 -0.00160301262087
Gc10_1062 0 n20 ns1062 0 -2.34823583423e-05
Gc10_1063 0 n20 ns1063 0 8.04176421976e-05
Gc10_1064 0 n20 ns1064 0 7.1191967102e-06
Gc10_1065 0 n20 ns1065 0 -0.000575869281366
Gc10_1066 0 n20 ns1066 0 0.000337861757732
Gc10_1067 0 n20 ns1067 0 -0.00151428725368
Gc10_1068 0 n20 ns1068 0 0.00133385872699
Gc10_1069 0 n20 ns1069 0 -0.000419445010841
Gc10_1070 0 n20 ns1070 0 0.000382558094574
Gc10_1071 0 n20 ns1071 0 0.000134920183025
Gc10_1072 0 n20 ns1072 0 -0.000198387044694
Gc10_1073 0 n20 ns1073 0 0.000303620506117
Gc10_1074 0 n20 ns1074 0 0.000356117908894
Gc10_1075 0 n20 ns1075 0 -6.38363867012e-05
Gc10_1076 0 n20 ns1076 0 0.000123297608653
Gc10_1077 0 n20 ns1077 0 0.000211820514598
Gc10_1078 0 n20 ns1078 0 -0.000398174377244
Gc10_1079 0 n20 ns1079 0 0.000653876683522
Gc10_1080 0 n20 ns1080 0 0.000432252979709
Gc10_1081 0 n20 ns1081 0 0.000567978963767
Gc10_1082 0 n20 ns1082 0 -0.000456085084841
Gc10_1083 0 n20 ns1083 0 0.000358756025688
Gc10_1084 0 n20 ns1084 0 -0.00024784918775
Gc10_1085 0 n20 ns1085 0 -0.000113946850938
Gc10_1086 0 n20 ns1086 0 3.17138523964e-05
Gc10_1087 0 n20 ns1087 0 -0.00437236959249
Gc10_1088 0 n20 ns1088 0 -0.00496096269455
Gc10_1089 0 n20 ns1089 0 -0.00411129028629
Gc10_1090 0 n20 ns1090 0 -0.00451676452818
Gc10_1091 0 n20 ns1091 0 -0.000809915395008
Gc10_1092 0 n20 ns1092 0 0.00200354669047
Gc10_1093 0 n20 ns1093 0 -0.000188377865157
Gc10_1094 0 n20 ns1094 0 -0.000966748484655
Gc10_1095 0 n20 ns1095 0 -0.000604726593448
Gc10_1096 0 n20 ns1096 0 -0.00261587142038
Gc10_1097 0 n20 ns1097 0 0.000179459231712
Gc10_1098 0 n20 ns1098 0 -0.00176819441954
Gc10_1099 0 n20 ns1099 0 -0.000645223901925
Gc10_1100 0 n20 ns1100 0 -1.93296099954e-05
Gc10_1101 0 n20 ns1101 0 9.85532710241e-05
Gc10_1102 0 n20 ns1102 0 -2.23007255758e-05
Gc10_1103 0 n20 ns1103 0 0.000487743169277
Gc10_1104 0 n20 ns1104 0 -0.000678548197085
Gc10_1105 0 n20 ns1105 0 0.00149752394618
Gc10_1106 0 n20 ns1106 0 -0.000947805459805
Gc10_1107 0 n20 ns1107 0 0.000305677936689
Gc10_1108 0 n20 ns1108 0 -0.000218733208305
Gc10_1109 0 n20 ns1109 0 -0.000135357437903
Gc10_1110 0 n20 ns1110 0 0.000133818266406
Gc10_1111 0 n20 ns1111 0 0.000181341028201
Gc10_1112 0 n20 ns1112 0 -0.000530679872963
Gc10_1113 0 n20 ns1113 0 -8.3447321129e-05
Gc10_1114 0 n20 ns1114 0 0.000159350915335
Gc10_1115 0 n20 ns1115 0 -5.37644505723e-05
Gc10_1116 0 n20 ns1116 0 0.00060759550789
Gc10_1117 0 n20 ns1117 0 0.00039993883451
Gc10_1118 0 n20 ns1118 0 -0.000139723501544
Gc10_1119 0 n20 ns1119 0 -0.000131581198354
Gc10_1120 0 n20 ns1120 0 -0.000536542173436
Gc10_1121 0 n20 ns1121 0 -0.000330666034492
Gc10_1122 0 n20 ns1122 0 -0.000460881748273
Gc10_1123 0 n20 ns1123 0 -7.46665914609e-05
Gc10_1124 0 n20 ns1124 0 -0.000585841772567
Gc10_1125 0 n20 ns1125 0 -0.0048870686506
Gc10_1126 0 n20 ns1126 0 -0.00204775910791
Gc10_1127 0 n20 ns1127 0 -0.00443020759944
Gc10_1128 0 n20 ns1128 0 -0.00171421399611
Gc10_1129 0 n20 ns1129 0 0.000369281480507
Gc10_1130 0 n20 ns1130 0 0.00153514328541
Gc10_1131 0 n20 ns1131 0 -0.000352952364689
Gc10_1132 0 n20 ns1132 0 -0.000468693827951
Gc10_1133 0 n20 ns1133 0 -0.00123132907265
Gc10_1134 0 n20 ns1134 0 -0.00143423533609
Gc10_1135 0 n20 ns1135 0 -0.000168756518613
Gc10_1136 0 n20 ns1136 0 -0.000972016442682
Gc10_1137 0 n20 ns1137 0 -0.000299408457031
Gc10_1138 0 n20 ns1138 0 -4.44639310532e-06
Gc10_1139 0 n20 ns1139 0 2.74537982323e-05
Gc10_1140 0 n20 ns1140 0 2.674847283e-05
Gc10_1141 0 n20 ns1141 0 -0.000303865737886
Gc10_1142 0 n20 ns1142 0 0.00104671189948
Gc10_1143 0 n20 ns1143 0 -0.0005043738702
Gc10_1144 0 n20 ns1144 0 0.00130529014184
Gc10_1145 0 n20 ns1145 0 -9.78341628896e-05
Gc10_1146 0 n20 ns1146 0 0.000501457808309
Gc10_1147 0 n20 ns1147 0 9.28751424071e-05
Gc10_1148 0 n20 ns1148 0 -0.000315223189837
Gc10_1149 0 n20 ns1149 0 -5.63147541827e-06
Gc10_1150 0 n20 ns1150 0 -1.38316743037e-05
Gc10_1151 0 n20 ns1151 0 0.000103047705235
Gc10_1152 0 n20 ns1152 0 3.61719969192e-05
Gc10_1153 0 n20 ns1153 0 0.000217972183071
Gc10_1154 0 n20 ns1154 0 -0.000462621758412
Gc10_1155 0 n20 ns1155 0 5.64590356026e-05
Gc10_1156 0 n20 ns1156 0 -0.000687213038767
Gc10_1157 0 n20 ns1157 0 -0.000285940257247
Gc10_1158 0 n20 ns1158 0 -0.00036773635157
Gc10_1159 0 n20 ns1159 0 -0.000254853145888
Gc10_1160 0 n20 ns1160 0 -0.000343583540374
Gc10_1161 0 n20 ns1161 0 -0.000454989825415
Gc10_1162 0 n20 ns1162 0 0.000163833886672
Gc10_1163 0 n20 ns1163 0 -0.00363478135148
Gc10_1164 0 n20 ns1164 0 0.00192375508635
Gc10_1165 0 n20 ns1165 0 -0.00316317932936
Gc10_1166 0 n20 ns1166 0 0.00170248637182
Gc10_1167 0 n20 ns1167 0 0.00103334536414
Gc10_1168 0 n20 ns1168 0 0.00139977917791
Gc10_1169 0 n20 ns1169 0 -0.000336518821545
Gc10_1170 0 n20 ns1170 0 -0.000270440050644
Gc10_1171 0 n20 ns1171 0 -0.00134831242474
Gc10_1172 0 n20 ns1172 0 -0.00117062297591
Gc10_1173 0 n20 ns1173 0 -0.000271105293198
Gc10_1174 0 n20 ns1174 0 -0.00119549462092
Gc10_1175 0 n20 ns1175 0 -0.000313168757062
Gc10_1176 0 n20 ns1176 0 -6.55371417485e-06
Gc10_1177 0 n20 ns1177 0 1.39451694228e-05
Gc10_1178 0 n20 ns1178 0 1.68051771906e-05
Gc10_1179 0 n20 ns1179 0 0.000114325348416
Gc10_1180 0 n20 ns1180 0 0.000196968274033
Gc10_1181 0 n20 ns1181 0 0.000418220592338
Gc10_1182 0 n20 ns1182 0 0.000117957710652
Gc10_1183 0 n20 ns1183 0 4.78926815323e-05
Gc10_1184 0 n20 ns1184 0 4.24071793587e-06
Gc10_1185 0 n20 ns1185 0 -5.99295914094e-05
Gc10_1186 0 n20 ns1186 0 1.90940584626e-07
Gc10_1187 0 n20 ns1187 0 -0.00012889217058
Gc10_1188 0 n20 ns1188 0 0.000165217439641
Gc10_1189 0 n20 ns1189 0 9.88282965248e-05
Gc10_1190 0 n20 ns1190 0 -4.47380235607e-05
Gc10_1191 0 n20 ns1191 0 -5.85437408948e-05
Gc10_1192 0 n20 ns1192 0 -0.000408211415683
Gc10_1193 0 n20 ns1193 0 -0.000327516487572
Gc10_1194 0 n20 ns1194 0 -0.000214671938106
Gc10_1195 0 n20 ns1195 0 -0.000290862795523
Gc10_1196 0 n20 ns1196 0 4.70220322556e-05
Gc10_1197 0 n20 ns1197 0 -0.000295970851198
Gc10_1198 0 n20 ns1198 0 9.45501868876e-05
Gc10_1199 0 n20 ns1199 0 -0.000291962524691
Gc10_1200 0 n20 ns1200 0 0.000239154228471
Gc10_1201 0 n20 ns1201 0 -0.00130720477332
Gc10_1202 0 n20 ns1202 0 0.00207899749266
Gc10_1203 0 n20 ns1203 0 -0.00111086066434
Gc10_1204 0 n20 ns1204 0 0.00181264481748
Gc10_1205 0 n20 ns1205 0 0.000736095468404
Gc10_1206 0 n20 ns1206 0 0.000524904233799
Gc10_1207 0 n20 ns1207 0 -0.000187738834202
Gc10_1208 0 n20 ns1208 0 -9.55672827196e-05
Gc10_1209 0 n20 ns1209 0 -0.000807058475878
Gc10_1210 0 n20 ns1210 0 -0.000425793612298
Gc10_1211 0 n20 ns1211 0 -0.000143230136095
Gc10_1212 0 n20 ns1212 0 -0.00056180593884
Gc10_1213 0 n20 ns1213 0 -0.00016530559057
Gc10_1214 0 n20 ns1214 0 -1.11062538275e-05
Gc10_1215 0 n20 ns1215 0 7.35635772238e-06
Gc10_1216 0 n20 ns1216 0 3.4795815091e-06
Gd10_1 0 n20 ni1 0 -0.00235573333362
Gd10_2 0 n20 ni2 0 -0.00322359802752
Gd10_3 0 n20 ni3 0 -0.00086137121605
Gd10_4 0 n20 ni4 0 -0.00170290820132
Gd10_5 0 n20 ni5 0 0.000144375672361
Gd10_6 0 n20 ni6 0 0.000236379299559
Gd10_7 0 n20 ni7 0 0.000215472612383
Gd10_8 0 n20 ni8 0 -0.0001615812698
Gd10_9 0 n20 ni9 0 -7.61297339822e-05
Gd10_10 0 n20 ni10 0 0.000893919848042
Gd10_11 0 n20 ni11 0 -0.0019119036941
Gd10_12 0 n20 ni12 0 -0.000620870377412
Gd10_13 0 n20 ni13 0 7.13966646671e-05
Gd10_14 0 n20 ni14 0 0.000756611049082
Gd10_15 0 n20 ni15 0 9.79056980453e-05
Gd10_16 0 n20 ni16 0 -5.49203164844e-05
Gd10_17 0 n20 ni17 0 0.000119720158905
Gd10_18 0 n20 ni18 0 -0.00176689214382
Gd10_19 0 n20 ni19 0 -0.00323643610039
Gd10_20 0 n20 ni20 0 9.03211613012e-05
Gd10_21 0 n20 ni21 0 0.000339511700382
Gd10_22 0 n20 ni22 0 2.04796446744e-05
Gd10_23 0 n20 ni23 0 -0.000475055677177
Gd10_24 0 n20 ni24 0 0.0010876290105
Gd10_25 0 n20 ni25 0 -0.000441521367314
Gd10_26 0 n20 ni26 0 0.000318099769477
Gd10_27 0 n20 ni27 0 -0.000383577997608
Gd10_28 0 n20 ni28 0 0.000591542057793
Gd10_29 0 n20 ni29 0 0.00072464471388
Gd10_30 0 n20 ni30 0 -0.000843973033349
Gd10_31 0 n20 ni31 0 0.000829178840288
Gd10_32 0 n20 ni32 0 -2.05275612708e-05
Gc11_1 0 n22 ns1 0 0.000351800620385
Gc11_2 0 n22 ns2 0 -0.000550422864025
Gc11_3 0 n22 ns3 0 0.00101931931625
Gc11_4 0 n22 ns4 0 0.000364086919221
Gc11_5 0 n22 ns5 0 -0.000165726113475
Gc11_6 0 n22 ns6 0 0.000377062483312
Gc11_7 0 n22 ns7 0 -5.86283793482e-05
Gc11_8 0 n22 ns8 0 3.52334706426e-05
Gc11_9 0 n22 ns9 0 0.000649508623842
Gc11_10 0 n22 ns10 0 -0.000269963327632
Gc11_11 0 n22 ns11 0 0.000170450982343
Gc11_12 0 n22 ns12 0 4.16156170519e-05
Gc11_13 0 n22 ns13 0 6.78364222116e-06
Gc11_14 0 n22 ns14 0 -0.000460134726482
Gc11_15 0 n22 ns15 0 -0.00155754095396
Gc11_16 0 n22 ns16 0 -0.000290233680783
Gc11_17 0 n22 ns17 0 0.000215928387317
Gc11_18 0 n22 ns18 0 -9.66660665198e-05
Gc11_19 0 n22 ns19 0 -0.000244156338612
Gc11_20 0 n22 ns20 0 -0.000740384774328
Gc11_21 0 n22 ns21 0 0.00142360630688
Gc11_22 0 n22 ns22 0 -0.00131701583724
Gc11_23 0 n22 ns23 0 -0.00130701887354
Gc11_24 0 n22 ns24 0 0.00204444251115
Gc11_25 0 n22 ns25 0 -0.00120936821286
Gc11_26 0 n22 ns26 0 0.0026149700702
Gc11_27 0 n22 ns27 0 -0.00157898003003
Gc11_28 0 n22 ns28 0 -0.00230449573492
Gc11_29 0 n22 ns29 0 0.000749030079536
Gc11_30 0 n22 ns30 0 -0.000915576294168
Gc11_31 0 n22 ns31 0 0.00117682319916
Gc11_32 0 n22 ns32 0 -0.000273488008014
Gc11_33 0 n22 ns33 0 -0.00122800686201
Gc11_34 0 n22 ns34 0 0.00248133693945
Gc11_35 0 n22 ns35 0 0.00148784788332
Gc11_36 0 n22 ns36 0 3.98129611988e-05
Gc11_37 0 n22 ns37 0 -0.000338617486402
Gc11_38 0 n22 ns38 0 0.000135054851874
Gc11_39 0 n22 ns39 0 0.000767878356085
Gc11_40 0 n22 ns40 0 -0.00213773459469
Gc11_41 0 n22 ns41 0 0.00193652141632
Gc11_42 0 n22 ns42 0 -0.00160885601257
Gc11_43 0 n22 ns43 0 -0.0003792809233
Gc11_44 0 n22 ns44 0 -6.25417956665e-05
Gc11_45 0 n22 ns45 0 3.8814957846e-05
Gc11_46 0 n22 ns46 0 2.3148792193e-05
Gc11_47 0 n22 ns47 0 0.000553005463869
Gc11_48 0 n22 ns48 0 -0.000355680546938
Gc11_49 0 n22 ns49 0 0.000174480382206
Gc11_50 0 n22 ns50 0 7.61354245183e-05
Gc11_51 0 n22 ns51 0 -0.000128485041077
Gc11_52 0 n22 ns52 0 0.000203939223097
Gc11_53 0 n22 ns53 0 -0.00129930514847
Gc11_54 0 n22 ns54 0 -0.000256832178304
Gc11_55 0 n22 ns55 0 0.000376095684237
Gc11_56 0 n22 ns56 0 -9.34894706532e-06
Gc11_57 0 n22 ns57 0 -0.000240468492144
Gc11_58 0 n22 ns58 0 -0.000627953552767
Gc11_59 0 n22 ns59 0 0.00162044469821
Gc11_60 0 n22 ns60 0 -0.000909157829361
Gc11_61 0 n22 ns61 0 -0.000743273516483
Gc11_62 0 n22 ns62 0 0.00217126042139
Gc11_63 0 n22 ns63 0 -0.000804637515704
Gc11_64 0 n22 ns64 0 0.00286996699856
Gc11_65 0 n22 ns65 0 -0.000920060532508
Gc11_66 0 n22 ns66 0 -0.00260942233674
Gc11_67 0 n22 ns67 0 0.000980373200173
Gc11_68 0 n22 ns68 0 -0.000993535709383
Gc11_69 0 n22 ns69 0 0.00111356172068
Gc11_70 0 n22 ns70 0 -0.000190579315295
Gc11_71 0 n22 ns71 0 -0.00196220494849
Gc11_72 0 n22 ns72 0 0.00268218783232
Gc11_73 0 n22 ns73 0 0.00207708271603
Gc11_74 0 n22 ns74 0 1.34211982981e-05
Gc11_75 0 n22 ns75 0 -0.000279293654738
Gc11_76 0 n22 ns76 0 0.000108967004762
Gc11_77 0 n22 ns77 0 0.00109887541892
Gc11_78 0 n22 ns78 0 -0.00481944114995
Gc11_79 0 n22 ns79 0 0.000860132349099
Gc11_80 0 n22 ns80 0 -0.00358388010793
Gc11_81 0 n22 ns81 0 -0.00116983371413
Gc11_82 0 n22 ns82 0 -0.000693247369224
Gc11_83 0 n22 ns83 0 0.000606351960951
Gc11_84 0 n22 ns84 0 -0.000129223339677
Gc11_85 0 n22 ns85 0 -0.000108820093197
Gc11_86 0 n22 ns86 0 0.000219867906027
Gc11_87 0 n22 ns87 0 0.000286583394472
Gc11_88 0 n22 ns88 0 5.09290200943e-05
Gc11_89 0 n22 ns89 0 -0.000365729122271
Gc11_90 0 n22 ns90 0 0.000614050437082
Gc11_91 0 n22 ns91 0 0.000701549064806
Gc11_92 0 n22 ns92 0 -2.00361794979e-05
Gc11_93 0 n22 ns93 0 0.000958399570586
Gc11_94 0 n22 ns94 0 -6.46979810812e-05
Gc11_95 0 n22 ns95 0 0.000346226593043
Gc11_96 0 n22 ns96 0 -0.000607750476314
Gc11_97 0 n22 ns97 0 0.000302219192824
Gc11_98 0 n22 ns98 0 0.00135670438338
Gc11_99 0 n22 ns99 0 0.00356763495877
Gc11_100 0 n22 ns100 0 0.00641574635193
Gc11_101 0 n22 ns101 0 0.00252783752314
Gc11_102 0 n22 ns102 0 0.00639046568382
Gc11_103 0 n22 ns103 0 0.00210808223683
Gc11_104 0 n22 ns104 0 0.00177082766572
Gc11_105 0 n22 ns105 0 0.00107398361087
Gc11_106 0 n22 ns106 0 -0.000941596858472
Gc11_107 0 n22 ns107 0 -0.00349829557464
Gc11_108 0 n22 ns108 0 -0.00115371352406
Gc11_109 0 n22 ns109 0 -0.000467751593415
Gc11_110 0 n22 ns110 0 -0.0020139539162
Gc11_111 0 n22 ns111 0 0.00383260780932
Gc11_112 0 n22 ns112 0 -4.4775599501e-06
Gc11_113 0 n22 ns113 0 -0.000118625831693
Gc11_114 0 n22 ns114 0 3.33500648597e-06
Gc11_115 0 n22 ns115 0 0.00089302982155
Gc11_116 0 n22 ns116 0 -0.00381327829283
Gc11_117 0 n22 ns117 0 -0.000701442826732
Gc11_118 0 n22 ns118 0 -0.00118752475448
Gc11_119 0 n22 ns119 0 -0.000949554083184
Gc11_120 0 n22 ns120 0 -4.22493275244e-05
Gc11_121 0 n22 ns121 0 0.000469312091036
Gc11_122 0 n22 ns122 0 -0.000180835380447
Gc11_123 0 n22 ns123 0 -2.35511326206e-05
Gc11_124 0 n22 ns124 0 0.000448268983369
Gc11_125 0 n22 ns125 0 0.000294938140858
Gc11_126 0 n22 ns126 0 -1.44364736319e-05
Gc11_127 0 n22 ns127 0 -0.000357518979072
Gc11_128 0 n22 ns128 0 -0.000373261117435
Gc11_129 0 n22 ns129 0 0.000372081898452
Gc11_130 0 n22 ns130 0 -8.30171939992e-05
Gc11_131 0 n22 ns131 0 0.000568627388906
Gc11_132 0 n22 ns132 0 -0.000421998097334
Gc11_133 0 n22 ns133 0 -7.81282827793e-05
Gc11_134 0 n22 ns134 0 -0.00132673859257
Gc11_135 0 n22 ns135 0 -0.000301875325595
Gc11_136 0 n22 ns136 0 0.000394738627232
Gc11_137 0 n22 ns137 0 0.0067739874993
Gc11_138 0 n22 ns138 0 0.00741615521044
Gc11_139 0 n22 ns139 0 0.0051168160126
Gc11_140 0 n22 ns140 0 0.00709038272433
Gc11_141 0 n22 ns141 0 0.000677003105381
Gc11_142 0 n22 ns142 0 0.00530280999942
Gc11_143 0 n22 ns143 0 0.000859813103739
Gc11_144 0 n22 ns144 0 -0.00091925392724
Gc11_145 0 n22 ns145 0 -0.00632069632987
Gc11_146 0 n22 ns146 0 -0.00199930611104
Gc11_147 0 n22 ns147 0 0.00324569383258
Gc11_148 0 n22 ns148 0 -0.00526252670626
Gc11_149 0 n22 ns149 0 0.00455511510008
Gc11_150 0 n22 ns150 0 -4.97383278791e-06
Gc11_151 0 n22 ns151 0 -1.75039201523e-05
Gc11_152 0 n22 ns152 0 -4.45660929616e-05
Gc11_153 0 n22 ns153 0 0.000469151220984
Gc11_154 0 n22 ns154 0 -0.00183099016933
Gc11_155 0 n22 ns155 0 0.00112837002349
Gc11_156 0 n22 ns156 0 -0.00146456394066
Gc11_157 0 n22 ns157 0 -0.000768516663571
Gc11_158 0 n22 ns158 0 -5.94810179199e-05
Gc11_159 0 n22 ns159 0 0.000157941779844
Gc11_160 0 n22 ns160 0 -0.00022359702156
Gc11_161 0 n22 ns161 0 0.000272636817806
Gc11_162 0 n22 ns162 0 0.000158789567963
Gc11_163 0 n22 ns163 0 0.000194077470565
Gc11_164 0 n22 ns164 0 -2.95440682451e-05
Gc11_165 0 n22 ns165 0 4.17017548103e-05
Gc11_166 0 n22 ns166 0 0.000393722507533
Gc11_167 0 n22 ns167 0 0.000163061449179
Gc11_168 0 n22 ns168 0 -0.000923794482709
Gc11_169 0 n22 ns169 0 0.000683000044221
Gc11_170 0 n22 ns170 0 -0.00049085655069
Gc11_171 0 n22 ns171 0 0.000335399923143
Gc11_172 0 n22 ns172 0 -0.000812144785306
Gc11_173 0 n22 ns173 0 0.00163903621966
Gc11_174 0 n22 ns174 0 0.00116544610292
Gc11_175 0 n22 ns175 0 0.00241399545493
Gc11_176 0 n22 ns176 0 0.0038169178565
Gc11_177 0 n22 ns177 0 0.00194385591138
Gc11_178 0 n22 ns178 0 0.00404378311957
Gc11_179 0 n22 ns179 0 0.0014897558545
Gc11_180 0 n22 ns180 0 -0.002018036392
Gc11_181 0 n22 ns181 0 0.000857845526668
Gc11_182 0 n22 ns182 0 -0.000921304410573
Gc11_183 0 n22 ns183 0 -0.000382305934175
Gc11_184 0 n22 ns184 0 -0.00026977874424
Gc11_185 0 n22 ns185 0 -0.00322636845174
Gc11_186 0 n22 ns186 0 0.00258365624365
Gc11_187 0 n22 ns187 0 0.00268115971144
Gc11_188 0 n22 ns188 0 2.39419440294e-05
Gc11_189 0 n22 ns189 0 -0.000135599734126
Gc11_190 0 n22 ns190 0 2.98221261729e-05
Gc11_191 0 n22 ns191 0 -0.000318385476057
Gc11_192 0 n22 ns192 0 0.000155210316622
Gc11_193 0 n22 ns193 0 -0.000632781964575
Gc11_194 0 n22 ns194 0 0.000547805353984
Gc11_195 0 n22 ns195 0 -9.38235223419e-05
Gc11_196 0 n22 ns196 0 0.000441613190994
Gc11_197 0 n22 ns197 0 3.84983377205e-05
Gc11_198 0 n22 ns198 0 -8.63993391568e-05
Gc11_199 0 n22 ns199 0 9.8409805594e-05
Gc11_200 0 n22 ns200 0 -0.000243863897508
Gc11_201 0 n22 ns201 0 0.000150557322482
Gc11_202 0 n22 ns202 0 -7.55628482288e-05
Gc11_203 0 n22 ns203 0 1.28919074553e-05
Gc11_204 0 n22 ns204 0 -0.000346341063166
Gc11_205 0 n22 ns205 0 -0.000582352247387
Gc11_206 0 n22 ns206 0 0.000299283428732
Gc11_207 0 n22 ns207 0 0.000198772032558
Gc11_208 0 n22 ns208 0 -0.000344918369833
Gc11_209 0 n22 ns209 0 -0.000329284708544
Gc11_210 0 n22 ns210 0 -0.000516516868276
Gc11_211 0 n22 ns211 0 0.000287653763071
Gc11_212 0 n22 ns212 0 -0.00113090033158
Gc11_213 0 n22 ns213 0 0.00141094715826
Gc11_214 0 n22 ns214 0 0.0023832301332
Gc11_215 0 n22 ns215 0 0.00148048824409
Gc11_216 0 n22 ns216 0 0.00263731325074
Gc11_217 0 n22 ns217 0 -0.0021351018879
Gc11_218 0 n22 ns218 0 -0.000711061224769
Gc11_219 0 n22 ns219 0 0.00023369511437
Gc11_220 0 n22 ns220 0 -0.000977806057218
Gc11_221 0 n22 ns221 0 0.000481325288028
Gc11_222 0 n22 ns222 0 -0.000914320613044
Gc11_223 0 n22 ns223 0 -0.000837366123025
Gc11_224 0 n22 ns224 0 0.00243015013908
Gc11_225 0 n22 ns225 0 0.00113996600555
Gc11_226 0 n22 ns226 0 1.80728025987e-05
Gc11_227 0 n22 ns227 0 -0.000183869929656
Gc11_228 0 n22 ns228 0 5.50576772027e-05
Gc11_229 0 n22 ns229 0 -0.000114287350954
Gc11_230 0 n22 ns230 0 0.000156296929433
Gc11_231 0 n22 ns231 0 -8.30358068366e-06
Gc11_232 0 n22 ns232 0 0.00104629525789
Gc11_233 0 n22 ns233 0 1.35387182277e-06
Gc11_234 0 n22 ns234 0 0.000146198355816
Gc11_235 0 n22 ns235 0 0.00011341703967
Gc11_236 0 n22 ns236 0 -0.000149700903615
Gc11_237 0 n22 ns237 0 -0.000191549251692
Gc11_238 0 n22 ns238 0 0.000107816183443
Gc11_239 0 n22 ns239 0 0.000101386162848
Gc11_240 0 n22 ns240 0 -0.000157833208928
Gc11_241 0 n22 ns241 0 -0.000247658851414
Gc11_242 0 n22 ns242 0 -0.000283472606817
Gc11_243 0 n22 ns243 0 0.000551177811735
Gc11_244 0 n22 ns244 0 0.000237658850901
Gc11_245 0 n22 ns245 0 0.000283932396118
Gc11_246 0 n22 ns246 0 -0.000499231217689
Gc11_247 0 n22 ns247 0 8.63361260835e-05
Gc11_248 0 n22 ns248 0 -0.000383394866259
Gc11_249 0 n22 ns249 0 -0.000498361651461
Gc11_250 0 n22 ns250 0 0.00028169277616
Gc11_251 0 n22 ns251 0 0.00260054164317
Gc11_252 0 n22 ns252 0 0.00322580135896
Gc11_253 0 n22 ns253 0 0.00260422933824
Gc11_254 0 n22 ns254 0 0.00287602465317
Gc11_255 0 n22 ns255 0 -0.00051300945182
Gc11_256 0 n22 ns256 0 0.00132230259334
Gc11_257 0 n22 ns257 0 -0.000265686087573
Gc11_258 0 n22 ns258 0 -0.000696638027198
Gc11_259 0 n22 ns259 0 -0.000881242804541
Gc11_260 0 n22 ns260 0 -0.00166953492635
Gc11_261 0 n22 ns261 0 -0.000592790846486
Gc11_262 0 n22 ns262 0 -1.55839954814e-05
Gc11_263 0 n22 ns263 0 0.000235375691851
Gc11_264 0 n22 ns264 0 1.15374545908e-05
Gc11_265 0 n22 ns265 0 -7.75176820238e-05
Gc11_266 0 n22 ns266 0 -6.87660020499e-06
Gc11_267 0 n22 ns267 0 6.34961174962e-05
Gc11_268 0 n22 ns268 0 0.000324213026186
Gc11_269 0 n22 ns269 0 0.000264684579011
Gc11_270 0 n22 ns270 0 0.000567988480218
Gc11_271 0 n22 ns271 0 -2.26429033838e-05
Gc11_272 0 n22 ns272 0 3.8960385189e-05
Gc11_273 0 n22 ns273 0 -4.10966632608e-05
Gc11_274 0 n22 ns274 0 -2.04442469309e-05
Gc11_275 0 n22 ns275 0 -2.54956714193e-05
Gc11_276 0 n22 ns276 0 0.000359033909488
Gc11_277 0 n22 ns277 0 -4.39511273917e-06
Gc11_278 0 n22 ns278 0 -0.0001234821916
Gc11_279 0 n22 ns279 0 -4.1012630159e-05
Gc11_280 0 n22 ns280 0 -0.000240625145164
Gc11_281 0 n22 ns281 0 0.000434782781132
Gc11_282 0 n22 ns282 0 -0.000619369845364
Gc11_283 0 n22 ns283 0 -7.98879319341e-05
Gc11_284 0 n22 ns284 0 -0.000582526322594
Gc11_285 0 n22 ns285 0 -1.22873654174e-05
Gc11_286 0 n22 ns286 0 -0.000560606255167
Gc11_287 0 n22 ns287 0 0.000260419346767
Gc11_288 0 n22 ns288 0 0.000704431497396
Gc11_289 0 n22 ns289 0 0.00354977236985
Gc11_290 0 n22 ns290 0 0.00106571842938
Gc11_291 0 n22 ns291 0 0.00321786362591
Gc11_292 0 n22 ns292 0 0.000798464896896
Gc11_293 0 n22 ns293 0 0.000470280909692
Gc11_294 0 n22 ns294 0 0.000955008642068
Gc11_295 0 n22 ns295 0 -0.000321409374188
Gc11_296 0 n22 ns296 0 -0.000344669085763
Gc11_297 0 n22 ns297 0 -0.00125097780448
Gc11_298 0 n22 ns298 0 -0.000923473064803
Gc11_299 0 n22 ns299 0 -0.000515387958214
Gc11_300 0 n22 ns300 0 -0.000138322227167
Gc11_301 0 n22 ns301 0 0.000115232714869
Gc11_302 0 n22 ns302 0 1.05711660084e-05
Gc11_303 0 n22 ns303 0 -3.98991903925e-05
Gc11_304 0 n22 ns304 0 -1.57125002789e-05
Gc11_305 0 n22 ns305 0 0.000442035678206
Gc11_306 0 n22 ns306 0 1.19539267523e-05
Gc11_307 0 n22 ns307 0 0.00141574484941
Gc11_308 0 n22 ns308 0 -0.000146458213933
Gc11_309 0 n22 ns309 0 0.000105256703062
Gc11_310 0 n22 ns310 0 -8.71465172875e-05
Gc11_311 0 n22 ns311 0 -3.21546612863e-05
Gc11_312 0 n22 ns312 0 0.000116463949319
Gc11_313 0 n22 ns313 0 0.000253675663368
Gc11_314 0 n22 ns314 0 0.000158165495631
Gc11_315 0 n22 ns315 0 -6.17069469617e-05
Gc11_316 0 n22 ns316 0 -6.43880120615e-05
Gc11_317 0 n22 ns317 0 -0.00030145258676
Gc11_318 0 n22 ns318 0 -0.000198325059213
Gc11_319 0 n22 ns319 0 -0.000290822734644
Gc11_320 0 n22 ns320 0 -0.000654527781054
Gc11_321 0 n22 ns321 0 -0.000387058635113
Gc11_322 0 n22 ns322 0 -0.000365772541714
Gc11_323 0 n22 ns323 0 -0.000391694802425
Gc11_324 0 n22 ns324 0 -0.000521827622893
Gc11_325 0 n22 ns325 0 0.000711103706244
Gc11_326 0 n22 ns326 0 0.000222766147085
Gc11_327 0 n22 ns327 0 0.00275771640015
Gc11_328 0 n22 ns328 0 -0.000653761808814
Gc11_329 0 n22 ns329 0 0.00237656290744
Gc11_330 0 n22 ns330 0 -0.000660842674818
Gc11_331 0 n22 ns331 0 0.000503231674792
Gc11_332 0 n22 ns332 0 0.000268932731744
Gc11_333 0 n22 ns333 0 -0.000186138504696
Gc11_334 0 n22 ns334 0 -0.000118898488237
Gc11_335 0 n22 ns335 0 -0.000807923853566
Gc11_336 0 n22 ns336 0 -0.000295165792979
Gc11_337 0 n22 ns337 0 -0.000336726907861
Gc11_338 0 n22 ns338 0 -0.000164231605807
Gc11_339 0 n22 ns339 0 5.20834574825e-05
Gc11_340 0 n22 ns340 0 1.7058410701e-05
Gc11_341 0 n22 ns341 0 -5.71244993331e-05
Gc11_342 0 n22 ns342 0 1.64733219604e-05
Gc11_343 0 n22 ns343 0 0.000353913539027
Gc11_344 0 n22 ns344 0 -0.00259445633506
Gc11_345 0 n22 ns345 0 0.00028764545059
Gc11_346 0 n22 ns346 0 -0.00147558866163
Gc11_347 0 n22 ns347 0 -0.000860467400275
Gc11_348 0 n22 ns348 0 4.81343996712e-05
Gc11_349 0 n22 ns349 0 0.000395285904845
Gc11_350 0 n22 ns350 0 -0.000401867736728
Gc11_351 0 n22 ns351 0 0.000139305740382
Gc11_352 0 n22 ns352 0 -2.1672781893e-05
Gc11_353 0 n22 ns353 0 0.000265587109265
Gc11_354 0 n22 ns354 0 8.14442009311e-05
Gc11_355 0 n22 ns355 0 -0.00027855489514
Gc11_356 0 n22 ns356 0 0.000482022849779
Gc11_357 0 n22 ns357 0 0.000578503100444
Gc11_358 0 n22 ns358 0 4.0763885053e-05
Gc11_359 0 n22 ns359 0 0.00108844999232
Gc11_360 0 n22 ns360 0 0.000159038877448
Gc11_361 0 n22 ns361 0 0.00054602749167
Gc11_362 0 n22 ns362 0 -0.000169937931788
Gc11_363 0 n22 ns363 0 0.000194382962054
Gc11_364 0 n22 ns364 0 0.00154921508798
Gc11_365 0 n22 ns365 0 -8.89717881355e-05
Gc11_366 0 n22 ns366 0 0.0047340964903
Gc11_367 0 n22 ns367 0 -0.000360443045693
Gc11_368 0 n22 ns368 0 0.0050393923899
Gc11_369 0 n22 ns369 0 0.00271870330318
Gc11_370 0 n22 ns370 0 9.16073260376e-05
Gc11_371 0 n22 ns371 0 0.00111454091064
Gc11_372 0 n22 ns372 0 -0.00098163120719
Gc11_373 0 n22 ns373 0 -0.000979464766836
Gc11_374 0 n22 ns374 0 -0.00115494176371
Gc11_375 0 n22 ns375 0 -0.00364332008884
Gc11_376 0 n22 ns376 0 0.000148200089801
Gc11_377 0 n22 ns377 0 0.00316254250816
Gc11_378 0 n22 ns378 0 1.84522477558e-05
Gc11_379 0 n22 ns379 0 -0.000155628036779
Gc11_380 0 n22 ns380 0 1.67757661591e-05
Gc11_381 0 n22 ns381 0 0.000292972708425
Gc11_382 0 n22 ns382 0 -0.002519939395
Gc11_383 0 n22 ns383 0 -0.00199820254279
Gc11_384 0 n22 ns384 0 -0.000146641417067
Gc11_385 0 n22 ns385 0 -0.000671693798915
Gc11_386 0 n22 ns386 0 0.000112844098548
Gc11_387 0 n22 ns387 0 0.000356731784607
Gc11_388 0 n22 ns388 0 -0.000238692096628
Gc11_389 0 n22 ns389 0 -0.000204921439068
Gc11_390 0 n22 ns390 0 0.000303018585862
Gc11_391 0 n22 ns391 0 0.000313994256658
Gc11_392 0 n22 ns392 0 3.96756410045e-05
Gc11_393 0 n22 ns393 0 -0.000358529848684
Gc11_394 0 n22 ns394 0 -0.000308298933725
Gc11_395 0 n22 ns395 0 0.000685235235402
Gc11_396 0 n22 ns396 0 0.00043957812357
Gc11_397 0 n22 ns397 0 0.000671832886584
Gc11_398 0 n22 ns398 0 -0.00013182804994
Gc11_399 0 n22 ns399 0 -0.000105215400446
Gc11_400 0 n22 ns400 0 -0.000918928947712
Gc11_401 0 n22 ns401 0 -0.0010319254554
Gc11_402 0 n22 ns402 0 0.000380794589879
Gc11_403 0 n22 ns403 0 0.00637463620433
Gc11_404 0 n22 ns404 0 0.00637807213507
Gc11_405 0 n22 ns405 0 0.00477158337341
Gc11_406 0 n22 ns406 0 0.00629681971518
Gc11_407 0 n22 ns407 0 0.000783224981538
Gc11_408 0 n22 ns408 0 0.00553773152688
Gc11_409 0 n22 ns409 0 0.00096004306806
Gc11_410 0 n22 ns410 0 -0.000850768767179
Gc11_411 0 n22 ns411 0 -0.0058464755024
Gc11_412 0 n22 ns412 0 -0.00167032993068
Gc11_413 0 n22 ns413 0 0.00283351519932
Gc11_414 0 n22 ns414 0 -0.00451443930477
Gc11_415 0 n22 ns415 0 0.00470432667899
Gc11_416 0 n22 ns416 0 -2.6917690186e-06
Gc11_417 0 n22 ns417 0 0.000110381276359
Gc11_418 0 n22 ns418 0 -0.000160209980481
Gc11_419 0 n22 ns419 0 0.000528619266791
Gc11_420 0 n22 ns420 0 -0.00217086238859
Gc11_421 0 n22 ns421 0 0.0010963185585
Gc11_422 0 n22 ns422 0 -0.000524236930632
Gc11_423 0 n22 ns423 0 -0.000721588814947
Gc11_424 0 n22 ns424 0 0.000238041685245
Gc11_425 0 n22 ns425 0 0.000236099599126
Gc11_426 0 n22 ns426 0 -0.000426930340203
Gc11_427 0 n22 ns427 0 0.000277744733467
Gc11_428 0 n22 ns428 0 0.000424929367301
Gc11_429 0 n22 ns429 0 0.000252231678445
Gc11_430 0 n22 ns430 0 -5.46186069331e-05
Gc11_431 0 n22 ns431 0 -0.000425183420782
Gc11_432 0 n22 ns432 0 -1.81728045477e-05
Gc11_433 0 n22 ns433 0 0.00073419484892
Gc11_434 0 n22 ns434 0 -0.00102576134518
Gc11_435 0 n22 ns435 0 0.000865170640908
Gc11_436 0 n22 ns436 0 -0.000550984437589
Gc11_437 0 n22 ns437 0 0.000471729029444
Gc11_438 0 n22 ns438 0 -0.00107201504399
Gc11_439 0 n22 ns439 0 0.00103233340772
Gc11_440 0 n22 ns440 0 0.00228313546145
Gc11_441 0 n22 ns441 0 0.00332518715745
Gc11_442 0 n22 ns442 0 0.00496711317686
Gc11_443 0 n22 ns443 0 0.00258058164662
Gc11_444 0 n22 ns444 0 0.0050697423618
Gc11_445 0 n22 ns445 0 0.00367856375328
Gc11_446 0 n22 ns446 0 0.00038096685207
Gc11_447 0 n22 ns447 0 0.000890694034037
Gc11_448 0 n22 ns448 0 -0.00097626932888
Gc11_449 0 n22 ns449 0 -0.00194504340835
Gc11_450 0 n22 ns450 0 -0.00131579467423
Gc11_451 0 n22 ns451 0 -0.00393308771798
Gc11_452 0 n22 ns452 0 -0.000324369107698
Gc11_453 0 n22 ns453 0 0.00307887696164
Gc11_454 0 n22 ns454 0 4.99295909274e-05
Gc11_455 0 n22 ns455 0 -0.00019179670378
Gc11_456 0 n22 ns456 0 6.26389399738e-05
Gc11_457 0 n22 ns457 0 2.51905026994e-05
Gc11_458 0 n22 ns458 0 -0.000523792369529
Gc11_459 0 n22 ns459 0 0.000208343716466
Gc11_460 0 n22 ns460 0 -0.00017338739199
Gc11_461 0 n22 ns461 0 -0.000347994204548
Gc11_462 0 n22 ns462 0 0.000390692512492
Gc11_463 0 n22 ns463 0 1.90997996397e-05
Gc11_464 0 n22 ns464 0 -0.000120803178445
Gc11_465 0 n22 ns465 0 0.000310109819913
Gc11_466 0 n22 ns466 0 -0.000137789831069
Gc11_467 0 n22 ns467 0 0.000178173079075
Gc11_468 0 n22 ns468 0 -6.71914350943e-05
Gc11_469 0 n22 ns469 0 6.30601063382e-05
Gc11_470 0 n22 ns470 0 -0.000265065136589
Gc11_471 0 n22 ns471 0 -0.000766739066888
Gc11_472 0 n22 ns472 0 -0.00029752602758
Gc11_473 0 n22 ns473 0 0.000256102936913
Gc11_474 0 n22 ns474 0 -0.000512843520896
Gc11_475 0 n22 ns475 0 -0.000261202864496
Gc11_476 0 n22 ns476 0 -0.000887387004131
Gc11_477 0 n22 ns477 0 0.00116655827644
Gc11_478 0 n22 ns478 0 -0.000799144640299
Gc11_479 0 n22 ns479 0 0.00198166252223
Gc11_480 0 n22 ns480 0 0.00272148369945
Gc11_481 0 n22 ns481 0 0.00183573381244
Gc11_482 0 n22 ns482 0 0.00305503932658
Gc11_483 0 n22 ns483 0 -0.00144460625246
Gc11_484 0 n22 ns484 0 -0.0016276379286
Gc11_485 0 n22 ns485 0 0.000438730981529
Gc11_486 0 n22 ns486 0 -0.00101545001449
Gc11_487 0 n22 ns487 0 0.000381336163634
Gc11_488 0 n22 ns488 0 -0.000534812707662
Gc11_489 0 n22 ns489 0 -0.00138250681164
Gc11_490 0 n22 ns490 0 0.00288329894345
Gc11_491 0 n22 ns491 0 0.00157390192004
Gc11_492 0 n22 ns492 0 1.60184605205e-05
Gc11_493 0 n22 ns493 0 -0.000192861785219
Gc11_494 0 n22 ns494 0 5.84283691847e-05
Gc11_495 0 n22 ns495 0 -0.000140452659079
Gc11_496 0 n22 ns496 0 0.000134226585405
Gc11_497 0 n22 ns497 0 -2.23121404597e-05
Gc11_498 0 n22 ns498 0 0.00101220618611
Gc11_499 0 n22 ns499 0 2.52219258539e-05
Gc11_500 0 n22 ns500 0 0.000176904101333
Gc11_501 0 n22 ns501 0 0.000151656017486
Gc11_502 0 n22 ns502 0 -8.43594973781e-05
Gc11_503 0 n22 ns503 0 -0.0001337673086
Gc11_504 0 n22 ns504 0 -6.80287086222e-05
Gc11_505 0 n22 ns505 0 0.000141794879749
Gc11_506 0 n22 ns506 0 -0.000143187620413
Gc11_507 0 n22 ns507 0 -0.00028428538748
Gc11_508 0 n22 ns508 0 -0.000360356934003
Gc11_509 0 n22 ns509 0 0.00018602001407
Gc11_510 0 n22 ns510 0 0.000493920082058
Gc11_511 0 n22 ns511 0 0.000300813309492
Gc11_512 0 n22 ns512 0 -0.000430436822785
Gc11_513 0 n22 ns513 0 -7.80511334802e-05
Gc11_514 0 n22 ns514 0 -0.000380103568498
Gc11_515 0 n22 ns515 0 -0.000491154609693
Gc11_516 0 n22 ns516 0 -0.000249957713101
Gc11_517 0 n22 ns517 0 0.00208745749538
Gc11_518 0 n22 ns518 0 0.00336729993084
Gc11_519 0 n22 ns519 0 0.00219371553318
Gc11_520 0 n22 ns520 0 0.00316630239939
Gc11_521 0 n22 ns521 0 -0.0011250048472
Gc11_522 0 n22 ns522 0 0.000972090990591
Gc11_523 0 n22 ns523 0 -0.000156751147785
Gc11_524 0 n22 ns524 0 -0.000835479938943
Gc11_525 0 n22 ns525 0 -0.000511685584544
Gc11_526 0 n22 ns526 0 -0.00165637624885
Gc11_527 0 n22 ns527 0 -0.000638892660586
Gc11_528 0 n22 ns528 0 0.000568107550182
Gc11_529 0 n22 ns529 0 0.000455271912713
Gc11_530 0 n22 ns530 0 2.42330164718e-05
Gc11_531 0 n22 ns531 0 -0.000141649381842
Gc11_532 0 n22 ns532 0 1.93602531883e-05
Gc11_533 0 n22 ns533 0 -0.000346614665208
Gc11_534 0 n22 ns534 0 0.000591414184333
Gc11_535 0 n22 ns535 0 -0.000743956557606
Gc11_536 0 n22 ns536 0 0.00142038086644
Gc11_537 0 n22 ns537 0 -0.000229472706524
Gc11_538 0 n22 ns538 0 0.000334661517807
Gc11_539 0 n22 ns539 0 9.63653522509e-05
Gc11_540 0 n22 ns540 0 -0.000241825840065
Gc11_541 0 n22 ns541 0 -0.000141285765456
Gc11_542 0 n22 ns542 0 0.000443027395396
Gc11_543 0 n22 ns543 0 7.42900678026e-05
Gc11_544 0 n22 ns544 0 -0.000153785440811
Gc11_545 0 n22 ns545 0 6.04555207316e-05
Gc11_546 0 n22 ns546 0 -0.000460864556821
Gc11_547 0 n22 ns547 0 0.000820292356474
Gc11_548 0 n22 ns548 0 -0.00046417168688
Gc11_549 0 n22 ns549 0 0.0002085988217
Gc11_550 0 n22 ns550 0 -0.000669098120056
Gc11_551 0 n22 ns551 0 0.000309249435712
Gc11_552 0 n22 ns552 0 -0.000575417694785
Gc11_553 0 n22 ns553 0 -0.000120503101206
Gc11_554 0 n22 ns554 0 0.000923185018681
Gc11_555 0 n22 ns555 0 0.00325154867338
Gc11_556 0 n22 ns556 0 0.00249015404347
Gc11_557 0 n22 ns557 0 0.00305847758598
Gc11_558 0 n22 ns558 0 0.0020500279553
Gc11_559 0 n22 ns559 0 0.000365583215513
Gc11_560 0 n22 ns560 0 0.00136115716476
Gc11_561 0 n22 ns561 0 -0.00034390298246
Gc11_562 0 n22 ns562 0 -0.000466724641809
Gc11_563 0 n22 ns563 0 -0.00126695120641
Gc11_564 0 n22 ns564 0 -0.00137242742082
Gc11_565 0 n22 ns565 0 -0.000548321118909
Gc11_566 0 n22 ns566 0 -0.000504887806031
Gc11_567 0 n22 ns567 0 4.34577664103e-05
Gc11_568 0 n22 ns568 0 2.92018056808e-06
Gc11_569 0 n22 ns569 0 -4.72249692768e-06
Gc11_570 0 n22 ns570 0 -3.69302513715e-05
Gc11_571 0 n22 ns571 0 0.00015204012861
Gc11_572 0 n22 ns572 0 0.000340585653285
Gc11_573 0 n22 ns573 0 0.000700237876677
Gc11_574 0 n22 ns574 0 0.000358025542548
Gc11_575 0 n22 ns575 0 -3.08189933121e-05
Gc11_576 0 n22 ns576 0 9.71874801559e-05
Gc11_577 0 n22 ns577 0 4.526319564e-06
Gc11_578 0 n22 ns578 0 7.26793356034e-06
Gc11_579 0 n22 ns579 0 0.000219305135029
Gc11_580 0 n22 ns580 0 0.000309383802735
Gc11_581 0 n22 ns581 0 -4.14452416296e-05
Gc11_582 0 n22 ns582 0 -9.0683433699e-05
Gc11_583 0 n22 ns583 0 -0.000182990260818
Gc11_584 0 n22 ns584 0 -0.000343594806993
Gc11_585 0 n22 ns585 0 -5.12275515128e-05
Gc11_586 0 n22 ns586 0 -0.000800555065553
Gc11_587 0 n22 ns587 0 -0.000316397608281
Gc11_588 0 n22 ns588 0 -0.000501547839847
Gc11_589 0 n22 ns589 0 -0.000262024716329
Gc11_590 0 n22 ns590 0 -0.000624128841638
Gc11_591 0 n22 ns591 0 0.000644324609071
Gc11_592 0 n22 ns592 0 0.000444834516202
Gc11_593 0 n22 ns593 0 0.00315559216398
Gc11_594 0 n22 ns594 0 -0.000186337214302
Gc11_595 0 n22 ns595 0 0.00276152906676
Gc11_596 0 n22 ns596 0 -0.000284609377978
Gc11_597 0 n22 ns597 0 0.000583238021439
Gc11_598 0 n22 ns598 0 0.000498429790083
Gc11_599 0 n22 ns599 0 -0.000239843942112
Gc11_600 0 n22 ns600 0 -0.000176104011639
Gc11_601 0 n22 ns601 0 -0.000988843787265
Gc11_602 0 n22 ns602 0 -0.0004894528847
Gc11_603 0 n22 ns603 0 -0.000406672719067
Gc11_604 0 n22 ns604 0 -0.00024400803697
Gc11_605 0 n22 ns605 0 5.03143543561e-05
Gc11_606 0 n22 ns606 0 1.18386029738e-05
Gc11_607 0 n22 ns607 0 -1.6797611129e-05
Gc11_608 0 n22 ns608 0 -7.29337321454e-06
Gc11_609 0 n22 ns609 0 -0.000397947148471
Gc11_610 0 n22 ns610 0 9.83915497195e-05
Gc11_611 0 n22 ns611 0 -0.001147374431
Gc11_612 0 n22 ns612 0 0.00151017406691
Gc11_613 0 n22 ns613 0 -7.76844598777e-05
Gc11_614 0 n22 ns614 0 0.000126294787262
Gc11_615 0 n22 ns615 0 8.21602905817e-05
Gc11_616 0 n22 ns616 0 -0.00026559879806
Gc11_617 0 n22 ns617 0 -0.00069463575086
Gc11_618 0 n22 ns618 0 0.000663531123892
Gc11_619 0 n22 ns619 0 -4.06198399928e-05
Gc11_620 0 n22 ns620 0 -1.37132571914e-05
Gc11_621 0 n22 ns621 0 0.000975808861122
Gc11_622 0 n22 ns622 0 -0.00078463808234
Gc11_623 0 n22 ns623 0 -0.00102054583921
Gc11_624 0 n22 ns624 0 8.51813931536e-05
Gc11_625 0 n22 ns625 0 0.000446664017074
Gc11_626 0 n22 ns626 0 0.000291722167159
Gc11_627 0 n22 ns627 0 3.63931081486e-06
Gc11_628 0 n22 ns628 0 8.96042027733e-05
Gc11_629 0 n22 ns629 0 -0.000973942807757
Gc11_630 0 n22 ns630 0 0.00135809311863
Gc11_631 0 n22 ns631 0 0.00215249202907
Gc11_632 0 n22 ns632 0 -0.00150651101231
Gc11_633 0 n22 ns633 0 0.00188664486839
Gc11_634 0 n22 ns634 0 -0.00218066897808
Gc11_635 0 n22 ns635 0 -0.000916987016856
Gc11_636 0 n22 ns636 0 -0.000871781192417
Gc11_637 0 n22 ns637 0 0.000708378723277
Gc11_638 0 n22 ns638 0 -0.00107597425273
Gc11_639 0 n22 ns639 0 0.0010872646844
Gc11_640 0 n22 ns640 0 -0.00162059972792
Gc11_641 0 n22 ns641 0 0.00138758116438
Gc11_642 0 n22 ns642 0 -0.00215557297631
Gc11_643 0 n22 ns643 0 -0.00140345585597
Gc11_644 0 n22 ns644 0 -3.13715507561e-05
Gc11_645 0 n22 ns645 0 0.00013278481045
Gc11_646 0 n22 ns646 0 -1.23766587663e-05
Gc11_647 0 n22 ns647 0 -0.000759082392747
Gc11_648 0 n22 ns648 0 -6.52230447817e-05
Gc11_649 0 n22 ns649 0 -0.00245143584733
Gc11_650 0 n22 ns650 0 0.00143146573033
Gc11_651 0 n22 ns651 0 -0.000418081464429
Gc11_652 0 n22 ns652 0 0.000638479580747
Gc11_653 0 n22 ns653 0 0.000244858419865
Gc11_654 0 n22 ns654 0 -0.000384508247312
Gc11_655 0 n22 ns655 0 -0.000660333142641
Gc11_656 0 n22 ns656 0 0.00070247638599
Gc11_657 0 n22 ns657 0 -9.46066769701e-05
Gc11_658 0 n22 ns658 0 -3.95480697221e-05
Gc11_659 0 n22 ns659 0 0.000960449809178
Gc11_660 0 n22 ns660 0 -0.000637800573712
Gc11_661 0 n22 ns661 0 -0.000652541986772
Gc11_662 0 n22 ns662 0 -0.00014596323439
Gc11_663 0 n22 ns663 0 0.000756278686986
Gc11_664 0 n22 ns664 0 0.000198920792876
Gc11_665 0 n22 ns665 0 0.000370055845111
Gc11_666 0 n22 ns666 0 -9.45923099576e-05
Gc11_667 0 n22 ns667 0 -0.00147210307297
Gc11_668 0 n22 ns668 0 0.00108142981265
Gc11_669 0 n22 ns669 0 0.000610296807891
Gc11_670 0 n22 ns670 0 -0.00192679582541
Gc11_671 0 n22 ns671 0 0.00069296825011
Gc11_672 0 n22 ns672 0 -0.00268143848337
Gc11_673 0 n22 ns673 0 -0.000168437479978
Gc11_674 0 n22 ns674 0 -0.0007139271269
Gc11_675 0 n22 ns675 0 0.000900383357006
Gc11_676 0 n22 ns676 0 -0.00120330448706
Gc11_677 0 n22 ns677 0 0.000857785206751
Gc11_678 0 n22 ns678 0 -0.00183049387223
Gc11_679 0 n22 ns679 0 0.00198767841938
Gc11_680 0 n22 ns680 0 -0.00254684640524
Gc11_681 0 n22 ns681 0 -0.00202056410417
Gc11_682 0 n22 ns682 0 -2.61280148191e-05
Gc11_683 0 n22 ns683 0 0.000114841119191
Gc11_684 0 n22 ns684 0 -1.25042676388e-05
Gc11_685 0 n22 ns685 0 0.00127731282665
Gc11_686 0 n22 ns686 0 -0.00281894209472
Gc11_687 0 n22 ns687 0 0.00238220128778
Gc11_688 0 n22 ns688 0 -0.00469325496177
Gc11_689 0 n22 ns689 0 -0.00236964116464
Gc11_690 0 n22 ns690 0 -0.00138976492711
Gc11_691 0 n22 ns691 0 0.000835283952648
Gc11_692 0 n22 ns692 0 0.000582865210148
Gc11_693 0 n22 ns693 0 -0.000211282817167
Gc11_694 0 n22 ns694 0 -0.000209503616269
Gc11_695 0 n22 ns695 0 -0.000300686566121
Gc11_696 0 n22 ns696 0 -7.71539135619e-05
Gc11_697 0 n22 ns697 0 -0.000319597947757
Gc11_698 0 n22 ns698 0 0.000162063301219
Gc11_699 0 n22 ns699 0 0.00128989462436
Gc11_700 0 n22 ns700 0 -1.99553556559e-05
Gc11_701 0 n22 ns701 0 0.00127338355133
Gc11_702 0 n22 ns702 0 0.000151497896794
Gc11_703 0 n22 ns703 0 0.000830455600002
Gc11_704 0 n22 ns704 0 -2.97072642908e-05
Gc11_705 0 n22 ns705 0 -0.000344789691902
Gc11_706 0 n22 ns706 0 -0.00206161337245
Gc11_707 0 n22 ns707 0 -0.00308683415714
Gc11_708 0 n22 ns708 0 -0.00580919407147
Gc11_709 0 n22 ns709 0 -0.00219850587526
Gc11_710 0 n22 ns710 0 -0.00588062219648
Gc11_711 0 n22 ns711 0 0.00390245288907
Gc11_712 0 n22 ns712 0 0.00359172480248
Gc11_713 0 n22 ns713 0 0.00109313492521
Gc11_714 0 n22 ns714 0 -0.00112102431007
Gc11_715 0 n22 ns715 0 -0.00258399589484
Gc11_716 0 n22 ns716 0 -0.00314223982981
Gc11_717 0 n22 ns717 0 0.00235033629803
Gc11_718 0 n22 ns718 0 0.00171986598379
Gc11_719 0 n22 ns719 0 -0.00372604223796
Gc11_720 0 n22 ns720 0 1.27399837417e-05
Gc11_721 0 n22 ns721 0 0.000246746801643
Gc11_722 0 n22 ns722 0 -0.000119377157488
Gc11_723 0 n22 ns723 0 0.0021296057683
Gc11_724 0 n22 ns724 0 -0.00318304769967
Gc11_725 0 n22 ns725 0 0.00466217777326
Gc11_726 0 n22 ns726 0 -0.00648606946338
Gc11_727 0 n22 ns727 0 -0.00338749081495
Gc11_728 0 n22 ns728 0 -0.00227185890214
Gc11_729 0 n22 ns729 0 0.00120438430519
Gc11_730 0 n22 ns730 0 0.000660776183055
Gc11_731 0 n22 ns731 0 -0.000280810883407
Gc11_732 0 n22 ns732 0 -0.000540083854102
Gc11_733 0 n22 ns733 0 -0.000276251544715
Gc11_734 0 n22 ns734 0 6.62270735554e-06
Gc11_735 0 n22 ns735 0 -0.00039810931916
Gc11_736 0 n22 ns736 0 -0.000338764029021
Gc11_737 0 n22 ns737 0 0.00147537115344
Gc11_738 0 n22 ns738 0 5.27543232272e-05
Gc11_739 0 n22 ns739 0 0.00102651647713
Gc11_740 0 n22 ns740 0 0.000225959122021
Gc11_741 0 n22 ns741 0 0.000426478952124
Gc11_742 0 n22 ns742 0 0.000420122865493
Gc11_743 0 n22 ns743 0 0.000876595153754
Gc11_744 0 n22 ns744 0 -0.00304612761199
Gc11_745 0 n22 ns745 0 -0.00224068378164
Gc11_746 0 n22 ns746 0 -0.00807560223734
Gc11_747 0 n22 ns747 0 -0.00156979166091
Gc11_748 0 n22 ns748 0 -0.00755873688071
Gc11_749 0 n22 ns749 0 0.00536145295291
Gc11_750 0 n22 ns750 0 0.00809247940683
Gc11_751 0 n22 ns751 0 0.000821590345266
Gc11_752 0 n22 ns752 0 -0.00122174996386
Gc11_753 0 n22 ns753 0 -0.00523953007477
Gc11_754 0 n22 ns754 0 -0.00598775752244
Gc11_755 0 n22 ns755 0 0.00146575118826
Gc11_756 0 n22 ns756 0 0.00530811182257
Gc11_757 0 n22 ns757 0 -0.00429759318673
Gc11_758 0 n22 ns758 0 2.4455024466e-06
Gc11_759 0 n22 ns759 0 0.000434159258727
Gc11_760 0 n22 ns760 0 -0.000239159813462
Gc11_761 0 n22 ns761 0 -0.00103891539964
Gc11_762 0 n22 ns762 0 5.66495335856e-05
Gc11_763 0 n22 ns763 0 -0.00308826406189
Gc11_764 0 n22 ns764 0 0.00148441838803
Gc11_765 0 n22 ns765 0 -0.000327488047188
Gc11_766 0 n22 ns766 0 0.001132659656
Gc11_767 0 n22 ns767 0 0.00022055039068
Gc11_768 0 n22 ns768 0 -0.000491304555241
Gc11_769 0 n22 ns769 0 -0.000375592540926
Gc11_770 0 n22 ns770 0 0.000140386756375
Gc11_771 0 n22 ns771 0 -0.000156596833134
Gc11_772 0 n22 ns772 0 9.58101944758e-05
Gc11_773 0 n22 ns773 0 0.00094333411124
Gc11_774 0 n22 ns774 0 0.000127706830563
Gc11_775 0 n22 ns775 0 0.000325666078766
Gc11_776 0 n22 ns776 0 -0.000823572392662
Gc11_777 0 n22 ns777 0 0.000751554080762
Gc11_778 0 n22 ns778 0 -0.000476378062734
Gc11_779 0 n22 ns779 0 0.000456962777997
Gc11_780 0 n22 ns780 0 -0.000828996063689
Gc11_781 0 n22 ns781 0 -0.0023092241127
Gc11_782 0 n22 ns782 0 -6.47992045104e-05
Gc11_783 0 n22 ns783 0 -0.00607050419506
Gc11_784 0 n22 ns784 0 -0.00215208147382
Gc11_785 0 n22 ns785 0 -0.00494075172943
Gc11_786 0 n22 ns786 0 -0.00271333975261
Gc11_787 0 n22 ns787 0 0.00173501609883
Gc11_788 0 n22 ns788 0 0.000165570327769
Gc11_789 0 n22 ns789 0 0.000786251613452
Gc11_790 0 n22 ns790 0 -0.00118058085678
Gc11_791 0 n22 ns791 0 -0.000503971600459
Gc11_792 0 n22 ns792 0 -0.00192601143683
Gc11_793 0 n22 ns793 0 0.00240477902424
Gc11_794 0 n22 ns794 0 -0.0026166969939
Gc11_795 0 n22 ns795 0 -0.00252541521085
Gc11_796 0 n22 ns796 0 -9.19671793745e-06
Gc11_797 0 n22 ns797 0 0.000198139082209
Gc11_798 0 n22 ns798 0 -5.1977572563e-05
Gc11_799 0 n22 ns799 0 0.000290351256912
Gc11_800 0 n22 ns800 0 -0.000726873168613
Gc11_801 0 n22 ns801 0 0.000895686946148
Gc11_802 0 n22 ns802 0 5.93117885981e-05
Gc11_803 0 n22 ns803 0 4.61810937854e-05
Gc11_804 0 n22 ns804 0 -0.000294933719835
Gc11_805 0 n22 ns805 0 -7.80957892642e-05
Gc11_806 0 n22 ns806 0 2.64672040181e-05
Gc11_807 0 n22 ns807 0 -0.000168008544628
Gc11_808 0 n22 ns808 0 0.000305337546234
Gc11_809 0 n22 ns809 0 -0.000100335733773
Gc11_810 0 n22 ns810 0 0.000121296405884
Gc11_811 0 n22 ns811 0 0.000420737528454
Gc11_812 0 n22 ns812 0 -0.000355499176096
Gc11_813 0 n22 ns813 0 -0.000389107121699
Gc11_814 0 n22 ns814 0 0.000397408218914
Gc11_815 0 n22 ns815 0 0.000278962896583
Gc11_816 0 n22 ns816 0 -0.000169845486284
Gc11_817 0 n22 ns817 0 -0.000232336392668
Gc11_818 0 n22 ns818 0 -8.43053604105e-05
Gc11_819 0 n22 ns819 0 -0.000444170124839
Gc11_820 0 n22 ns820 0 0.000714329795325
Gc11_821 0 n22 ns821 0 -0.00227134571201
Gc11_822 0 n22 ns822 0 -0.00321682474895
Gc11_823 0 n22 ns823 0 -0.00223052895089
Gc11_824 0 n22 ns824 0 -0.00332464989823
Gc11_825 0 n22 ns825 0 -0.000678986016325
Gc11_826 0 n22 ns826 0 0.00117486381936
Gc11_827 0 n22 ns827 0 7.905038844e-05
Gc11_828 0 n22 ns828 0 -0.00120729228217
Gc11_829 0 n22 ns829 0 -0.000323938389484
Gc11_830 0 n22 ns830 0 -0.00284236749552
Gc11_831 0 n22 ns831 0 0.0005440899645
Gc11_832 0 n22 ns832 0 -0.0028011573225
Gc11_833 0 n22 ns833 0 -0.00114288125913
Gc11_834 0 n22 ns834 0 -3.35585563099e-05
Gc11_835 0 n22 ns835 0 9.53839928455e-05
Gc11_836 0 n22 ns836 0 -1.34712757848e-06
Gc11_837 0 n22 ns837 0 -2.01664049837e-05
Gc11_838 0 n22 ns838 0 0.0002118477428
Gc11_839 0 n22 ns839 0 0.000245938311013
Gc11_840 0 n22 ns840 0 0.000335756019793
Gc11_841 0 n22 ns841 0 -2.3513479776e-05
Gc11_842 0 n22 ns842 0 0.000203173955268
Gc11_843 0 n22 ns843 0 -4.43599431181e-05
Gc11_844 0 n22 ns844 0 -2.65963460489e-05
Gc11_845 0 n22 ns845 0 0.000449507519458
Gc11_846 0 n22 ns846 0 9.50754354351e-05
Gc11_847 0 n22 ns847 0 -6.49806879605e-05
Gc11_848 0 n22 ns848 0 6.0171567103e-05
Gc11_849 0 n22 ns849 0 -0.000331531758606
Gc11_850 0 n22 ns850 0 -9.1856530067e-05
Gc11_851 0 n22 ns851 0 0.000487312446709
Gc11_852 0 n22 ns852 0 0.000283839343145
Gc11_853 0 n22 ns853 0 0.00027758434847
Gc11_854 0 n22 ns854 0 -0.000431309065442
Gc11_855 0 n22 ns855 0 0.000139418560621
Gc11_856 0 n22 ns856 0 -0.000280156023382
Gc11_857 0 n22 ns857 0 5.38288641886e-05
Gc11_858 0 n22 ns858 0 -3.15889800441e-05
Gc11_859 0 n22 ns859 0 -0.00444150981995
Gc11_860 0 n22 ns860 0 -0.00303146812389
Gc11_861 0 n22 ns861 0 -0.00413118785917
Gc11_862 0 n22 ns862 0 -0.00272951468694
Gc11_863 0 n22 ns863 0 0.000145805770792
Gc11_864 0 n22 ns864 0 0.00204073326431
Gc11_865 0 n22 ns865 0 -0.000356522615936
Gc11_866 0 n22 ns866 0 -0.000759853915006
Gc11_867 0 n22 ns867 0 -0.00130189358684
Gc11_868 0 n22 ns868 0 -0.00229953525024
Gc11_869 0 n22 ns869 0 -0.000117071305185
Gc11_870 0 n22 ns870 0 -0.00185522723202
Gc11_871 0 n22 ns871 0 -0.000575466846081
Gc11_872 0 n22 ns872 0 -1.22188216298e-05
Gc11_873 0 n22 ns873 0 4.00561372283e-05
Gc11_874 0 n22 ns874 0 1.05904018369e-05
Gc11_875 0 n22 ns875 0 0.000427756074041
Gc11_876 0 n22 ns876 0 -0.000184602335889
Gc11_877 0 n22 ns877 0 0.00132377499849
Gc11_878 0 n22 ns878 0 -0.00046281003069
Gc11_879 0 n22 ns879 0 0.000357433621909
Gc11_880 0 n22 ns880 0 -6.62420137009e-05
Gc11_881 0 n22 ns881 0 -0.000154670228154
Gc11_882 0 n22 ns882 0 1.50390962886e-05
Gc11_883 0 n22 ns883 0 4.91011174099e-05
Gc11_884 0 n22 ns884 0 -0.000508435340567
Gc11_885 0 n22 ns885 0 -2.65472064256e-05
Gc11_886 0 n22 ns886 0 0.000128884270954
Gc11_887 0 n22 ns887 0 3.91895947988e-05
Gc11_888 0 n22 ns888 0 0.000403337189268
Gc11_889 0 n22 ns889 0 0.000193083908981
Gc11_890 0 n22 ns890 0 -0.000391611212528
Gc11_891 0 n22 ns891 0 -0.000290208902944
Gc11_892 0 n22 ns892 0 -0.000474283209773
Gc11_893 0 n22 ns893 0 -0.000435672066591
Gc11_894 0 n22 ns894 0 -0.000439444866979
Gc11_895 0 n22 ns895 0 -0.000198128095372
Gc11_896 0 n22 ns896 0 -0.000419449276931
Gc11_897 0 n22 ns897 0 -0.00443593663679
Gc11_898 0 n22 ns898 0 -0.000482774787735
Gc11_899 0 n22 ns899 0 -0.00396521699568
Gc11_900 0 n22 ns900 0 -0.00034547903857
Gc11_901 0 n22 ns901 0 0.000705898698877
Gc11_902 0 n22 ns902 0 0.00134990637513
Gc11_903 0 n22 ns903 0 -0.000357858919172
Gc11_904 0 n22 ns904 0 -0.000355166885695
Gc11_905 0 n22 ns905 0 -0.00134535358313
Gc11_906 0 n22 ns906 0 -0.00115417947045
Gc11_907 0 n22 ns907 0 -0.000228579609354
Gc11_908 0 n22 ns908 0 -0.000821659981199
Gc11_909 0 n22 ns909 0 -0.000239787973333
Gc11_910 0 n22 ns910 0 -7.33548726674e-06
Gc11_911 0 n22 ns911 0 -1.58069548051e-05
Gc11_912 0 n22 ns912 0 5.31744851001e-05
Gc11_913 0 n22 ns913 0 -0.000491220319123
Gc11_914 0 n22 ns914 0 0.000959020622247
Gc11_915 0 n22 ns915 0 -0.00134912251304
Gc11_916 0 n22 ns916 0 0.00134536605944
Gc11_917 0 n22 ns917 0 -0.000130737288443
Gc11_918 0 n22 ns918 0 0.00045465383767
Gc11_919 0 n22 ns919 0 4.90114690648e-05
Gc11_920 0 n22 ns920 0 -0.000300356033273
Gc11_921 0 n22 ns921 0 -0.000220133853077
Gc11_922 0 n22 ns922 0 1.32496465514e-05
Gc11_923 0 n22 ns923 0 0.000129115792949
Gc11_924 0 n22 ns924 0 7.14095228941e-05
Gc11_925 0 n22 ns925 0 0.000505989330464
Gc11_926 0 n22 ns926 0 -0.000451744060892
Gc11_927 0 n22 ns927 0 5.15978398635e-05
Gc11_928 0 n22 ns928 0 -0.000565377614946
Gc11_929 0 n22 ns929 0 -0.000277949406827
Gc11_930 0 n22 ns930 0 -0.000244310986603
Gc11_931 0 n22 ns931 0 -0.000286923144121
Gc11_932 0 n22 ns932 0 -0.000167061066815
Gc11_933 0 n22 ns933 0 -0.000569874911657
Gc11_934 0 n22 ns934 0 -8.08316616821e-05
Gc11_935 0 n22 ns935 0 -0.00322900663704
Gc11_936 0 n22 ns936 0 0.00102452585406
Gc11_937 0 n22 ns937 0 -0.00278262582054
Gc11_938 0 n22 ns938 0 0.000948741856897
Gc11_939 0 n22 ns939 0 0.000397631391816
Gc11_940 0 n22 ns940 0 0.000940889103026
Gc11_941 0 n22 ns941 0 -0.000204180951198
Gc11_942 0 n22 ns942 0 -0.000187822397476
Gc11_943 0 n22 ns943 0 -0.000707810671355
Gc11_944 0 n22 ns944 0 -0.000699529223249
Gc11_945 0 n22 ns945 0 -7.81515949567e-05
Gc11_946 0 n22 ns946 0 -0.000421019659692
Gc11_947 0 n22 ns947 0 -0.000142531424694
Gc11_948 0 n22 ns948 0 -1.6851532158e-05
Gc11_949 0 n22 ns949 0 4.70670073693e-05
Gc11_950 0 n22 ns950 0 3.67145972406e-06
Gc11_951 0 n22 ns951 0 -0.000757911802636
Gc11_952 0 n22 ns952 0 -0.000896199920179
Gc11_953 0 n22 ns953 0 -0.00330573739266
Gc11_954 0 n22 ns954 0 -0.00145405538924
Gc11_955 0 n22 ns955 0 -0.00183818291068
Gc11_956 0 n22 ns956 0 0.00104632090072
Gc11_957 0 n22 ns957 0 0.000726556530735
Gc11_958 0 n22 ns958 0 -0.000361763126179
Gc11_959 0 n22 ns959 0 -0.000280464998927
Gc11_960 0 n22 ns960 0 0.000456951394128
Gc11_961 0 n22 ns961 0 -0.00021369471402
Gc11_962 0 n22 ns962 0 -0.00010201940285
Gc11_963 0 n22 ns963 0 0.000210527899242
Gc11_964 0 n22 ns964 0 -1.27456551796e-05
Gc11_965 0 n22 ns965 0 0.000773376280103
Gc11_966 0 n22 ns966 0 -0.000362256613581
Gc11_967 0 n22 ns967 0 0.00138903849524
Gc11_968 0 n22 ns968 0 -6.77087529473e-06
Gc11_969 0 n22 ns969 0 0.00127147376034
Gc11_970 0 n22 ns970 0 -0.000346848146388
Gc11_971 0 n22 ns971 0 -0.00160191761074
Gc11_972 0 n22 ns972 0 -0.000624185741918
Gc11_973 0 n22 ns973 0 -0.00272688456122
Gc11_974 0 n22 ns974 0 -0.00417006193875
Gc11_975 0 n22 ns975 0 -0.001914750085
Gc11_976 0 n22 ns976 0 -0.00453853576505
Gc11_977 0 n22 ns977 0 0.00283976089698
Gc11_978 0 n22 ns978 0 0.0012628359798
Gc11_979 0 n22 ns979 0 0.00106480613819
Gc11_980 0 n22 ns980 0 -0.00115867860557
Gc11_981 0 n22 ns981 0 -0.00135812737403
Gc11_982 0 n22 ns982 0 -0.0025702195077
Gc11_983 0 n22 ns983 0 0.00266472677096
Gc11_984 0 n22 ns984 0 -0.000281302627955
Gc11_985 0 n22 ns985 0 -0.00316135818988
Gc11_986 0 n22 ns986 0 -3.02315818497e-05
Gc11_987 0 n22 ns987 0 0.000274413196926
Gc11_988 0 n22 ns988 0 -0.000132257988796
Gc11_989 0 n22 ns989 0 -0.000511429877674
Gc11_990 0 n22 ns990 0 -0.00012421967302
Gc11_991 0 n22 ns991 0 0.000455016709482
Gc11_992 0 n22 ns992 0 0.00306289840396
Gc11_993 0 n22 ns993 0 0.00131251603764
Gc11_994 0 n22 ns994 0 -0.000835513249155
Gc11_995 0 n22 ns995 0 -0.000291438273566
Gc11_996 0 n22 ns996 0 2.85735321793e-05
Gc11_997 0 n22 ns997 0 0.000402572759793
Gc11_998 0 n22 ns998 0 0.000221033322222
Gc11_999 0 n22 ns999 0 -0.000194334797
Gc11_1000 0 n22 ns1000 0 -1.90918631087e-05
Gc11_1001 0 n22 ns1001 0 0.00181813105036
Gc11_1002 0 n22 ns1002 0 -0.000783177052509
Gc11_1003 0 n22 ns1003 0 -0.00017093892831
Gc11_1004 0 n22 ns1004 0 0.00135202439347
Gc11_1005 0 n22 ns1005 0 -9.79380489283e-05
Gc11_1006 0 n22 ns1006 0 -9.66377988313e-05
Gc11_1007 0 n22 ns1007 0 -0.0016758165044
Gc11_1008 0 n22 ns1008 0 -0.00144777403337
Gc11_1009 0 n22 ns1009 0 0.00323024270312
Gc11_1010 0 n22 ns1010 0 0.00371755265635
Gc11_1011 0 n22 ns1011 0 -0.00947980514086
Gc11_1012 0 n22 ns1012 0 -0.000953691288374
Gc11_1013 0 n22 ns1013 0 -0.00720893173127
Gc11_1014 0 n22 ns1014 0 -0.00207825760397
Gc11_1015 0 n22 ns1015 0 -0.0111791333636
Gc11_1016 0 n22 ns1016 0 -0.000343482175927
Gc11_1017 0 n22 ns1017 0 0.0015193088741
Gc11_1018 0 n22 ns1018 0 -1.69610492589e-05
Gc11_1019 0 n22 ns1019 0 -0.00327598964423
Gc11_1020 0 n22 ns1020 0 0.00837678496031
Gc11_1021 0 n22 ns1021 0 -0.0141830309503
Gc11_1022 0 n22 ns1022 0 -0.0040978404656
Gc11_1023 0 n22 ns1023 0 -0.00626009851656
Gc11_1024 0 n22 ns1024 0 -6.18522893707e-05
Gc11_1025 0 n22 ns1025 0 -0.000388425211143
Gc11_1026 0 n22 ns1026 0 0.000610160302597
Gc11_1027 0 n22 ns1027 0 -0.00133328683618
Gc11_1028 0 n22 ns1028 0 -5.96278577578e-05
Gc11_1029 0 n22 ns1029 0 -0.00472630926844
Gc11_1030 0 n22 ns1030 0 -0.000592557420002
Gc11_1031 0 n22 ns1031 0 -0.00211159117942
Gc11_1032 0 n22 ns1032 0 0.00146790999433
Gc11_1033 0 n22 ns1033 0 0.000955171812943
Gc11_1034 0 n22 ns1034 0 -0.000670353383024
Gc11_1035 0 n22 ns1035 0 -0.000350343052281
Gc11_1036 0 n22 ns1036 0 0.000158175391452
Gc11_1037 0 n22 ns1037 0 -0.000164468635755
Gc11_1038 0 n22 ns1038 0 5.90621010369e-05
Gc11_1039 0 n22 ns1039 0 0.000848353948674
Gc11_1040 0 n22 ns1040 0 -2.8241829302e-05
Gc11_1041 0 n22 ns1041 0 0.0011125652893
Gc11_1042 0 n22 ns1042 0 -0.00102381578625
Gc11_1043 0 n22 ns1043 0 0.00114831573587
Gc11_1044 0 n22 ns1044 0 -0.00043385399734
Gc11_1045 0 n22 ns1045 0 0.0010102501297
Gc11_1046 0 n22 ns1046 0 -0.000699894653826
Gc11_1047 0 n22 ns1047 0 -0.00219268186027
Gc11_1048 0 n22 ns1048 0 -0.000856103997341
Gc11_1049 0 n22 ns1049 0 -0.00647608743502
Gc11_1050 0 n22 ns1050 0 -0.00321312852323
Gc11_1051 0 n22 ns1051 0 -0.00514619085069
Gc11_1052 0 n22 ns1052 0 -0.00361206491884
Gc11_1053 0 n22 ns1053 0 0.00336087172817
Gc11_1054 0 n22 ns1054 0 0.00220214710016
Gc11_1055 0 n22 ns1055 0 0.000861248449567
Gc11_1056 0 n22 ns1056 0 -0.00123311600532
Gc11_1057 0 n22 ns1057 0 -0.00202443384686
Gc11_1058 0 n22 ns1058 0 -0.00310741904997
Gc11_1059 0 n22 ns1059 0 0.00248611189386
Gc11_1060 0 n22 ns1060 0 -0.000705242381407
Gc11_1061 0 n22 ns1061 0 -0.00322061720515
Gc11_1062 0 n22 ns1062 0 -4.79641588354e-05
Gc11_1063 0 n22 ns1063 0 0.000383949812556
Gc11_1064 0 n22 ns1064 0 -0.000176631499012
Gc11_1065 0 n22 ns1065 0 7.72235099491e-05
Gc11_1066 0 n22 ns1066 0 -0.000552539830221
Gc11_1067 0 n22 ns1067 0 0.000356348541722
Gc11_1068 0 n22 ns1068 0 0.000999704007071
Gc11_1069 0 n22 ns1069 0 0.000193882715169
Gc11_1070 0 n22 ns1070 0 4.90419754077e-05
Gc11_1071 0 n22 ns1071 0 -7.04063778615e-05
Gc11_1072 0 n22 ns1072 0 -0.000152618614822
Gc11_1073 0 n22 ns1073 0 -0.000342305078728
Gc11_1074 0 n22 ns1074 0 0.000268551691336
Gc11_1075 0 n22 ns1075 0 -0.000117670016309
Gc11_1076 0 n22 ns1076 0 0.000114369573605
Gc11_1077 0 n22 ns1077 0 0.000728987495482
Gc11_1078 0 n22 ns1078 0 -0.000337927214242
Gc11_1079 0 n22 ns1079 0 -0.000485964425027
Gc11_1080 0 n22 ns1080 0 -0.000114034887444
Gc11_1081 0 n22 ns1081 0 0.000349375177368
Gc11_1082 0 n22 ns1082 0 -0.000307638090071
Gc11_1083 0 n22 ns1083 0 -0.000196744952653
Gc11_1084 0 n22 ns1084 0 -0.000435831224581
Gc11_1085 0 n22 ns1085 0 -0.00100967417187
Gc11_1086 0 n22 ns1086 0 0.00087921827053
Gc11_1087 0 n22 ns1087 0 -0.00267287519636
Gc11_1088 0 n22 ns1088 0 -0.00224664686376
Gc11_1089 0 n22 ns1089 0 -0.00244444846984
Gc11_1090 0 n22 ns1090 0 -0.00268694408441
Gc11_1091 0 n22 ns1091 0 -0.000155020663968
Gc11_1092 0 n22 ns1092 0 0.000740845561201
Gc11_1093 0 n22 ns1093 0 0.000291025755494
Gc11_1094 0 n22 ns1094 0 -0.00129850443533
Gc11_1095 0 n22 ns1095 0 -0.000253209027344
Gc11_1096 0 n22 ns1096 0 -0.00276340586542
Gc11_1097 0 n22 ns1097 0 0.000998889111225
Gc11_1098 0 n22 ns1098 0 -0.00320513000062
Gc11_1099 0 n22 ns1099 0 -0.00155637226018
Gc11_1100 0 n22 ns1100 0 -2.41475842519e-05
Gc11_1101 0 n22 ns1101 0 0.000103557261211
Gc11_1102 0 n22 ns1102 0 7.66429434652e-07
Gc11_1103 0 n22 ns1103 0 -0.000135632010252
Gc11_1104 0 n22 ns1104 0 0.000133213332355
Gc11_1105 0 n22 ns1105 0 -0.000101042014665
Gc11_1106 0 n22 ns1106 0 0.000565701880893
Gc11_1107 0 n22 ns1107 0 -0.00018342582403
Gc11_1108 0 n22 ns1108 0 0.000194152594762
Gc11_1109 0 n22 ns1109 0 -1.00023556555e-05
Gc11_1110 0 n22 ns1110 0 -8.70799015844e-05
Gc11_1111 0 n22 ns1111 0 0.000343029343697
Gc11_1112 0 n22 ns1112 0 0.00036335826
Gc11_1113 0 n22 ns1113 0 -6.77388425516e-05
Gc11_1114 0 n22 ns1114 0 6.06747759937e-05
Gc11_1115 0 n22 ns1115 0 -0.000171027156969
Gc11_1116 0 n22 ns1116 0 -0.000395689824616
Gc11_1117 0 n22 ns1117 0 0.000308727481443
Gc11_1118 0 n22 ns1118 0 0.000523978041515
Gc11_1119 0 n22 ns1119 0 0.000416413391062
Gc11_1120 0 n22 ns1120 0 -0.000313022874175
Gc11_1121 0 n22 ns1121 0 0.000188047813083
Gc11_1122 0 n22 ns1122 0 -0.00011499922428
Gc11_1123 0 n22 ns1123 0 -3.2566360413e-05
Gc11_1124 0 n22 ns1124 0 0.000266370131521
Gc11_1125 0 n22 ns1125 0 -0.00395567524455
Gc11_1126 0 n22 ns1126 0 -0.0036560115678
Gc11_1127 0 n22 ns1127 0 -0.00374901538609
Gc11_1128 0 n22 ns1128 0 -0.00340814552134
Gc11_1129 0 n22 ns1129 0 -0.00023805179475
Gc11_1130 0 n22 ns1130 0 0.00205096514143
Gc11_1131 0 n22 ns1131 0 -0.000263143131605
Gc11_1132 0 n22 ns1132 0 -0.000955890164954
Gc11_1133 0 n22 ns1133 0 -0.00104380081623
Gc11_1134 0 n22 ns1134 0 -0.00271028651575
Gc11_1135 0 n22 ns1135 0 3.09761074157e-05
Gc11_1136 0 n22 ns1136 0 -0.00224736854143
Gc11_1137 0 n22 ns1137 0 -0.000746921209686
Gc11_1138 0 n22 ns1138 0 -1.79805454337e-05
Gc11_1139 0 n22 ns1139 0 8.41860420467e-05
Gc11_1140 0 n22 ns1140 0 -1.31467791839e-05
Gc11_1141 0 n22 ns1141 0 0.000341523606315
Gc11_1142 0 n22 ns1142 0 -0.000184436877662
Gc11_1143 0 n22 ns1143 0 0.0012568444896
Gc11_1144 0 n22 ns1144 0 -0.00042139325962
Gc11_1145 0 n22 ns1145 0 0.000233779669039
Gc11_1146 0 n22 ns1146 0 -3.52749480404e-05
Gc11_1147 0 n22 ns1147 0 -7.82309299064e-05
Gc11_1148 0 n22 ns1148 0 5.81710295156e-05
Gc11_1149 0 n22 ns1149 0 0.000299193198647
Gc11_1150 0 n22 ns1150 0 -0.000389549344573
Gc11_1151 0 n22 ns1151 0 -7.29434754568e-05
Gc11_1152 0 n22 ns1152 0 0.000110105548477
Gc11_1153 0 n22 ns1153 0 -0.000180484687129
Gc11_1154 0 n22 ns1154 0 0.00040116900998
Gc11_1155 0 n22 ns1155 0 0.000411916068315
Gc11_1156 0 n22 ns1156 0 -0.000201304747922
Gc11_1157 0 n22 ns1157 0 -7.83661576395e-05
Gc11_1158 0 n22 ns1158 0 -0.000557875310996
Gc11_1159 0 n22 ns1159 0 -0.000214812192143
Gc11_1160 0 n22 ns1160 0 -0.000509082206782
Gc11_1161 0 n22 ns1161 0 -4.50464313559e-05
Gc11_1162 0 n22 ns1162 0 -0.000364043838799
Gc11_1163 0 n22 ns1163 0 -0.00473524238718
Gc11_1164 0 n22 ns1164 0 -0.00141045137242
Gc11_1165 0 n22 ns1165 0 -0.00429333852879
Gc11_1166 0 n22 ns1166 0 -0.00118583352293
Gc11_1167 0 n22 ns1167 0 0.000608779081311
Gc11_1168 0 n22 ns1168 0 0.00170141769471
Gc11_1169 0 n22 ns1169 0 -0.000385593433046
Gc11_1170 0 n22 ns1170 0 -0.000491675969276
Gc11_1171 0 n22 ns1171 0 -0.00142249499725
Gc11_1172 0 n22 ns1172 0 -0.00162470099727
Gc11_1173 0 n22 ns1173 0 -0.00023478706896
Gc11_1174 0 n22 ns1174 0 -0.00132904990134
Gc11_1175 0 n22 ns1175 0 -0.000380935114489
Gc11_1176 0 n22 ns1176 0 -2.5946018501e-06
Gc11_1177 0 n22 ns1177 0 2.97158714403e-05
Gc11_1178 0 n22 ns1178 0 2.61732601811e-05
Gc11_1179 0 n22 ns1179 0 -0.000240758947627
Gc11_1180 0 n22 ns1180 0 0.000663103020884
Gc11_1181 0 n22 ns1181 0 -0.000551990443024
Gc11_1182 0 n22 ns1182 0 0.00105708299656
Gc11_1183 0 n22 ns1183 0 -1.27134296133e-05
Gc11_1184 0 n22 ns1184 0 0.000364920410935
Gc11_1185 0 n22 ns1185 0 1.91811501038e-05
Gc11_1186 0 n22 ns1186 0 -0.000256224739349
Gc11_1187 0 n22 ns1187 0 -0.00015340568375
Gc11_1188 0 n22 ns1188 0 -0.000145996931975
Gc11_1189 0 n22 ns1189 0 0.000102065636233
Gc11_1190 0 n22 ns1190 0 9.58946432102e-05
Gc11_1191 0 n22 ns1191 0 0.00042613862939
Gc11_1192 0 n22 ns1192 0 -0.000287823124573
Gc11_1193 0 n22 ns1193 0 9.9026358688e-05
Gc11_1194 0 n22 ns1194 0 -0.000653273525018
Gc11_1195 0 n22 ns1195 0 -0.000318188691284
Gc11_1196 0 n22 ns1196 0 -0.000371503416914
Gc11_1197 0 n22 ns1197 0 -0.000345361432011
Gc11_1198 0 n22 ns1198 0 -0.000317866793922
Gc11_1199 0 n22 ns1199 0 -0.0005080990029
Gc11_1200 0 n22 ns1200 0 -0.000105972580064
Gc11_1201 0 n22 ns1201 0 -0.0038646033614
Gc11_1202 0 n22 ns1202 0 0.00102468080382
Gc11_1203 0 n22 ns1203 0 -0.00336572442225
Gc11_1204 0 n22 ns1204 0 0.000952645244856
Gc11_1205 0 n22 ns1205 0 0.000659933436414
Gc11_1206 0 n22 ns1206 0 0.00122887820724
Gc11_1207 0 n22 ns1207 0 -0.000284716713729
Gc11_1208 0 n22 ns1208 0 -0.00025021807916
Gc11_1209 0 n22 ns1209 0 -0.00104855739501
Gc11_1210 0 n22 ns1210 0 -0.000967356069735
Gc11_1211 0 n22 ns1211 0 -0.000165725786645
Gc11_1212 0 n22 ns1212 0 -0.000749454059517
Gc11_1213 0 n22 ns1213 0 -0.000217741911924
Gc11_1214 0 n22 ns1214 0 4.92127563344e-08
Gc11_1215 0 n22 ns1215 0 1.68002653289e-05
Gc11_1216 0 n22 ns1216 0 2.57711801898e-05
Gd11_1 0 n22 ni1 0 -0.000270409538958
Gd11_2 0 n22 ni2 0 -0.00179626079759
Gd11_3 0 n22 ni3 0 -0.00306576270854
Gd11_4 0 n22 ni4 0 -0.000578792383936
Gd11_5 0 n22 ni5 0 -0.0015355263054
Gd11_6 0 n22 ni6 0 0.000552371698447
Gd11_7 0 n22 ni7 0 0.000428540495797
Gd11_8 0 n22 ni8 0 0.000186496216608
Gd11_9 0 n22 ni9 0 -0.000395357739401
Gd11_10 0 n22 ni10 0 -0.00191190371936
Gd11_11 0 n22 ni11 0 0.000857989596918
Gd11_12 0 n22 ni12 0 -0.00181071383731
Gd11_13 0 n22 ni13 0 -0.00022222712507
Gd11_14 0 n22 ni14 0 0.000489725255398
Gd11_15 0 n22 ni15 0 0.000719154229185
Gd11_16 0 n22 ni16 0 1.80356979481e-05
Gd11_17 0 n22 ni17 0 0.000494782117935
Gd11_18 0 n22 ni18 0 0.000490451691006
Gd11_19 0 n22 ni19 0 -0.00241101567343
Gd11_20 0 n22 ni20 0 -0.003004834063
Gd11_21 0 n22 ni21 0 0.000643994784119
Gd11_22 0 n22 ni22 0 -0.00059376606662
Gd11_23 0 n22 ni23 0 6.18525423522e-05
Gd11_24 0 n22 ni24 0 -0.000481745259165
Gd11_25 0 n22 ni25 0 0.00100535922249
Gd11_26 0 n22 ni26 0 -0.000376073633886
Gd11_27 0 n22 ni27 0 0.000501874041598
Gd11_28 0 n22 ni28 0 0.000523421026641
Gd11_29 0 n22 ni29 0 -0.000303890047389
Gd11_30 0 n22 ni30 0 0.000144338558179
Gd11_31 0 n22 ni31 0 -0.000462130031158
Gd11_32 0 n22 ni32 0 0.000623772059736
Gc12_1 0 n24 ns1 0 2.3718658642e-05
Gc12_2 0 n24 ns2 0 -0.000627661970792
Gc12_3 0 n24 ns3 0 2.67264953045e-05
Gc12_4 0 n24 ns4 0 -0.000255257536344
Gc12_5 0 n24 ns5 0 0.000136127452957
Gc12_6 0 n24 ns6 0 -0.000213028704431
Gc12_7 0 n24 ns7 0 0.000138721514815
Gc12_8 0 n24 ns8 0 7.5177207966e-05
Gc12_9 0 n24 ns9 0 -0.000379738528512
Gc12_10 0 n24 ns10 0 -0.000549682610337
Gc12_11 0 n24 ns11 0 0.000162193287013
Gc12_12 0 n24 ns12 0 -1.82133358976e-05
Gc12_13 0 n24 ns13 0 -0.000157107969454
Gc12_14 0 n24 ns14 0 0.000200285119555
Gc12_15 0 n24 ns15 0 0.000108732550809
Gc12_16 0 n24 ns16 0 0.0014659270612
Gc12_17 0 n24 ns17 0 0.000549560478896
Gc12_18 0 n24 ns18 0 0.000108011022263
Gc12_19 0 n24 ns19 0 -2.52164047577e-06
Gc12_20 0 n24 ns20 0 0.000299581075244
Gc12_21 0 n24 ns21 0 -0.00117766148817
Gc12_22 0 n24 ns22 0 -0.000823621013645
Gc12_23 0 n24 ns23 0 -0.000467624779202
Gc12_24 0 n24 ns24 0 0.00392056734526
Gc12_25 0 n24 ns25 0 4.20419035594e-06
Gc12_26 0 n24 ns26 0 0.00380824216674
Gc12_27 0 n24 ns27 0 -0.00189013820524
Gc12_28 0 n24 ns28 0 0.00050008856597
Gc12_29 0 n24 ns29 0 6.48017229667e-05
Gc12_30 0 n24 ns30 0 -0.000803711921226
Gc12_31 0 n24 ns31 0 0.000358658172865
Gc12_32 0 n24 ns32 0 -0.00135741494154
Gc12_33 0 n24 ns33 0 -0.000387850789125
Gc12_34 0 n24 ns34 0 0.00101625511024
Gc12_35 0 n24 ns35 0 0.000551760358965
Gc12_36 0 n24 ns36 0 -7.89546530502e-06
Gc12_37 0 n24 ns37 0 -0.000151974302793
Gc12_38 0 n24 ns38 0 1.09707761652e-05
Gc12_39 0 n24 ns39 0 -0.000148647765736
Gc12_40 0 n24 ns40 0 -0.000587787569437
Gc12_41 0 n24 ns41 0 -0.000522528223105
Gc12_42 0 n24 ns42 0 -0.000307343149384
Gc12_43 0 n24 ns43 0 0.000102427320383
Gc12_44 0 n24 ns44 0 -9.51592379077e-05
Gc12_45 0 n24 ns45 0 2.61063144581e-05
Gc12_46 0 n24 ns46 0 9.92874677751e-05
Gc12_47 0 n24 ns47 0 -0.000362986369819
Gc12_48 0 n24 ns48 0 -0.000568163205836
Gc12_49 0 n24 ns49 0 0.000204999246106
Gc12_50 0 n24 ns50 0 -7.5966391814e-06
Gc12_51 0 n24 ns51 0 6.12460547288e-05
Gc12_52 0 n24 ns52 0 0.000159876075012
Gc12_53 0 n24 ns53 0 -0.000105287096947
Gc12_54 0 n24 ns54 0 0.00137470869623
Gc12_55 0 n24 ns55 0 0.000585136206723
Gc12_56 0 n24 ns56 0 4.43812967079e-05
Gc12_57 0 n24 ns57 0 -6.94365795382e-05
Gc12_58 0 n24 ns58 0 0.000160275671631
Gc12_59 0 n24 ns59 0 -0.000880213263674
Gc12_60 0 n24 ns60 0 -0.00115902716863
Gc12_61 0 n24 ns61 0 -0.000205180933195
Gc12_62 0 n24 ns62 0 0.00387029051518
Gc12_63 0 n24 ns63 0 0.000230032754676
Gc12_64 0 n24 ns64 0 0.00392653082726
Gc12_65 0 n24 ns65 0 -0.00244025040439
Gc12_66 0 n24 ns66 0 -0.000167046437391
Gc12_67 0 n24 ns67 0 0.000206217427049
Gc12_68 0 n24 ns68 0 -0.000925372430508
Gc12_69 0 n24 ns69 0 0.000739966530503
Gc12_70 0 n24 ns70 0 -0.00110085266751
Gc12_71 0 n24 ns71 0 -0.000509608144013
Gc12_72 0 n24 ns72 0 0.00199356807191
Gc12_73 0 n24 ns73 0 0.000915198410885
Gc12_74 0 n24 ns74 0 -9.38782458403e-06
Gc12_75 0 n24 ns75 0 -0.000147333041267
Gc12_76 0 n24 ns76 0 1.00638890401e-05
Gc12_77 0 n24 ns77 0 0.000663077469509
Gc12_78 0 n24 ns78 0 -0.0018121936774
Gc12_79 0 n24 ns79 0 0.00181199096991
Gc12_80 0 n24 ns80 0 -0.00118984980756
Gc12_81 0 n24 ns81 0 -0.000317329608208
Gc12_82 0 n24 ns82 0 8.57407610962e-05
Gc12_83 0 n24 ns83 0 -0.00014180704369
Gc12_84 0 n24 ns84 0 -0.000135753716471
Gc12_85 0 n24 ns85 0 0.000255138631013
Gc12_86 0 n24 ns86 0 -3.41304373695e-05
Gc12_87 0 n24 ns87 0 0.000214620129393
Gc12_88 0 n24 ns88 0 -5.14925422333e-05
Gc12_89 0 n24 ns89 0 1.61871760283e-05
Gc12_90 0 n24 ns90 0 7.73582403899e-05
Gc12_91 0 n24 ns91 0 -0.000360495324386
Gc12_92 0 n24 ns92 0 -0.000835277281194
Gc12_93 0 n24 ns93 0 0.000584623914989
Gc12_94 0 n24 ns94 0 -0.000727410304856
Gc12_95 0 n24 ns95 0 0.000122615736437
Gc12_96 0 n24 ns96 0 -0.0012925401712
Gc12_97 0 n24 ns97 0 0.00181415329427
Gc12_98 0 n24 ns98 0 0.00021044078504
Gc12_99 0 n24 ns99 0 0.00300190578674
Gc12_100 0 n24 ns100 0 0.00429496603484
Gc12_101 0 n24 ns101 0 0.00256930946007
Gc12_102 0 n24 ns102 0 0.00451586514176
Gc12_103 0 n24 ns103 0 -6.21628592857e-05
Gc12_104 0 n24 ns104 0 -0.0018979111558
Gc12_105 0 n24 ns105 0 0.000673721801103
Gc12_106 0 n24 ns106 0 -0.00107267225709
Gc12_107 0 n24 ns107 0 -1.53288776461e-06
Gc12_108 0 n24 ns108 0 -0.000651799431147
Gc12_109 0 n24 ns109 0 -0.00224402190507
Gc12_110 0 n24 ns110 0 0.00217422699101
Gc12_111 0 n24 ns111 0 0.00197072403582
Gc12_112 0 n24 ns112 0 1.44166384595e-05
Gc12_113 0 n24 ns113 0 -0.000225810750974
Gc12_114 0 n24 ns114 0 7.05318318451e-05
Gc12_115 0 n24 ns115 0 0.00116251609135
Gc12_116 0 n24 ns116 0 -0.00436697894905
Gc12_117 0 n24 ns117 0 0.00132837529975
Gc12_118 0 n24 ns118 0 -0.00286535700617
Gc12_119 0 n24 ns119 0 -0.00122101419783
Gc12_120 0 n24 ns120 0 -0.000551928483121
Gc12_121 0 n24 ns121 0 0.000635770240489
Gc12_122 0 n24 ns122 0 -9.82366759141e-05
Gc12_123 0 n24 ns123 0 0.000168777802246
Gc12_124 0 n24 ns124 0 0.00060952056538
Gc12_125 0 n24 ns125 0 0.000258329283768
Gc12_126 0 n24 ns126 0 -4.83334485422e-05
Gc12_127 0 n24 ns127 0 -0.000563164608047
Gc12_128 0 n24 ns128 0 0.000121112238798
Gc12_129 0 n24 ns129 0 0.000515387283949
Gc12_130 0 n24 ns130 0 -0.000868850847001
Gc12_131 0 n24 ns131 0 0.00061920378973
Gc12_132 0 n24 ns132 0 -0.000510794432048
Gc12_133 0 n24 ns133 0 8.15704428667e-05
Gc12_134 0 n24 ns134 0 -0.00122940803048
Gc12_135 0 n24 ns135 0 0.0010333340344
Gc12_136 0 n24 ns136 0 0.00166633997006
Gc12_137 0 n24 ns137 0 0.00587063954313
Gc12_138 0 n24 ns138 0 0.00566027701102
Gc12_139 0 n24 ns139 0 0.00447843416199
Gc12_140 0 n24 ns140 0 0.00562551819585
Gc12_141 0 n24 ns141 0 0.00272094015407
Gc12_142 0 n24 ns142 0 0.0018778579033
Gc12_143 0 n24 ns143 0 0.000928604798937
Gc12_144 0 n24 ns144 0 -0.000916253463742
Gc12_145 0 n24 ns145 0 -0.00411431457915
Gc12_146 0 n24 ns146 0 -0.00115603630009
Gc12_147 0 n24 ns147 0 -0.00064756313154
Gc12_148 0 n24 ns148 0 -0.00222976933264
Gc12_149 0 n24 ns149 0 0.00379699932178
Gc12_150 0 n24 ns150 0 1.50094591449e-05
Gc12_151 0 n24 ns151 0 -0.000128508414592
Gc12_152 0 n24 ns152 0 3.19880489907e-05
Gc12_153 0 n24 ns153 0 0.000598570513067
Gc12_154 0 n24 ns154 0 -0.00353918310275
Gc12_155 0 n24 ns155 0 -0.00146066599813
Gc12_156 0 n24 ns156 0 -0.00112245889532
Gc12_157 0 n24 ns157 0 -0.00128267022239
Gc12_158 0 n24 ns158 0 3.16234210582e-05
Gc12_159 0 n24 ns159 0 0.000725895221754
Gc12_160 0 n24 ns160 0 -0.000201945588675
Gc12_161 0 n24 ns161 0 0.00014187953383
Gc12_162 0 n24 ns162 0 0.000551223501484
Gc12_163 0 n24 ns163 0 0.00028369717787
Gc12_164 0 n24 ns164 0 -1.63168164098e-05
Gc12_165 0 n24 ns165 0 -0.000399861618368
Gc12_166 0 n24 ns166 0 -0.00050563524029
Gc12_167 0 n24 ns167 0 9.8308478289e-05
Gc12_168 0 n24 ns168 0 -7.57233976807e-05
Gc12_169 0 n24 ns169 0 0.000364363007362
Gc12_170 0 n24 ns170 0 -0.000273328110863
Gc12_171 0 n24 ns171 0 -0.000328760486497
Gc12_172 0 n24 ns172 0 -0.00113252347944
Gc12_173 0 n24 ns173 0 -0.000337549242174
Gc12_174 0 n24 ns174 0 7.96526211413e-05
Gc12_175 0 n24 ns175 0 0.00629004335415
Gc12_176 0 n24 ns176 0 0.00589077903362
Gc12_177 0 n24 ns177 0 0.0046854595633
Gc12_178 0 n24 ns178 0 0.00577910155442
Gc12_179 0 n24 ns179 0 0.000511822479252
Gc12_180 0 n24 ns180 0 0.00535618509181
Gc12_181 0 n24 ns181 0 0.000843487406993
Gc12_182 0 n24 ns182 0 -0.000899585528279
Gc12_183 0 n24 ns183 0 -0.00625338438111
Gc12_184 0 n24 ns184 0 -0.0018789642571
Gc12_185 0 n24 ns185 0 0.00333946744042
Gc12_186 0 n24 ns186 0 -0.005030336932
Gc12_187 0 n24 ns187 0 0.00459132701974
Gc12_188 0 n24 ns188 0 -1.91979791011e-05
Gc12_189 0 n24 ns189 0 4.27689669782e-05
Gc12_190 0 n24 ns190 0 -7.68806401538e-05
Gc12_191 0 n24 ns191 0 0.000438780516528
Gc12_192 0 n24 ns192 0 -0.00167295419055
Gc12_193 0 n24 ns193 0 0.00118461184883
Gc12_194 0 n24 ns194 0 -0.000997895382437
Gc12_195 0 n24 ns195 0 -0.000772301262365
Gc12_196 0 n24 ns196 0 9.75522123519e-05
Gc12_197 0 n24 ns197 0 0.000184122176042
Gc12_198 0 n24 ns198 0 -0.000333200663679
Gc12_199 0 n24 ns199 0 0.000338682432549
Gc12_200 0 n24 ns200 0 0.000142056557174
Gc12_201 0 n24 ns201 0 0.000205733947882
Gc12_202 0 n24 ns202 0 -3.29772107259e-05
Gc12_203 0 n24 ns203 0 -1.86351805227e-05
Gc12_204 0 n24 ns204 0 0.000296490757401
Gc12_205 0 n24 ns205 0 0.000149283245643
Gc12_206 0 n24 ns206 0 -0.000928476152226
Gc12_207 0 n24 ns207 0 0.000731494357508
Gc12_208 0 n24 ns208 0 -0.000474190025932
Gc12_209 0 n24 ns209 0 0.000424440487289
Gc12_210 0 n24 ns210 0 -0.000818308497246
Gc12_211 0 n24 ns211 0 0.00160860183153
Gc12_212 0 n24 ns212 0 0.00121224023054
Gc12_213 0 n24 ns213 0 0.00196100350447
Gc12_214 0 n24 ns214 0 0.00377345023851
Gc12_215 0 n24 ns215 0 0.00155462836496
Gc12_216 0 n24 ns216 0 0.00399666706277
Gc12_217 0 n24 ns217 0 0.00162516236915
Gc12_218 0 n24 ns218 0 -0.00166895206426
Gc12_219 0 n24 ns219 0 0.000820761884673
Gc12_220 0 n24 ns220 0 -0.000971271312347
Gc12_221 0 n24 ns221 0 -0.000527769417868
Gc12_222 0 n24 ns222 0 -0.000594045813214
Gc12_223 0 n24 ns223 0 -0.00325937856233
Gc12_224 0 n24 ns224 0 0.00212280786339
Gc12_225 0 n24 ns225 0 0.00256414816337
Gc12_226 0 n24 ns226 0 3.58373031488e-05
Gc12_227 0 n24 ns227 0 -0.000168824887792
Gc12_228 0 n24 ns228 0 3.91848270985e-05
Gc12_229 0 n24 ns229 0 -0.000320611636874
Gc12_230 0 n24 ns230 0 0.000134474432156
Gc12_231 0 n24 ns231 0 -0.000641678420423
Gc12_232 0 n24 ns232 0 0.000529214069482
Gc12_233 0 n24 ns233 0 -0.000100797327284
Gc12_234 0 n24 ns234 0 0.000435896171758
Gc12_235 0 n24 ns235 0 4.36842631883e-05
Gc12_236 0 n24 ns236 0 -8.44467294038e-05
Gc12_237 0 n24 ns237 0 9.47741396573e-05
Gc12_238 0 n24 ns238 0 -0.000246135048192
Gc12_239 0 n24 ns239 0 0.00015083172068
Gc12_240 0 n24 ns240 0 -7.4841056686e-05
Gc12_241 0 n24 ns241 0 1.7247092233e-05
Gc12_242 0 n24 ns242 0 -0.000341642472004
Gc12_243 0 n24 ns243 0 -0.000579957946886
Gc12_244 0 n24 ns244 0 0.00030855660062
Gc12_245 0 n24 ns245 0 0.000201124741978
Gc12_246 0 n24 ns246 0 -0.000340720094561
Gc12_247 0 n24 ns247 0 -0.000328292685205
Gc12_248 0 n24 ns248 0 -0.000508705339913
Gc12_249 0 n24 ns249 0 0.000278475469666
Gc12_250 0 n24 ns250 0 -0.00113603446452
Gc12_251 0 n24 ns251 0 0.00139190960763
Gc12_252 0 n24 ns252 0 0.00238123888877
Gc12_253 0 n24 ns253 0 0.00146559795944
Gc12_254 0 n24 ns254 0 0.00263674347095
Gc12_255 0 n24 ns255 0 -0.00214695432265
Gc12_256 0 n24 ns256 0 -0.000706409869922
Gc12_257 0 n24 ns257 0 0.000234777377265
Gc12_258 0 n24 ns258 0 -0.000980096169857
Gc12_259 0 n24 ns259 0 0.000489003774294
Gc12_260 0 n24 ns260 0 -0.000920725653503
Gc12_261 0 n24 ns261 0 -0.00083409522332
Gc12_262 0 n24 ns262 0 0.00242725804959
Gc12_263 0 n24 ns263 0 0.00113800359596
Gc12_264 0 n24 ns264 0 1.90971387554e-05
Gc12_265 0 n24 ns265 0 -0.000180184800697
Gc12_266 0 n24 ns266 0 5.40814777715e-05
Gc12_267 0 n24 ns267 0 -7.37782682824e-05
Gc12_268 0 n24 ns268 0 -2.38015477747e-05
Gc12_269 0 n24 ns269 0 1.29282409135e-05
Gc12_270 0 n24 ns270 0 0.000562968957797
Gc12_271 0 n24 ns271 0 2.96974566067e-05
Gc12_272 0 n24 ns272 0 2.47471262564e-06
Gc12_273 0 n24 ns273 0 6.86127257371e-05
Gc12_274 0 n24 ns274 0 -5.1071310093e-05
Gc12_275 0 n24 ns275 0 -0.000253778771004
Gc12_276 0 n24 ns276 0 0.000105567421283
Gc12_277 0 n24 ns277 0 8.87017399721e-05
Gc12_278 0 n24 ns278 0 -0.000154460910868
Gc12_279 0 n24 ns279 0 -0.000200135076575
Gc12_280 0 n24 ns280 0 -0.000174490995086
Gc12_281 0 n24 ns281 0 0.000554796451609
Gc12_282 0 n24 ns282 0 0.000238905584309
Gc12_283 0 n24 ns283 0 0.000233022355557
Gc12_284 0 n24 ns284 0 -0.000527963281203
Gc12_285 0 n24 ns285 0 -1.34064666471e-05
Gc12_286 0 n24 ns286 0 -0.000395646755274
Gc12_287 0 n24 ns287 0 -0.000454300853346
Gc12_288 0 n24 ns288 0 0.000228646279335
Gc12_289 0 n24 ns289 0 0.00309176574952
Gc12_290 0 n24 ns290 0 0.00329439363988
Gc12_291 0 n24 ns291 0 0.00302920577887
Gc12_292 0 n24 ns292 0 0.00294707319408
Gc12_293 0 n24 ns293 0 -0.00063207340085
Gc12_294 0 n24 ns294 0 0.000973803868772
Gc12_295 0 n24 ns295 0 -0.000233277621534
Gc12_296 0 n24 ns296 0 -0.00064830150748
Gc12_297 0 n24 ns297 0 -0.00075499182402
Gc12_298 0 n24 ns298 0 -0.00134640587144
Gc12_299 0 n24 ns299 0 -0.000567372357664
Gc12_300 0 n24 ns300 0 0.000434421317393
Gc12_301 0 n24 ns301 0 0.000354060096454
Gc12_302 0 n24 ns302 0 -3.26023851204e-06
Gc12_303 0 n24 ns303 0 -5.4858429353e-05
Gc12_304 0 n24 ns304 0 -1.82992027178e-05
Gc12_305 0 n24 ns305 0 -1.16475865213e-05
Gc12_306 0 n24 ns306 0 0.000242389692178
Gc12_307 0 n24 ns307 0 -4.92129850709e-05
Gc12_308 0 n24 ns308 0 0.0007813706106
Gc12_309 0 n24 ns309 0 3.17330929434e-05
Gc12_310 0 n24 ns310 0 -5.33275190297e-05
Gc12_311 0 n24 ns311 0 -0.00014692460287
Gc12_312 0 n24 ns312 0 4.16673061566e-05
Gc12_313 0 n24 ns313 0 -0.000306449666881
Gc12_314 0 n24 ns314 0 0.00044141006827
Gc12_315 0 n24 ns315 0 5.76170165356e-05
Gc12_316 0 n24 ns316 0 -0.000112481712885
Gc12_317 0 n24 ns317 0 0.000291222425255
Gc12_318 0 n24 ns318 0 -0.00029853220615
Gc12_319 0 n24 ns319 0 0.000920995130748
Gc12_320 0 n24 ns320 0 -0.000674521110017
Gc12_321 0 n24 ns321 0 0.000239915976009
Gc12_322 0 n24 ns322 0 -0.000747386530794
Gc12_323 0 n24 ns323 0 0.000426202167801
Gc12_324 0 n24 ns324 0 -0.000719319548975
Gc12_325 0 n24 ns325 0 0.000128236582628
Gc12_326 0 n24 ns326 0 0.00114162769654
Gc12_327 0 n24 ns327 0 0.00363087839687
Gc12_328 0 n24 ns328 0 0.00285433319443
Gc12_329 0 n24 ns329 0 0.00332066174013
Gc12_330 0 n24 ns330 0 0.00233032331171
Gc12_331 0 n24 ns331 0 0.000740189442426
Gc12_332 0 n24 ns332 0 0.000991897473847
Gc12_333 0 n24 ns333 0 -0.000342339617813
Gc12_334 0 n24 ns334 0 -0.000354895002092
Gc12_335 0 n24 ns335 0 -0.00144460093822
Gc12_336 0 n24 ns336 0 -0.000972329650424
Gc12_337 0 n24 ns337 0 -0.000550762698324
Gc12_338 0 n24 ns338 0 -0.000241964002379
Gc12_339 0 n24 ns339 0 9.9027053607e-05
Gc12_340 0 n24 ns340 0 1.14551970305e-05
Gc12_341 0 n24 ns341 0 -6.47333397235e-05
Gc12_342 0 n24 ns342 0 -1.06101537692e-05
Gc12_343 0 n24 ns343 0 0.000259579742779
Gc12_344 0 n24 ns344 0 -0.00100703621982
Gc12_345 0 n24 ns345 0 0.000677547496599
Gc12_346 0 n24 ns346 0 -0.00046003083635
Gc12_347 0 n24 ns347 0 -0.000101430499384
Gc12_348 0 n24 ns348 0 0.000269959988064
Gc12_349 0 n24 ns349 0 -0.000181769676806
Gc12_350 0 n24 ns350 0 -0.000124122010452
Gc12_351 0 n24 ns351 0 4.0498153842e-05
Gc12_352 0 n24 ns352 0 -0.000341087968572
Gc12_353 0 n24 ns353 0 0.000209071130647
Gc12_354 0 n24 ns354 0 -3.00063344054e-05
Gc12_355 0 n24 ns355 0 0.000222892706738
Gc12_356 0 n24 ns356 0 -4.89539112803e-06
Gc12_357 0 n24 ns357 0 -0.000390359860646
Gc12_358 0 n24 ns358 0 -4.337484947e-05
Gc12_359 0 n24 ns359 0 0.000593499546096
Gc12_360 0 n24 ns360 0 -0.000518505644132
Gc12_361 0 n24 ns361 0 0.000116527589351
Gc12_362 0 n24 ns362 0 -0.00086889495145
Gc12_363 0 n24 ns363 0 0.000933307346271
Gc12_364 0 n24 ns364 0 -0.000558039735275
Gc12_365 0 n24 ns365 0 0.00161770041646
Gc12_366 0 n24 ns366 0 0.00437531812892
Gc12_367 0 n24 ns367 0 0.00155450432518
Gc12_368 0 n24 ns368 0 0.0045073342025
Gc12_369 0 n24 ns369 0 -0.00145565740941
Gc12_370 0 n24 ns370 0 -0.00154639748612
Gc12_371 0 n24 ns371 0 0.000486538157732
Gc12_372 0 n24 ns372 0 -0.00106771037952
Gc12_373 0 n24 ns373 0 0.000465943556111
Gc12_374 0 n24 ns374 0 -0.000793755079637
Gc12_375 0 n24 ns375 0 -0.00142111593992
Gc12_376 0 n24 ns376 0 0.00254421167209
Gc12_377 0 n24 ns377 0 0.00150827044108
Gc12_378 0 n24 ns378 0 2.00895807069e-05
Gc12_379 0 n24 ns379 0 -0.000229864090124
Gc12_380 0 n24 ns380 0 7.61244240275e-05
Gc12_381 0 n24 ns381 0 0.000528619129435
Gc12_382 0 n24 ns382 0 -0.00217086237876
Gc12_383 0 n24 ns383 0 0.00109631808585
Gc12_384 0 n24 ns384 0 -0.000524237191149
Gc12_385 0 n24 ns385 0 -0.00072158889706
Gc12_386 0 n24 ns386 0 0.000238041601131
Gc12_387 0 n24 ns387 0 0.000236099633782
Gc12_388 0 n24 ns388 0 -0.000426930290066
Gc12_389 0 n24 ns389 0 0.000277744657798
Gc12_390 0 n24 ns390 0 0.000424929363622
Gc12_391 0 n24 ns391 0 0.000252231679971
Gc12_392 0 n24 ns392 0 -5.46185856063e-05
Gc12_393 0 n24 ns393 0 -0.000425183288987
Gc12_394 0 n24 ns394 0 -1.81727203898e-05
Gc12_395 0 n24 ns395 0 0.000734194888954
Gc12_396 0 n24 ns396 0 -0.00102576123286
Gc12_397 0 n24 ns397 0 0.00086517065257
Gc12_398 0 n24 ns398 0 -0.000550984353093
Gc12_399 0 n24 ns399 0 0.000471729025691
Gc12_400 0 n24 ns400 0 -0.00107201489715
Gc12_401 0 n24 ns401 0 0.00103233328579
Gc12_402 0 n24 ns402 0 0.00228313534681
Gc12_403 0 n24 ns403 0 0.00332518691891
Gc12_404 0 n24 ns404 0 0.00496711282474
Gc12_405 0 n24 ns405 0 0.00258058144936
Gc12_406 0 n24 ns406 0 0.00506974207275
Gc12_407 0 n24 ns407 0 0.00367856352066
Gc12_408 0 n24 ns408 0 0.000380966812829
Gc12_409 0 n24 ns409 0 0.000890694063985
Gc12_410 0 n24 ns410 0 -0.000976269326079
Gc12_411 0 n24 ns411 0 -0.00194504321769
Gc12_412 0 n24 ns412 0 -0.00131579461377
Gc12_413 0 n24 ns413 0 -0.00393308761673
Gc12_414 0 n24 ns414 0 -0.000324368990441
Gc12_415 0 n24 ns415 0 0.003078876959
Gc12_416 0 n24 ns416 0 4.99295892064e-05
Gc12_417 0 n24 ns417 0 -0.000191796673095
Gc12_418 0 n24 ns418 0 6.26389319828e-05
Gc12_419 0 n24 ns419 0 0.000149316847652
Gc12_420 0 n24 ns420 0 -0.0021609367706
Gc12_421 0 n24 ns421 0 -0.00224076426051
Gc12_422 0 n24 ns422 0 0.000336467645559
Gc12_423 0 n24 ns423 0 -0.000929946176601
Gc12_424 0 n24 ns424 0 0.000229203353302
Gc12_425 0 n24 ns425 0 0.000584503320131
Gc12_426 0 n24 ns426 0 -0.00022723415427
Gc12_427 0 n24 ns427 0 9.22879403762e-05
Gc12_428 0 n24 ns428 0 0.000554886046077
Gc12_429 0 n24 ns429 0 0.000295588988496
Gc12_430 0 n24 ns430 0 -1.27146684012e-05
Gc12_431 0 n24 ns431 0 -0.000567224973488
Gc12_432 0 n24 ns432 0 -0.000665897653047
Gc12_433 0 n24 ns433 0 0.000311381939133
Gc12_434 0 n24 ns434 0 0.000111096473246
Gc12_435 0 n24 ns435 0 0.0003462997368
Gc12_436 0 n24 ns436 0 -0.000176680373703
Gc12_437 0 n24 ns437 0 -0.000456902421091
Gc12_438 0 n24 ns438 0 -0.00101900043255
Gc12_439 0 n24 ns439 0 -0.000756060296659
Gc12_440 0 n24 ns440 0 0.000230942784218
Gc12_441 0 n24 ns441 0 0.00682267789648
Gc12_442 0 n24 ns442 0 0.00492589016828
Gc12_443 0 n24 ns443 0 0.00512587081027
Gc12_444 0 n24 ns444 0 0.00501520662727
Gc12_445 0 n24 ns445 0 0.000924662497106
Gc12_446 0 n24 ns446 0 0.00554912780741
Gc12_447 0 n24 ns447 0 0.000899479492862
Gc12_448 0 n24 ns448 0 -0.000819598610359
Gc12_449 0 n24 ns449 0 -0.00602491950829
Gc12_450 0 n24 ns450 0 -0.00151961289393
Gc12_451 0 n24 ns451 0 0.00280681864243
Gc12_452 0 n24 ns452 0 -0.00432011362046
Gc12_453 0 n24 ns453 0 0.0047415018091
Gc12_454 0 n24 ns454 0 -1.06701547613e-05
Gc12_455 0 n24 ns455 0 0.000118791403723
Gc12_456 0 n24 ns456 0 -0.000147894752239
Gc12_457 0 n24 ns457 0 0.000293002343461
Gc12_458 0 n24 ns458 0 -0.00183641674958
Gc12_459 0 n24 ns459 0 0.000565489105948
Gc12_460 0 n24 ns460 0 -2.66087963764e-05
Gc12_461 0 n24 ns461 0 -0.000889264435678
Gc12_462 0 n24 ns462 0 0.000434108710673
Gc12_463 0 n24 ns463 0 0.000375130199811
Gc12_464 0 n24 ns464 0 -0.000549805578277
Gc12_465 0 n24 ns465 0 0.000379403693318
Gc12_466 0 n24 ns466 0 0.000457465593317
Gc12_467 0 n24 ns467 0 0.000261824332782
Gc12_468 0 n24 ns468 0 -5.39368532819e-05
Gc12_469 0 n24 ns469 0 -0.000448912758627
Gc12_470 0 n24 ns470 0 -0.000147492706499
Gc12_471 0 n24 ns471 0 0.000672902920104
Gc12_472 0 n24 ns472 0 -0.000980770398664
Gc12_473 0 n24 ns473 0 0.000866591384541
Gc12_474 0 n24 ns474 0 -0.000450953513134
Gc12_475 0 n24 ns475 0 0.000500992133865
Gc12_476 0 n24 ns476 0 -0.000948836688588
Gc12_477 0 n24 ns477 0 0.00091565452995
Gc12_478 0 n24 ns478 0 0.00221836014837
Gc12_479 0 n24 ns479 0 0.00259144727778
Gc12_480 0 n24 ns480 0 0.00446412801513
Gc12_481 0 n24 ns481 0 0.0019486293108
Gc12_482 0 n24 ns482 0 0.00463259027335
Gc12_483 0 n24 ns483 0 0.00368907631895
Gc12_484 0 n24 ns484 0 0.00068274962765
Gc12_485 0 n24 ns485 0 0.000864833276616
Gc12_486 0 n24 ns486 0 -0.00100858138676
Gc12_487 0 n24 ns487 0 -0.00199256161055
Gc12_488 0 n24 ns488 0 -0.00152828444986
Gc12_489 0 n24 ns489 0 -0.00391267460926
Gc12_490 0 n24 ns490 0 -0.000573942533118
Gc12_491 0 n24 ns491 0 0.00300508404429
Gc12_492 0 n24 ns492 0 5.02051380515e-05
Gc12_493 0 n24 ns493 0 -0.000195794277258
Gc12_494 0 n24 ns494 0 5.05902557019e-05
Gc12_495 0 n24 ns495 0 0.000120802425163
Gc12_496 0 n24 ns496 0 -0.000499772547828
Gc12_497 0 n24 ns497 0 0.00059464983182
Gc12_498 0 n24 ns498 0 8.28399264635e-05
Gc12_499 0 n24 ns499 0 -0.000271129775068
Gc12_500 0 n24 ns500 0 0.000483707750617
Gc12_501 0 n24 ns501 0 -1.47469482979e-05
Gc12_502 0 n24 ns502 0 -0.0001919477579
Gc12_503 0 n24 ns503 0 0.00035306222618
Gc12_504 0 n24 ns504 0 -0.000174609823814
Gc12_505 0 n24 ns505 0 0.000181701352186
Gc12_506 0 n24 ns506 0 -7.40993195868e-05
Gc12_507 0 n24 ns507 0 -1.94494254038e-05
Gc12_508 0 n24 ns508 0 -0.00031444682277
Gc12_509 0 n24 ns509 0 -0.000764922523917
Gc12_510 0 n24 ns510 0 -0.000340507583864
Gc12_511 0 n24 ns511 0 0.000296416064399
Gc12_512 0 n24 ns512 0 -0.000553641685132
Gc12_513 0 n24 ns513 0 -0.000189685287634
Gc12_514 0 n24 ns514 0 -0.000971582768885
Gc12_515 0 n24 ns515 0 0.00121421248065
Gc12_516 0 n24 ns516 0 -0.000694953184575
Gc12_517 0 n24 ns517 0 0.00192187974188
Gc12_518 0 n24 ns518 0 0.00296134277063
Gc12_519 0 n24 ns519 0 0.00178313623689
Gc12_520 0 n24 ns520 0 0.00324805005005
Gc12_521 0 n24 ns521 0 -0.00125556494856
Gc12_522 0 n24 ns522 0 -0.00139325477616
Gc12_523 0 n24 ns523 0 0.000406846128457
Gc12_524 0 n24 ns524 0 -0.0010538475348
Gc12_525 0 n24 ns525 0 0.000210717523544
Gc12_526 0 n24 ns526 0 -0.000793619189812
Gc12_527 0 n24 ns527 0 -0.00144965284533
Gc12_528 0 n24 ns528 0 0.00247870845872
Gc12_529 0 n24 ns529 0 0.00148146657321
Gc12_530 0 n24 ns530 0 2.95770852914e-05
Gc12_531 0 n24 ns531 0 -0.000226966353635
Gc12_532 0 n24 ns532 0 7.10171147346e-05
Gc12_533 0 n24 ns533 0 -0.000189145239062
Gc12_534 0 n24 ns534 0 6.17880633609e-05
Gc12_535 0 n24 ns535 0 -0.000256053935625
Gc12_536 0 n24 ns536 0 0.000546521282945
Gc12_537 0 n24 ns537 0 -1.05777943897e-05
Gc12_538 0 n24 ns538 0 7.1357415124e-05
Gc12_539 0 n24 ns539 0 0.000151350880924
Gc12_540 0 n24 ns540 0 -1.3500612879e-05
Gc12_541 0 n24 ns541 0 -0.000181841248299
Gc12_542 0 n24 ns542 0 -7.6210443409e-05
Gc12_543 0 n24 ns543 0 0.000129507556748
Gc12_544 0 n24 ns544 0 -0.000132559836583
Gc12_545 0 n24 ns545 0 -0.000222577614376
Gc12_546 0 n24 ns546 0 -0.000250132375841
Gc12_547 0 n24 ns547 0 0.000158934100716
Gc12_548 0 n24 ns548 0 0.00055112752279
Gc12_549 0 n24 ns549 0 0.000239256610417
Gc12_550 0 n24 ns550 0 -0.000395655936765
Gc12_551 0 n24 ns551 0 -0.000192967395896
Gc12_552 0 n24 ns552 0 -0.000304942112928
Gc12_553 0 n24 ns553 0 -0.00050847476789
Gc12_554 0 n24 ns554 0 -0.000374493491603
Gc12_555 0 n24 ns555 0 0.0023021498966
Gc12_556 0 n24 ns556 0 0.00315305086921
Gc12_557 0 n24 ns557 0 0.0023800726809
Gc12_558 0 n24 ns558 0 0.00299808061191
Gc12_559 0 n24 ns559 0 -0.00130932709383
Gc12_560 0 n24 ns560 0 0.000667486899269
Gc12_561 0 n24 ns561 0 -0.000123092826039
Gc12_562 0 n24 ns562 0 -0.000789469996157
Gc12_563 0 n24 ns563 0 -0.000342958462279
Gc12_564 0 n24 ns564 0 -0.00134302691575
Gc12_565 0 n24 ns565 0 -0.00057994235655
Gc12_566 0 n24 ns566 0 0.00102710811702
Gc12_567 0 n24 ns567 0 0.000565155977321
Gc12_568 0 n24 ns568 0 5.16473491926e-06
Gc12_569 0 n24 ns569 0 -9.89789839335e-05
Gc12_570 0 n24 ns570 0 -2.44738413917e-06
Gc12_571 0 n24 ns571 0 -2.41532983555e-05
Gc12_572 0 n24 ns572 0 0.000203256189633
Gc12_573 0 n24 ns573 0 0.000123459283876
Gc12_574 0 n24 ns574 0 0.00127299353322
Gc12_575 0 n24 ns575 0 3.8169093851e-05
Gc12_576 0 n24 ns576 0 0.000211747408381
Gc12_577 0 n24 ns577 0 -9.93395800176e-05
Gc12_578 0 n24 ns578 0 -0.000167964509011
Gc12_579 0 n24 ns579 0 -0.000221272032186
Gc12_580 0 n24 ns580 0 0.000401113873041
Gc12_581 0 n24 ns581 0 6.69687997967e-05
Gc12_582 0 n24 ns582 0 -0.000166551639579
Gc12_583 0 n24 ns583 0 3.48773004652e-05
Gc12_584 0 n24 ns584 0 -0.000372080086733
Gc12_585 0 n24 ns585 0 0.000962906796534
Gc12_586 0 n24 ns586 0 -0.000575034185367
Gc12_587 0 n24 ns587 0 0.000282954549431
Gc12_588 0 n24 ns588 0 -0.000845169512392
Gc12_589 0 n24 ns589 0 0.00039805351934
Gc12_590 0 n24 ns590 0 -0.000812908992983
Gc12_591 0 n24 ns591 0 2.98471346221e-05
Gc12_592 0 n24 ns592 0 0.00115268879339
Gc12_593 0 n24 ns593 0 0.00403823852033
Gc12_594 0 n24 ns594 0 0.00352765307026
Gc12_595 0 n24 ns595 0 0.00373991684784
Gc12_596 0 n24 ns596 0 0.00293703940957
Gc12_597 0 n24 ns597 0 0.000518962737297
Gc12_598 0 n24 ns598 0 0.0012007351384
Gc12_599 0 n24 ns599 0 -0.000327612207746
Gc12_600 0 n24 ns600 0 -0.000463171109589
Gc12_601 0 n24 ns601 0 -0.00133119575832
Gc12_602 0 n24 ns602 0 -0.00135500727904
Gc12_603 0 n24 ns603 0 -0.000640712247695
Gc12_604 0 n24 ns604 0 -0.000570770583946
Gc12_605 0 n24 ns605 0 6.27316841827e-05
Gc12_606 0 n24 ns606 0 1.58448570601e-05
Gc12_607 0 n24 ns607 0 -6.76045136923e-05
Gc12_608 0 n24 ns608 0 -3.33583857102e-06
Gc12_609 0 n24 ns609 0 -0.000164397167112
Gc12_610 0 n24 ns610 0 -0.000393253947886
Gc12_611 0 n24 ns611 0 -0.000531853327502
Gc12_612 0 n24 ns612 0 0.000590423168106
Gc12_613 0 n24 ns613 0 -0.000203397944054
Gc12_614 0 n24 ns614 0 -2.94563382976e-05
Gc12_615 0 n24 ns615 0 -6.87821969694e-05
Gc12_616 0 n24 ns616 0 0.000116238352972
Gc12_617 0 n24 ns617 0 0.000366918120257
Gc12_618 0 n24 ns618 0 0.000687885539479
Gc12_619 0 n24 ns619 0 -0.000117073856496
Gc12_620 0 n24 ns620 0 -2.75038703346e-05
Gc12_621 0 n24 ns621 0 -0.00035377402214
Gc12_622 0 n24 ns622 0 -0.000374980515698
Gc12_623 0 n24 ns623 0 0.000386662471861
Gc12_624 0 n24 ns624 0 0.00116274131668
Gc12_625 0 n24 ns625 0 0.00085323956812
Gc12_626 0 n24 ns626 0 -1.3041044137e-05
Gc12_627 0 n24 ns627 0 0.000656052297637
Gc12_628 0 n24 ns628 0 0.000159395875076
Gc12_629 0 n24 ns629 0 0.00039447718917
Gc12_630 0 n24 ns630 0 0.000196375965741
Gc12_631 0 n24 ns631 0 -0.000944587315738
Gc12_632 0 n24 ns632 0 -0.00619033059348
Gc12_633 0 n24 ns633 0 -0.00116259625546
Gc12_634 0 n24 ns634 0 -0.00566875115459
Gc12_635 0 n24 ns635 0 -0.00144535336684
Gc12_636 0 n24 ns636 0 0.00105061726484
Gc12_637 0 n24 ns637 0 2.96016280855e-05
Gc12_638 0 n24 ns638 0 -0.000881839752803
Gc12_639 0 n24 ns639 0 0.000160571925959
Gc12_640 0 n24 ns640 0 -0.00201534778614
Gc12_641 0 n24 ns641 0 0.000373314813425
Gc12_642 0 n24 ns642 0 -0.00113623414906
Gc12_643 0 n24 ns643 0 -0.000534339271477
Gc12_644 0 n24 ns644 0 -6.76093914112e-06
Gc12_645 0 n24 ns645 0 7.65650187603e-05
Gc12_646 0 n24 ns646 0 -9.9012309494e-07
Gc12_647 0 n24 ns647 0 0.000100069394252
Gc12_648 0 n24 ns648 0 -0.000894395880045
Gc12_649 0 n24 ns649 0 0.000180410147783
Gc12_650 0 n24 ns650 0 0.000283339212649
Gc12_651 0 n24 ns651 0 -7.73899540393e-05
Gc12_652 0 n24 ns652 0 -0.000240811247933
Gc12_653 0 n24 ns653 0 -8.72516632403e-05
Gc12_654 0 n24 ns654 0 0.000144493052919
Gc12_655 0 n24 ns655 0 0.000202442118913
Gc12_656 0 n24 ns656 0 0.00059668031089
Gc12_657 0 n24 ns657 0 -0.000172764669109
Gc12_658 0 n24 ns658 0 2.53252983664e-05
Gc12_659 0 n24 ns659 0 -9.67779088475e-05
Gc12_660 0 n24 ns660 0 -0.000259333309112
Gc12_661 0 n24 ns661 0 0.000147475562594
Gc12_662 0 n24 ns662 0 0.00108897848536
Gc12_663 0 n24 ns663 0 0.000848387341477
Gc12_664 0 n24 ns664 0 -7.48696886367e-05
Gc12_665 0 n24 ns665 0 0.000482159239444
Gc12_666 0 n24 ns666 0 2.93735485745e-05
Gc12_667 0 n24 ns667 0 0.000252773892142
Gc12_668 0 n24 ns668 0 0.000357069574527
Gc12_669 0 n24 ns669 0 -0.000871720006633
Gc12_670 0 n24 ns670 0 -0.0065237861056
Gc12_671 0 n24 ns671 0 -0.00112057899547
Gc12_672 0 n24 ns672 0 -0.00611035385675
Gc12_673 0 n24 ns673 0 -0.00153674429192
Gc12_674 0 n24 ns674 0 0.00100052569577
Gc12_675 0 n24 ns675 0 0.0001118831748
Gc12_676 0 n24 ns676 0 -0.00108332584125
Gc12_677 0 n24 ns677 0 0.000234439579778
Gc12_678 0 n24 ns678 0 -0.00239607151281
Gc12_679 0 n24 ns679 0 0.000557669283391
Gc12_680 0 n24 ns680 0 -0.00170979061015
Gc12_681 0 n24 ns681 0 -0.000797230492168
Gc12_682 0 n24 ns682 0 -1.12209272235e-05
Gc12_683 0 n24 ns683 0 5.73462208522e-05
Gc12_684 0 n24 ns684 0 4.69889324786e-06
Gc12_685 0 n24 ns685 0 -0.000880905039113
Gc12_686 0 n24 ns686 0 0.000130102288853
Gc12_687 0 n24 ns687 0 -0.00248834050175
Gc12_688 0 n24 ns688 0 0.00211659584455
Gc12_689 0 n24 ns689 0 -0.000479482614439
Gc12_690 0 n24 ns690 0 0.000886808872619
Gc12_691 0 n24 ns691 0 0.00041210161421
Gc12_692 0 n24 ns692 0 -0.000472033873645
Gc12_693 0 n24 ns693 0 -0.000264130816089
Gc12_694 0 n24 ns694 0 0.000326380185271
Gc12_695 0 n24 ns695 0 -0.000175455353894
Gc12_696 0 n24 ns696 0 9.34621251779e-05
Gc12_697 0 n24 ns697 0 0.00106118287611
Gc12_698 0 n24 ns698 0 -0.000274240672774
Gc12_699 0 n24 ns699 0 0.000160604374869
Gc12_700 0 n24 ns700 0 -0.000671904931053
Gc12_701 0 n24 ns701 0 0.000847543187336
Gc12_702 0 n24 ns702 0 -0.000562571332673
Gc12_703 0 n24 ns703 0 0.000468771092938
Gc12_704 0 n24 ns704 0 -0.000895910992594
Gc12_705 0 n24 ns705 0 -0.00155407716822
Gc12_706 0 n24 ns706 0 0.000682691803282
Gc12_707 0 n24 ns707 0 -0.00368884641121
Gc12_708 0 n24 ns708 0 -0.00271406665594
Gc12_709 0 n24 ns709 0 -0.00313458101783
Gc12_710 0 n24 ns710 0 -0.00325854394473
Gc12_711 0 n24 ns711 0 0.000442036450916
Gc12_712 0 n24 ns712 0 0.000785836330585
Gc12_713 0 n24 ns713 0 0.00057855335854
Gc12_714 0 n24 ns714 0 -0.00139535576905
Gc12_715 0 n24 ns715 0 -0.000178024875396
Gc12_716 0 n24 ns716 0 -0.00288786371038
Gc12_717 0 n24 ns717 0 0.00165737034599
Gc12_718 0 n24 ns718 0 -0.00343880746544
Gc12_719 0 n24 ns719 0 -0.00215505708889
Gc12_720 0 n24 ns720 0 -2.5187209173e-05
Gc12_721 0 n24 ns721 0 0.000136717196221
Gc12_722 0 n24 ns722 0 -2.10802624036e-05
Gc12_723 0 n24 ns723 0 0.000943396271079
Gc12_724 0 n24 ns724 0 -0.00220292667002
Gc12_725 0 n24 ns725 0 0.0015301695557
Gc12_726 0 n24 ns726 0 -0.00422199335406
Gc12_727 0 n24 ns727 0 -0.00244375350689
Gc12_728 0 n24 ns728 0 -0.00108863456313
Gc12_729 0 n24 ns729 0 0.000870807533775
Gc12_730 0 n24 ns730 0 0.000321236606418
Gc12_731 0 n24 ns731 0 -0.000466266766136
Gc12_732 0 n24 ns732 0 -0.000422367542976
Gc12_733 0 n24 ns733 0 -0.000209521554827
Gc12_734 0 n24 ns734 0 4.14177649708e-05
Gc12_735 0 n24 ns735 0 0.00021647918578
Gc12_736 0 n24 ns736 0 1.70095483595e-05
Gc12_737 0 n24 ns737 0 0.00125680964206
Gc12_738 0 n24 ns738 0 -0.000519309970753
Gc12_739 0 n24 ns739 0 0.00092145331837
Gc12_740 0 n24 ns740 0 -2.35934232597e-05
Gc12_741 0 n24 ns741 0 0.000430616180381
Gc12_742 0 n24 ns742 0 -0.000115391545168
Gc12_743 0 n24 ns743 0 -0.000915890406755
Gc12_744 0 n24 ns744 0 -0.0021610186392
Gc12_745 0 n24 ns745 0 -0.00574763540606
Gc12_746 0 n24 ns746 0 -0.00434217777484
Gc12_747 0 n24 ns747 0 -0.0044631133185
Gc12_748 0 n24 ns748 0 -0.00454019890782
Gc12_749 0 n24 ns749 0 0.0044347858214
Gc12_750 0 n24 ns750 0 0.00413726668834
Gc12_751 0 n24 ns751 0 0.000938117582009
Gc12_752 0 n24 ns752 0 -0.0011373856482
Gc12_753 0 n24 ns753 0 -0.00313975877858
Gc12_754 0 n24 ns754 0 -0.00338168964677
Gc12_755 0 n24 ns755 0 0.00221508275228
Gc12_756 0 n24 ns756 0 0.00151185261005
Gc12_757 0 n24 ns757 0 -0.00374589559335
Gc12_758 0 n24 ns758 0 -1.60178015933e-06
Gc12_759 0 n24 ns759 0 0.000319856799206
Gc12_760 0 n24 ns760 0 -0.000139984763242
Gc12_761 0 n24 ns761 0 0.00275578677271
Gc12_762 0 n24 ns762 0 -0.00383076500312
Gc12_763 0 n24 ns763 0 0.00637407431814
Gc12_764 0 n24 ns764 0 -0.00785087876406
Gc12_765 0 n24 ns765 0 -0.00296256030273
Gc12_766 0 n24 ns766 0 -0.00265573260558
Gc12_767 0 n24 ns767 0 0.000888418125655
Gc12_768 0 n24 ns768 0 0.000848054235944
Gc12_769 0 n24 ns769 0 -0.0005081152305
Gc12_770 0 n24 ns770 0 -0.000681492809922
Gc12_771 0 n24 ns771 0 -0.000246830537453
Gc12_772 0 n24 ns772 0 3.49291088765e-06
Gc12_773 0 n24 ns773 0 -0.000582858500154
Gc12_774 0 n24 ns774 0 -0.000216499002406
Gc12_775 0 n24 ns775 0 0.00095376778705
Gc12_776 0 n24 ns776 0 0.000165960614343
Gc12_777 0 n24 ns777 0 0.000674420484432
Gc12_778 0 n24 ns778 0 0.000458238001065
Gc12_779 0 n24 ns779 0 -3.82007191861e-05
Gc12_780 0 n24 ns780 0 0.000711760133061
Gc12_781 0 n24 ns781 0 0.000785651186759
Gc12_782 0 n24 ns782 0 -0.00302524637677
Gc12_783 0 n24 ns783 0 -0.00227873648026
Gc12_784 0 n24 ns784 0 -0.00679116666698
Gc12_785 0 n24 ns785 0 -0.00159022411066
Gc12_786 0 n24 ns786 0 -0.00643349354334
Gc12_787 0 n24 ns787 0 0.00585318676635
Gc12_788 0 n24 ns788 0 0.00789469151737
Gc12_789 0 n24 ns789 0 0.00075075398382
Gc12_790 0 n24 ns790 0 -0.00115444478013
Gc12_791 0 n24 ns791 0 -0.00560761055791
Gc12_792 0 n24 ns792 0 -0.005734889041
Gc12_793 0 n24 ns793 0 0.00135946770016
Gc12_794 0 n24 ns794 0 0.00536302913175
Gc12_795 0 n24 ns795 0 -0.00426584029535
Gc12_796 0 n24 ns796 0 -2.05552622133e-06
Gc12_797 0 n24 ns797 0 0.000421384275762
Gc12_798 0 n24 ns798 0 -0.000231486163452
Gc12_799 0 n24 ns799 0 -0.000972153505153
Gc12_800 0 n24 ns800 0 0.000376297105951
Gc12_801 0 n24 ns801 0 -0.00260797505052
Gc12_802 0 n24 ns802 0 0.00159702688095
Gc12_803 0 n24 ns803 0 -0.000329910211045
Gc12_804 0 n24 ns804 0 0.00121181346116
Gc12_805 0 n24 ns805 0 0.000245695720492
Gc12_806 0 n24 ns806 0 -0.000510111788747
Gc12_807 0 n24 ns807 0 -0.000218612031424
Gc12_808 0 n24 ns808 0 0.000292578882001
Gc12_809 0 n24 ns809 0 -0.000153395897443
Gc12_810 0 n24 ns810 0 1.62024362169e-05
Gc12_811 0 n24 ns811 0 0.00062676568412
Gc12_812 0 n24 ns812 0 -7.76802562654e-05
Gc12_813 0 n24 ns813 0 0.000186489875695
Gc12_814 0 n24 ns814 0 -0.000844297676052
Gc12_815 0 n24 ns815 0 0.000748117219574
Gc12_816 0 n24 ns816 0 -0.000443679487241
Gc12_817 0 n24 ns817 0 0.000509961904659
Gc12_818 0 n24 ns818 0 -0.000832168387457
Gc12_819 0 n24 ns819 0 -0.00222846160563
Gc12_820 0 n24 ns820 0 0.000296009505608
Gc12_821 0 n24 ns821 0 -0.00575533662978
Gc12_822 0 n24 ns822 0 -0.000868395144382
Gc12_823 0 n24 ns823 0 -0.00466767341843
Gc12_824 0 n24 ns824 0 -0.00164148977792
Gc12_825 0 n24 ns825 0 0.00229193732086
Gc12_826 0 n24 ns826 0 0.00039082105204
Gc12_827 0 n24 ns827 0 0.000708382360194
Gc12_828 0 n24 ns828 0 -0.00120723791677
Gc12_829 0 n24 ns829 0 -0.000953709286005
Gc12_830 0 n24 ns830 0 -0.00220417689144
Gc12_831 0 n24 ns831 0 0.00223843970315
Gc12_832 0 n24 ns832 0 -0.00323529447502
Gc12_833 0 n24 ns833 0 -0.00265580892577
Gc12_834 0 n24 ns834 0 -7.54318403667e-06
Gc12_835 0 n24 ns835 0 0.000187599095861
Gc12_836 0 n24 ns836 0 -5.96027279816e-05
Gc12_837 0 n24 ns837 0 0.0002880748141
Gc12_838 0 n24 ns838 0 -0.000725526138659
Gc12_839 0 n24 ns839 0 0.000895283039963
Gc12_840 0 n24 ns840 0 7.40970724556e-05
Gc12_841 0 n24 ns841 0 4.8364373785e-05
Gc12_842 0 n24 ns842 0 -0.000291166330895
Gc12_843 0 n24 ns843 0 -8.03431128621e-05
Gc12_844 0 n24 ns844 0 2.52339132226e-05
Gc12_845 0 n24 ns845 0 -0.000165443464253
Gc12_846 0 n24 ns846 0 0.000308172752843
Gc12_847 0 n24 ns847 0 -0.000100568608088
Gc12_848 0 n24 ns848 0 0.000120747079382
Gc12_849 0 n24 ns849 0 0.000417706951616
Gc12_850 0 n24 ns850 0 -0.00035912675041
Gc12_851 0 n24 ns851 0 -0.000388081009973
Gc12_852 0 n24 ns852 0 0.00039984913134
Gc12_853 0 n24 ns853 0 0.000281561634266
Gc12_854 0 n24 ns854 0 -0.000170505907637
Gc12_855 0 n24 ns855 0 -0.000229950092875
Gc12_856 0 n24 ns856 0 -8.46427815959e-05
Gc12_857 0 n24 ns857 0 -0.000443703857861
Gc12_858 0 n24 ns858 0 0.000717068467424
Gc12_859 0 n24 ns859 0 -0.00227747479154
Gc12_860 0 n24 ns860 0 -0.00322642923787
Gc12_861 0 n24 ns861 0 -0.00223673411885
Gc12_862 0 n24 ns862 0 -0.00333383470687
Gc12_863 0 n24 ns863 0 -0.000683029440513
Gc12_864 0 n24 ns864 0 0.00118110738891
Gc12_865 0 n24 ns865 0 7.91883582964e-05
Gc12_866 0 n24 ns866 0 -0.00120962988561
Gc12_867 0 n24 ns867 0 -0.00032143630798
Gc12_868 0 n24 ns868 0 -0.00285138978576
Gc12_869 0 n24 ns869 0 0.000548010809391
Gc12_870 0 n24 ns870 0 -0.00281837527718
Gc12_871 0 n24 ns871 0 -0.001149364381
Gc12_872 0 n24 ns872 0 -3.36816901522e-05
Gc12_873 0 n24 ns873 0 9.40981687832e-05
Gc12_874 0 n24 ns874 0 -4.6320725246e-07
Gc12_875 0 n24 ns875 0 -0.000102940590015
Gc12_876 0 n24 ns876 0 -0.00013442181812
Gc12_877 0 n24 ns877 0 -0.000249645798651
Gc12_878 0 n24 ns878 0 0.000248030721348
Gc12_879 0 n24 ns879 0 -4.48749701083e-05
Gc12_880 0 n24 ns880 0 0.000123371880343
Gc12_881 0 n24 ns881 0 -5.1517504916e-05
Gc12_882 0 n24 ns882 0 -9.77713372864e-06
Gc12_883 0 n24 ns883 0 0.000293668018945
Gc12_884 0 n24 ns884 0 -4.66013142188e-05
Gc12_885 0 n24 ns885 0 -6.73287243466e-05
Gc12_886 0 n24 ns886 0 0.000141806904536
Gc12_887 0 n24 ns887 0 -8.4648975524e-07
Gc12_888 0 n24 ns888 0 9.70386760147e-05
Gc12_889 0 n24 ns889 0 0.00063854794179
Gc12_890 0 n24 ns890 0 0.000299408935371
Gc12_891 0 n24 ns891 0 0.000291755648315
Gc12_892 0 n24 ns892 0 -0.000471358818673
Gc12_893 0 n24 ns893 0 0.000100801180671
Gc12_894 0 n24 ns894 0 -0.000280710298349
Gc12_895 0 n24 ns895 0 -4.15015669982e-05
Gc12_896 0 n24 ns896 0 -0.000365189832841
Gc12_897 0 n24 ns897 0 -0.00485048249728
Gc12_898 0 n24 ns898 0 -0.00426220116488
Gc12_899 0 n24 ns899 0 -0.00448799328986
Gc12_900 0 n24 ns900 0 -0.0037599857277
Gc12_901 0 n24 ns901 0 -0.000376521465974
Gc12_902 0 n24 ns902 0 0.00186822810961
Gc12_903 0 n24 ns903 0 -0.000288440467007
Gc12_904 0 n24 ns904 0 -0.000744008923082
Gc12_905 0 n24 ns905 0 -0.000896448340662
Gc12_906 0 n24 ns906 0 -0.00207340317196
Gc12_907 0 n24 ns907 0 2.18673692913e-05
Gc12_908 0 n24 ns908 0 -0.00126452277905
Gc12_909 0 n24 ns909 0 -0.000444153543054
Gc12_910 0 n24 ns910 0 -1.15597276247e-05
Gc12_911 0 n24 ns911 0 4.2024239987e-05
Gc12_912 0 n24 ns912 0 1.30374287067e-05
Gc12_913 0 n24 ns913 0 -0.000262761842865
Gc12_914 0 n24 ns914 0 0.000513181856122
Gc12_915 0 n24 ns915 0 -0.000523450530033
Gc12_916 0 n24 ns916 0 0.000815637558996
Gc12_917 0 n24 ns917 0 -7.20776907301e-05
Gc12_918 0 n24 ns918 0 0.000349739533527
Gc12_919 0 n24 ns919 0 0.000158920836275
Gc12_920 0 n24 ns920 0 -0.000193278477962
Gc12_921 0 n24 ns921 0 0.000274468641579
Gc12_922 0 n24 ns922 0 -0.000411644441065
Gc12_923 0 n24 ns923 0 -6.40502254307e-05
Gc12_924 0 n24 ns924 0 0.000146618469151
Gc12_925 0 n24 ns925 0 0.000256517208666
Gc12_926 0 n24 ns926 0 0.000339485274888
Gc12_927 0 n24 ns927 0 0.00074093955106
Gc12_928 0 n24 ns928 0 -0.00050280593945
Gc12_929 0 n24 ns929 0 6.16536897054e-05
Gc12_930 0 n24 ns930 0 -0.000714028991973
Gc12_931 0 n24 ns931 0 2.18983717079e-05
Gc12_932 0 n24 ns932 0 -0.000730725390442
Gc12_933 0 n24 ns933 0 -0.00011520008114
Gc12_934 0 n24 ns934 0 -0.000470080301609
Gc12_935 0 n24 ns935 0 -0.00443859298565
Gc12_936 0 n24 ns936 0 -0.00178738431126
Gc12_937 0 n24 ns937 0 -0.00398267125187
Gc12_938 0 n24 ns938 0 -0.00148511237823
Gc12_939 0 n24 ns939 0 0.000225171014182
Gc12_940 0 n24 ns940 0 0.00145228897039
Gc12_941 0 n24 ns941 0 -0.000284165757148
Gc12_942 0 n24 ns942 0 -0.000407524906377
Gc12_943 0 n24 ns943 0 -0.000977735125216
Gc12_944 0 n24 ns944 0 -0.00129129785697
Gc12_945 0 n24 ns945 0 -0.000109110549289
Gc12_946 0 n24 ns946 0 -0.00071032485117
Gc12_947 0 n24 ns947 0 -0.000239626733841
Gc12_948 0 n24 ns948 0 -9.26565948211e-07
Gc12_949 0 n24 ns949 0 4.21557508432e-05
Gc12_950 0 n24 ns950 0 2.02892492247e-05
Gc12_951 0 n24 ns951 0 -0.000427359930661
Gc12_952 0 n24 ns952 0 8.40996519401e-05
Gc12_953 0 n24 ns953 0 -0.000929937462606
Gc12_954 0 n24 ns954 0 0.00244227633525
Gc12_955 0 n24 ns955 0 -0.000133030075935
Gc12_956 0 n24 ns956 0 0.000404287614315
Gc12_957 0 n24 ns957 0 0.000191807676456
Gc12_958 0 n24 ns958 0 -0.000266093333362
Gc12_959 0 n24 ns959 0 1.49969369434e-05
Gc12_960 0 n24 ns960 0 0.000518594469121
Gc12_961 0 n24 ns961 0 -0.000172078581805
Gc12_962 0 n24 ns962 0 5.54177848865e-05
Gc12_963 0 n24 ns963 0 0.000645718613484
Gc12_964 0 n24 ns964 0 -0.000495630295724
Gc12_965 0 n24 ns965 0 2.46152997321e-05
Gc12_966 0 n24 ns966 0 -0.000130026885981
Gc12_967 0 n24 ns967 0 0.000812634782337
Gc12_968 0 n24 ns968 0 -0.000518795020973
Gc12_969 0 n24 ns969 0 0.000414927511806
Gc12_970 0 n24 ns970 0 -0.000761179215451
Gc12_971 0 n24 ns971 0 -0.00070905747811
Gc12_972 0 n24 ns972 0 0.00100211768124
Gc12_973 0 n24 ns973 0 -0.00179620017431
Gc12_974 0 n24 ns974 0 -0.00353415349247
Gc12_975 0 n24 ns975 0 -0.00171267114708
Gc12_976 0 n24 ns976 0 -0.00384914865361
Gc12_977 0 n24 ns977 0 -0.000580116990882
Gc12_978 0 n24 ns978 0 0.000814196998411
Gc12_979 0 n24 ns979 0 0.000374880224838
Gc12_980 0 n24 ns980 0 -0.00136033620289
Gc12_981 0 n24 ns981 0 0.000101366088625
Gc12_982 0 n24 ns982 0 -0.00297524913062
Gc12_983 0 n24 ns983 0 0.00109029444701
Gc12_984 0 n24 ns984 0 -0.0033282088596
Gc12_985 0 n24 ns985 0 -0.00160564756926
Gc12_986 0 n24 ns986 0 -2.44059839662e-05
Gc12_987 0 n24 ns987 0 8.00668726308e-05
Gc12_988 0 n24 ns988 0 7.41870915765e-06
Gc12_989 0 n24 ns989 0 -0.00133117519159
Gc12_990 0 n24 ns990 0 -4.43701920232e-05
Gc12_991 0 n24 ns991 0 -0.00471353953906
Gc12_992 0 n24 ns992 0 -0.000551141097642
Gc12_993 0 n24 ns993 0 -0.00210418245848
Gc12_994 0 n24 ns994 0 0.00147859515145
Gc12_995 0 n24 ns995 0 0.000951203982505
Gc12_996 0 n24 ns996 0 -0.000674744286426
Gc12_997 0 n24 ns997 0 -0.000345301641184
Gc12_998 0 n24 ns998 0 0.000161330798211
Gc12_999 0 n24 ns999 0 -0.000163597887613
Gc12_1000 0 n24 ns1000 0 5.71950727222e-05
Gc12_1001 0 n24 ns1001 0 0.000841549246635
Gc12_1002 0 n24 ns1002 0 -3.81820411834e-05
Gc12_1003 0 n24 ns1003 0 0.00111413858338
Gc12_1004 0 n24 ns1004 0 -0.00103383360572
Gc12_1005 0 n24 ns1005 0 0.00115027025229
Gc12_1006 0 n24 ns1006 0 -0.000440657133708
Gc12_1007 0 n24 ns1007 0 0.00101550587655
Gc12_1008 0 n24 ns1008 0 -0.000711415651267
Gc12_1009 0 n24 ns1009 0 -0.00218713686271
Gc12_1010 0 n24 ns1010 0 -0.000845348795587
Gc12_1011 0 n24 ns1011 0 -0.00646445027249
Gc12_1012 0 n24 ns1012 0 -0.00318311036852
Gc12_1013 0 n24 ns1013 0 -0.00513592067161
Gc12_1014 0 n24 ns1014 0 -0.00358761205487
Gc12_1015 0 n24 ns1015 0 0.003377018959
Gc12_1016 0 n24 ns1016 0 0.00220599331515
Gc12_1017 0 n24 ns1017 0 0.000859712135271
Gc12_1018 0 n24 ns1018 0 -0.00123383184082
Gc12_1019 0 n24 ns1019 0 -0.00203673257515
Gc12_1020 0 n24 ns1020 0 -0.00311308994914
Gc12_1021 0 n24 ns1021 0 0.00248231288243
Gc12_1022 0 n24 ns1022 0 -0.000717298963561
Gc12_1023 0 n24 ns1023 0 -0.00322303452261
Gc12_1024 0 n24 ns1024 0 -4.94161567353e-05
Gc12_1025 0 n24 ns1025 0 0.000378890899821
Gc12_1026 0 n24 ns1026 0 -0.000174270297622
Gc12_1027 0 n24 ns1027 0 2.42677683948e-05
Gc12_1028 0 n24 ns1028 0 -0.000703715028125
Gc12_1029 0 n24 ns1029 0 0.00184144899231
Gc12_1030 0 n24 ns1030 0 0.00161068250171
Gc12_1031 0 n24 ns1031 0 0.00164612580245
Gc12_1032 0 n24 ns1032 0 -0.00120055241441
Gc12_1033 0 n24 ns1033 0 -0.00055853909465
Gc12_1034 0 n24 ns1034 0 0.000146591809324
Gc12_1035 0 n24 ns1035 0 4.46090356148e-05
Gc12_1036 0 n24 ns1036 0 -3.51337030517e-05
Gc12_1037 0 n24 ns1037 0 -0.000141868735404
Gc12_1038 0 n24 ns1038 0 4.23006825919e-05
Gc12_1039 0 n24 ns1039 0 0.00191253957428
Gc12_1040 0 n24 ns1040 0 -0.000636671474916
Gc12_1041 0 n24 ns1041 0 -0.000644144812395
Gc12_1042 0 n24 ns1042 0 0.00134993013836
Gc12_1043 0 n24 ns1043 0 -0.000523341717163
Gc12_1044 0 n24 ns1044 0 9.91429651352e-05
Gc12_1045 0 n24 ns1045 0 -0.00223221278152
Gc12_1046 0 n24 ns1046 0 -0.00114972819396
Gc12_1047 0 n24 ns1047 0 0.00292050646071
Gc12_1048 0 n24 ns1048 0 0.00366068621672
Gc12_1049 0 n24 ns1049 0 -0.0105592989608
Gc12_1050 0 n24 ns1050 0 0.00052914489019
Gc12_1051 0 n24 ns1051 0 -0.00811479668774
Gc12_1052 0 n24 ns1052 0 -0.000763530346506
Gc12_1053 0 n24 ns1053 0 -0.0106205248262
Gc12_1054 0 n24 ns1054 0 -0.000244965462492
Gc12_1055 0 n24 ns1055 0 0.00141636111134
Gc12_1056 0 n24 ns1056 0 1.59779352806e-05
Gc12_1057 0 n24 ns1057 0 -0.00373884801941
Gc12_1058 0 n24 ns1058 0 0.0084177732097
Gc12_1059 0 n24 ns1059 0 -0.0143173195154
Gc12_1060 0 n24 ns1060 0 -0.00428408152338
Gc12_1061 0 n24 ns1061 0 -0.00628571524233
Gc12_1062 0 n24 ns1062 0 -5.27580427246e-05
Gc12_1063 0 n24 ns1063 0 -0.000353307802309
Gc12_1064 0 n24 ns1064 0 0.000576464742505
Gc12_1065 0 n24 ns1065 0 -0.000908562260176
Gc12_1066 0 n24 ns1066 0 -0.000257130380721
Gc12_1067 0 n24 ns1067 0 -0.00333925178291
Gc12_1068 0 n24 ns1068 0 -0.00126623507585
Gc12_1069 0 n24 ns1069 0 -0.00189832403972
Gc12_1070 0 n24 ns1070 0 0.00129629379116
Gc12_1071 0 n24 ns1071 0 0.000827902655962
Gc12_1072 0 n24 ns1072 0 -0.000564153935571
Gc12_1073 0 n24 ns1073 0 -0.000302532186995
Gc12_1074 0 n24 ns1074 0 0.000191245788826
Gc12_1075 0 n24 ns1075 0 -0.000163521211821
Gc12_1076 0 n24 ns1076 0 -7.55913646946e-06
Gc12_1077 0 n24 ns1077 0 0.000467474583579
Gc12_1078 0 n24 ns1078 0 -6.95789117649e-05
Gc12_1079 0 n24 ns1079 0 0.000782587623279
Gc12_1080 0 n24 ns1080 0 -0.00095828970398
Gc12_1081 0 n24 ns1081 0 0.00101269999366
Gc12_1082 0 n24 ns1082 0 -0.000307364418187
Gc12_1083 0 n24 ns1083 0 0.00086953414969
Gc12_1084 0 n24 ns1084 0 -0.000591415696947
Gc12_1085 0 n24 ns1085 0 -0.00210531130387
Gc12_1086 0 n24 ns1086 0 -0.000577408004357
Gc12_1087 0 n24 ns1087 0 -0.00605908417694
Gc12_1088 0 n24 ns1088 0 -0.00181129051927
Gc12_1089 0 n24 ns1089 0 -0.00478402000053
Gc12_1090 0 n24 ns1090 0 -0.00242640157357
Gc12_1091 0 n24 ns1091 0 0.00399184821895
Gc12_1092 0 n24 ns1092 0 0.00227704568322
Gc12_1093 0 n24 ns1093 0 0.000777891450473
Gc12_1094 0 n24 ns1094 0 -0.00122667951425
Gc12_1095 0 n24 ns1095 0 -0.00251615706018
Gc12_1096 0 n24 ns1096 0 -0.00322695685758
Gc12_1097 0 n24 ns1097 0 0.00231217103743
Gc12_1098 0 n24 ns1098 0 -0.00119806807911
Gc12_1099 0 n24 ns1099 0 -0.00331962632517
Gc12_1100 0 n24 ns1100 0 -4.51920219343e-05
Gc12_1101 0 n24 ns1101 0 0.000360788465429
Gc12_1102 0 n24 ns1102 0 -0.000174349465511
Gc12_1103 0 n24 ns1103 0 -9.53495571876e-05
Gc12_1104 0 n24 ns1104 0 -5.36085113805e-05
Gc12_1105 0 n24 ns1105 0 7.38338062914e-05
Gc12_1106 0 n24 ns1106 0 0.00157513841533
Gc12_1107 0 n24 ns1107 0 9.55308471832e-05
Gc12_1108 0 n24 ns1108 0 0.000240602043376
Gc12_1109 0 n24 ns1109 0 5.32214509981e-06
Gc12_1110 0 n24 ns1110 0 -0.0002321626436
Gc12_1111 0 n24 ns1111 0 -0.000216519920409
Gc12_1112 0 n24 ns1112 0 0.000426320082751
Gc12_1113 0 n24 ns1113 0 -0.000105550119885
Gc12_1114 0 n24 ns1114 0 6.52621265746e-05
Gc12_1115 0 n24 ns1115 0 0.00060933083912
Gc12_1116 0 n24 ns1116 0 -0.000568262532545
Gc12_1117 0 n24 ns1117 0 -0.00045700087652
Gc12_1118 0 n24 ns1118 0 -0.000181412181855
Gc12_1119 0 n24 ns1119 0 0.000414753680712
Gc12_1120 0 n24 ns1120 0 -0.000337969027029
Gc12_1121 0 n24 ns1121 0 -6.22767462015e-05
Gc12_1122 0 n24 ns1122 0 -0.000490081228544
Gc12_1123 0 n24 ns1123 0 -0.000991376578471
Gc12_1124 0 n24 ns1124 0 0.00112451133694
Gc12_1125 0 n24 ns1125 0 -0.00261555074112
Gc12_1126 0 n24 ns1126 0 -0.00156243962751
Gc12_1127 0 n24 ns1127 0 -0.00239126939591
Gc12_1128 0 n24 ns1128 0 -0.00212048980181
Gc12_1129 0 n24 ns1129 0 0.000110080448598
Gc12_1130 0 n24 ns1130 0 0.000959745228538
Gc12_1131 0 n24 ns1131 0 0.000251369770652
Gc12_1132 0 n24 ns1132 0 -0.00133166520137
Gc12_1133 0 n24 ns1133 0 -0.000474728791594
Gc12_1134 0 n24 ns1134 0 -0.00300734497312
Gc12_1135 0 n24 ns1135 0 0.000920661424026
Gc12_1136 0 n24 ns1136 0 -0.00362137442679
Gc12_1137 0 n24 ns1137 0 -0.00165086081747
Gc12_1138 0 n24 ns1138 0 -2.49544963008e-05
Gc12_1139 0 n24 ns1139 0 0.000102634319245
Gc12_1140 0 n24 ns1140 0 -8.45289473053e-07
Gc12_1141 0 n24 ns1141 0 -6.51823722686e-05
Gc12_1142 0 n24 ns1142 0 -0.000320456882277
Gc12_1143 0 n24 ns1143 0 -0.000167823827219
Gc12_1144 0 n24 ns1144 0 0.000243837505789
Gc12_1145 0 n24 ns1145 0 -0.000105053767061
Gc12_1146 0 n24 ns1146 0 2.21439144677e-05
Gc12_1147 0 n24 ns1147 0 -8.27396719822e-05
Gc12_1148 0 n24 ns1148 0 -8.05013972866e-06
Gc12_1149 0 n24 ns1149 0 0.000174962667888
Gc12_1150 0 n24 ns1150 0 0.00022850171205
Gc12_1151 0 n24 ns1151 0 -6.7830973595e-05
Gc12_1152 0 n24 ns1152 0 0.000124213039394
Gc12_1153 0 n24 ns1153 0 5.82841941081e-05
Gc12_1154 0 n24 ns1154 0 -0.000201670130518
Gc12_1155 0 n24 ns1155 0 0.000351656771905
Gc12_1156 0 n24 ns1156 0 0.000580014898388
Gc12_1157 0 n24 ns1157 0 0.00038311561259
Gc12_1158 0 n24 ns1158 0 -0.000300944075097
Gc12_1159 0 n24 ns1159 0 9.07772251245e-05
Gc12_1160 0 n24 ns1160 0 -6.42875471248e-05
Gc12_1161 0 n24 ns1161 0 -9.82704209019e-05
Gc12_1162 0 n24 ns1162 0 -2.53999299102e-05
Gc12_1163 0 n24 ns1163 0 -0.00417130077038
Gc12_1164 0 n24 ns1164 0 -0.00460164257636
Gc12_1165 0 n24 ns1165 0 -0.00393829609689
Gc12_1166 0 n24 ns1166 0 -0.00419517877351
Gc12_1167 0 n24 ns1167 0 -0.000650270188315
Gc12_1168 0 n24 ns1168 0 0.00182633350507
Gc12_1169 0 n24 ns1169 0 -0.000208012333244
Gc12_1170 0 n24 ns1170 0 -0.000926928962635
Gc12_1171 0 n24 ns1171 0 -0.000717106491431
Gc12_1172 0 n24 ns1172 0 -0.00244018022088
Gc12_1173 0 n24 ns1173 0 0.000146701301329
Gc12_1174 0 n24 ns1174 0 -0.00168283477313
Gc12_1175 0 n24 ns1175 0 -0.000619481931062
Gc12_1176 0 n24 ns1176 0 -1.87317629537e-05
Gc12_1177 0 n24 ns1177 0 7.5210542669e-05
Gc12_1178 0 n24 ns1178 0 2.31901244258e-06
Gc12_1179 0 n24 ns1179 0 -0.000173937314738
Gc12_1180 0 n24 ns1180 0 0.000156445045071
Gc12_1181 0 n24 ns1181 0 -0.000201723350003
Gc12_1182 0 n24 ns1182 0 0.000571523102425
Gc12_1183 0 n24 ns1183 0 -9.44832379013e-05
Gc12_1184 0 n24 ns1184 0 0.000267769869023
Gc12_1185 0 n24 ns1185 0 0.000149277473194
Gc12_1186 0 n24 ns1186 0 -0.000121114472804
Gc12_1187 0 n24 ns1187 0 0.00037220108012
Gc12_1188 0 n24 ns1188 0 -0.000365761009818
Gc12_1189 0 n24 ns1189 0 -8.21969306703e-05
Gc12_1190 0 n24 ns1190 0 0.000155702774169
Gc12_1191 0 n24 ns1191 0 0.00012955408347
Gc12_1192 0 n24 ns1192 0 0.000349790273145
Gc12_1193 0 n24 ns1193 0 0.000824229248248
Gc12_1194 0 n24 ns1194 0 -0.00033963930405
Gc12_1195 0 n24 ns1195 0 0.000137552710475
Gc12_1196 0 n24 ns1196 0 -0.000755805230397
Gc12_1197 0 n24 ns1197 0 5.87665532888e-05
Gc12_1198 0 n24 ns1198 0 -0.000726981617454
Gc12_1199 0 n24 ns1199 0 -8.72858968189e-05
Gc12_1200 0 n24 ns1200 0 -0.000491663465984
Gc12_1201 0 n24 ns1201 0 -0.00518863068961
Gc12_1202 0 n24 ns1202 0 -0.00256434615477
Gc12_1203 0 n24 ns1203 0 -0.00468948419827
Gc12_1204 0 n24 ns1204 0 -0.00217980912361
Gc12_1205 0 n24 ns1205 0 0.000170871854723
Gc12_1206 0 n24 ns1206 0 0.0018635264083
Gc12_1207 0 n24 ns1207 0 -0.000326117811094
Gc12_1208 0 n24 ns1208 0 -0.000539274643202
Gc12_1209 0 n24 ns1209 0 -0.00109184715637
Gc12_1210 0 n24 ns1210 0 -0.00177947505476
Gc12_1211 0 n24 ns1211 0 -0.000134441750929
Gc12_1212 0 n24 ns1212 0 -0.00123786159378
Gc12_1213 0 n24 ns1213 0 -0.000374295336742
Gc12_1214 0 n24 ns1214 0 6.34418842749e-07
Gc12_1215 0 n24 ns1215 0 5.07954547572e-05
Gc12_1216 0 n24 ns1216 0 1.17536394544e-05
Gd12_1 0 n24 ni1 0 -4.02834651059e-05
Gd12_2 0 n24 ni2 0 0.000108582230542
Gd12_3 0 n24 ni3 0 -0.00160985960734
Gd12_4 0 n24 ni4 0 -0.00289217609054
Gd12_5 0 n24 ni5 0 -0.000248820967952
Gd12_6 0 n24 ni6 0 -0.00136824294414
Gd12_7 0 n24 ni7 0 0.000540331753126
Gd12_8 0 n24 ni8 0 0.000238204403099
Gd12_9 0 n24 ni9 0 0.000243899857269
Gd12_10 0 n24 ni10 0 -0.000620870240716
Gd12_11 0 n24 ni11 0 -0.00181071375618
Gd12_12 0 n24 ni12 0 0.00114040029505
Gd12_13 0 n24 ni13 0 -0.00141635101717
Gd12_14 0 n24 ni14 0 -0.00024549051029
Gd12_15 0 n24 ni15 0 0.000420419172696
Gd12_16 0 n24 ni16 0 0.000285036062742
Gd12_17 0 n24 ni17 0 3.33096642604e-05
Gd12_18 0 n24 ni18 0 -0.000450976919303
Gd12_19 0 n24 ni19 0 0.000716168481473
Gd12_20 0 n24 ni20 0 -0.00183107525765
Gd12_21 0 n24 ni21 0 -0.00397297033848
Gd12_22 0 n24 ni22 0 0.000688288321231
Gd12_23 0 n24 ni23 0 -0.000589590957267
Gd12_24 0 n24 ni24 0 1.21430534675e-05
Gd12_25 0 n24 ni25 0 0.000532484142515
Gd12_26 0 n24 ni26 0 0.000575663231069
Gd12_27 0 n24 ni27 0 0.000534676523298
Gd12_28 0 n24 ni28 0 -0.000383736156501
Gd12_29 0 n24 ni29 0 -3.7867377511e-05
Gd12_30 0 n24 ni30 0 9.97455383528e-05
Gd12_31 0 n24 ni31 0 -0.000102273079807
Gd12_32 0 n24 ni32 0 0.00023075384813
Gc13_1 0 n26 ns1 0 -1.16568148615e-05
Gc13_2 0 n26 ns2 0 -1.90775353336e-05
Gc13_3 0 n26 ns3 0 -8.83582986058e-05
Gc13_4 0 n26 ns4 0 0.000975000964811
Gc13_5 0 n26 ns5 0 0.000107558389207
Gc13_6 0 n26 ns6 0 0.000119975305528
Gc13_7 0 n26 ns7 0 -0.000169926056081
Gc13_8 0 n26 ns8 0 -0.000178480500064
Gc13_9 0 n26 ns9 0 -0.000445893360034
Gc13_10 0 n26 ns10 0 0.000233978554042
Gc13_11 0 n26 ns11 0 9.5968076448e-05
Gc13_12 0 n26 ns12 0 -0.000121236388898
Gc13_13 0 n26 ns13 0 0.000212616840363
Gc13_14 0 n26 ns14 0 -0.000138825512516
Gc13_15 0 n26 ns15 0 0.00118312798173
Gc13_16 0 n26 ns16 0 -0.000231378540952
Gc13_17 0 n26 ns17 0 0.000489519748697
Gc13_18 0 n26 ns18 0 -0.000707905977166
Gc13_19 0 n26 ns19 0 0.000594896056133
Gc13_20 0 n26 ns20 0 -0.000581016482717
Gc13_21 0 n26 ns21 0 -0.000311481052179
Gc13_22 0 n26 ns22 0 0.00111900058377
Gc13_23 0 n26 ns23 0 0.00320602624648
Gc13_24 0 n26 ns24 0 0.00403142689569
Gc13_25 0 n26 ns25 0 0.00305272346408
Gc13_26 0 n26 ns26 0 0.00340765062416
Gc13_27 0 n26 ns27 0 0.000322711690667
Gc13_28 0 n26 ns28 0 0.00123104098227
Gc13_29 0 n26 ns29 0 -0.000282026677597
Gc13_30 0 n26 ns30 0 -0.000470823510656
Gc13_31 0 n26 ns31 0 -0.00112003740293
Gc13_32 0 n26 ns32 0 -0.00138159694829
Gc13_33 0 n26 ns33 0 -0.000542725712175
Gc13_34 0 n26 ns34 0 -0.000583113613548
Gc13_35 0 n26 ns35 0 4.12809467359e-05
Gc13_36 0 n26 ns36 0 -8.63216630353e-07
Gc13_37 0 n26 ns37 0 -9.15722880894e-05
Gc13_38 0 n26 ns38 0 3.56575729625e-06
Gc13_39 0 n26 ns39 0 -0.000103119109373
Gc13_40 0 n26 ns40 0 -0.000145883418173
Gc13_41 0 n26 ns41 0 -0.000257669485774
Gc13_42 0 n26 ns42 0 0.000643132662567
Gc13_43 0 n26 ns43 0 4.55438757011e-05
Gc13_44 0 n26 ns44 0 -2.99351741783e-05
Gc13_45 0 n26 ns45 0 -5.7433486231e-05
Gc13_46 0 n26 ns46 0 -8.1874140161e-05
Gc13_47 0 n26 ns47 0 -0.000517797831323
Gc13_48 0 n26 ns48 0 0.000162638964548
Gc13_49 0 n26 ns49 0 0.000122352307274
Gc13_50 0 n26 ns50 0 -0.000132389835333
Gc13_51 0 n26 ns51 0 0.000172033554438
Gc13_52 0 n26 ns52 0 -9.68730792652e-05
Gc13_53 0 n26 ns53 0 0.00113446264602
Gc13_54 0 n26 ns54 0 8.68011374104e-05
Gc13_55 0 n26 ns55 0 0.000519467192295
Gc13_56 0 n26 ns56 0 -0.000663621482513
Gc13_57 0 n26 ns57 0 0.00047408886984
Gc13_58 0 n26 ns58 0 -0.000474504219836
Gc13_59 0 n26 ns59 0 -0.000530229689979
Gc13_60 0 n26 ns60 0 0.00084335011582
Gc13_61 0 n26 ns61 0 0.00325631908691
Gc13_62 0 n26 ns62 0 0.00434276857101
Gc13_63 0 n26 ns63 0 0.00317526937291
Gc13_64 0 n26 ns64 0 0.00375852168509
Gc13_65 0 n26 ns65 0 -0.000111473531041
Gc13_66 0 n26 ns66 0 0.0011992396623
Gc13_67 0 n26 ns67 0 -0.000273731746288
Gc13_68 0 n26 ns68 0 -0.000580111728153
Gc13_69 0 n26 ns69 0 -0.000993693220807
Gc13_70 0 n26 ns70 0 -0.00144423015126
Gc13_71 0 n26 ns71 0 -0.000590399857094
Gc13_72 0 n26 ns72 0 -0.000110843780281
Gc13_73 0 n26 ns73 0 0.000207246970517
Gc13_74 0 n26 ns74 0 3.19874524501e-06
Gc13_75 0 n26 ns75 0 -6.60287763863e-05
Gc13_76 0 n26 ns76 0 -1.53681260224e-05
Gc13_77 0 n26 ns77 0 -6.63523078951e-05
Gc13_78 0 n26 ns78 0 -4.22360743294e-05
Gc13_79 0 n26 ns79 0 8.93941339846e-05
Gc13_80 0 n26 ns80 0 0.000388253514318
Gc13_81 0 n26 ns81 0 9.31024271076e-05
Gc13_82 0 n26 ns82 0 0.000104588401709
Gc13_83 0 n26 ns83 0 2.78992071641e-05
Gc13_84 0 n26 ns84 0 8.7942347307e-05
Gc13_85 0 n26 ns85 0 -5.24755893926e-05
Gc13_86 0 n26 ns86 0 -0.00020330035697
Gc13_87 0 n26 ns87 0 0.000167899455059
Gc13_88 0 n26 ns88 0 -0.000112874824278
Gc13_89 0 n26 ns89 0 -0.000200037405999
Gc13_90 0 n26 ns90 0 -0.000321269312612
Gc13_91 0 n26 ns91 0 -0.000311908817238
Gc13_92 0 n26 ns92 0 0.000501724564352
Gc13_93 0 n26 ns93 0 0.000231353377292
Gc13_94 0 n26 ns94 0 -0.000426011389543
Gc13_95 0 n26 ns95 0 -0.000350624141555
Gc13_96 0 n26 ns96 0 -0.000506004306068
Gc13_97 0 n26 ns97 0 -9.49536196786e-05
Gc13_98 0 n26 ns98 0 -0.000815923414543
Gc13_99 0 n26 ns99 0 0.00226036289677
Gc13_100 0 n26 ns100 0 0.00324284773863
Gc13_101 0 n26 ns101 0 0.00231608417533
Gc13_102 0 n26 ns102 0 0.00326485901061
Gc13_103 0 n26 ns103 0 -0.00174780119574
Gc13_104 0 n26 ns104 0 -6.26748140286e-05
Gc13_105 0 n26 ns105 0 4.3137834119e-05
Gc13_106 0 n26 ns106 0 -0.000904188909937
Gc13_107 0 n26 ns107 0 3.49440617128e-05
Gc13_108 0 n26 ns108 0 -0.00111625399132
Gc13_109 0 n26 ns109 0 -0.000711812995867
Gc13_110 0 n26 ns110 0 0.00174162659249
Gc13_111 0 n26 ns111 0 0.000867006290339
Gc13_112 0 n26 ns112 0 1.85212272007e-05
Gc13_113 0 n26 ns113 0 -0.00016306642201
Gc13_114 0 n26 ns114 0 2.89701668868e-05
Gc13_115 0 n26 ns115 0 0.000368853082754
Gc13_116 0 n26 ns116 0 -0.00143332389497
Gc13_117 0 n26 ns117 0 0.00109016959946
Gc13_118 0 n26 ns118 0 -0.00105370353715
Gc13_119 0 n26 ns119 0 -0.000592904582626
Gc13_120 0 n26 ns120 0 0.000205589853747
Gc13_121 0 n26 ns121 0 7.69347765827e-05
Gc13_122 0 n26 ns122 0 -0.000181811681991
Gc13_123 0 n26 ns123 0 0.000433593303758
Gc13_124 0 n26 ns124 0 4.63038579588e-05
Gc13_125 0 n26 ns125 0 0.000197183169181
Gc13_126 0 n26 ns126 0 -5.40978045494e-05
Gc13_127 0 n26 ns127 0 -5.38667584201e-05
Gc13_128 0 n26 ns128 0 -4.41770300263e-05
Gc13_129 0 n26 ns129 0 -0.000643409635969
Gc13_130 0 n26 ns130 0 -0.00082729239087
Gc13_131 0 n26 ns131 0 0.000374271197339
Gc13_132 0 n26 ns132 0 -0.000579885486302
Gc13_133 0 n26 ns133 0 -0.000132222044256
Gc13_134 0 n26 ns134 0 -0.00110454899962
Gc13_135 0 n26 ns135 0 0.00179467440657
Gc13_136 0 n26 ns136 0 -9.72193723321e-05
Gc13_137 0 n26 ns137 0 0.0025744498767
Gc13_138 0 n26 ns138 0 0.00280282392462
Gc13_139 0 n26 ns139 0 0.00218405883465
Gc13_140 0 n26 ns140 0 0.00322925492053
Gc13_141 0 n26 ns141 0 -0.000209452306854
Gc13_142 0 n26 ns142 0 -0.00188407000103
Gc13_143 0 n26 ns143 0 0.000656049609175
Gc13_144 0 n26 ns144 0 -0.00104296181035
Gc13_145 0 n26 ns145 0 6.01140206932e-05
Gc13_146 0 n26 ns146 0 -0.000495108613506
Gc13_147 0 n26 ns147 0 -0.00215974569561
Gc13_148 0 n26 ns148 0 0.00245392043821
Gc13_149 0 n26 ns149 0 0.00201562934398
Gc13_150 0 n26 ns150 0 3.66143847149e-06
Gc13_151 0 n26 ns151 0 -0.000180448365528
Gc13_152 0 n26 ns152 0 4.1817757306e-05
Gc13_153 0 n26 ns153 0 0.00113150034224
Gc13_154 0 n26 ns154 0 -0.00421936564834
Gc13_155 0 n26 ns155 0 0.00137868669931
Gc13_156 0 n26 ns156 0 -0.00239395591433
Gc13_157 0 n26 ns157 0 -0.00122041316822
Gc13_158 0 n26 ns158 0 -0.000390917912842
Gc13_159 0 n26 ns159 0 0.00066159917979
Gc13_160 0 n26 ns160 0 -0.000210649162259
Gc13_161 0 n26 ns161 0 0.000233112896851
Gc13_162 0 n26 ns162 0 0.000587719494111
Gc13_163 0 n26 ns163 0 0.000266898627415
Gc13_164 0 n26 ns164 0 -5.05757781763e-05
Gc13_165 0 n26 ns165 0 -0.000623624170238
Gc13_166 0 n26 ns166 0 3.0418042895e-05
Gc13_167 0 n26 ns167 0 0.000509165306096
Gc13_168 0 n26 ns168 0 -0.000863195064967
Gc13_169 0 n26 ns169 0 0.000667561045564
Gc13_170 0 n26 ns170 0 -0.000484313224754
Gc13_171 0 n26 ns171 0 0.000175165021813
Gc13_172 0 n26 ns172 0 -0.0012200373551
Gc13_173 0 n26 ns173 0 0.000985499575991
Gc13_174 0 n26 ns174 0 0.00172176418677
Gc13_175 0 n26 ns175 0 0.00536820628681
Gc13_176 0 n26 ns176 0 0.00561846922647
Gc13_177 0 n26 ns177 0 0.00404469756848
Gc13_178 0 n26 ns178 0 0.00557669339619
Gc13_179 0 n26 ns179 0 0.0028662729401
Gc13_180 0 n26 ns180 0 0.00223707694012
Gc13_181 0 n26 ns181 0 0.000894007510768
Gc13_182 0 n26 ns182 0 -0.000965129012748
Gc13_183 0 n26 ns183 0 -0.00425862057815
Gc13_184 0 n26 ns184 0 -0.00148903208652
Gc13_185 0 n26 ns185 0 -0.000693355076466
Gc13_186 0 n26 ns186 0 -0.00268887856199
Gc13_187 0 n26 ns187 0 0.00368352709289
Gc13_188 0 n26 ns188 0 2.97411938157e-05
Gc13_189 0 n26 ns189 0 -0.000163428737797
Gc13_190 0 n26 ns190 0 4.20396596008e-05
Gc13_191 0 n26 ns191 0 0.000600187831004
Gc13_192 0 n26 ns192 0 -0.00356674418841
Gc13_193 0 n26 ns193 0 -0.00146025509422
Gc13_194 0 n26 ns194 0 -0.00117592905154
Gc13_195 0 n26 ns195 0 -0.00128918043335
Gc13_196 0 n26 ns196 0 1.51052025007e-05
Gc13_197 0 n26 ns197 0 0.000730624101648
Gc13_198 0 n26 ns198 0 -0.000193206447708
Gc13_199 0 n26 ns199 0 0.00013617632602
Gc13_200 0 n26 ns200 0 0.000549716148113
Gc13_201 0 n26 ns201 0 0.000285063081888
Gc13_202 0 n26 ns202 0 -1.62650394757e-05
Gc13_203 0 n26 ns203 0 -0.000397948991372
Gc13_204 0 n26 ns204 0 -0.000496696310905
Gc13_205 0 n26 ns205 0 9.49508830215e-05
Gc13_206 0 n26 ns206 0 -6.86501330174e-05
Gc13_207 0 n26 ns207 0 0.000364262408581
Gc13_208 0 n26 ns208 0 -0.00027323646189
Gc13_209 0 n26 ns209 0 -0.000335636069634
Gc13_210 0 n26 ns210 0 -0.00113110106928
Gc13_211 0 n26 ns211 0 -0.000330342942849
Gc13_212 0 n26 ns212 0 6.4415944679e-05
Gc13_213 0 n26 ns213 0 0.00632617264065
Gc13_214 0 n26 ns214 0 0.00587804808303
Gc13_215 0 n26 ns215 0 0.00471810893638
Gc13_216 0 n26 ns216 0 0.00577149508009
Gc13_217 0 n26 ns217 0 0.000480026777918
Gc13_218 0 n26 ns218 0 0.00533774269513
Gc13_219 0 n26 ns219 0 0.000843456623314
Gc13_220 0 n26 ns220 0 -0.000902815110642
Gc13_221 0 n26 ns221 0 -0.00624581187532
Gc13_222 0 n26 ns222 0 -0.0018672572686
Gc13_223 0 n26 ns223 0 0.00336164000421
Gc13_224 0 n26 ns224 0 -0.00500834362252
Gc13_225 0 n26 ns225 0 0.00459133921936
Gc13_226 0 n26 ns226 0 -1.96781679178e-05
Gc13_227 0 n26 ns227 0 4.16982111897e-05
Gc13_228 0 n26 ns228 0 -7.61514429734e-05
Gc13_229 0 n26 ns229 0 0.000455085978559
Gc13_230 0 n26 ns230 0 -0.00182188100818
Gc13_231 0 n26 ns231 0 0.00109551431993
Gc13_232 0 n26 ns232 0 -0.00147478487278
Gc13_233 0 n26 ns233 0 -0.000773671210888
Gc13_234 0 n26 ns234 0 -5.92086701241e-05
Gc13_235 0 n26 ns235 0 0.000159302331163
Gc13_236 0 n26 ns236 0 -0.000222492637836
Gc13_237 0 n26 ns237 0 0.000269399109151
Gc13_238 0 n26 ns238 0 0.000156679969074
Gc13_239 0 n26 ns239 0 0.000195224412957
Gc13_240 0 n26 ns240 0 -2.9050092408e-05
Gc13_241 0 n26 ns241 0 4.9831802427e-05
Gc13_242 0 n26 ns242 0 0.000396483591926
Gc13_243 0 n26 ns243 0 0.000163024851348
Gc13_244 0 n26 ns244 0 -0.000916212515165
Gc13_245 0 n26 ns245 0 0.000685135424371
Gc13_246 0 n26 ns246 0 -0.000488899204169
Gc13_247 0 n26 ns247 0 0.000333729510849
Gc13_248 0 n26 ns248 0 -0.000806598880443
Gc13_249 0 n26 ns249 0 0.00163058376456
Gc13_250 0 n26 ns250 0 0.00115612536861
Gc13_251 0 n26 ns251 0 0.00240295591841
Gc13_252 0 n26 ns252 0 0.00381053876559
Gc13_253 0 n26 ns253 0 0.00193739238101
Gc13_254 0 n26 ns254 0 0.00404101465377
Gc13_255 0 n26 ns255 0 0.00147964460712
Gc13_256 0 n26 ns256 0 -0.00201256721902
Gc13_257 0 n26 ns257 0 0.000856958847179
Gc13_258 0 n26 ns258 0 -0.000923787836406
Gc13_259 0 n26 ns259 0 -0.000379504866046
Gc13_260 0 n26 ns260 0 -0.000272301019181
Gc13_261 0 n26 ns261 0 -0.00322603577512
Gc13_262 0 n26 ns262 0 0.00258876918778
Gc13_263 0 n26 ns263 0 0.00268397499074
Gc13_264 0 n26 ns264 0 2.32856335432e-05
Gc13_265 0 n26 ns265 0 -0.000129758774676
Gc13_266 0 n26 ns266 0 2.59005227205e-05
Gc13_267 0 n26 ns267 0 -1.83096112929e-05
Gc13_268 0 n26 ns268 0 -0.000254369833704
Gc13_269 0 n26 ns269 0 0.00010028970197
Gc13_270 0 n26 ns270 0 0.000425441455743
Gc13_271 0 n26 ns271 0 0.000196348595855
Gc13_272 0 n26 ns272 0 0.00031963931031
Gc13_273 0 n26 ns273 0 -0.00018981269472
Gc13_274 0 n26 ns274 0 -3.9656462207e-05
Gc13_275 0 n26 ns275 0 -8.55901339588e-05
Gc13_276 0 n26 ns276 0 -0.000332046931814
Gc13_277 0 n26 ns277 0 0.000166116728629
Gc13_278 0 n26 ns278 0 -7.10338764536e-05
Gc13_279 0 n26 ns279 0 8.77862194544e-05
Gc13_280 0 n26 ns280 0 -0.000213172335293
Gc13_281 0 n26 ns281 0 -0.000295215345777
Gc13_282 0 n26 ns282 0 0.000299710776513
Gc13_283 0 n26 ns283 0 0.000409319429476
Gc13_284 0 n26 ns284 0 -0.000485328393666
Gc13_285 0 n26 ns285 0 -7.32283296139e-05
Gc13_286 0 n26 ns286 0 -0.000692339489254
Gc13_287 0 n26 ns287 0 0.000294620980833
Gc13_288 0 n26 ns288 0 -0.000829143469098
Gc13_289 0 n26 ns289 0 0.00179934775296
Gc13_290 0 n26 ns290 0 0.00385027113028
Gc13_291 0 n26 ns291 0 0.00183193794101
Gc13_292 0 n26 ns292 0 0.00390236553862
Gc13_293 0 n26 ns293 0 -0.00200564370769
Gc13_294 0 n26 ns294 0 -0.000723080825904
Gc13_295 0 n26 ns295 0 0.000256675392537
Gc13_296 0 n26 ns296 0 -0.00100763358696
Gc13_297 0 n26 ns297 0 0.000439223012643
Gc13_298 0 n26 ns298 0 -0.00107493954673
Gc13_299 0 n26 ns299 0 -0.000919728055798
Gc13_300 0 n26 ns300 0 0.00215633489493
Gc13_301 0 n26 ns301 0 0.0010979896341
Gc13_302 0 n26 ns302 0 2.7222533002e-05
Gc13_303 0 n26 ns303 0 -0.000239915299152
Gc13_304 0 n26 ns304 0 8.87063747066e-05
Gc13_305 0 n26 ns305 0 -1.36205108879e-05
Gc13_306 0 n26 ns306 0 -0.000496311281718
Gc13_307 0 n26 ns307 0 -0.000128311702079
Gc13_308 0 n26 ns308 0 4.10068909726e-05
Gc13_309 0 n26 ns309 0 0.000175427641168
Gc13_310 0 n26 ns310 0 -0.000136919349273
Gc13_311 0 n26 ns311 0 -1.14817723009e-05
Gc13_312 0 n26 ns312 0 -8.26037859751e-05
Gc13_313 0 n26 ns313 0 -0.000543812747691
Gc13_314 0 n26 ns314 0 -0.000292784162164
Gc13_315 0 n26 ns315 0 0.000127848517531
Gc13_316 0 n26 ns316 0 -6.22811108237e-05
Gc13_317 0 n26 ns317 0 -3.23119717367e-05
Gc13_318 0 n26 ns318 0 0.000273206197163
Gc13_319 0 n26 ns319 0 0.00076262081894
Gc13_320 0 n26 ns320 0 0.00102952863215
Gc13_321 0 n26 ns321 0 0.000587880220255
Gc13_322 0 n26 ns322 0 -0.000146179511915
Gc13_323 0 n26 ns323 0 0.000276463250351
Gc13_324 0 n26 ns324 0 0.000139630991989
Gc13_325 0 n26 ns325 0 -0.00114967957042
Gc13_326 0 n26 ns326 0 -4.56579435131e-06
Gc13_327 0 n26 ns327 0 0.000860256590214
Gc13_328 0 n26 ns328 0 0.00420713864128
Gc13_329 0 n26 ns329 0 0.00114602319044
Gc13_330 0 n26 ns330 0 0.00383771784723
Gc13_331 0 n26 ns331 0 -0.00108434700674
Gc13_332 0 n26 ns332 0 0.000971411007409
Gc13_333 0 n26 ns333 0 -0.000106120515085
Gc13_334 0 n26 ns334 0 -0.000671521426004
Gc13_335 0 n26 ns335 0 -0.000244354112028
Gc13_336 0 n26 ns336 0 -0.00141932867376
Gc13_337 0 n26 ns337 0 -0.000407960943013
Gc13_338 0 n26 ns338 0 0.000428935363033
Gc13_339 0 n26 ns339 0 0.000340395979421
Gc13_340 0 n26 ns340 0 -1.97308896262e-05
Gc13_341 0 n26 ns341 0 -0.000100602282291
Gc13_342 0 n26 ns342 0 -9.98794369048e-06
Gc13_343 0 n26 ns343 0 9.35806338219e-05
Gc13_344 0 n26 ns344 0 -0.000223330509598
Gc13_345 0 n26 ns345 0 0.000515290749463
Gc13_346 0 n26 ns346 0 0.000469838422563
Gc13_347 0 n26 ns347 0 0.000193722470665
Gc13_348 0 n26 ns348 0 -2.42499921526e-05
Gc13_349 0 n26 ns349 0 1.16108571422e-05
Gc13_350 0 n26 ns350 0 4.02368395125e-05
Gc13_351 0 n26 ns351 0 -0.000237352914644
Gc13_352 0 n26 ns352 0 -0.000107187296829
Gc13_353 0 n26 ns353 0 0.000131418955049
Gc13_354 0 n26 ns354 0 -0.000142435666809
Gc13_355 0 n26 ns355 0 -0.000259786843838
Gc13_356 0 n26 ns356 0 -0.000220320923983
Gc13_357 0 n26 ns357 0 0.000243309956824
Gc13_358 0 n26 ns358 0 0.000453810914271
Gc13_359 0 n26 ns359 0 0.000298058351997
Gc13_360 0 n26 ns360 0 -0.000529738614586
Gc13_361 0 n26 ns361 0 -0.000114556128098
Gc13_362 0 n26 ns362 0 -0.000502702409092
Gc13_363 0 n26 ns363 0 -0.000375900093675
Gc13_364 0 n26 ns364 0 -0.00019570496569
Gc13_365 0 n26 ns365 0 0.00280440751361
Gc13_366 0 n26 ns366 0 0.00386117901147
Gc13_367 0 n26 ns367 0 0.00281180355077
Gc13_368 0 n26 ns368 0 0.00359834651398
Gc13_369 0 n26 ns369 0 -0.0011381191107
Gc13_370 0 n26 ns370 0 0.000666996817913
Gc13_371 0 n26 ns371 0 -0.000127834208821
Gc13_372 0 n26 ns372 0 -0.000804511576376
Gc13_373 0 n26 ns373 0 -0.000458527696423
Gc13_374 0 n26 ns374 0 -0.00144586596805
Gc13_375 0 n26 ns375 0 -0.000661745703879
Gc13_376 0 n26 ns376 0 0.000810780496946
Gc13_377 0 n26 ns377 0 0.000531350162213
Gc13_378 0 n26 ns378 0 2.07177205104e-05
Gc13_379 0 n26 ns379 0 -0.000140486799536
Gc13_380 0 n26 ns380 0 2.44385420054e-05
Gc13_381 0 n26 ns381 0 2.51904271754e-05
Gc13_382 0 n26 ns382 0 -0.00052379234456
Gc13_383 0 n26 ns383 0 0.000208343441875
Gc13_384 0 n26 ns384 0 -0.000173387558698
Gc13_385 0 n26 ns385 0 -0.000347994254083
Gc13_386 0 n26 ns386 0 0.000390692463705
Gc13_387 0 n26 ns387 0 1.90998204105e-05
Gc13_388 0 n26 ns388 0 -0.000120803150721
Gc13_389 0 n26 ns389 0 0.000310109776004
Gc13_390 0 n26 ns390 0 -0.000137789834721
Gc13_391 0 n26 ns391 0 0.000178173079294
Gc13_392 0 n26 ns392 0 -6.71914223562e-05
Gc13_393 0 n26 ns393 0 6.30601833513e-05
Gc13_394 0 n26 ns394 0 -0.000265065084911
Gc13_395 0 n26 ns395 0 -0.000766739043333
Gc13_396 0 n26 ns396 0 -0.000297525961592
Gc13_397 0 n26 ns397 0 0.0002561029443
Gc13_398 0 n26 ns398 0 -0.000512843471067
Gc13_399 0 n26 ns399 0 -0.000261202865321
Gc13_400 0 n26 ns400 0 -0.000887386917861
Gc13_401 0 n26 ns401 0 0.00116655820542
Gc13_402 0 n26 ns402 0 -0.000799144702632
Gc13_403 0 n26 ns403 0 0.00198166238509
Gc13_404 0 n26 ns404 0 0.00272148351296
Gc13_405 0 n26 ns405 0 0.00183573369938
Gc13_406 0 n26 ns406 0 0.00305503917399
Gc13_407 0 n26 ns407 0 -0.00144460638444
Gc13_408 0 n26 ns408 0 -0.0016276379436
Gc13_409 0 n26 ns409 0 0.000438730999493
Gc13_410 0 n26 ns410 0 -0.00101545001417
Gc13_411 0 n26 ns411 0 0.000381336276014
Gc13_412 0 n26 ns412 0 -0.000534812684541
Gc13_413 0 n26 ns413 0 -0.00138250674669
Gc13_414 0 n26 ns414 0 0.00288329897264
Gc13_415 0 n26 ns415 0 0.00157390190456
Gc13_416 0 n26 ns416 0 1.60184701007e-05
Gc13_417 0 n26 ns417 0 -0.000192861750703
Gc13_418 0 n26 ns418 0 5.84283489053e-05
Gc13_419 0 n26 ns419 0 0.000293002113267
Gc13_420 0 n26 ns420 0 -0.00183641672765
Gc13_421 0 n26 ns421 0 0.000565488369922
Gc13_422 0 n26 ns422 0 -2.66092126187e-05
Gc13_423 0 n26 ns423 0 -0.000889264581093
Gc13_424 0 n26 ns424 0 0.000434108603306
Gc13_425 0 n26 ns425 0 0.000375130268421
Gc13_426 0 n26 ns426 0 -0.000549805519725
Gc13_427 0 n26 ns427 0 0.000379403597758
Gc13_428 0 n26 ns428 0 0.000457465583193
Gc13_429 0 n26 ns429 0 0.000261824331143
Gc13_430 0 n26 ns430 0 -5.39368228246e-05
Gc13_431 0 n26 ns431 0 -0.000448912579079
Gc13_432 0 n26 ns432 0 -0.000147492573962
Gc13_433 0 n26 ns433 0 0.00067290296562
Gc13_434 0 n26 ns434 0 -0.000980770229129
Gc13_435 0 n26 ns435 0 0.000866591391695
Gc13_436 0 n26 ns436 0 -0.000450953388187
Gc13_437 0 n26 ns437 0 0.000500992110133
Gc13_438 0 n26 ns438 0 -0.000948836474455
Gc13_439 0 n26 ns439 0 0.000915654370496
Gc13_440 0 n26 ns440 0 0.00221835995978
Gc13_441 0 n26 ns441 0 0.00259144700075
Gc13_442 0 n26 ns442 0 0.00446412746368
Gc13_443 0 n26 ns443 0 0.00194862908139
Gc13_444 0 n26 ns444 0 0.00463258982086
Gc13_445 0 n26 ns445 0 0.00368907599949
Gc13_446 0 n26 ns446 0 0.000682749477555
Gc13_447 0 n26 ns447 0 0.000864833311865
Gc13_448 0 n26 ns448 0 -0.00100858136767
Gc13_449 0 n26 ns449 0 -0.00199256137849
Gc13_450 0 n26 ns450 0 -0.00152828424722
Gc13_451 0 n26 ns451 0 -0.00391267452804
Gc13_452 0 n26 ns452 0 -0.000573942061197
Gc13_453 0 n26 ns453 0 0.00300508415557
Gc13_454 0 n26 ns454 0 5.02051258858e-05
Gc13_455 0 n26 ns455 0 -0.000195794216664
Gc13_456 0 n26 ns456 0 5.05902234006e-05
Gc13_457 0 n26 ns457 0 0.000262145996595
Gc13_458 0 n26 ns458 0 -0.00213245402063
Gc13_459 0 n26 ns459 0 -0.00182440171456
Gc13_460 0 n26 ns460 0 0.000549382825618
Gc13_461 0 n26 ns461 0 -0.000795690305709
Gc13_462 0 n26 ns462 0 0.00033492833511
Gc13_463 0 n26 ns463 0 0.000504682310932
Gc13_464 0 n26 ns464 0 -0.00030821651838
Gc13_465 0 n26 ns465 0 0.000131144700861
Gc13_466 0 n26 ns466 0 0.0004774429559
Gc13_467 0 n26 ns467 0 0.000289597747012
Gc13_468 0 n26 ns468 0 -1.30084053714e-05
Gc13_469 0 n26 ns469 0 -0.00065175576313
Gc13_470 0 n26 ns470 0 -0.000662637310681
Gc13_471 0 n26 ns471 0 0.000292981676581
Gc13_472 0 n26 ns472 0 8.90691763183e-05
Gc13_473 0 n26 ns473 0 0.000368587879405
Gc13_474 0 n26 ns474 0 -0.000204341535693
Gc13_475 0 n26 ns475 0 -0.000413693753383
Gc13_476 0 n26 ns476 0 -0.00108791472666
Gc13_477 0 n26 ns477 0 -0.00069270062865
Gc13_478 0 n26 ns478 0 0.000284185658786
Gc13_479 0 n26 ns479 0 0.0068207213685
Gc13_480 0 n26 ns480 0 0.00504668536293
Gc13_481 0 n26 ns481 0 0.00511769241749
Gc13_482 0 n26 ns482 0 0.00510808363271
Gc13_483 0 n26 ns483 0 0.00106509532294
Gc13_484 0 n26 ns484 0 0.0056822416829
Gc13_485 0 n26 ns485 0 0.000872187573106
Gc13_486 0 n26 ns486 0 -0.000841542260451
Gc13_487 0 n26 ns487 0 -0.00617328269257
Gc13_488 0 n26 ns488 0 -0.00166795152037
Gc13_489 0 n26 ns489 0 0.00272728771777
Gc13_490 0 n26 ns490 0 -0.00448879868886
Gc13_491 0 n26 ns491 0 0.00472431960012
Gc13_492 0 n26 ns492 0 -2.08466612782e-05
Gc13_493 0 n26 ns493 0 7.21224392393e-05
Gc13_494 0 n26 ns494 0 -0.000108726452443
Gc13_495 0 n26 ns495 0 0.0002298745519
Gc13_496 0 n26 ns496 0 -0.00187797713471
Gc13_497 0 n26 ns497 0 0.000285320370752
Gc13_498 0 n26 ns498 0 -0.000473030116058
Gc13_499 0 n26 ns499 0 -0.000946664398159
Gc13_500 0 n26 ns500 0 0.000330722003971
Gc13_501 0 n26 ns501 0 0.000387939994528
Gc13_502 0 n26 ns502 0 -0.000478107023992
Gc13_503 0 n26 ns503 0 0.000332587782076
Gc13_504 0 n26 ns504 0 0.000459783909466
Gc13_505 0 n26 ns505 0 0.000252823850282
Gc13_506 0 n26 ns506 0 -4.53331655678e-05
Gc13_507 0 n26 ns507 0 -0.000379808870582
Gc13_508 0 n26 ns508 0 -5.26596306431e-05
Gc13_509 0 n26 ns509 0 0.00064844661426
Gc13_510 0 n26 ns510 0 -0.000925897125535
Gc13_511 0 n26 ns511 0 0.000809225243491
Gc13_512 0 n26 ns512 0 -0.000420464510813
Gc13_513 0 n26 ns513 0 0.000390719384828
Gc13_514 0 n26 ns514 0 -0.000877444081139
Gc13_515 0 n26 ns515 0 0.000893812033257
Gc13_516 0 n26 ns516 0 0.00209444051194
Gc13_517 0 n26 ns517 0 0.00281303001871
Gc13_518 0 n26 ns518 0 0.00426713774677
Gc13_519 0 n26 ns519 0 0.00214392811495
Gc13_520 0 n26 ns520 0 0.00448036783599
Gc13_521 0 n26 ns521 0 0.00350421536217
Gc13_522 0 n26 ns522 0 0.000395775069042
Gc13_523 0 n26 ns523 0 0.000894040015374
Gc13_524 0 n26 ns524 0 -0.000966110807628
Gc13_525 0 n26 ns525 0 -0.00183514030544
Gc13_526 0 n26 ns526 0 -0.0012268116254
Gc13_527 0 n26 ns527 0 -0.00385785172634
Gc13_528 0 n26 ns528 0 -0.000114590412829
Gc13_529 0 n26 ns529 0 0.00311728967598
Gc13_530 0 n26 ns530 0 3.49304949048e-05
Gc13_531 0 n26 ns531 0 -0.000146959504734
Gc13_532 0 n26 ns532 0 2.33293509229e-05
Gc13_533 0 n26 ns533 0 0.00034408989253
Gc13_534 0 n26 ns534 0 -0.000751536749539
Gc13_535 0 n26 ns535 0 0.00114568099165
Gc13_536 0 n26 ns536 0 -1.90904659732e-05
Gc13_537 0 n26 ns537 0 -7.77534225196e-05
Gc13_538 0 n26 ns538 0 0.000361585878325
Gc13_539 0 n26 ns539 0 -0.000168219023636
Gc13_540 0 n26 ns540 0 -0.000108268123305
Gc13_541 0 n26 ns541 0 0.000254409272515
Gc13_542 0 n26 ns542 0 -0.000167859205395
Gc13_543 0 n26 ns543 0 0.000185076164332
Gc13_544 0 n26 ns544 0 -8.50090051309e-05
Gc13_545 0 n26 ns545 0 1.43612151525e-05
Gc13_546 0 n26 ns546 0 -0.000273345946432
Gc13_547 0 n26 ns547 0 -0.000594684070141
Gc13_548 0 n26 ns548 0 -0.000454008897833
Gc13_549 0 n26 ns549 0 0.000384697874219
Gc13_550 0 n26 ns550 0 -0.000715148555932
Gc13_551 0 n26 ns551 0 -7.18139121625e-05
Gc13_552 0 n26 ns552 0 -0.00118140731555
Gc13_553 0 n26 ns553 0 0.00132923729981
Gc13_554 0 n26 ns554 0 -0.000457099279012
Gc13_555 0 n26 ns555 0 0.00261185807966
Gc13_556 0 n26 ns556 0 0.00397088499229
Gc13_557 0 n26 ns557 0 0.00238094972484
Gc13_558 0 n26 ns558 0 0.0041099260015
Gc13_559 0 n26 ns559 0 -0.00113363946318
Gc13_560 0 n26 ns560 0 -0.00152475979113
Gc13_561 0 n26 ns561 0 0.000423480792175
Gc13_562 0 n26 ns562 0 -0.00105426781279
Gc13_563 0 n26 ns563 0 0.000163582404138
Gc13_564 0 n26 ns564 0 -0.000795021835967
Gc13_565 0 n26 ns565 0 -0.00152077384986
Gc13_566 0 n26 ns566 0 0.00240972628621
Gc13_567 0 n26 ns567 0 0.00148756432775
Gc13_568 0 n26 ns568 0 3.2870335526e-05
Gc13_569 0 n26 ns569 0 -0.000265491122416
Gc13_570 0 n26 ns570 0 9.82684580734e-05
Gc13_571 0 n26 ns571 0 -0.000174303640167
Gc13_572 0 n26 ns572 0 -0.000361392923975
Gc13_573 0 n26 ns573 0 -0.00049230265398
Gc13_574 0 n26 ns574 0 0.000295931541023
Gc13_575 0 n26 ns575 0 0.000142446441474
Gc13_576 0 n26 ns576 0 -4.29371860601e-05
Gc13_577 0 n26 ns577 0 1.04137474342e-05
Gc13_578 0 n26 ns578 0 -2.59040368093e-05
Gc13_579 0 n26 ns579 0 -0.000498615626008
Gc13_580 0 n26 ns580 0 -0.000301121108559
Gc13_581 0 n26 ns581 0 0.000170678035996
Gc13_582 0 n26 ns582 0 -7.60031215855e-05
Gc13_583 0 n26 ns583 0 1.9990824016e-05
Gc13_584 0 n26 ns584 0 7.6251557289e-05
Gc13_585 0 n26 ns585 0 0.000536951344526
Gc13_586 0 n26 ns586 0 0.00105158271071
Gc13_587 0 n26 ns587 0 0.000605415855226
Gc13_588 0 n26 ns588 0 -0.000217883362434
Gc13_589 0 n26 ns589 0 0.000178553657107
Gc13_590 0 n26 ns590 0 -8.34412293877e-06
Gc13_591 0 n26 ns591 0 -0.0010223995967
Gc13_592 0 n26 ns592 0 -0.000346053785783
Gc13_593 0 n26 ns593 0 0.00105719089528
Gc13_594 0 n26 ns594 0 0.00442717519089
Gc13_595 0 n26 ns595 0 0.00135136509082
Gc13_596 0 n26 ns596 0 0.00415926069324
Gc13_597 0 n26 ns597 0 -0.00162974626744
Gc13_598 0 n26 ns598 0 0.0006660296141
Gc13_599 0 n26 ns599 0 -2.64441468866e-05
Gc13_600 0 n26 ns600 0 -0.000821752089713
Gc13_601 0 n26 ns601 0 2.1562270735e-05
Gc13_602 0 n26 ns602 0 -0.00144885646362
Gc13_603 0 n26 ns603 0 -0.000506688601142
Gc13_604 0 n26 ns604 0 0.00102212288117
Gc13_605 0 n26 ns605 0 0.000571927452301
Gc13_606 0 n26 ns606 0 -9.22717916295e-06
Gc13_607 0 n26 ns607 0 -0.00012232626872
Gc13_608 0 n26 ns608 0 3.16225405606e-06
Gc13_609 0 n26 ns609 0 -8.01468544527e-05
Gc13_610 0 n26 ns610 0 6.32836973318e-07
Gc13_611 0 n26 ns611 0 2.04038342274e-05
Gc13_612 0 n26 ns612 0 0.000344302976554
Gc13_613 0 n26 ns613 0 -3.53906030951e-05
Gc13_614 0 n26 ns614 0 0.000128935934161
Gc13_615 0 n26 ns615 0 0.000129955153949
Gc13_616 0 n26 ns616 0 1.95435703722e-05
Gc13_617 0 n26 ns617 0 0.000532304788454
Gc13_618 0 n26 ns618 0 -0.000329103453997
Gc13_619 0 n26 ns619 0 -0.000149687544858
Gc13_620 0 n26 ns620 0 0.000117133135571
Gc13_621 0 n26 ns621 0 -9.97798524032e-05
Gc13_622 0 n26 ns622 0 0.000546550104428
Gc13_623 0 n26 ns623 0 0.00092784370663
Gc13_624 0 n26 ns624 0 -9.9951015305e-05
Gc13_625 0 n26 ns625 0 0.0003136248987
Gc13_626 0 n26 ns626 0 -0.000720405946433
Gc13_627 0 n26 ns627 0 0.000237172041691
Gc13_628 0 n26 ns628 0 -0.000723632471005
Gc13_629 0 n26 ns629 0 0.000155997027386
Gc13_630 0 n26 ns630 0 -0.000562504911261
Gc13_631 0 n26 ns631 0 -0.00426796659265
Gc13_632 0 n26 ns632 0 -0.00353199149595
Gc13_633 0 n26 ns633 0 -0.00392058595462
Gc13_634 0 n26 ns634 0 -0.00303143505384
Gc13_635 0 n26 ns635 0 -0.000146002613384
Gc13_636 0 n26 ns636 0 0.00155494146614
Gc13_637 0 n26 ns637 0 -0.000249495218093
Gc13_638 0 n26 ns638 0 -0.000517965735777
Gc13_639 0 n26 ns639 0 -0.00078331886172
Gc13_640 0 n26 ns640 0 -0.00157569000865
Gc13_641 0 n26 ns641 0 -5.67028942886e-05
Gc13_642 0 n26 ns642 0 -0.00094819135972
Gc13_643 0 n26 ns643 0 -0.000317038774128
Gc13_644 0 n26 ns644 0 -2.40976782069e-06
Gc13_645 0 n26 ns645 0 6.94349017731e-05
Gc13_646 0 n26 ns646 0 8.01493416664e-06
Gc13_647 0 n26 ns647 0 -0.000250181359871
Gc13_648 0 n26 ns648 0 -1.0745176261e-05
Gc13_649 0 n26 ns649 0 -0.000410605114397
Gc13_650 0 n26 ns650 0 0.000462143029309
Gc13_651 0 n26 ns651 0 -0.000131038486186
Gc13_652 0 n26 ns652 0 0.000197674489457
Gc13_653 0 n26 ns653 0 0.000113544065479
Gc13_654 0 n26 ns654 0 -2.35772547251e-05
Gc13_655 0 n26 ns655 0 0.000553749035507
Gc13_656 0 n26 ns656 0 -0.000198928093871
Gc13_657 0 n26 ns657 0 -0.000156644508259
Gc13_658 0 n26 ns658 0 0.000137861515566
Gc13_659 0 n26 ns659 0 -7.29960330282e-05
Gc13_660 0 n26 ns660 0 0.000434057016036
Gc13_661 0 n26 ns661 0 0.000991621867499
Gc13_662 0 n26 ns662 0 0.000154555331719
Gc13_663 0 n26 ns663 0 0.000437071716833
Gc13_664 0 n26 ns664 0 -0.000683276474224
Gc13_665 0 n26 ns665 0 0.000308291722387
Gc13_666 0 n26 ns666 0 -0.000590315298634
Gc13_667 0 n26 ns667 0 7.91538337729e-05
Gc13_668 0 n26 ns668 0 -0.000536651928403
Gc13_669 0 n26 ns669 0 -0.00495841160043
Gc13_670 0 n26 ns670 0 -0.00448985236084
Gc13_671 0 n26 ns671 0 -0.0045747139275
Gc13_672 0 n26 ns672 0 -0.00390600187663
Gc13_673 0 n26 ns673 0 -0.000372407722864
Gc13_674 0 n26 ns674 0 0.00184275819596
Gc13_675 0 n26 ns675 0 -0.000270025609416
Gc13_676 0 n26 ns676 0 -0.000666773889972
Gc13_677 0 n26 ns677 0 -0.000801600637086
Gc13_678 0 n26 ns678 0 -0.00194751244265
Gc13_679 0 n26 ns679 0 -7.41806987668e-06
Gc13_680 0 n26 ns680 0 -0.00115536121806
Gc13_681 0 n26 ns681 0 -0.000392794091226
Gc13_682 0 n26 ns682 0 -8.82599925605e-06
Gc13_683 0 n26 ns683 0 9.69827963544e-05
Gc13_684 0 n26 ns684 0 -1.42624094884e-05
Gc13_685 0 n26 ns685 0 -0.00019067490583
Gc13_686 0 n26 ns686 0 -0.000316206782871
Gc13_687 0 n26 ns687 0 -0.000541813010464
Gc13_688 0 n26 ns688 0 0.000674234370366
Gc13_689 0 n26 ns689 0 -0.000172248125155
Gc13_690 0 n26 ns690 0 2.58896734811e-05
Gc13_691 0 n26 ns691 0 -2.93832547352e-05
Gc13_692 0 n26 ns692 0 -0.000102775915682
Gc13_693 0 n26 ns693 0 -4.0265938059e-05
Gc13_694 0 n26 ns694 0 0.000383762947064
Gc13_695 0 n26 ns695 0 -8.19589657297e-05
Gc13_696 0 n26 ns696 0 0.000141875858224
Gc13_697 0 n26 ns697 0 0.000419760232631
Gc13_698 0 n26 ns698 0 -0.000408646118659
Gc13_699 0 n26 ns699 0 0.000111585592537
Gc13_700 0 n26 ns700 0 0.000573430640881
Gc13_701 0 n26 ns701 0 0.000487782997465
Gc13_702 0 n26 ns702 0 -0.000261969068947
Gc13_703 0 n26 ns703 0 7.62217461174e-05
Gc13_704 0 n26 ns704 0 -7.25475707656e-05
Gc13_705 0 n26 ns705 0 -0.000295075019888
Gc13_706 0 n26 ns706 0 0.00027821647789
Gc13_707 0 n26 ns707 0 -0.00352730804902
Gc13_708 0 n26 ns708 0 -0.00495375680247
Gc13_709 0 n26 ns709 0 -0.00338281177387
Gc13_710 0 n26 ns710 0 -0.00468191754111
Gc13_711 0 n26 ns711 0 -0.000975454983985
Gc13_712 0 n26 ns712 0 0.00161529965913
Gc13_713 0 n26 ns713 0 -5.28471570357e-05
Gc13_714 0 n26 ns714 0 -0.00111572401626
Gc13_715 0 n26 ns715 0 -0.000362403581178
Gc13_716 0 n26 ns716 0 -0.00271943840883
Gc13_717 0 n26 ns717 0 0.000397028784559
Gc13_718 0 n26 ns718 0 -0.00205218773869
Gc13_719 0 n26 ns719 0 -0.000843352701165
Gc13_720 0 n26 ns720 0 -2.06138966729e-05
Gc13_721 0 n26 ns721 0 0.000107932702157
Gc13_722 0 n26 ns722 0 -1.50415012725e-05
Gc13_723 0 n26 ns723 0 -0.000296958993093
Gc13_724 0 n26 ns724 0 -0.000479036833593
Gc13_725 0 n26 ns725 0 -0.00089579219075
Gc13_726 0 n26 ns726 0 0.000800940712059
Gc13_727 0 n26 ns727 0 -0.000106351744095
Gc13_728 0 n26 ns728 0 0.000507824058057
Gc13_729 0 n26 ns729 0 0.000131885732952
Gc13_730 0 n26 ns730 0 -0.000290977796576
Gc13_731 0 n26 ns731 0 -0.000485971021011
Gc13_732 0 n26 ns732 0 0.000207569315836
Gc13_733 0 n26 ns733 0 -0.000141145143982
Gc13_734 0 n26 ns734 0 8.91683290718e-05
Gc13_735 0 n26 ns735 0 0.000894120392077
Gc13_736 0 n26 ns736 0 -0.000178721982527
Gc13_737 0 n26 ns737 0 -0.000344880201002
Gc13_738 0 n26 ns738 0 -0.000557473951115
Gc13_739 0 n26 ns739 0 0.000501523401666
Gc13_740 0 n26 ns740 0 -0.000325603196727
Gc13_741 0 n26 ns741 0 1.91787242553e-05
Gc13_742 0 n26 ns742 0 -0.00059126998022
Gc13_743 0 n26 ns743 0 -0.00166664496366
Gc13_744 0 n26 ns744 0 0.000714532165234
Gc13_745 0 n26 ns745 0 -0.00378788153614
Gc13_746 0 n26 ns746 0 -0.00140581449176
Gc13_747 0 n26 ns747 0 -0.00320453248054
Gc13_748 0 n26 ns748 0 -0.00210950891654
Gc13_749 0 n26 ns749 0 0.00091406198072
Gc13_750 0 n26 ns750 0 0.000644909510322
Gc13_751 0 n26 ns751 0 0.000508123094322
Gc13_752 0 n26 ns752 0 -0.00133526139409
Gc13_753 0 n26 ns753 0 -0.00053546952917
Gc13_754 0 n26 ns754 0 -0.00269456060373
Gc13_755 0 n26 ns755 0 0.00155562198479
Gc13_756 0 n26 ns756 0 -0.00345086592239
Gc13_757 0 n26 ns757 0 -0.00214247720353
Gc13_758 0 n26 ns758 0 -2.34030073342e-05
Gc13_759 0 n26 ns759 0 0.000132570045405
Gc13_760 0 n26 ns760 0 -1.22459068665e-05
Gc13_761 0 n26 ns761 0 0.00105330813399
Gc13_762 0 n26 ns762 0 -0.00191509017779
Gc13_763 0 n26 ns763 0 0.00213071669205
Gc13_764 0 n26 ns764 0 -0.00414113817309
Gc13_765 0 n26 ns765 0 -0.00241478614298
Gc13_766 0 n26 ns766 0 -0.00102805959243
Gc13_767 0 n26 ns767 0 0.000876972695641
Gc13_768 0 n26 ns768 0 0.000313866382995
Gc13_769 0 n26 ns769 0 -0.000305761028385
Gc13_770 0 n26 ns770 0 -0.00028272925265
Gc13_771 0 n26 ns771 0 -0.000207335346199
Gc13_772 0 n26 ns772 0 -3.91280044531e-05
Gc13_773 0 n26 ns773 0 -0.000121194156042
Gc13_774 0 n26 ns774 0 -0.000175659468842
Gc13_775 0 n26 ns775 0 0.00110984998096
Gc13_776 0 n26 ns776 0 -0.00054253113455
Gc13_777 0 n26 ns777 0 0.000909563248973
Gc13_778 0 n26 ns778 0 7.23943915038e-06
Gc13_779 0 n26 ns779 0 0.000476165086365
Gc13_780 0 n26 ns780 0 -0.000126822573614
Gc13_781 0 n26 ns781 0 -0.000811879197136
Gc13_782 0 n26 ns782 0 -0.00180572654615
Gc13_783 0 n26 ns783 0 -0.0053622942387
Gc13_784 0 n26 ns784 0 -0.00304854068451
Gc13_785 0 n26 ns785 0 -0.00412766139046
Gc13_786 0 n26 ns786 0 -0.00345768442162
Gc13_787 0 n26 ns787 0 0.00500736637085
Gc13_788 0 n26 ns788 0 0.00434148944709
Gc13_789 0 n26 ns789 0 0.000862542791391
Gc13_790 0 n26 ns790 0 -0.00115708141061
Gc13_791 0 n26 ns791 0 -0.00359061582066
Gc13_792 0 n26 ns792 0 -0.00363733356426
Gc13_793 0 n26 ns793 0 0.00205238708989
Gc13_794 0 n26 ns794 0 0.000889363996521
Gc13_795 0 n26 ns795 0 -0.0038793736226
Gc13_796 0 n26 ns796 0 -7.11177463189e-07
Gc13_797 0 n26 ns797 0 0.00030331623597
Gc13_798 0 n26 ns798 0 -0.000147119026171
Gc13_799 0 n26 ns799 0 0.00272544666331
Gc13_800 0 n26 ns800 0 -0.00384235257167
Gc13_801 0 n26 ns801 0 0.0062721047892
Gc13_802 0 n26 ns802 0 -0.00782448747685
Gc13_803 0 n26 ns803 0 -0.00299017706076
Gc13_804 0 n26 ns804 0 -0.00264766678457
Gc13_805 0 n26 ns805 0 0.000903221066639
Gc13_806 0 n26 ns806 0 0.000847752098637
Gc13_807 0 n26 ns807 0 -0.000514213626949
Gc13_808 0 n26 ns808 0 -0.000664242285896
Gc13_809 0 n26 ns809 0 -0.00024448046218
Gc13_810 0 n26 ns810 0 4.93964546931e-06
Gc13_811 0 n26 ns811 0 -0.000561346632406
Gc13_812 0 n26 ns812 0 -0.000230061458551
Gc13_813 0 n26 ns813 0 0.000968415293642
Gc13_814 0 n26 ns814 0 0.000168148847075
Gc13_815 0 n26 ns815 0 0.0006867510878
Gc13_816 0 n26 ns816 0 0.000457533066402
Gc13_817 0 n26 ns817 0 -2.26533895959e-05
Gc13_818 0 n26 ns818 0 0.000716176735545
Gc13_819 0 n26 ns819 0 0.000764328413949
Gc13_820 0 n26 ns820 0 -0.00301861499297
Gc13_821 0 n26 ns821 0 -0.00233667731493
Gc13_822 0 n26 ns822 0 -0.00680568349394
Gc13_823 0 n26 ns823 0 -0.00164082892825
Gc13_824 0 n26 ns824 0 -0.00644807558165
Gc13_825 0 n26 ns825 0 0.00583513534552
Gc13_826 0 n26 ns826 0 0.00788697551169
Gc13_827 0 n26 ns827 0 0.000749418609874
Gc13_828 0 n26 ns828 0 -0.00115815714303
Gc13_829 0 n26 ns829 0 -0.00559769187662
Gc13_830 0 n26 ns830 0 -0.00572888290944
Gc13_831 0 n26 ns831 0 0.00136272554258
Gc13_832 0 n26 ns832 0 0.00537123738634
Gc13_833 0 n26 ns833 0 -0.00425528159267
Gc13_834 0 n26 ns834 0 -1.75988818232e-06
Gc13_835 0 n26 ns835 0 0.000419661850387
Gc13_836 0 n26 ns836 0 -0.000230137470584
Gc13_837 0 n26 ns837 0 -0.00105230697909
Gc13_838 0 n26 ns838 0 4.9542996056e-05
Gc13_839 0 n26 ns839 0 -0.00312469531615
Gc13_840 0 n26 ns840 0 0.00152956856156
Gc13_841 0 n26 ns841 0 -0.000337222402
Gc13_842 0 n26 ns842 0 0.00113701083329
Gc13_843 0 n26 ns843 0 0.000227722261138
Gc13_844 0 n26 ns844 0 -0.0004930506406
Gc13_845 0 n26 ns845 0 -0.00037600868848
Gc13_846 0 n26 ns846 0 0.000151382170386
Gc13_847 0 n26 ns847 0 -0.000155305699256
Gc13_848 0 n26 ns848 0 9.6147261732e-05
Gc13_849 0 n26 ns849 0 0.000952907251611
Gc13_850 0 n26 ns850 0 0.000113318204591
Gc13_851 0 n26 ns851 0 0.000331849587335
Gc13_852 0 n26 ns852 0 -0.000825064406307
Gc13_853 0 n26 ns853 0 0.000758242518308
Gc13_854 0 n26 ns854 0 -0.00047989620305
Gc13_855 0 n26 ns855 0 0.000464678001709
Gc13_856 0 n26 ns856 0 -0.000830573213273
Gc13_857 0 n26 ns857 0 -0.00231646338754
Gc13_858 0 n26 ns858 0 -5.76257034675e-05
Gc13_859 0 n26 ns859 0 -0.00610402802743
Gc13_860 0 n26 ns860 0 -0.00216289203975
Gc13_861 0 n26 ns861 0 -0.00497106021251
Gc13_862 0 n26 ns862 0 -0.00272452477462
Gc13_863 0 n26 ns863 0 0.00173265868464
Gc13_864 0 n26 ns864 0 0.000178309219437
Gc13_865 0 n26 ns865 0 0.000784245198252
Gc13_866 0 n26 ns866 0 -0.00118444968903
Gc13_867 0 n26 ns867 0 -0.000508758472391
Gc13_868 0 n26 ns868 0 -0.00193601477646
Gc13_869 0 n26 ns869 0 0.00240689221278
Gc13_870 0 n26 ns870 0 -0.00261413929327
Gc13_871 0 n26 ns871 0 -0.00252675276776
Gc13_872 0 n26 ns872 0 -9.53261419371e-06
Gc13_873 0 n26 ns873 0 0.000196250290402
Gc13_874 0 n26 ns874 0 -5.11436227592e-05
Gc13_875 0 n26 ns875 0 -0.000311659589222
Gc13_876 0 n26 ns876 0 -0.000120330666448
Gc13_877 0 n26 ns877 0 -0.000719166931954
Gc13_878 0 n26 ns878 0 0.00141539171893
Gc13_879 0 n26 ns879 0 -0.000344557403282
Gc13_880 0 n26 ns880 0 0.000100389989078
Gc13_881 0 n26 ns881 0 0.000214243453974
Gc13_882 0 n26 ns882 0 -0.000165516352341
Gc13_883 0 n26 ns883 0 6.15354806204e-05
Gc13_884 0 n26 ns884 0 0.000429616350268
Gc13_885 0 n26 ns885 0 -0.000132884137193
Gc13_886 0 n26 ns886 0 0.000125341653208
Gc13_887 0 n26 ns887 0 0.000589595613435
Gc13_888 0 n26 ns888 0 -0.000465991697704
Gc13_889 0 n26 ns889 0 0.000126682965778
Gc13_890 0 n26 ns890 0 0.000273788136444
Gc13_891 0 n26 ns891 0 0.000630562181379
Gc13_892 0 n26 ns892 0 -0.000411550868029
Gc13_893 0 n26 ns893 0 0.000230272475544
Gc13_894 0 n26 ns894 0 -0.000394199447126
Gc13_895 0 n26 ns895 0 -0.000337721122711
Gc13_896 0 n26 ns896 0 0.00069951025677
Gc13_897 0 n26 ns897 0 -0.00220379769102
Gc13_898 0 n26 ns898 0 -0.0044793408973
Gc13_899 0 n26 ns899 0 -0.00218581118407
Gc13_900 0 n26 ns900 0 -0.00443543974565
Gc13_901 0 n26 ns901 0 -0.0011264291424
Gc13_902 0 n26 ns902 0 0.00134510825023
Gc13_903 0 n26 ns903 0 0.000147520967973
Gc13_904 0 n26 ns904 0 -0.0012700495353
Gc13_905 0 n26 ns905 0 1.72351622156e-05
Gc13_906 0 n26 ns906 0 -0.0030639452229
Gc13_907 0 n26 ns907 0 0.000641178470072
Gc13_908 0 n26 ns908 0 -0.00283366504511
Gc13_909 0 n26 ns909 0 -0.00116759091123
Gc13_910 0 n26 ns910 0 -3.86427514755e-05
Gc13_911 0 n26 ns911 0 0.000102264851581
Gc13_912 0 n26 ns912 0 -1.01515117191e-05
Gc13_913 0 n26 ns913 0 9.14447398111e-05
Gc13_914 0 n26 ns914 0 -0.000594900752099
Gc13_915 0 n26 ns915 0 0.00023669913377
Gc13_916 0 n26 ns916 0 -3.15964281339e-05
Gc13_917 0 n26 ns917 0 -4.09116104384e-07
Gc13_918 0 n26 ns918 0 -0.000109559727286
Gc13_919 0 n26 ns919 0 -7.73052428981e-05
Gc13_920 0 n26 ns920 0 0.000225565611322
Gc13_921 0 n26 ns921 0 0.000563573172797
Gc13_922 0 n26 ns922 0 0.000184392363313
Gc13_923 0 n26 ns923 0 -0.000161567850646
Gc13_924 0 n26 ns924 0 2.85031480745e-05
Gc13_925 0 n26 ns925 0 -0.000499935594477
Gc13_926 0 n26 ns926 0 0.000239916966865
Gc13_927 0 n26 ns927 0 0.000728109606351
Gc13_928 0 n26 ns928 0 0.00082253072065
Gc13_929 0 n26 ns929 0 0.000673325272985
Gc13_930 0 n26 ns930 0 -0.000301213924236
Gc13_931 0 n26 ns931 0 0.00052871432403
Gc13_932 0 n26 ns932 0 -0.000180542034229
Gc13_933 0 n26 ns933 0 0.000470570362345
Gc13_934 0 n26 ns934 0 -0.000301424619108
Gc13_935 0 n26 ns935 0 -0.00240336041965
Gc13_936 0 n26 ns936 0 -0.00585973696472
Gc13_937 0 n26 ns937 0 -0.00241004081796
Gc13_938 0 n26 ns938 0 -0.00520667997505
Gc13_939 0 n26 ns939 0 -0.00096094273467
Gc13_940 0 n26 ns940 0 0.00127142030481
Gc13_941 0 n26 ns941 0 -0.000119473583803
Gc13_942 0 n26 ns942 0 -0.000714709694922
Gc13_943 0 n26 ns943 0 -0.000281341726713
Gc13_944 0 n26 ns944 0 -0.00176002606315
Gc13_945 0 n26 ns945 0 0.00016473198143
Gc13_946 0 n26 ns946 0 -0.000858910647663
Gc13_947 0 n26 ns947 0 -0.000375043039849
Gc13_948 0 n26 ns948 0 -1.51609473363e-06
Gc13_949 0 n26 ns949 0 4.27491549663e-05
Gc13_950 0 n26 ns950 0 1.97964989234e-05
Gc13_951 0 n26 ns951 0 -0.000569288585616
Gc13_952 0 n26 ns952 0 0.000324258877426
Gc13_953 0 n26 ns953 0 -0.00150135007476
Gc13_954 0 n26 ns954 0 0.00131335374617
Gc13_955 0 n26 ns955 0 -0.000416551262957
Gc13_956 0 n26 ns956 0 0.000374387570997
Gc13_957 0 n26 ns957 0 0.000133085215263
Gc13_958 0 n26 ns958 0 -0.000194004989078
Gc13_959 0 n26 ns959 0 0.000300509127935
Gc13_960 0 n26 ns960 0 0.000353367307343
Gc13_961 0 n26 ns961 0 -6.43092362542e-05
Gc13_962 0 n26 ns962 0 0.00012397371045
Gc13_963 0 n26 ns963 0 0.000212861368269
Gc13_964 0 n26 ns964 0 -0.000392170995372
Gc13_965 0 n26 ns965 0 0.000651837870383
Gc13_966 0 n26 ns966 0 0.000436443054435
Gc13_967 0 n26 ns967 0 0.000566672602835
Gc13_968 0 n26 ns968 0 -0.000453521949684
Gc13_969 0 n26 ns969 0 0.00035566364545
Gc13_970 0 n26 ns970 0 -0.000244228456543
Gc13_971 0 n26 ns971 0 -0.000114266740046
Gc13_972 0 n26 ns972 0 2.68916408023e-05
Gc13_973 0 n26 ns973 0 -0.0043719442863
Gc13_974 0 n26 ns974 0 -0.00497748449553
Gc13_975 0 n26 ns975 0 -0.00411110260876
Gc13_976 0 n26 ns976 0 -0.00453067073607
Gc13_977 0 n26 ns977 0 -0.000817405914185
Gc13_978 0 n26 ns978 0 0.00200125673247
Gc13_979 0 n26 ns979 0 -0.000187304135092
Gc13_980 0 n26 ns980 0 -0.000966703084588
Gc13_981 0 n26 ns981 0 -0.000598243499978
Gc13_982 0 n26 ns982 0 -0.00261433564775
Gc13_983 0 n26 ns983 0 0.000183271151227
Gc13_984 0 n26 ns984 0 -0.00176935467165
Gc13_985 0 n26 ns985 0 -0.000646838258
Gc13_986 0 n26 ns986 0 -2.00654356313e-05
Gc13_987 0 n26 ns987 0 9.85165105222e-05
Gc13_988 0 n26 ns988 0 -2.14666901426e-05
Gc13_989 0 n26 ns989 0 8.31799240711e-05
Gc13_990 0 n26 ns990 0 -0.000554927814779
Gc13_991 0 n26 ns991 0 0.000376232393249
Gc13_992 0 n26 ns992 0 0.000998766443166
Gc13_993 0 n26 ns993 0 0.000201948509823
Gc13_994 0 n26 ns994 0 4.69885514074e-05
Gc13_995 0 n26 ns995 0 -7.51305150608e-05
Gc13_996 0 n26 ns996 0 -0.000151028284759
Gc13_997 0 n26 ns997 0 -0.000342784891714
Gc13_998 0 n26 ns998 0 0.000265692011881
Gc13_999 0 n26 ns999 0 -0.000117972771204
Gc13_1000 0 n26 ns1000 0 0.000114383797183
Gc13_1001 0 n26 ns1001 0 0.000726777020496
Gc13_1002 0 n26 ns1002 0 -0.000335600812615
Gc13_1003 0 n26 ns1003 0 -0.00048853639247
Gc13_1004 0 n26 ns1004 0 -0.000114844488874
Gc13_1005 0 n26 ns1005 0 0.000347973246608
Gc13_1006 0 n26 ns1006 0 -0.000308187456834
Gc13_1007 0 n26 ns1007 0 -0.000199126108825
Gc13_1008 0 n26 ns1008 0 -0.000437459198486
Gc13_1009 0 n26 ns1009 0 -0.00100780246196
Gc13_1010 0 n26 ns1010 0 0.000879450364285
Gc13_1011 0 n26 ns1011 0 -0.00266791598731
Gc13_1012 0 n26 ns1012 0 -0.00224751679987
Gc13_1013 0 n26 ns1013 0 -0.00244038311915
Gc13_1014 0 n26 ns1014 0 -0.00268809818676
Gc13_1015 0 n26 ns1015 0 -0.000155451380543
Gc13_1016 0 n26 ns1016 0 0.000741557459578
Gc13_1017 0 n26 ns1017 0 0.000291331157641
Gc13_1018 0 n26 ns1018 0 -0.00129906313997
Gc13_1019 0 n26 ns1019 0 -0.000251940722416
Gc13_1020 0 n26 ns1020 0 -0.00276635104561
Gc13_1021 0 n26 ns1021 0 0.00100105212775
Gc13_1022 0 n26 ns1022 0 -0.003216086813
Gc13_1023 0 n26 ns1023 0 -0.00156047917712
Gc13_1024 0 n26 ns1024 0 -2.56045797545e-05
Gc13_1025 0 n26 ns1025 0 9.83824242504e-05
Gc13_1026 0 n26 ns1026 0 5.78946839893e-06
Gc13_1027 0 n26 ns1027 0 -0.000903647166923
Gc13_1028 0 n26 ns1028 0 -0.000254870634733
Gc13_1029 0 n26 ns1029 0 -0.0033236322743
Gc13_1030 0 n26 ns1030 0 -0.00125755955614
Gc13_1031 0 n26 ns1031 0 -0.00189336229804
Gc13_1032 0 n26 ns1032 0 0.0012988238053
Gc13_1033 0 n26 ns1033 0 0.000824787321231
Gc13_1034 0 n26 ns1034 0 -0.000565336347438
Gc13_1035 0 n26 ns1035 0 -0.000300306563794
Gc13_1036 0 n26 ns1036 0 0.000191031420897
Gc13_1037 0 n26 ns1037 0 -0.000163584357446
Gc13_1038 0 n26 ns1038 0 -8.1710894301e-06
Gc13_1039 0 n26 ns1039 0 0.000462912713184
Gc13_1040 0 n26 ns1040 0 -7.11203505687e-05
Gc13_1041 0 n26 ns1041 0 0.000782449676954
Gc13_1042 0 n26 ns1042 0 -0.000961079795883
Gc13_1043 0 n26 ns1043 0 0.00101272153189
Gc13_1044 0 n26 ns1044 0 -0.000309732317486
Gc13_1045 0 n26 ns1045 0 0.000870473197644
Gc13_1046 0 n26 ns1046 0 -0.000595816524458
Gc13_1047 0 n26 ns1047 0 -0.00210257293006
Gc13_1048 0 n26 ns1048 0 -0.000575373634474
Gc13_1049 0 n26 ns1049 0 -0.00605615764505
Gc13_1050 0 n26 ns1050 0 -0.00180544711431
Gc13_1051 0 n26 ns1051 0 -0.00478108942641
Gc13_1052 0 n26 ns1052 0 -0.00242166719364
Gc13_1053 0 n26 ns1053 0 0.00399770970453
Gc13_1054 0 n26 ns1054 0 0.00227966907393
Gc13_1055 0 n26 ns1055 0 0.000778180882355
Gc13_1056 0 n26 ns1056 0 -0.0012271227842
Gc13_1057 0 n26 ns1057 0 -0.00251845139244
Gc13_1058 0 n26 ns1058 0 -0.00323154809678
Gc13_1059 0 n26 ns1059 0 0.00231536579953
Gc13_1060 0 n26 ns1060 0 -0.00121525259272
Gc13_1061 0 n26 ns1061 0 -0.00332616326935
Gc13_1062 0 n26 ns1062 0 -4.55059730281e-05
Gc13_1063 0 n26 ns1063 0 0.000358814993093
Gc13_1064 0 n26 ns1064 0 -0.000173717935996
Gc13_1065 0 n26 ns1065 0 -0.000146595626387
Gc13_1066 0 n26 ns1066 0 -0.000197022690039
Gc13_1067 0 n26 ns1067 0 0.00156660540967
Gc13_1068 0 n26 ns1068 0 0.00224114840343
Gc13_1069 0 n26 ns1069 0 0.00158915478606
Gc13_1070 0 n26 ns1070 0 -0.000984411995757
Gc13_1071 0 n26 ns1071 0 -0.000509773827683
Gc13_1072 0 n26 ns1072 0 5.30555334053e-05
Gc13_1073 0 n26 ns1073 0 0.000177736192279
Gc13_1074 0 n26 ns1074 0 0.000110565525063
Gc13_1075 0 n26 ns1075 0 -0.000130681516955
Gc13_1076 0 n26 ns1076 0 -8.98434032227e-06
Gc13_1077 0 n26 ns1077 0 0.00176934527883
Gc13_1078 0 n26 ns1078 0 -0.000857827850423
Gc13_1079 0 n26 ns1079 0 -0.000646178697443
Gc13_1080 0 n26 ns1080 0 0.00128028310839
Gc13_1081 0 n26 ns1081 0 -0.000483639838293
Gc13_1082 0 n26 ns1082 0 6.53802915675e-05
Gc13_1083 0 n26 ns1083 0 -0.00213825369014
Gc13_1084 0 n26 ns1084 0 -0.00121601367078
Gc13_1085 0 n26 ns1085 0 0.00297516245541
Gc13_1086 0 n26 ns1086 0 0.00384920774364
Gc13_1087 0 n26 ns1087 0 -0.0103505418116
Gc13_1088 0 n26 ns1088 0 0.00102860429192
Gc13_1089 0 n26 ns1089 0 -0.00793353951191
Gc13_1090 0 n26 ns1090 0 -0.000348719258379
Gc13_1091 0 n26 ns1091 0 -0.0104127659207
Gc13_1092 0 n26 ns1092 0 -0.000139694868169
Gc13_1093 0 n26 ns1093 0 0.00138230121759
Gc13_1094 0 n26 ns1094 0 4.3242471365e-06
Gc13_1095 0 n26 ns1095 0 -0.00392393871777
Gc13_1096 0 n26 ns1096 0 0.00830444325014
Gc13_1097 0 n26 ns1097 0 -0.0143896703635
Gc13_1098 0 n26 ns1098 0 -0.00445351993563
Gc13_1099 0 n26 ns1099 0 -0.00631515674175
Gc13_1100 0 n26 ns1100 0 -5.36744763736e-05
Gc13_1101 0 n26 ns1101 0 -0.000364964038647
Gc13_1102 0 n26 ns1102 0 0.000581547565009
Gc13_1103 0 n26 ns1103 0 -0.000878392738482
Gc13_1104 0 n26 ns1104 0 -0.000654241001794
Gc13_1105 0 n26 ns1105 0 -0.00352688409658
Gc13_1106 0 n26 ns1106 0 -0.00150441241766
Gc13_1107 0 n26 ns1107 0 -0.00183265336813
Gc13_1108 0 n26 ns1108 0 0.00115343632331
Gc13_1109 0 n26 ns1109 0 0.00076088907547
Gc13_1110 0 n26 ns1110 0 -0.000500177013386
Gc13_1111 0 n26 ns1111 0 -0.000468544156714
Gc13_1112 0 n26 ns1112 0 7.02324387334e-05
Gc13_1113 0 n26 ns1113 0 -0.000162081973061
Gc13_1114 0 n26 ns1114 0 5.52818448089e-05
Gc13_1115 0 n26 ns1115 0 0.000707454154731
Gc13_1116 0 n26 ns1116 0 0.000106670286971
Gc13_1117 0 n26 ns1117 0 0.000832206385715
Gc13_1118 0 n26 ns1118 0 -0.000897375577876
Gc13_1119 0 n26 ns1119 0 0.000985831043859
Gc13_1120 0 n26 ns1120 0 -0.000292766111198
Gc13_1121 0 n26 ns1121 0 0.000778352942086
Gc13_1122 0 n26 ns1122 0 -0.000532334206084
Gc13_1123 0 n26 ns1123 0 -0.00218545714291
Gc13_1124 0 n26 ns1124 0 -0.000871455719183
Gc13_1125 0 n26 ns1125 0 -0.00630547490617
Gc13_1126 0 n26 ns1126 0 -0.00279790129103
Gc13_1127 0 n26 ns1127 0 -0.00500039613459
Gc13_1128 0 n26 ns1128 0 -0.00324840174888
Gc13_1129 0 n26 ns1129 0 0.00354827401457
Gc13_1130 0 n26 ns1130 0 0.00206297138039
Gc13_1131 0 n26 ns1131 0 0.000834495305198
Gc13_1132 0 n26 ns1132 0 -0.00120083574626
Gc13_1133 0 n26 ns1133 0 -0.00217225450667
Gc13_1134 0 n26 ns1134 0 -0.00296478384773
Gc13_1135 0 n26 ns1135 0 0.00244217030123
Gc13_1136 0 n26 ns1136 0 -0.000617360476327
Gc13_1137 0 n26 ns1137 0 -0.00319545400571
Gc13_1138 0 n26 ns1138 0 -4.37373094499e-05
Gc13_1139 0 n26 ns1139 0 0.000364466027933
Gc13_1140 0 n26 ns1140 0 -0.000160387987768
Gc13_1141 0 n26 ns1141 0 -0.000595742418378
Gc13_1142 0 n26 ns1142 0 0.000327271436235
Gc13_1143 0 n26 ns1143 0 -0.00137607999673
Gc13_1144 0 n26 ns1144 0 0.00259256904337
Gc13_1145 0 n26 ns1145 0 -0.000203410471191
Gc13_1146 0 n26 ns1146 0 0.000551821707993
Gc13_1147 0 n26 ns1147 0 0.000212217405712
Gc13_1148 0 n26 ns1148 0 -0.00041428857211
Gc13_1149 0 n26 ns1149 0 -0.000148989010279
Gc13_1150 0 n26 ns1150 0 0.000440701743482
Gc13_1151 0 n26 ns1151 0 -0.000114076029489
Gc13_1152 0 n26 ns1152 0 0.000109980380057
Gc13_1153 0 n26 ns1153 0 0.000915430599949
Gc13_1154 0 n26 ns1154 0 -0.000613927061864
Gc13_1155 0 n26 ns1155 0 -5.25382299109e-05
Gc13_1156 0 n26 ns1156 0 -0.000326839531287
Gc13_1157 0 n26 ns1157 0 0.000625065188532
Gc13_1158 0 n26 ns1158 0 -0.00053689855324
Gc13_1159 0 n26 ns1159 0 0.000205301719782
Gc13_1160 0 n26 ns1160 0 -0.000716525865982
Gc13_1161 0 n26 ns1161 0 -0.00100819091345
Gc13_1162 0 n26 ns1162 0 0.000985066975909
Gc13_1163 0 n26 ns1163 0 -0.0029209475163
Gc13_1164 0 n26 ns1164 0 -0.00273539507521
Gc13_1165 0 n26 ns1165 0 -0.00265828611137
Gc13_1166 0 n26 ns1166 0 -0.00312894606114
Gc13_1167 0 n26 ns1167 0 -0.000352570446474
Gc13_1168 0 n26 ns1168 0 0.00105353381458
Gc13_1169 0 n26 ns1169 0 0.000314804869247
Gc13_1170 0 n26 ns1170 0 -0.00136826744456
Gc13_1171 0 n26 ns1171 0 -0.000125667194825
Gc13_1172 0 n26 ns1172 0 -0.00309037896802
Gc13_1173 0 n26 ns1173 0 0.00102782629217
Gc13_1174 0 n26 ns1174 0 -0.00342516546588
Gc13_1175 0 n26 ns1175 0 -0.00161547849354
Gc13_1176 0 n26 ns1176 0 -2.88854435993e-05
Gc13_1177 0 n26 ns1177 0 0.000112779170422
Gc13_1178 0 n26 ns1178 0 -6.51369639181e-06
Gc13_1179 0 n26 ns1179 0 -7.43271973777e-05
Gc13_1180 0 n26 ns1180 0 -0.000575872591418
Gc13_1181 0 n26 ns1181 0 -0.000184249875062
Gc13_1182 0 n26 ns1182 0 0.000321322356654
Gc13_1183 0 n26 ns1183 0 -0.000239248883676
Gc13_1184 0 n26 ns1184 0 -3.06262236384e-05
Gc13_1185 0 n26 ns1185 0 5.19880769814e-05
Gc13_1186 0 n26 ns1186 0 9.047118628e-05
Gc13_1187 0 n26 ns1187 0 0.00048689791284
Gc13_1188 0 n26 ns1188 0 0.000343483763208
Gc13_1189 0 n26 ns1189 0 -0.000164427369311
Gc13_1190 0 n26 ns1190 0 6.27176253761e-05
Gc13_1191 0 n26 ns1191 0 -0.000232418839461
Gc13_1192 0 n26 ns1192 0 -2.98770357637e-05
Gc13_1193 0 n26 ns1193 0 0.000644943814338
Gc13_1194 0 n26 ns1194 0 0.000847201434826
Gc13_1195 0 n26 ns1195 0 0.000766744765423
Gc13_1196 0 n26 ns1196 0 -0.000330638369427
Gc13_1197 0 n26 ns1197 0 0.000542833403366
Gc13_1198 0 n26 ns1198 0 -0.000186167262099
Gc13_1199 0 n26 ns1199 0 0.000324423239419
Gc13_1200 0 n26 ns1200 0 -2.46652482932e-05
Gc13_1201 0 n26 ns1201 0 -0.00264506617453
Gc13_1202 0 n26 ns1202 0 -0.00623315192759
Gc13_1203 0 n26 ns1203 0 -0.0026564545695
Gc13_1204 0 n26 ns1204 0 -0.00565276867892
Gc13_1205 0 n26 ns1205 0 -0.00114130185804
Gc13_1206 0 n26 ns1206 0 0.00157917498279
Gc13_1207 0 n26 ns1207 0 -9.05820886089e-05
Gc13_1208 0 n26 ns1208 0 -0.000944311185228
Gc13_1209 0 n26 ns1209 0 -0.000264833584152
Gc13_1210 0 n26 ns1210 0 -0.00239594817971
Gc13_1211 0 n26 ns1211 0 0.000259455465247
Gc13_1212 0 n26 ns1212 0 -0.00155782891467
Gc13_1213 0 n26 ns1213 0 -0.000614746807844
Gc13_1214 0 n26 ns1214 0 -1.42893496055e-05
Gc13_1215 0 n26 ns1215 0 6.72051038207e-05
Gc13_1216 0 n26 ns1216 0 -3.54054556451e-06
Gd13_1 0 n26 ni1 0 0.000189811727899
Gd13_2 0 n26 ni2 0 0.000190137586041
Gd13_3 0 n26 ni3 0 0.0002967424797
Gd13_4 0 n26 ni4 0 -0.00121382909184
Gd13_5 0 n26 ni5 0 -0.00273337346651
Gd13_6 0 n26 ni6 0 -0.000269976170149
Gd13_7 0 n26 ni7 0 -0.00152139360558
Gd13_8 0 n26 ni8 0 0.000143015251155
Gd13_9 0 n26 ni9 0 1.80629743589e-05
Gd13_10 0 n26 ni10 0 7.13966636324e-05
Gd13_11 0 n26 ni11 0 -0.000222227075619
Gd13_12 0 n26 ni12 0 -0.0014163508793
Gd13_13 0 n26 ni13 0 0.00111161932633
Gd13_14 0 n26 ni14 0 -0.00145266951135
Gd13_15 0 n26 ni15 0 -0.000540585851627
Gd13_16 0 n26 ni16 0 0.000254639745803
Gd13_17 0 n26 ni17 0 8.87116875932e-05
Gd13_18 0 n26 ni18 0 0.000215182048152
Gd13_19 0 n26 ni19 0 6.14362123136e-05
Gd13_20 0 n26 ni20 0 -0.000198259526374
Gd13_21 0 n26 ni21 0 -0.00183325353271
Gd13_22 0 n26 ni22 0 -0.00395662068999
Gd13_23 0 n26 ni23 0 0.000655321847801
Gd13_24 0 n26 ni24 0 0.00033212839582
Gd13_25 0 n26 ni25 0 -0.000353156714415
Gd13_26 0 n26 ni26 0 0.000711487823199
Gd13_27 0 n26 ni27 0 -0.000308560304807
Gd13_28 0 n26 ni28 0 -3.91196944745e-05
Gd13_29 0 n26 ni29 0 4.09470469347e-05
Gd13_30 0 n26 ni30 0 -0.000215707043526
Gd13_31 0 n26 ni31 0 0.000815847323792
Gd13_32 0 n26 ni32 0 -0.000204052509201
Gc14_1 0 n28 ns1 0 0.000564498421666
Gc14_2 0 n28 ns2 0 -4.05238961665e-05
Gc14_3 0 n28 ns3 0 0.00176813003745
Gc14_4 0 n28 ns4 0 0.000366154285568
Gc14_5 0 n28 ns5 0 0.000258657893481
Gc14_6 0 n28 ns6 0 -4.42147101141e-06
Gc14_7 0 n28 ns7 0 -0.000186911322721
Gc14_8 0 n28 ns8 0 6.40601338964e-05
Gc14_9 0 n28 ns9 0 0.000174165421074
Gc14_10 0 n28 ns10 0 0.000258740455688
Gc14_11 0 n28 ns11 0 -4.54139617993e-05
Gc14_12 0 n28 ns12 0 -0.000103662425665
Gc14_13 0 n28 ns13 0 -0.000261943844276
Gc14_14 0 n28 ns14 0 -0.000306224242523
Gc14_15 0 n28 ns15 0 7.76099699901e-06
Gc14_16 0 n28 ns16 0 -0.000931486696571
Gc14_17 0 n28 ns17 0 -0.000281355678109
Gc14_18 0 n28 ns18 0 -0.000656430638652
Gc14_19 0 n28 ns19 0 -0.000209140341716
Gc14_20 0 n28 ns20 0 -0.000856171386084
Gc14_21 0 n28 ns21 0 0.000820030306668
Gc14_22 0 n28 ns22 0 0.000628999788372
Gc14_23 0 n28 ns23 0 0.00375909094203
Gc14_24 0 n28 ns24 0 0.00047693611908
Gc14_25 0 n28 ns25 0 0.00327716885442
Gc14_26 0 n28 ns26 0 0.000273114915679
Gc14_27 0 n28 ns27 0 0.000783756437437
Gc14_28 0 n28 ns28 0 0.000496394225552
Gc14_29 0 n28 ns29 0 -0.000248146365544
Gc14_30 0 n28 ns30 0 -0.000186774704879
Gc14_31 0 n28 ns31 0 -0.00112608186739
Gc14_32 0 n28 ns32 0 -0.000582380161425
Gc14_33 0 n28 ns33 0 -0.000481974170328
Gc14_34 0 n28 ns34 0 -0.000482263121817
Gc14_35 0 n28 ns35 0 8.82566218334e-06
Gc14_36 0 n28 ns36 0 3.11913565934e-05
Gc14_37 0 n28 ns37 0 -0.000120247589856
Gc14_38 0 n28 ns38 0 4.74668683694e-05
Gc14_39 0 n28 ns39 0 0.000107706750084
Gc14_40 0 n28 ns40 0 0.000287102700785
Gc14_41 0 n28 ns41 0 0.000544247070536
Gc14_42 0 n28 ns42 0 0.000618359968422
Gc14_43 0 n28 ns43 0 -3.44962425969e-05
Gc14_44 0 n28 ns44 0 1.2382657428e-05
Gc14_45 0 n28 ns45 0 -3.25410797526e-05
Gc14_46 0 n28 ns46 0 5.46415844345e-05
Gc14_47 0 n28 ns47 0 4.14176805524e-05
Gc14_48 0 n28 ns48 0 0.000477551792722
Gc14_49 0 n28 ns49 0 -1.58936386027e-06
Gc14_50 0 n28 ns50 0 -0.000138441141683
Gc14_51 0 n28 ns51 0 -5.73947798996e-05
Gc14_52 0 n28 ns52 0 -0.000434933016435
Gc14_53 0 n28 ns53 0 0.00033733227662
Gc14_54 0 n28 ns54 0 -0.000919202786136
Gc14_55 0 n28 ns55 0 -0.000156188570055
Gc14_56 0 n28 ns56 0 -0.000730490214277
Gc14_57 0 n28 ns57 0 -4.94676486102e-05
Gc14_58 0 n28 ns58 0 -0.000825281614675
Gc14_59 0 n28 ns59 0 0.000591680459857
Gc14_60 0 n28 ns60 0 0.000786240729693
Gc14_61 0 n28 ns61 0 0.00407034445783
Gc14_62 0 n28 ns62 0 0.000956268500482
Gc14_63 0 n28 ns63 0 0.00361578425118
Gc14_64 0 n28 ns64 0 0.000679149509739
Gc14_65 0 n28 ns65 0 0.000647194573528
Gc14_66 0 n28 ns66 0 0.00070156541027
Gc14_67 0 n28 ns67 0 -0.000284588201145
Gc14_68 0 n28 ns68 0 -0.000258092720637
Gc14_69 0 n28 ns69 0 -0.00117036636847
Gc14_70 0 n28 ns70 0 -0.000736234370524
Gc14_71 0 n28 ns71 0 -0.000498911110933
Gc14_72 0 n28 ns72 0 -0.00038165883143
Gc14_73 0 n28 ns73 0 4.85553719475e-05
Gc14_74 0 n28 ns74 0 1.58672595666e-05
Gc14_75 0 n28 ns75 0 -3.14199864909e-05
Gc14_76 0 n28 ns76 0 -9.9345603522e-06
Gc14_77 0 n28 ns77 0 -0.000386228876691
Gc14_78 0 n28 ns78 0 0.000291234483351
Gc14_79 0 n28 ns79 0 -0.000910383177427
Gc14_80 0 n28 ns80 0 0.000849618782253
Gc14_81 0 n28 ns81 0 -0.000228500600395
Gc14_82 0 n28 ns82 0 0.000124993710727
Gc14_83 0 n28 ns83 0 0.000163291905799
Gc14_84 0 n28 ns84 0 -0.000148715602112
Gc14_85 0 n28 ns85 0 -0.000312150687913
Gc14_86 0 n28 ns86 0 0.0002531006949
Gc14_87 0 n28 ns87 0 0.000104923583853
Gc14_88 0 n28 ns88 0 -0.000142324646645
Gc14_89 0 n28 ns89 0 6.79271393604e-05
Gc14_90 0 n28 ns90 0 -0.000250202918165
Gc14_91 0 n28 ns91 0 0.000839753648893
Gc14_92 0 n28 ns92 0 5.69344667397e-05
Gc14_93 0 n28 ns93 0 0.000304299324384
Gc14_94 0 n28 ns94 0 -0.000540791442299
Gc14_95 0 n28 ns95 0 0.000220433886427
Gc14_96 0 n28 ns96 0 -0.000327644695214
Gc14_97 0 n28 ns97 0 -0.000510330913976
Gc14_98 0 n28 ns98 0 0.000572926514555
Gc14_99 0 n28 ns99 0 0.00293293417675
Gc14_100 0 n28 ns100 0 0.00293751936278
Gc14_101 0 n28 ns101 0 0.00287861462758
Gc14_102 0 n28 ns102 0 0.00254146014767
Gc14_103 0 n28 ns103 0 -0.000192916199
Gc14_104 0 n28 ns104 0 0.00124727370907
Gc14_105 0 n28 ns105 0 -0.000309478923824
Gc14_106 0 n28 ns106 0 -0.000557986484166
Gc14_107 0 n28 ns107 0 -0.00100822624652
Gc14_108 0 n28 ns108 0 -0.00132293564908
Gc14_109 0 n28 ns109 0 -0.000525008401962
Gc14_110 0 n28 ns110 0 0.000116895890761
Gc14_111 0 n28 ns111 0 0.00023580440263
Gc14_112 0 n28 ns112 0 2.772257267e-06
Gc14_113 0 n28 ns113 0 -1.77281365343e-05
Gc14_114 0 n28 ns114 0 -4.58005255781e-05
Gc14_115 0 n28 ns115 0 -9.57870919112e-05
Gc14_116 0 n28 ns116 0 0.00010796965153
Gc14_117 0 n28 ns117 0 0.000137418214732
Gc14_118 0 n28 ns118 0 0.000899689465491
Gc14_119 0 n28 ns119 0 8.20276419206e-05
Gc14_120 0 n28 ns120 0 0.000259774981217
Gc14_121 0 n28 ns121 0 6.26556412195e-05
Gc14_122 0 n28 ns122 0 -2.12924402175e-05
Gc14_123 0 n28 ns123 0 1.20565515584e-05
Gc14_124 0 n28 ns124 0 -0.000210162978937
Gc14_125 0 n28 ns125 0 0.000179635374727
Gc14_126 0 n28 ns126 0 -0.000117168586245
Gc14_127 0 n28 ns127 0 -0.0002579328452
Gc14_128 0 n28 ns128 0 -0.000427956016865
Gc14_129 0 n28 ns129 0 -0.000307742607154
Gc14_130 0 n28 ns130 0 0.00049270055042
Gc14_131 0 n28 ns131 0 0.000286399475777
Gc14_132 0 n28 ns132 0 -0.000408311675912
Gc14_133 0 n28 ns133 0 -0.000243905893587
Gc14_134 0 n28 ns134 0 -0.000508345661678
Gc14_135 0 n28 ns135 0 -0.000131436372218
Gc14_136 0 n28 ns136 0 -0.000742650093157
Gc14_137 0 n28 ns137 0 0.00180126028188
Gc14_138 0 n28 ns138 0 0.00323191814625
Gc14_139 0 n28 ns139 0 0.00191937666336
Gc14_140 0 n28 ns140 0 0.00324069414745
Gc14_141 0 n28 ns141 0 -0.00159600987777
Gc14_142 0 n28 ns142 0 0.000289532959571
Gc14_143 0 n28 ns143 0 6.47646167118e-06
Gc14_144 0 n28 ns144 0 -0.000951423709492
Gc14_145 0 n28 ns145 0 -0.000117184893656
Gc14_146 0 n28 ns146 0 -0.0014405460165
Gc14_147 0 n28 ns147 0 -0.000750215683771
Gc14_148 0 n28 ns148 0 0.0012881715465
Gc14_149 0 n28 ns149 0 0.000752114932667
Gc14_150 0 n28 ns150 0 3.34988790625e-05
Gc14_151 0 n28 ns151 0 -0.000201350213163
Gc14_152 0 n28 ns152 0 4.32741037301e-05
Gc14_153 0 n28 ns153 0 0.000360380143368
Gc14_154 0 n28 ns154 0 -0.00143134561366
Gc14_155 0 n28 ns155 0 0.00107181187279
Gc14_156 0 n28 ns156 0 -0.00106870842859
Gc14_157 0 n28 ns157 0 -0.000592345643473
Gc14_158 0 n28 ns158 0 0.000205677008793
Gc14_159 0 n28 ns159 0 7.61161936627e-05
Gc14_160 0 n28 ns160 0 -0.000181654920329
Gc14_161 0 n28 ns161 0 0.000429492548559
Gc14_162 0 n28 ns162 0 3.99108761731e-05
Gc14_163 0 n28 ns163 0 0.000197987802959
Gc14_164 0 n28 ns164 0 -5.35916213596e-05
Gc14_165 0 n28 ns165 0 -5.09143313006e-05
Gc14_166 0 n28 ns166 0 -3.78719379151e-05
Gc14_167 0 n28 ns167 0 -0.00064352706882
Gc14_168 0 n28 ns168 0 -0.000813627065636
Gc14_169 0 n28 ns169 0 0.000376028048521
Gc14_170 0 n28 ns170 0 -0.000576349537929
Gc14_171 0 n28 ns171 0 -0.000135542123425
Gc14_172 0 n28 ns172 0 -0.00109645300424
Gc14_173 0 n28 ns173 0 0.00178337626022
Gc14_174 0 n28 ns174 0 -0.00010709613328
Gc14_175 0 n28 ns175 0 0.00256675153329
Gc14_176 0 n28 ns176 0 0.00279876157774
Gc14_177 0 n28 ns177 0 0.0021808177364
Gc14_178 0 n28 ns178 0 0.00322768376812
Gc14_179 0 n28 ns179 0 -0.00021978862664
Gc14_180 0 n28 ns180 0 -0.00188106501722
Gc14_181 0 n28 ns181 0 0.00065491591795
Gc14_182 0 n28 ns182 0 -0.00104446600177
Gc14_183 0 n28 ns183 0 6.29536283234e-05
Gc14_184 0 n28 ns184 0 -0.000494625231393
Gc14_185 0 n28 ns185 0 -0.0021598233725
Gc14_186 0 n28 ns186 0 0.00246614869669
Gc14_187 0 n28 ns187 0 0.00201936100191
Gc14_188 0 n28 ns188 0 4.8986043795e-06
Gc14_189 0 n28 ns189 0 -0.000176646044465
Gc14_190 0 n28 ns190 0 3.96819966824e-05
Gc14_191 0 n28 ns191 0 0.00114613613361
Gc14_192 0 n28 ns192 0 -0.00439539240573
Gc14_193 0 n28 ns193 0 0.00128215112856
Gc14_194 0 n28 ns194 0 -0.00297635832066
Gc14_195 0 n28 ns195 0 -0.0012441392603
Gc14_196 0 n28 ns196 0 -0.000583165215801
Gc14_197 0 n28 ns197 0 0.000647076732904
Gc14_198 0 n28 ns198 0 -8.12673846484e-05
Gc14_199 0 n28 ns199 0 0.000156578898887
Gc14_200 0 n28 ns200 0 0.000609356749861
Gc14_201 0 n28 ns201 0 0.000260478376306
Gc14_202 0 n28 ns202 0 -4.63433059523e-05
Gc14_203 0 n28 ns203 0 -0.000545110377948
Gc14_204 0 n28 ns204 0 0.000140785189369
Gc14_205 0 n28 ns205 0 0.000511288097239
Gc14_206 0 n28 ns206 0 -0.000855131851939
Gc14_207 0 n28 ns207 0 0.000618887832537
Gc14_208 0 n28 ns208 0 -0.000504746620469
Gc14_209 0 n28 ns209 0 6.94237670864e-05
Gc14_210 0 n28 ns210 0 -0.00121702980709
Gc14_211 0 n28 ns211 0 0.00103198480652
Gc14_212 0 n28 ns212 0 0.00163740471621
Gc14_213 0 n28 ns213 0 0.0058854641742
Gc14_214 0 n28 ns214 0 0.00561208611196
Gc14_215 0 n28 ns215 0 0.00449439100559
Gc14_216 0 n28 ns216 0 0.00559134704554
Gc14_217 0 n28 ns217 0 0.00268239828033
Gc14_218 0 n28 ns218 0 0.0018670703278
Gc14_219 0 n28 ns219 0 0.000929063154588
Gc14_220 0 n28 ns220 0 -0.000920764444471
Gc14_221 0 n28 ns221 0 -0.00410460200156
Gc14_222 0 n28 ns222 0 -0.00114357873874
Gc14_223 0 n28 ns223 0 -0.000623193816303
Gc14_224 0 n28 ns224 0 -0.00220780464979
Gc14_225 0 n28 ns225 0 0.00380208283954
Gc14_226 0 n28 ns226 0 1.43735512841e-05
Gc14_227 0 n28 ns227 0 -0.000116648183083
Gc14_228 0 n28 ns228 0 2.35136649764e-05
Gc14_229 0 n28 ns229 0 0.00094373855925
Gc14_230 0 n28 ns230 0 -0.0039139137658
Gc14_231 0 n28 ns231 0 -0.00057684929171
Gc14_232 0 n28 ns232 0 -0.00132382025416
Gc14_233 0 n28 ns233 0 -0.000947503519375
Gc14_234 0 n28 ns234 0 -8.42342066908e-05
Gc14_235 0 n28 ns235 0 0.000468686729708
Gc14_236 0 n28 ns236 0 -0.000162149616795
Gc14_237 0 n28 ns237 0 -3.06021049234e-05
Gc14_238 0 n28 ns238 0 0.000440744164059
Gc14_239 0 n28 ns239 0 0.000294735885817
Gc14_240 0 n28 ns240 0 -1.43924547286e-05
Gc14_241 0 n28 ns241 0 -0.000368555098896
Gc14_242 0 n28 ns242 0 -0.00035105648885
Gc14_243 0 n28 ns243 0 0.000360663865249
Gc14_244 0 n28 ns244 0 -8.67641131522e-05
Gc14_245 0 n28 ns245 0 0.000560573400054
Gc14_246 0 n28 ns246 0 -0.000429137579128
Gc14_247 0 n28 ns247 0 -9.90004961758e-05
Gc14_248 0 n28 ns248 0 -0.00133950497607
Gc14_249 0 n28 ns249 0 -0.000275429499916
Gc14_250 0 n28 ns250 0 0.000389542713263
Gc14_251 0 n28 ns251 0 0.00685686080468
Gc14_252 0 n28 ns252 0 0.00739346341144
Gc14_253 0 n28 ns253 0 0.00518695349752
Gc14_254 0 n28 ns254 0 0.00707601093232
Gc14_255 0 n28 ns255 0 0.000693142405363
Gc14_256 0 n28 ns256 0 0.00529217792411
Gc14_257 0 n28 ns257 0 0.000858564516242
Gc14_258 0 n28 ns258 0 -0.000924256763152
Gc14_259 0 n28 ns259 0 -0.00633610517483
Gc14_260 0 n28 ns260 0 -0.00199068674648
Gc14_261 0 n28 ns261 0 0.00324901166969
Gc14_262 0 n28 ns262 0 -0.00528665481559
Gc14_263 0 n28 ns263 0 0.00454956272977
Gc14_264 0 n28 ns264 0 -4.31884102748e-06
Gc14_265 0 n28 ns265 0 -2.3349594698e-05
Gc14_266 0 n28 ns266 0 -3.89519542689e-05
Gc14_267 0 n28 ns267 0 0.000375061888839
Gc14_268 0 n28 ns268 0 -0.00233876424897
Gc14_269 0 n28 ns269 0 0.000523064749326
Gc14_270 0 n28 ns270 0 -0.00216804839661
Gc14_271 0 n28 ns271 0 -0.00077927605745
Gc14_272 0 n28 ns272 0 -0.000222734527534
Gc14_273 0 n28 ns273 0 0.000166603225929
Gc14_274 0 n28 ns274 0 -0.000240594588062
Gc14_275 0 n28 ns275 0 -1.78923678487e-05
Gc14_276 0 n28 ns276 0 -0.000203008628677
Gc14_277 0 n28 ns277 0 0.000230291523199
Gc14_278 0 n28 ns278 0 7.07510574499e-05
Gc14_279 0 n28 ns279 0 0.000281077591774
Gc14_280 0 n28 ns280 0 0.000864505075929
Gc14_281 0 n28 ns281 0 0.000366200157994
Gc14_282 0 n28 ns282 0 -7.61327693762e-05
Gc14_283 0 n28 ns283 0 0.00103393907326
Gc14_284 0 n28 ns284 0 -4.38052370145e-05
Gc14_285 0 n28 ns285 0 0.000612619190127
Gc14_286 0 n28 ns286 0 -0.000180947560494
Gc14_287 0 n28 ns287 0 0.000887726212494
Gc14_288 0 n28 ns288 0 0.000837101860131
Gc14_289 0 n28 ns289 0 6.02568658754e-05
Gc14_290 0 n28 ns290 0 0.00450451331023
Gc14_291 0 n28 ns291 0 -4.51621679277e-05
Gc14_292 0 n28 ns292 0 0.00475579515968
Gc14_293 0 n28 ns293 0 0.000816857897328
Gc14_294 0 n28 ns294 0 -0.00211610123017
Gc14_295 0 n28 ns295 0 0.00100837178502
Gc14_296 0 n28 ns296 0 -0.000952915347757
Gc14_297 0 n28 ns297 0 0.000276547369813
Gc14_298 0 n28 ns298 0 -0.000276134107971
Gc14_299 0 n28 ns299 0 -0.00303533520109
Gc14_300 0 n28 ns300 0 0.00282823280321
Gc14_301 0 n28 ns301 0 0.00272311212101
Gc14_302 0 n28 ns302 0 -4.90085729031e-06
Gc14_303 0 n28 ns303 0 -0.000124992965335
Gc14_304 0 n28 ns304 0 2.65780995403e-06
Gc14_305 0 n28 ns305 0 0.000110793020304
Gc14_306 0 n28 ns306 0 -0.000370985773342
Gc14_307 0 n28 ns307 0 0.000389873136553
Gc14_308 0 n28 ns308 0 0.000418773494498
Gc14_309 0 n28 ns309 0 0.000149870851888
Gc14_310 0 n28 ns310 0 0.000233364535682
Gc14_311 0 n28 ns311 0 2.01061766651e-06
Gc14_312 0 n28 ns312 0 0.000113878982584
Gc14_313 0 n28 ns313 0 0.000248276715877
Gc14_314 0 n28 ns314 0 -0.000592683453937
Gc14_315 0 n28 ns315 0 0.000158213368538
Gc14_316 0 n28 ns316 0 3.41538106627e-05
Gc14_317 0 n28 ns317 0 -0.000111047183699
Gc14_318 0 n28 ns318 0 -0.000280321229279
Gc14_319 0 n28 ns319 0 -0.0012219021779
Gc14_320 0 n28 ns320 0 0.000780565066885
Gc14_321 0 n28 ns321 0 0.000249639677109
Gc14_322 0 n28 ns322 0 0.000128134960427
Gc14_323 0 n28 ns323 0 -0.000369409097198
Gc14_324 0 n28 ns324 0 -0.000184187699157
Gc14_325 0 n28 ns325 0 0.000148321260419
Gc14_326 0 n28 ns326 0 -0.00179081819736
Gc14_327 0 n28 ns327 0 -0.00174349632188
Gc14_328 0 n28 ns328 0 0.00227671491636
Gc14_329 0 n28 ns329 0 -0.0013492142889
Gc14_330 0 n28 ns330 0 0.00271946855397
Gc14_331 0 n28 ns331 0 -0.00259410340336
Gc14_332 0 n28 ns332 0 -0.0012339400146
Gc14_333 0 n28 ns333 0 0.000509755807711
Gc14_334 0 n28 ns334 0 -0.000940301212879
Gc14_335 0 n28 ns335 0 0.00132195797035
Gc14_336 0 n28 ns336 0 -0.000765979615869
Gc14_337 0 n28 ns337 0 -0.000663633119005
Gc14_338 0 n28 ns338 0 0.00227342561075
Gc14_339 0 n28 ns339 0 0.00110661838836
Gc14_340 0 n28 ns340 0 2.87359396504e-05
Gc14_341 0 n28 ns341 0 -0.00033902774661
Gc14_342 0 n28 ns342 0 0.000139126742657
Gc14_343 0 n28 ns343 0 -0.000455195242256
Gc14_344 0 n28 ns344 0 0.000574067651005
Gc14_345 0 n28 ns345 0 -0.00111905768578
Gc14_346 0 n28 ns346 0 0.00120038859614
Gc14_347 0 n28 ns347 0 -0.00030491499079
Gc14_348 0 n28 ns348 0 0.000262046427293
Gc14_349 0 n28 ns349 0 0.000130525485888
Gc14_350 0 n28 ns350 0 -0.000182556759452
Gc14_351 0 n28 ns351 0 -0.000177760971953
Gc14_352 0 n28 ns352 0 0.000479086132117
Gc14_353 0 n28 ns353 0 7.20697400782e-05
Gc14_354 0 n28 ns354 0 -0.000149981073746
Gc14_355 0 n28 ns355 0 0.000132510376286
Gc14_356 0 n28 ns356 0 -0.00042314210227
Gc14_357 0 n28 ns357 0 0.000821184749395
Gc14_358 0 n28 ns358 0 -0.000426731344596
Gc14_359 0 n28 ns359 0 0.000171160882513
Gc14_360 0 n28 ns360 0 -0.000640700332515
Gc14_361 0 n28 ns361 0 0.000239253513967
Gc14_362 0 n28 ns362 0 -0.000505976024487
Gc14_363 0 n28 ns363 0 -0.00016701652732
Gc14_364 0 n28 ns364 0 0.000831064382726
Gc14_365 0 n28 ns365 0 0.00334052171878
Gc14_366 0 n28 ns366 0 0.00229948226766
Gc14_367 0 n28 ns367 0 0.00314024251566
Gc14_368 0 n28 ns368 0 0.00189806006901
Gc14_369 0 n28 ns369 0 0.000204244935034
Gc14_370 0 n28 ns370 0 0.00114518702584
Gc14_371 0 n28 ns371 0 -0.000319285764337
Gc14_372 0 n28 ns372 0 -0.000430471907398
Gc14_373 0 n28 ns373 0 -0.00112573474358
Gc14_374 0 n28 ns374 0 -0.00112587600868
Gc14_375 0 n28 ns375 0 -0.000494085732829
Gc14_376 0 n28 ns376 0 -0.000114741558359
Gc14_377 0 n28 ns377 0 0.000136910783162
Gc14_378 0 n28 ns378 0 -1.25310554286e-05
Gc14_379 0 n28 ns379 0 2.29883326155e-05
Gc14_380 0 n28 ns380 0 -5.41580016975e-05
Gc14_381 0 n28 ns381 0 -0.00014045291157
Gc14_382 0 n28 ns382 0 0.00013422663123
Gc14_383 0 n28 ns383 0 -2.23128680138e-05
Gc14_384 0 n28 ns384 0 0.00101220586967
Gc14_385 0 n28 ns385 0 2.52217043937e-05
Gc14_386 0 n28 ns386 0 0.000176904041994
Gc14_387 0 n28 ns387 0 0.00015165614754
Gc14_388 0 n28 ns388 0 -8.43594718736e-05
Gc14_389 0 n28 ns389 0 -0.000133767358957
Gc14_390 0 n28 ns390 0 -6.80286819573e-05
Gc14_391 0 n28 ns391 0 0.000141794880976
Gc14_392 0 n28 ns392 0 -0.000143187602558
Gc14_393 0 n28 ns393 0 -0.000284285243498
Gc14_394 0 n28 ns394 0 -0.000360356868634
Gc14_395 0 n28 ns395 0 0.000186020066036
Gc14_396 0 n28 ns396 0 0.000493920210285
Gc14_397 0 n28 ns397 0 0.000300813327052
Gc14_398 0 n28 ns398 0 -0.000430436722235
Gc14_399 0 n28 ns399 0 -7.80511293598e-05
Gc14_400 0 n28 ns400 0 -0.000380103391352
Gc14_401 0 n28 ns401 0 -0.000491154775667
Gc14_402 0 n28 ns402 0 -0.000249957829365
Gc14_403 0 n28 ns403 0 0.00208745711447
Gc14_404 0 n28 ns404 0 0.00336729960715
Gc14_405 0 n28 ns405 0 0.00219371521588
Gc14_406 0 n28 ns406 0 0.00316630213588
Gc14_407 0 n28 ns407 0 -0.00112500505612
Gc14_408 0 n28 ns408 0 0.000972090976686
Gc14_409 0 n28 ns409 0 -0.000156751125912
Gc14_410 0 n28 ns410 0 -0.00083547993949
Gc14_411 0 n28 ns411 0 -0.000511685433992
Gc14_412 0 n28 ns412 0 -0.00165637619709
Gc14_413 0 n28 ns413 0 -0.000638892591058
Gc14_414 0 n28 ns414 0 0.000568107740391
Gc14_415 0 n28 ns415 0 0.000455271938968
Gc14_416 0 n28 ns416 0 2.42330166692e-05
Gc14_417 0 n28 ns417 0 -0.000141649268307
Gc14_418 0 n28 ns418 0 1.93601764443e-05
Gc14_419 0 n28 ns419 0 0.00012080209974
Gc14_420 0 n28 ns420 0 -0.000499772553674
Gc14_421 0 n28 ns421 0 0.000594648875285
Gc14_422 0 n28 ns422 0 8.28395023156e-05
Gc14_423 0 n28 ns423 0 -0.00027113001323
Gc14_424 0 n28 ns424 0 0.000483707634756
Gc14_425 0 n28 ns425 0 -1.47468196103e-05
Gc14_426 0 n28 ns426 0 -0.000191947691466
Gc14_427 0 n28 ns427 0 0.000353062124978
Gc14_428 0 n28 ns428 0 -0.00017460979499
Gc14_429 0 n28 ns429 0 0.000181701356907
Gc14_430 0 n28 ns430 0 -7.4099290909e-05
Gc14_431 0 n28 ns431 0 -1.94492082668e-05
Gc14_432 0 n28 ns432 0 -0.000314446718862
Gc14_433 0 n28 ns433 0 -0.000764922451087
Gc14_434 0 n28 ns434 0 -0.000340507401952
Gc14_435 0 n28 ns435 0 0.000296416088916
Gc14_436 0 n28 ns436 0 -0.000553641545324
Gc14_437 0 n28 ns437 0 -0.000189685283675
Gc14_438 0 n28 ns438 0 -0.000971582524479
Gc14_439 0 n28 ns439 0 0.00121421227973
Gc14_440 0 n28 ns440 0 -0.000694953354905
Gc14_441 0 n28 ns441 0 0.0019218793778
Gc14_442 0 n28 ns442 0 0.00296134231244
Gc14_443 0 n28 ns443 0 0.00178313593546
Gc14_444 0 n28 ns444 0 0.00324804967815
Gc14_445 0 n28 ns445 0 -0.0012555652429
Gc14_446 0 n28 ns446 0 -0.00139325495223
Gc14_447 0 n28 ns447 0 0.000406846155704
Gc14_448 0 n28 ns448 0 -0.00105384750895
Gc14_449 0 n28 ns449 0 0.000210717716546
Gc14_450 0 n28 ns450 0 -0.000793618933743
Gc14_451 0 n28 ns451 0 -0.00144965280361
Gc14_452 0 n28 ns452 0 0.00247870911687
Gc14_453 0 n28 ns453 0 0.00148146675044
Gc14_454 0 n28 ns454 0 2.95770931526e-05
Gc14_455 0 n28 ns455 0 -0.000226966249677
Gc14_456 0 n28 ns456 0 7.10170809605e-05
Gc14_457 0 n28 ns457 0 0.000229874607495
Gc14_458 0 n28 ns458 0 -0.00187797709351
Gc14_459 0 n28 ns459 0 0.000285320600866
Gc14_460 0 n28 ns460 0 -0.000473030004372
Gc14_461 0 n28 ns461 0 -0.000946664379813
Gc14_462 0 n28 ns462 0 0.000330722057299
Gc14_463 0 n28 ns463 0 0.000387939992359
Gc14_464 0 n28 ns464 0 -0.000478107062167
Gc14_465 0 n28 ns465 0 0.000332587825226
Gc14_466 0 n28 ns466 0 0.000459783912064
Gc14_467 0 n28 ns467 0 0.000252823849443
Gc14_468 0 n28 ns468 0 -4.5333175805e-05
Gc14_469 0 n28 ns469 0 -0.000379808934655
Gc14_470 0 n28 ns470 0 -5.26596779172e-05
Gc14_471 0 n28 ns471 0 0.000648446602448
Gc14_472 0 n28 ns472 0 -0.000925897183916
Gc14_473 0 n28 ns473 0 0.00080922524532
Gc14_474 0 n28 ns474 0 -0.000420464552289
Gc14_475 0 n28 ns475 0 0.000390719401406
Gc14_476 0 n28 ns476 0 -0.000877444151747
Gc14_477 0 n28 ns477 0 0.000893812071697
Gc14_478 0 n28 ns478 0 0.00209444059399
Gc14_479 0 n28 ns479 0 0.00281303002565
Gc14_480 0 n28 ns480 0 0.00426713798793
Gc14_481 0 n28 ns481 0 0.00214392811945
Gc14_482 0 n28 ns482 0 0.00448036803398
Gc14_483 0 n28 ns483 0 0.00350421549405
Gc14_484 0 n28 ns484 0 0.000395775208495
Gc14_485 0 n28 ns485 0 0.000894040002327
Gc14_486 0 n28 ns486 0 -0.000966110829217
Gc14_487 0 n28 ns487 0 -0.00183514039348
Gc14_488 0 n28 ns488 0 -0.00122681179931
Gc14_489 0 n28 ns489 0 -0.00385785173169
Gc14_490 0 n28 ns490 0 -0.000114590797788
Gc14_491 0 n28 ns491 0 0.00311728956134
Gc14_492 0 n28 ns492 0 3.49305165842e-05
Gc14_493 0 n28 ns493 0 -0.000146959503641
Gc14_494 0 n28 ns494 0 2.33293365342e-05
Gc14_495 0 n28 ns495 0 0.00052700779853
Gc14_496 0 n28 ns496 0 -0.00246740784255
Gc14_497 0 n28 ns497 0 -0.00116716628681
Gc14_498 0 n28 ns498 0 0.000264083626171
Gc14_499 0 n28 ns499 0 -0.000584311187618
Gc14_500 0 n28 ns500 0 0.000153845164702
Gc14_501 0 n28 ns501 0 0.000335144683346
Gc14_502 0 n28 ns502 0 -0.00019043577412
Gc14_503 0 n28 ns503 0 1.01116239102e-05
Gc14_504 0 n28 ns504 0 0.000476369244549
Gc14_505 0 n28 ns505 0 0.000296179815418
Gc14_506 0 n28 ns506 0 -2.27190216265e-05
Gc14_507 0 n28 ns507 0 -0.000621754553862
Gc14_508 0 n28 ns508 0 -0.000594912937074
Gc14_509 0 n28 ns509 0 0.000446114905323
Gc14_510 0 n28 ns510 0 -1.90233614575e-05
Gc14_511 0 n28 ns511 0 0.000447623525206
Gc14_512 0 n28 ns512 0 -0.000370953102507
Gc14_513 0 n28 ns513 0 -0.000325832574646
Gc14_514 0 n28 ns514 0 -0.00130893737623
Gc14_515 0 n28 ns515 0 -0.000541919077723
Gc14_516 0 n28 ns516 0 0.000505334971417
Gc14_517 0 n28 ns517 0 0.00766620628461
Gc14_518 0 n28 ns518 0 0.00602083995791
Gc14_519 0 n28 ns519 0 0.00584920907754
Gc14_520 0 n28 ns520 0 0.00594783728557
Gc14_521 0 n28 ns521 0 0.00120954006652
Gc14_522 0 n28 ns522 0 0.00547278424335
Gc14_523 0 n28 ns523 0 0.000884447613874
Gc14_524 0 n28 ns524 0 -0.00083395597918
Gc14_525 0 n28 ns525 0 -0.00623618586372
Gc14_526 0 n28 ns526 0 -0.00157639925736
Gc14_527 0 n28 ns527 0 0.00264008437447
Gc14_528 0 n28 ns528 0 -0.00444876452684
Gc14_529 0 n28 ns529 0 0.00476752050543
Gc14_530 0 n28 ns530 0 -2.93890507311e-05
Gc14_531 0 n28 ns531 0 2.14733894393e-05
Gc14_532 0 n28 ns532 0 -6.40588884732e-05
Gc14_533 0 n28 ns533 0 0.000240198193181
Gc14_534 0 n28 ns534 0 -0.00224038327017
Gc14_535 0 n28 ns535 0 8.05834309932e-05
Gc14_536 0 n28 ns536 0 -0.000679459352398
Gc14_537 0 n28 ns537 0 -0.000798511911637
Gc14_538 0 n28 ns538 0 0.000258449958517
Gc14_539 0 n28 ns539 0 0.000251354975604
Gc14_540 0 n28 ns540 0 -0.000518714907302
Gc14_541 0 n28 ns541 0 3.98517405629e-05
Gc14_542 0 n28 ns542 0 0.000246046511312
Gc14_543 0 n28 ns543 0 0.000291422299795
Gc14_544 0 n28 ns544 0 4.80265659115e-06
Gc14_545 0 n28 ns545 0 -0.000168222683316
Gc14_546 0 n28 ns546 0 0.000249855146928
Gc14_547 0 n28 ns547 0 0.00102775641158
Gc14_548 0 n28 ns548 0 -0.000461393786556
Gc14_549 0 n28 ns549 0 0.00117289719716
Gc14_550 0 n28 ns550 0 -0.000263650094995
Gc14_551 0 n28 ns551 0 0.000772254983536
Gc14_552 0 n28 ns552 0 -0.000616448154518
Gc14_553 0 n28 ns553 0 0.00041892352556
Gc14_554 0 n28 ns554 0 0.00217255104473
Gc14_555 0 n28 ns555 0 0.0016824022061
Gc14_556 0 n28 ns556 0 0.00566542940604
Gc14_557 0 n28 ns557 0 0.00120904576897
Gc14_558 0 n28 ns558 0 0.00573982157478
Gc14_559 0 n28 ns559 0 0.00324872562829
Gc14_560 0 n28 ns560 0 0.000393723195469
Gc14_561 0 n28 ns561 0 0.000975961058149
Gc14_562 0 n28 ns562 0 -0.000999329476315
Gc14_563 0 n28 ns563 0 -0.00153686006631
Gc14_564 0 n28 ns564 0 -0.00133869988114
Gc14_565 0 n28 ns565 0 -0.00379700895499
Gc14_566 0 n28 ns566 0 -0.000142546526291
Gc14_567 0 n28 ns567 0 0.00311022216716
Gc14_568 0 n28 ns568 0 2.11805690561e-05
Gc14_569 0 n28 ns569 0 -0.000177045278802
Gc14_570 0 n28 ns570 0 2.45106650332e-05
Gc14_571 0 n28 ns571 0 0.000432445727141
Gc14_572 0 n28 ns572 0 -0.00137953808776
Gc14_573 0 n28 ns573 0 0.0010752702795
Gc14_574 0 n28 ns574 0 -0.000805792006985
Gc14_575 0 n28 ns575 0 -8.04699903847e-05
Gc14_576 0 n28 ns576 0 0.000126379553069
Gc14_577 0 n28 ns577 0 -4.40862819978e-05
Gc14_578 0 n28 ns578 0 -6.20733679031e-06
Gc14_579 0 n28 ns579 0 0.000262399772102
Gc14_580 0 n28 ns580 0 -0.000630160995487
Gc14_581 0 n28 ns581 0 0.000181247258283
Gc14_582 0 n28 ns582 0 4.71276951065e-05
Gc14_583 0 n28 ns583 0 -2.3341483289e-05
Gc14_584 0 n28 ns584 0 0.000120774271753
Gc14_585 0 n28 ns585 0 -0.00112037714891
Gc14_586 0 n28 ns586 0 0.000497398247218
Gc14_587 0 n28 ns587 0 0.000411801794461
Gc14_588 0 n28 ns588 0 1.00139443903e-05
Gc14_589 0 n28 ns589 0 -0.000249905574918
Gc14_590 0 n28 ns590 0 -0.000361388420873
Gc14_591 0 n28 ns591 0 0.000708828117666
Gc14_592 0 n28 ns592 0 -0.00146597121632
Gc14_593 0 n28 ns593 0 -0.00103213607284
Gc14_594 0 n28 ns594 0 0.00282604752251
Gc14_595 0 n28 ns595 0 -0.000805727020418
Gc14_596 0 n28 ns596 0 0.00331630385138
Gc14_597 0 n28 ns597 0 -0.00214947405336
Gc14_598 0 n28 ns598 0 -0.00198136695817
Gc14_599 0 n28 ns599 0 0.000682906785363
Gc14_600 0 n28 ns600 0 -0.00103002518191
Gc14_601 0 n28 ns601 0 0.00124212382365
Gc14_602 0 n28 ns602 0 -0.000500124654538
Gc14_603 0 n28 ns603 0 -0.00121754321899
Gc14_604 0 n28 ns604 0 0.00297484159023
Gc14_605 0 n28 ns605 0 0.00160064409848
Gc14_606 0 n28 ns606 0 1.46765630969e-05
Gc14_607 0 n28 ns607 0 -0.000301574983559
Gc14_608 0 n28 ns608 0 0.000120921900826
Gc14_609 0 n28 ns609 0 -0.000703644920341
Gc14_610 0 n28 ns610 0 0.0013020966957
Gc14_611 0 n28 ns611 0 -0.00179625716885
Gc14_612 0 n28 ns612 0 0.00184589295876
Gc14_613 0 n28 ns613 0 -0.000243104757292
Gc14_614 0 n28 ns614 0 0.00068837926894
Gc14_615 0 n28 ns615 0 0.000172620057707
Gc14_616 0 n28 ns616 0 -0.000439758171644
Gc14_617 0 n28 ns617 0 -5.96982469657e-05
Gc14_618 0 n28 ns618 0 -0.00011284259096
Gc14_619 0 n28 ns619 0 9.34526925552e-05
Gc14_620 0 n28 ns620 0 0.00011458309757
Gc14_621 0 n28 ns621 0 0.000588757809476
Gc14_622 0 n28 ns622 0 -0.00035343943246
Gc14_623 0 n28 ns623 0 0.000347443073043
Gc14_624 0 n28 ns624 0 -0.000742859329749
Gc14_625 0 n28 ns625 0 -0.000192391424596
Gc14_626 0 n28 ns626 0 -0.000484807610501
Gc14_627 0 n28 ns627 0 -0.000179781270293
Gc14_628 0 n28 ns628 0 -0.000433885581266
Gc14_629 0 n28 ns629 0 -0.000558548327382
Gc14_630 0 n28 ns630 0 -0.000159095714778
Gc14_631 0 n28 ns631 0 -0.00418175013011
Gc14_632 0 n28 ns632 0 0.00047936675107
Gc14_633 0 n28 ns633 0 -0.0036399252605
Gc14_634 0 n28 ns634 0 0.000483937229918
Gc14_635 0 n28 ns635 0 0.000435859604265
Gc14_636 0 n28 ns636 0 0.00132572497515
Gc14_637 0 n28 ns637 0 -0.000254232785169
Gc14_638 0 n28 ns638 0 -0.000276285598628
Gc14_639 0 n28 ns639 0 -0.000879980376378
Gc14_640 0 n28 ns640 0 -0.00105388359183
Gc14_641 0 n28 ns641 0 -0.000120889277836
Gc14_642 0 n28 ns642 0 -0.000688936492577
Gc14_643 0 n28 ns643 0 -0.000209234050805
Gc14_644 0 n28 ns644 0 2.45384656587e-06
Gc14_645 0 n28 ns645 0 6.66818725608e-05
Gc14_646 0 n28 ns646 0 -7.10932229705e-06
Gc14_647 0 n28 ns647 0 -0.000516958409032
Gc14_648 0 n28 ns648 0 0.000747922985301
Gc14_649 0 n28 ns649 0 -0.00126106039052
Gc14_650 0 n28 ns650 0 0.000724713926007
Gc14_651 0 n28 ns651 0 -0.000175953122601
Gc14_652 0 n28 ns652 0 0.000371811875996
Gc14_653 0 n28 ns653 0 0.000148039157649
Gc14_654 0 n28 ns654 0 -0.000261696254411
Gc14_655 0 n28 ns655 0 -5.32028138469e-05
Gc14_656 0 n28 ns656 0 -0.000334618613662
Gc14_657 0 n28 ns657 0 3.64584452274e-05
Gc14_658 0 n28 ns658 0 0.000172652245535
Gc14_659 0 n28 ns659 0 0.000581119763739
Gc14_660 0 n28 ns660 0 7.91805133468e-05
Gc14_661 0 n28 ns661 0 0.000429319662143
Gc14_662 0 n28 ns662 0 -0.000569806212853
Gc14_663 0 n28 ns663 0 -0.000225430482933
Gc14_664 0 n28 ns664 0 -0.00049778702378
Gc14_665 0 n28 ns665 0 -0.00030603634587
Gc14_666 0 n28 ns666 0 -0.000383419693532
Gc14_667 0 n28 ns667 0 -0.000573688395846
Gc14_668 0 n28 ns668 0 -0.000441248926835
Gc14_669 0 n28 ns669 0 -0.00504561717152
Gc14_670 0 n28 ns670 0 -0.000375237490703
Gc14_671 0 n28 ns671 0 -0.00443485858615
Gc14_672 0 n28 ns672 0 -0.000227794663032
Gc14_673 0 n28 ns673 0 0.000312525139721
Gc14_674 0 n28 ns674 0 0.00135261063254
Gc14_675 0 n28 ns675 0 -0.000279853892961
Gc14_676 0 n28 ns676 0 -0.000323124377903
Gc14_677 0 n28 ns677 0 -0.00091346144335
Gc14_678 0 n28 ns678 0 -0.00107166140202
Gc14_679 0 n28 ns679 0 -9.8293016403e-05
Gc14_680 0 n28 ns680 0 -0.000577907867833
Gc14_681 0 n28 ns681 0 -0.000187466207782
Gc14_682 0 n28 ns682 0 -1.49922246057e-05
Gc14_683 0 n28 ns683 0 0.000107617570326
Gc14_684 0 n28 ns684 0 -2.6063776974e-05
Gc14_685 0 n28 ns685 0 0.000319550949488
Gc14_686 0 n28 ns686 0 -0.000583695730261
Gc14_687 0 n28 ns687 0 0.0011294163015
Gc14_688 0 n28 ns688 0 -0.000922020727067
Gc14_689 0 n28 ns689 0 0.000235487030031
Gc14_690 0 n28 ns690 0 -0.000182570671853
Gc14_691 0 n28 ns691 0 -0.000165372489552
Gc14_692 0 n28 ns692 0 0.000155231128029
Gc14_693 0 n28 ns693 0 0.000321905991569
Gc14_694 0 n28 ns694 0 -0.000327054833322
Gc14_695 0 n28 ns695 0 -0.000123004781343
Gc14_696 0 n28 ns696 0 0.000137477120273
Gc14_697 0 n28 ns697 0 -0.000226297830724
Gc14_698 0 n28 ns698 0 0.000544161398257
Gc14_699 0 n28 ns699 0 0.000476842026872
Gc14_700 0 n28 ns700 0 0.000273541049973
Gc14_701 0 n28 ns701 0 7.95787627383e-05
Gc14_702 0 n28 ns702 0 -0.000442440905853
Gc14_703 0 n28 ns703 0 -0.000162260546993
Gc14_704 0 n28 ns704 0 -0.000277834661396
Gc14_705 0 n28 ns705 0 -3.7771745759e-05
Gc14_706 0 n28 ns706 0 -0.000529158078111
Gc14_707 0 n28 ns707 0 -0.00506900005024
Gc14_708 0 n28 ns708 0 -0.00321735748981
Gc14_709 0 n28 ns709 0 -0.0046561794558
Gc14_710 0 n28 ns710 0 -0.00278450811648
Gc14_711 0 n28 ns711 0 7.11528410567e-05
Gc14_712 0 n28 ns712 0 0.00168646424193
Gc14_713 0 n28 ns713 0 -0.000343482424787
Gc14_714 0 n28 ns714 0 -0.000605788287885
Gc14_715 0 n28 ns715 0 -0.00114778182411
Gc14_716 0 n28 ns716 0 -0.00173253125041
Gc14_717 0 n28 ns717 0 -0.00010240443283
Gc14_718 0 n28 ns718 0 -0.0011447620309
Gc14_719 0 n28 ns719 0 -0.000371842410855
Gc14_720 0 n28 ns720 0 -1.0476998696e-05
Gc14_721 0 n28 ns721 0 8.98304469241e-05
Gc14_722 0 n28 ns722 0 -7.36302326448e-06
Gc14_723 0 n28 ns723 0 -0.000117034462788
Gc14_724 0 n28 ns724 0 2.58869904536e-05
Gc14_725 0 n28 ns725 0 -4.91919466782e-05
Gc14_726 0 n28 ns726 0 0.000754487793369
Gc14_727 0 n28 ns727 0 -0.0001449131738
Gc14_728 0 n28 ns728 0 0.000105583152239
Gc14_729 0 n28 ns729 0 -2.7728392922e-05
Gc14_730 0 n28 ns730 0 -0.000119358416966
Gc14_731 0 n28 ns731 0 0.000116074736662
Gc14_732 0 n28 ns732 0 0.000517339912363
Gc14_733 0 n28 ns733 0 -8.12410170953e-05
Gc14_734 0 n28 ns734 0 6.35284534548e-05
Gc14_735 0 n28 ns735 0 9.31351671944e-05
Gc14_736 0 n28 ns736 0 -0.000584630942186
Gc14_737 0 n28 ns737 0 -3.0260168308e-05
Gc14_738 0 n28 ns738 0 0.000565762778047
Gc14_739 0 n28 ns739 0 0.0004753227311
Gc14_740 0 n28 ns740 0 -0.000219663263911
Gc14_741 0 n28 ns741 0 0.000116504284073
Gc14_742 0 n28 ns742 0 -6.28072174027e-05
Gc14_743 0 n28 ns743 0 -0.000216552995492
Gc14_744 0 n28 ns744 0 0.000610171171289
Gc14_745 0 n28 ns745 0 -0.003198182578
Gc14_746 0 n28 ns746 0 -0.00371201149342
Gc14_747 0 n28 ns747 0 -0.00309440586687
Gc14_748 0 n28 ns748 0 -0.00364071355035
Gc14_749 0 n28 ns749 0 -0.000447225762534
Gc14_750 0 n28 ns750 0 0.00181580717981
Gc14_751 0 n28 ns751 0 -0.00012269161167
Gc14_752 0 n28 ns752 0 -0.00113600816921
Gc14_753 0 n28 ns753 0 -0.000776612330912
Gc14_754 0 n28 ns754 0 -0.00297250880997
Gc14_755 0 n28 ns755 0 0.000250122991886
Gc14_756 0 n28 ns756 0 -0.00266319129319
Gc14_757 0 n28 ns757 0 -0.000977289553218
Gc14_758 0 n28 ns758 0 -1.68348363666e-05
Gc14_759 0 n28 ns759 0 0.000105305043235
Gc14_760 0 n28 ns760 0 -2.28602845534e-05
Gc14_761 0 n28 ns761 0 -0.00030521317359
Gc14_762 0 n28 ns762 0 -0.000493311503085
Gc14_763 0 n28 ns763 0 -0.000921246202362
Gc14_764 0 n28 ns764 0 0.000787894115518
Gc14_765 0 n28 ns765 0 -0.000112987884229
Gc14_766 0 n28 ns766 0 0.000504422781378
Gc14_767 0 n28 ns767 0 0.000133947858416
Gc14_768 0 n28 ns768 0 -0.000289752732859
Gc14_769 0 n28 ns769 0 -0.000488303512668
Gc14_770 0 n28 ns770 0 0.000210640415962
Gc14_771 0 n28 ns771 0 -0.000142257200046
Gc14_772 0 n28 ns772 0 9.0749275275e-05
Gc14_773 0 n28 ns773 0 0.000899993052171
Gc14_774 0 n28 ns774 0 -0.000176299879123
Gc14_775 0 n28 ns775 0 -0.0003431258133
Gc14_776 0 n28 ns776 0 -0.000544752644352
Gc14_777 0 n28 ns777 0 0.000505111542932
Gc14_778 0 n28 ns778 0 -0.00032185102986
Gc14_779 0 n28 ns779 0 1.90488751645e-05
Gc14_780 0 n28 ns780 0 -0.000582472803881
Gc14_781 0 n28 ns781 0 -0.00167103435091
Gc14_782 0 n28 ns782 0 0.000707661094593
Gc14_783 0 n28 ns783 0 -0.00381472780852
Gc14_784 0 n28 ns784 0 -0.00145325813302
Gc14_785 0 n28 ns785 0 -0.0032300345928
Gc14_786 0 n28 ns786 0 -0.0021504340675
Gc14_787 0 n28 ns787 0 0.000898729276075
Gc14_788 0 n28 ns788 0 0.000641856065461
Gc14_789 0 n28 ns789 0 0.000507407641565
Gc14_790 0 n28 ns790 0 -0.00133658791989
Gc14_791 0 n28 ns791 0 -0.000530833778279
Gc14_792 0 n28 ns792 0 -0.00268863784344
Gc14_793 0 n28 ns793 0 0.00155698316273
Gc14_794 0 n28 ns794 0 -0.0034239380095
Gc14_795 0 n28 ns795 0 -0.00213463624575
Gc14_796 0 n28 ns796 0 -2.27348180488e-05
Gc14_797 0 n28 ns797 0 0.000135946073731
Gc14_798 0 n28 ns798 0 -1.49502497219e-05
Gc14_799 0 n28 ns799 0 0.000904620643177
Gc14_800 0 n28 ns800 0 -0.00221781905432
Gc14_801 0 n28 ns801 0 0.00140696767366
Gc14_802 0 n28 ns802 0 -0.00419116303025
Gc14_803 0 n28 ns803 0 -0.00248240362799
Gc14_804 0 n28 ns804 0 -0.00108470815504
Gc14_805 0 n28 ns805 0 0.000892149722508
Gc14_806 0 n28 ns806 0 0.000320629710222
Gc14_807 0 n28 ns807 0 -0.000476672481087
Gc14_808 0 n28 ns808 0 -0.000405925723841
Gc14_809 0 n28 ns809 0 -0.000207598278157
Gc14_810 0 n28 ns810 0 4.42770246679e-05
Gc14_811 0 n28 ns811 0 0.000249050110775
Gc14_812 0 n28 ns812 0 1.16345705502e-06
Gc14_813 0 n28 ns813 0 0.00127470676375
Gc14_814 0 n28 ns814 0 -0.00051578209088
Gc14_815 0 n28 ns815 0 0.000935764780799
Gc14_816 0 n28 ns816 0 -2.10605169111e-05
Gc14_817 0 n28 ns817 0 0.000444421359786
Gc14_818 0 n28 ns818 0 -0.000103456539559
Gc14_819 0 n28 ns819 0 -0.000945458542064
Gc14_820 0 n28 ns820 0 -0.00215923989589
Gc14_821 0 n28 ns821 0 -0.00583973773852
Gc14_822 0 n28 ns822 0 -0.00436778373706
Gc14_823 0 n28 ns823 0 -0.00454336831659
Gc14_824 0 n28 ns824 0 -0.00456634140777
Gc14_825 0 n28 ns825 0 0.0044141745071
Gc14_826 0 n28 ns826 0 0.00415584341876
Gc14_827 0 n28 ns827 0 0.000937068181134
Gc14_828 0 n28 ns828 0 -0.00114524487191
Gc14_829 0 n28 ns829 0 -0.00313362590195
Gc14_830 0 n28 ns830 0 -0.00339133612993
Gc14_831 0 n28 ns831 0 0.00221871562263
Gc14_832 0 n28 ns832 0 0.00153144127269
Gc14_833 0 n28 ns833 0 -0.00374151237194
Gc14_834 0 n28 ns834 0 -8.79865801751e-07
Gc14_835 0 n28 ns835 0 0.000324769878861
Gc14_836 0 n28 ns836 0 -0.000145905528453
Gc14_837 0 n28 ns837 0 0.00216920964778
Gc14_838 0 n28 ns838 0 -0.00324655652403
Gc14_839 0 n28 ns839 0 0.00476099373393
Gc14_840 0 n28 ns840 0 -0.00645600557353
Gc14_841 0 n28 ns841 0 -0.00336974411651
Gc14_842 0 n28 ns842 0 -0.00226708644342
Gc14_843 0 n28 ns843 0 0.00119284521242
Gc14_844 0 n28 ns844 0 0.000660763518617
Gc14_845 0 n28 ns845 0 -0.000279182721795
Gc14_846 0 n28 ns846 0 -0.000543016058182
Gc14_847 0 n28 ns847 0 -0.000276999969314
Gc14_848 0 n28 ns848 0 6.0725803064e-06
Gc14_849 0 n28 ns849 0 -0.000409269931307
Gc14_850 0 n28 ns850 0 -0.000347240738747
Gc14_851 0 n28 ns851 0 0.00147525564083
Gc14_852 0 n28 ns852 0 3.00501606028e-05
Gc14_853 0 n28 ns853 0 0.00102846619705
Gc14_854 0 n28 ns854 0 0.000207914475623
Gc14_855 0 n28 ns855 0 0.000426699484749
Gc14_856 0 n28 ns856 0 0.00039235056118
Gc14_857 0 n28 ns857 0 0.000882535048636
Gc14_858 0 n28 ns858 0 -0.00303849130944
Gc14_859 0 n28 ns859 0 -0.00227244253426
Gc14_860 0 n28 ns860 0 -0.00804981800041
Gc14_861 0 n28 ns861 0 -0.00159817249512
Gc14_862 0 n28 ns862 0 -0.00754340035063
Gc14_863 0 n28 ns863 0 0.00539243508007
Gc14_864 0 n28 ns864 0 0.00810537847547
Gc14_865 0 n28 ns865 0 0.00081868227688
Gc14_866 0 n28 ns866 0 -0.00123026945751
Gc14_867 0 n28 ns867 0 -0.00526149343535
Gc14_868 0 n28 ns868 0 -0.00599960337444
Gc14_869 0 n28 ns869 0 0.00146081685526
Gc14_870 0 n28 ns870 0 0.00525646580975
Gc14_871 0 n28 ns871 0 -0.00430917073443
Gc14_872 0 n28 ns872 0 2.32228876226e-06
Gc14_873 0 n28 ns873 0 0.000421490658542
Gc14_874 0 n28 ns874 0 -0.000231461263005
Gc14_875 0 n28 ns875 0 -0.000729787969263
Gc14_876 0 n28 ns876 0 -0.00050567676814
Gc14_877 0 n28 ns877 0 -0.00229293092839
Gc14_878 0 n28 ns878 0 0.00105275711129
Gc14_879 0 n28 ns879 0 -0.000233936768231
Gc14_880 0 n28 ns880 0 0.000864107656288
Gc14_881 0 n28 ns881 0 0.000169756613618
Gc14_882 0 n28 ns882 0 -0.000243894986633
Gc14_883 0 n28 ns883 0 -0.00012094586725
Gc14_884 0 n28 ns884 0 0.00034954753237
Gc14_885 0 n28 ns885 0 -0.000249501205814
Gc14_886 0 n28 ns886 0 -2.18512124208e-05
Gc14_887 0 n28 ns887 0 0.000410427712926
Gc14_888 0 n28 ns888 0 0.000275683812516
Gc14_889 0 n28 ns889 0 0.000352874981845
Gc14_890 0 n28 ns890 0 -0.000327403464202
Gc14_891 0 n28 ns891 0 0.00110431605551
Gc14_892 0 n28 ns892 0 -0.000306172645175
Gc14_893 0 n28 ns893 0 0.000852270698068
Gc14_894 0 n28 ns894 0 -0.000750452299087
Gc14_895 0 n28 ns895 0 -0.00174303954493
Gc14_896 0 n28 ns896 0 3.67309944847e-05
Gc14_897 0 n28 ns897 0 -0.00340881019412
Gc14_898 0 n28 ns898 0 -0.00364214168882
Gc14_899 0 n28 ns899 0 -0.00267867848439
Gc14_900 0 n28 ns900 0 -0.00407652955676
Gc14_901 0 n28 ns901 0 0.00120218383268
Gc14_902 0 n28 ns902 0 -0.000411597338995
Gc14_903 0 n28 ns903 0 0.000938298757735
Gc14_904 0 n28 ns904 0 -0.00116292457087
Gc14_905 0 n28 ns905 0 4.58342002395e-05
Gc14_906 0 n28 ns906 0 -0.00165882081506
Gc14_907 0 n28 ns907 0 0.00254157348306
Gc14_908 0 n28 ns908 0 -0.00236003032746
Gc14_909 0 n28 ns909 0 -0.00249108489838
Gc14_910 0 n28 ns910 0 3.06402447269e-06
Gc14_911 0 n28 ns911 0 0.000132730823955
Gc14_912 0 n28 ns912 0 -2.97465896167e-05
Gc14_913 0 n28 ns913 0 -0.000316475539088
Gc14_914 0 n28 ns914 0 -0.000201815061478
Gc14_915 0 n28 ns915 0 -0.001002516693
Gc14_916 0 n28 ns916 0 0.000811157846428
Gc14_917 0 n28 ns917 0 -0.00033474194066
Gc14_918 0 n28 ns918 0 -0.000145508844991
Gc14_919 0 n28 ns919 0 6.89854359082e-05
Gc14_920 0 n28 ns920 0 -7.93763735846e-05
Gc14_921 0 n28 ns921 0 -0.000353499923333
Gc14_922 0 n28 ns922 0 0.000855248505474
Gc14_923 0 n28 ns923 0 -5.36839689602e-05
Gc14_924 0 n28 ns924 0 -2.20653013537e-06
Gc14_925 0 n28 ns925 0 0.000549584692043
Gc14_926 0 n28 ns926 0 -0.000856610876199
Gc14_927 0 n28 ns927 0 -0.000645406540505
Gc14_928 0 n28 ns928 0 0.000861225640696
Gc14_929 0 n28 ns929 0 0.000590519917987
Gc14_930 0 n28 ns930 0 0.000359014754897
Gc14_931 0 n28 ns931 0 0.00017414308205
Gc14_932 0 n28 ns932 0 0.000441073571914
Gc14_933 0 n28 ns933 0 -0.000295155927595
Gc14_934 0 n28 ns934 0 0.0010751579733
Gc14_935 0 n28 ns935 0 0.00184660569816
Gc14_936 0 n28 ns936 0 -0.00392268881422
Gc14_937 0 n28 ns937 0 0.00141149372883
Gc14_938 0 n28 ns938 0 -0.0040585158703
Gc14_939 0 n28 ns939 0 -0.00178229790822
Gc14_940 0 n28 ns940 0 -0.000114059793202
Gc14_941 0 n28 ns941 0 0.000460444939959
Gc14_942 0 n28 ns942 0 -0.00108087944371
Gc14_943 0 n28 ns943 0 0.0010594960476
Gc14_944 0 n28 ns944 0 -0.00199810130532
Gc14_945 0 n28 ns945 0 0.000942319174691
Gc14_946 0 n28 ns946 0 -0.00179062024292
Gc14_947 0 n28 ns947 0 -0.000983300591812
Gc14_948 0 n28 ns948 0 -3.71261487198e-05
Gc14_949 0 n28 ns949 0 0.000151306709893
Gc14_950 0 n28 ns950 0 -2.91701856998e-05
Gc14_951 0 n28 ns951 0 0.00048909828865
Gc14_952 0 n28 ns952 0 -0.000681907069786
Gc14_953 0 n28 ns953 0 0.00149887330669
Gc14_954 0 n28 ns954 0 -0.00095844120935
Gc14_955 0 n28 ns955 0 0.000306185237273
Gc14_956 0 n28 ns956 0 -0.000220214406055
Gc14_957 0 n28 ns957 0 -0.000135908363952
Gc14_958 0 n28 ns958 0 0.000134006127091
Gc14_959 0 n28 ns959 0 0.000180845100953
Gc14_960 0 n28 ns960 0 -0.000533063158466
Gc14_961 0 n28 ns961 0 -8.40272119897e-05
Gc14_962 0 n28 ns962 0 0.00015979581961
Gc14_963 0 n28 ns963 0 -5.36254752265e-05
Gc14_964 0 n28 ns964 0 0.000612058116482
Gc14_965 0 n28 ns965 0 0.00039922399829
Gc14_966 0 n28 ns966 0 -0.0001376490177
Gc14_967 0 n28 ns967 0 -0.000132662679799
Gc14_968 0 n28 ns968 0 -0.000535593852579
Gc14_969 0 n28 ns969 0 -0.000333029404609
Gc14_970 0 n28 ns970 0 -0.000459393854312
Gc14_971 0 n28 ns971 0 -7.49622127339e-05
Gc14_972 0 n28 ns972 0 -0.000590340800586
Gc14_973 0 n28 ns973 0 -0.0048902107404
Gc14_974 0 n28 ns974 0 -0.0020590565234
Gc14_975 0 n28 ns975 0 -0.00443310997839
Gc14_976 0 n28 ns976 0 -0.00172346497335
Gc14_977 0 n28 ns977 0 0.000365700487493
Gc14_978 0 n28 ns978 0 0.00153185859952
Gc14_979 0 n28 ns979 0 -0.00035270584869
Gc14_980 0 n28 ns980 0 -0.000468132870911
Gc14_981 0 n28 ns981 0 -0.00122893564546
Gc14_982 0 n28 ns982 0 -0.00142999585876
Gc14_983 0 n28 ns983 0 -0.000167893754692
Gc14_984 0 n28 ns984 0 -0.000965242563966
Gc14_985 0 n28 ns985 0 -0.000297594565354
Gc14_986 0 n28 ns986 0 -5.26243217295e-06
Gc14_987 0 n28 ns987 0 2.73827747451e-05
Gc14_988 0 n28 ns988 0 2.81460961476e-05
Gc14_989 0 n28 ns989 0 -0.000135843411666
Gc14_990 0 n28 ns990 0 0.000131033771085
Gc14_991 0 n28 ns991 0 -9.8184436542e-05
Gc14_992 0 n28 ns992 0 0.000567027910106
Gc14_993 0 n28 ns993 0 -0.000181809277749
Gc14_994 0 n28 ns994 0 0.000193755450901
Gc14_995 0 n28 ns995 0 -1.11694456585e-05
Gc14_996 0 n28 ns996 0 -8.6403167459e-05
Gc14_997 0 n28 ns997 0 0.000343220484679
Gc14_998 0 n28 ns998 0 0.000363849475188
Gc14_999 0 n28 ns999 0 -6.76731590046e-05
Gc14_1000 0 n28 ns1000 0 6.0454490205e-05
Gc14_1001 0 n28 ns1001 0 -0.000172366662115
Gc14_1002 0 n28 ns1002 0 -0.000396129445069
Gc14_1003 0 n28 ns1003 0 0.000308504445994
Gc14_1004 0 n28 ns1004 0 0.000524147192859
Gc14_1005 0 n28 ns1005 0 0.000416269334899
Gc14_1006 0 n28 ns1006 0 -0.00031359939567
Gc14_1007 0 n28 ns1007 0 0.000187562369168
Gc14_1008 0 n28 ns1008 0 -0.000115858563001
Gc14_1009 0 n28 ns1009 0 -3.10557702769e-05
Gc14_1010 0 n28 ns1010 0 0.000264947934601
Gc14_1011 0 n28 ns1011 0 -0.0039551028787
Gc14_1012 0 n28 ns1012 0 -0.00366171024451
Gc14_1013 0 n28 ns1013 0 -0.00374886881739
Gc14_1014 0 n28 ns1014 0 -0.00341291341666
Gc14_1015 0 n28 ns1015 0 -0.000238800170514
Gc14_1016 0 n28 ns1016 0 0.00204928218694
Gc14_1017 0 n28 ns1017 0 -0.000263369172052
Gc14_1018 0 n28 ns1018 0 -0.000955681554888
Gc14_1019 0 n28 ns1019 0 -0.00104418275371
Gc14_1020 0 n28 ns1020 0 -0.002707990263
Gc14_1021 0 n28 ns1021 0 2.98955525016e-05
Gc14_1022 0 n28 ns1022 0 -0.00224137823899
Gc14_1023 0 n28 ns1023 0 -0.000744572845122
Gc14_1024 0 n28 ns1024 0 -1.80240112664e-05
Gc14_1025 0 n28 ns1025 0 8.18087094597e-05
Gc14_1026 0 n28 ns1026 0 -1.14523677642e-05
Gc14_1027 0 n28 ns1027 0 -8.84280016299e-05
Gc14_1028 0 n28 ns1028 0 -6.24806946721e-05
Gc14_1029 0 n28 ns1029 0 9.20581947656e-05
Gc14_1030 0 n28 ns1030 0 0.00155728140477
Gc14_1031 0 n28 ns1031 0 9.9878729947e-05
Gc14_1032 0 n28 ns1032 0 0.000235484087235
Gc14_1033 0 n28 ns1033 0 2.9036972738e-06
Gc14_1034 0 n28 ns1034 0 -0.000229827297575
Gc14_1035 0 n28 ns1035 0 -0.000217662614117
Gc14_1036 0 n28 ns1036 0 0.000422679393709
Gc14_1037 0 n28 ns1037 0 -0.000106282268778
Gc14_1038 0 n28 ns1038 0 6.56035042039e-05
Gc14_1039 0 n28 ns1039 0 0.000607463764741
Gc14_1040 0 n28 ns1040 0 -0.000562801916909
Gc14_1041 0 n28 ns1041 0 -0.000461126127185
Gc14_1042 0 n28 ns1042 0 -0.000179540853167
Gc14_1043 0 n28 ns1043 0 0.000412122655526
Gc14_1044 0 n28 ns1044 0 -0.000336938782639
Gc14_1045 0 n28 ns1045 0 -6.70591295322e-05
Gc14_1046 0 n28 ns1046 0 -0.00048938314433
Gc14_1047 0 n28 ns1047 0 -0.000988195135489
Gc14_1048 0 n28 ns1048 0 0.00112090119536
Gc14_1049 0 n28 ns1049 0 -0.00260368951569
Gc14_1050 0 n28 ns1050 0 -0.00157146510397
Gc14_1051 0 n28 ns1051 0 -0.00238150240174
Gc14_1052 0 n28 ns1052 0 -0.00212815505549
Gc14_1053 0 n28 ns1053 0 0.000109067648255
Gc14_1054 0 n28 ns1054 0 0.000950929185522
Gc14_1055 0 n28 ns1055 0 0.000251364918234
Gc14_1056 0 n28 ns1056 0 -0.00133056624829
Gc14_1057 0 n28 ns1057 0 -0.000475217166011
Gc14_1058 0 n28 ns1058 0 -0.00299862878924
Gc14_1059 0 n28 ns1059 0 0.000918415564018
Gc14_1060 0 n28 ns1060 0 -0.0036048363663
Gc14_1061 0 n28 ns1061 0 -0.00164503228162
Gc14_1062 0 n28 ns1062 0 -2.54467017168e-05
Gc14_1063 0 n28 ns1063 0 0.000103118167408
Gc14_1064 0 n28 ns1064 0 -1.69772456961e-06
Gc14_1065 0 n28 ns1065 0 -0.000887006764345
Gc14_1066 0 n28 ns1066 0 -0.000633318375303
Gc14_1067 0 n28 ns1067 0 -0.00354586706017
Gc14_1068 0 n28 ns1068 0 -0.00146644928249
Gc14_1069 0 n28 ns1069 0 -0.00183510626563
Gc14_1070 0 n28 ns1070 0 0.00116467059893
Gc14_1071 0 n28 ns1071 0 0.000762363581101
Gc14_1072 0 n28 ns1072 0 -0.000505115998785
Gc14_1073 0 n28 ns1073 0 -0.00046453580506
Gc14_1074 0 n28 ns1074 0 7.58886810509e-05
Gc14_1075 0 n28 ns1075 0 -0.000160877296469
Gc14_1076 0 n28 ns1076 0 5.38752141565e-05
Gc14_1077 0 n28 ns1077 0 0.000705930008184
Gc14_1078 0 n28 ns1078 0 9.61856962183e-05
Gc14_1079 0 n28 ns1079 0 0.000836864545918
Gc14_1080 0 n28 ns1080 0 -0.000904426213855
Gc14_1081 0 n28 ns1081 0 0.000989112482988
Gc14_1082 0 n28 ns1082 0 -0.000297103830165
Gc14_1083 0 n28 ns1083 0 0.000785073875252
Gc14_1084 0 n28 ns1084 0 -0.000538878922265
Gc14_1085 0 n28 ns1085 0 -0.00218552196613
Gc14_1086 0 n28 ns1086 0 -0.000863115352047
Gc14_1087 0 n28 ns1087 0 -0.00630599225438
Gc14_1088 0 n28 ns1088 0 -0.00277345139991
Gc14_1089 0 n28 ns1089 0 -0.00500029688849
Gc14_1090 0 n28 ns1090 0 -0.0032282773892
Gc14_1091 0 n28 ns1091 0 0.00355812908722
Gc14_1092 0 n28 ns1092 0 0.00206658090719
Gc14_1093 0 n28 ns1093 0 0.000833276527313
Gc14_1094 0 n28 ns1094 0 -0.00120136287204
Gc14_1095 0 n28 ns1095 0 -0.00218019561349
Gc14_1096 0 n28 ns1096 0 -0.00296816780132
Gc14_1097 0 n28 ns1097 0 0.00243880585492
Gc14_1098 0 n28 ns1098 0 -0.000620389217699
Gc14_1099 0 n28 ns1099 0 -0.00319505704101
Gc14_1100 0 n28 ns1100 0 -4.35713841153e-05
Gc14_1101 0 n28 ns1101 0 0.0003646003553
Gc14_1102 0 n28 ns1102 0 -0.00016164102219
Gc14_1103 0 n28 ns1103 0 -0.000635126385822
Gc14_1104 0 n28 ns1104 0 5.91078913782e-05
Gc14_1105 0 n28 ns1105 0 9.45600639144e-05
Gc14_1106 0 n28 ns1106 0 0.00314292503838
Gc14_1107 0 n28 ns1107 0 0.00126322663826
Gc14_1108 0 n28 ns1108 0 -0.000711891977948
Gc14_1109 0 n28 ns1109 0 -0.00029148468708
Gc14_1110 0 n28 ns1110 0 -0.00011048675917
Gc14_1111 0 n28 ns1111 0 0.000226447307974
Gc14_1112 0 n28 ns1112 0 0.000120740218824
Gc14_1113 0 n28 ns1113 0 -0.000142712276889
Gc14_1114 0 n28 ns1114 0 4.02383712041e-05
Gc14_1115 0 n28 ns1115 0 0.0020925073929
Gc14_1116 0 n28 ns1116 0 -0.000876515420705
Gc14_1117 0 n28 ns1117 0 -0.000253105979686
Gc14_1118 0 n28 ns1118 0 0.0011572892162
Gc14_1119 0 n28 ns1119 0 -0.000285432306749
Gc14_1120 0 n28 ns1120 0 -0.000121639465107
Gc14_1121 0 n28 ns1121 0 -0.00190626532889
Gc14_1122 0 n28 ns1122 0 -0.00141897202955
Gc14_1123 0 n28 ns1123 0 0.00295199466173
Gc14_1124 0 n28 ns1124 0 0.00365266998153
Gc14_1125 0 n28 ns1125 0 -0.0106142491328
Gc14_1126 0 n28 ns1126 0 -0.000324285900323
Gc14_1127 0 n28 ns1127 0 -0.00816805405156
Gc14_1128 0 n28 ns1128 0 -0.0015122310808
Gc14_1129 0 n28 ns1129 0 -0.0110071071055
Gc14_1130 0 n28 ns1130 0 -0.000138958700566
Gc14_1131 0 n28 ns1131 0 0.00146645138104
Gc14_1132 0 n28 ns1132 0 -3.09228258976e-05
Gc14_1133 0 n28 ns1133 0 -0.00345285718749
Gc14_1134 0 n28 ns1134 0 0.00830607957381
Gc14_1135 0 n28 ns1135 0 -0.0142211032454
Gc14_1136 0 n28 ns1136 0 -0.00420317881202
Gc14_1137 0 n28 ns1137 0 -0.00627678562206
Gc14_1138 0 n28 ns1138 0 -5.84681903875e-05
Gc14_1139 0 n28 ns1139 0 -0.000348302188567
Gc14_1140 0 n28 ns1140 0 0.000588299640446
Gc14_1141 0 n28 ns1141 0 -0.000801625893757
Gc14_1142 0 n28 ns1142 0 -0.000982734257036
Gc14_1143 0 n28 ns1143 0 -0.00331928683045
Gc14_1144 0 n28 ns1144 0 -0.0016686251253
Gc14_1145 0 n28 ns1145 0 -0.00194043662549
Gc14_1146 0 n28 ns1146 0 0.00103160581994
Gc14_1147 0 n28 ns1147 0 0.000884765987015
Gc14_1148 0 n28 ns1148 0 -0.000368855052413
Gc14_1149 0 n28 ns1149 0 -0.000163086421126
Gc14_1150 0 n28 ns1150 0 0.000147443644824
Gc14_1151 0 n28 ns1151 0 -0.000265288482634
Gc14_1152 0 n28 ns1152 0 -2.98892126328e-06
Gc14_1153 0 n28 ns1153 0 0.000394151021048
Gc14_1154 0 n28 ns1154 0 0.000337899547057
Gc14_1155 0 n28 ns1155 0 0.00109839900943
Gc14_1156 0 n28 ns1156 0 -0.000624282538448
Gc14_1157 0 n28 ns1157 0 0.00134237724462
Gc14_1158 0 n28 ns1158 0 -0.000319400067944
Gc14_1159 0 n28 ns1159 0 0.00119094273351
Gc14_1160 0 n28 ns1160 0 -0.000655505107228
Gc14_1161 0 n28 ns1161 0 -0.00173605279828
Gc14_1162 0 n28 ns1162 0 -0.000894270254262
Gc14_1163 0 n28 ns1163 0 -0.00471958164342
Gc14_1164 0 n28 ns1164 0 -0.00441889796348
Gc14_1165 0 n28 ns1165 0 -0.00366855402648
Gc14_1166 0 n28 ns1166 0 -0.00469343873555
Gc14_1167 0 n28 ns1167 0 0.00305789123229
Gc14_1168 0 n28 ns1168 0 0.00180980236701
Gc14_1169 0 n28 ns1169 0 0.00094874385052
Gc14_1170 0 n28 ns1170 0 -0.00122135983989
Gc14_1171 0 n28 ns1171 0 -0.00172607332082
Gc14_1172 0 n28 ns1172 0 -0.00293114112337
Gc14_1173 0 n28 ns1173 0 0.00254502012835
Gc14_1174 0 n28 ns1174 0 -0.000561744999335
Gc14_1175 0 n28 ns1175 0 -0.0031981776888
Gc14_1176 0 n28 ns1176 0 -3.79686800778e-05
Gc14_1177 0 n28 ns1177 0 0.000337293188227
Gc14_1178 0 n28 ns1178 0 -0.000161448424113
Gc14_1179 0 n28 ns1179 0 -0.000409491859973
Gc14_1180 0 n28 ns1180 0 -4.23014329197e-05
Gc14_1181 0 n28 ns1181 0 -0.00112117409145
Gc14_1182 0 n28 ns1182 0 0.00188751112429
Gc14_1183 0 n28 ns1183 0 -9.41632122769e-05
Gc14_1184 0 n28 ns1184 0 0.000268848948691
Gc14_1185 0 n28 ns1185 0 2.33103230813e-05
Gc14_1186 0 n28 ns1186 0 -0.000214661453312
Gc14_1187 0 n28 ns1187 0 -0.000254992760431
Gc14_1188 0 n28 ns1188 0 0.0008340794336
Gc14_1189 0 n28 ns1189 0 -0.000112583759468
Gc14_1190 0 n28 ns1190 0 -3.39644618132e-05
Gc14_1191 0 n28 ns1191 0 0.000531748261779
Gc14_1192 0 n28 ns1192 0 -0.000777070793088
Gc14_1193 0 n28 ns1193 0 -0.000546676073578
Gc14_1194 0 n28 ns1194 0 0.000392409123307
Gc14_1195 0 n28 ns1195 0 0.000761899642832
Gc14_1196 0 n28 ns1196 0 7.66104559243e-05
Gc14_1197 0 n28 ns1197 0 0.000335577497354
Gc14_1198 0 n28 ns1198 0 -7.40878222116e-05
Gc14_1199 0 n28 ns1199 0 -0.000670444799152
Gc14_1200 0 n28 ns1200 0 0.00122654145386
Gc14_1201 0 n28 ns1201 0 0.000993524619042
Gc14_1202 0 n28 ns1202 0 -0.00335402363209
Gc14_1203 0 n28 ns1203 0 0.000756251925179
Gc14_1204 0 n28 ns1204 0 -0.00375880818205
Gc14_1205 0 n28 ns1205 0 -0.00112480914978
Gc14_1206 0 n28 ns1206 0 -0.000211302496897
Gc14_1207 0 n28 ns1207 0 0.000588004802709
Gc14_1208 0 n28 ns1208 0 -0.00123877727171
Gc14_1209 0 n28 ns1209 0 0.000849324525835
Gc14_1210 0 n28 ns1210 0 -0.00222721913522
Gc14_1211 0 n28 ns1211 0 0.00132968474669
Gc14_1212 0 n28 ns1212 0 -0.00256908716473
Gc14_1213 0 n28 ns1213 0 -0.00147360366915
Gc14_1214 0 n28 ns1214 0 -2.10347206186e-05
Gc14_1215 0 n28 ns1215 0 9.07680479871e-05
Gc14_1216 0 n28 ns1216 0 8.26865798009e-07
Gd14_1 0 n28 ni1 0 -0.000437042283373
Gd14_2 0 n28 ni2 0 8.10067952071e-05
Gd14_3 0 n28 ni3 0 0.000608944214317
Gd14_4 0 n28 ni4 0 0.000468830363561
Gd14_5 0 n28 ni5 0 -0.00120858002046
Gd14_6 0 n28 ni6 0 -0.00290861998372
Gd14_7 0 n28 ni7 0 -0.000691924919463
Gd14_8 0 n28 ni8 0 -0.00171238568636
Gd14_9 0 n28 ni9 0 0.000112417224527
Gd14_10 0 n28 ni10 0 0.000756611062888
Gd14_11 0 n28 ni11 0 0.000489725410699
Gd14_12 0 n28 ni12 0 -0.000245490325937
Gd14_13 0 n28 ni13 0 -0.00145266953518
Gd14_14 0 n28 ni14 0 0.000713319245926
Gd14_15 0 n28 ni15 0 -0.00159537249497
Gd14_16 0 n28 ni16 0 -0.000877131760599
Gd14_17 0 n28 ni17 0 0.00137615198282
Gd14_18 0 n28 ni18 0 0.000816719087956
Gd14_19 0 n28 ni19 0 -0.000682100201851
Gd14_20 0 n28 ni20 0 0.000113928959367
Gd14_21 0 n28 ni21 0 -0.000201154115138
Gd14_22 0 n28 ni22 0 -0.00180712331857
Gd14_23 0 n28 ni23 0 -0.00306191898582
Gd14_24 0 n28 ni24 0 0.000109874626779
Gd14_25 0 n28 ni25 0 0.000276850980682
Gd14_26 0 n28 ni26 0 -0.000847874360624
Gd14_27 0 n28 ni27 0 0.000143978572841
Gd14_28 0 n28 ni28 0 8.87336591165e-05
Gd14_29 0 n28 ni29 0 -0.000194627992482
Gd14_30 0 n28 ni30 0 0.000681720129603
Gd14_31 0 n28 ni31 0 -0.000447635884921
Gd14_32 0 n28 ni32 0 0.000451812404024
Gc15_1 0 n30 ns1 0 5.33180198926e-05
Gc15_2 0 n30 ns2 0 0.000205461275461
Gc15_3 0 n30 ns3 0 0.000218847661241
Gc15_4 0 n30 ns4 0 -0.000588633849909
Gc15_5 0 n30 ns5 0 -0.00010041295437
Gc15_6 0 n30 ns6 0 -4.47093180149e-05
Gc15_7 0 n30 ns7 0 0.000104844834288
Gc15_8 0 n30 ns8 0 3.68077382247e-05
Gc15_9 0 n30 ns9 0 0.000189753793917
Gc15_10 0 n30 ns10 0 -2.12066253956e-05
Gc15_11 0 n30 ns11 0 -5.70133064605e-05
Gc15_12 0 n30 ns12 0 8.73763876037e-07
Gc15_13 0 n30 ns13 0 -0.00017778691894
Gc15_14 0 n30 ns14 0 4.65310443848e-05
Gc15_15 0 n30 ns15 0 -0.000408517276618
Gc15_16 0 n30 ns16 0 -9.38791546208e-05
Gc15_17 0 n30 ns17 0 -0.000357095952606
Gc15_18 0 n30 ns18 0 7.45546725979e-05
Gc15_19 0 n30 ns19 0 -0.000445365771861
Gc15_20 0 n30 ns20 0 8.37499441792e-05
Gc15_21 0 n30 ns21 0 0.000235218680896
Gc15_22 0 n30 ns22 0 -0.000273782650079
Gc15_23 0 n30 ns23 0 0.000796939322826
Gc15_24 0 n30 ns24 0 -0.00171643138112
Gc15_25 0 n30 ns25 0 0.000678009102577
Gc15_26 0 n30 ns26 0 -0.00150822940636
Gc15_27 0 n30 ns27 0 1.0084098054e-05
Gc15_28 0 n30 ns28 0 6.67934622471e-05
Gc15_29 0 n30 ns29 0 -9.91802515534e-05
Gc15_30 0 n30 ns30 0 -4.34680021056e-05
Gc15_31 0 n30 ns31 0 -0.000307555438638
Gc15_32 0 n30 ns32 0 5.90721121506e-05
Gc15_33 0 n30 ns33 0 -0.000112211729512
Gc15_34 0 n30 ns34 0 0.000400032306254
Gc15_35 0 n30 ns35 0 0.00015052414629
Gc15_36 0 n30 ns36 0 -6.57730021702e-06
Gc15_37 0 n30 ns37 0 1.56348403611e-05
Gc15_38 0 n30 ns38 0 -3.06496650985e-05
Gc15_39 0 n30 ns39 0 0.000150608162502
Gc15_40 0 n30 ns40 0 0.000306776686897
Gc15_41 0 n30 ns41 0 0.000683132521402
Gc15_42 0 n30 ns42 0 -0.000184673740248
Gc15_43 0 n30 ns43 0 8.9416776469e-06
Gc15_44 0 n30 ns44 0 4.28559142049e-05
Gc15_45 0 n30 ns45 0 3.25082654018e-05
Gc15_46 0 n30 ns46 0 1.04122953838e-05
Gc15_47 0 n30 ns47 0 0.000267328371227
Gc15_48 0 n30 ns48 0 5.90308264516e-05
Gc15_49 0 n30 ns49 0 -6.35484853156e-05
Gc15_50 0 n30 ns50 0 -3.37226314484e-05
Gc15_51 0 n30 ns51 0 -0.000281158337445
Gc15_52 0 n30 ns52 0 -9.76794352536e-05
Gc15_53 0 n30 ns53 0 -0.000404133758899
Gc15_54 0 n30 ns54 0 -0.000365658743399
Gc15_55 0 n30 ns55 0 -0.000405174327561
Gc15_56 0 n30 ns56 0 -0.000112190492515
Gc15_57 0 n30 ns57 0 -0.00045512974082
Gc15_58 0 n30 ns58 0 -0.000178392704472
Gc15_59 0 n30 ns59 0 0.000451874240218
Gc15_60 0 n30 ns60 0 -7.49622090525e-05
Gc15_61 0 n30 ns61 0 0.00156871382429
Gc15_62 0 n30 ns62 0 -0.00145956018313
Gc15_63 0 n30 ns63 0 0.00134557734822
Gc15_64 0 n30 ns64 0 -0.00132401424446
Gc15_65 0 n30 ns65 0 0.000278945541928
Gc15_66 0 n30 ns66 0 0.000241388059005
Gc15_67 0 n30 ns67 0 -0.000161998813336
Gc15_68 0 n30 ns68 0 -8.54043074038e-05
Gc15_69 0 n30 ns69 0 -0.0006043519278
Gc15_70 0 n30 ns70 0 -0.000142805405241
Gc15_71 0 n30 ns71 0 -0.000236981700919
Gc15_72 0 n30 ns72 0 0.000122811349873
Gc15_73 0 n30 ns73 0 0.000104599491495
Gc15_74 0 n30 ns74 0 1.25380233553e-05
Gc15_75 0 n30 ns75 0 -1.67105107164e-05
Gc15_76 0 n30 ns76 0 -1.38625651441e-05
Gc15_77 0 n30 ns77 0 9.7091522046e-05
Gc15_78 0 n30 ns78 0 0.000485974171668
Gc15_79 0 n30 ns79 0 0.00063361293975
Gc15_80 0 n30 ns80 0 0.00108392329577
Gc15_81 0 n30 ns81 0 -3.97774323187e-05
Gc15_82 0 n30 ns82 0 0.000155403395569
Gc15_83 0 n30 ns83 0 7.2387805098e-07
Gc15_84 0 n30 ns84 0 -4.1718837276e-05
Gc15_85 0 n30 ns85 0 0.000113963586633
Gc15_86 0 n30 ns86 0 0.000479338774029
Gc15_87 0 n30 ns87 0 1.05876209548e-05
Gc15_88 0 n30 ns88 0 -0.000146786108671
Gc15_89 0 n30 ns89 0 -0.000136095831666
Gc15_90 0 n30 ns90 0 -0.000552298478626
Gc15_91 0 n30 ns91 0 0.000318456945433
Gc15_92 0 n30 ns92 0 -0.000939638057395
Gc15_93 0 n30 ns93 0 -0.000112285566403
Gc15_94 0 n30 ns94 0 -0.000718801770884
Gc15_95 0 n30 ns95 0 4.27102100624e-05
Gc15_96 0 n30 ns96 0 -0.000844868312912
Gc15_97 0 n30 ns97 0 0.00059065671511
Gc15_98 0 n30 ns98 0 0.000858277264683
Gc15_99 0 n30 ns99 0 0.00370913986447
Gc15_100 0 n30 ns100 0 0.000951794796608
Gc15_101 0 n30 ns101 0 0.00329986242749
Gc15_102 0 n30 ns102 0 0.000660742454423
Gc15_103 0 n30 ns103 0 0.000809836267158
Gc15_104 0 n30 ns104 0 0.00103436764021
Gc15_105 0 n30 ns105 0 -0.000325557427986
Gc15_106 0 n30 ns106 0 -0.000305432666734
Gc15_107 0 n30 ns107 0 -0.00134054337891
Gc15_108 0 n30 ns108 0 -0.00105026331492
Gc15_109 0 n30 ns109 0 -0.000540654533223
Gc15_110 0 n30 ns110 0 -0.000831050406023
Gc15_111 0 n30 ns111 0 -6.85439860162e-05
Gc15_112 0 n30 ns112 0 3.47808398946e-05
Gc15_113 0 n30 ns113 0 -5.60870924389e-05
Gc15_114 0 n30 ns114 0 -4.46097294076e-06
Gc15_115 0 n30 ns115 0 -0.000383226894861
Gc15_116 0 n30 ns116 0 0.000275572328972
Gc15_117 0 n30 ns117 0 -0.000914887612546
Gc15_118 0 n30 ns118 0 0.000836142891457
Gc15_119 0 n30 ns119 0 -0.000230358643756
Gc15_120 0 n30 ns120 0 0.000118187925496
Gc15_121 0 n30 ns121 0 0.000164786730409
Gc15_122 0 n30 ns122 0 -0.000144651803609
Gc15_123 0 n30 ns123 0 -0.000313527851604
Gc15_124 0 n30 ns124 0 0.000250720152923
Gc15_125 0 n30 ns125 0 0.000104614073594
Gc15_126 0 n30 ns126 0 -0.000140796144638
Gc15_127 0 n30 ns127 0 7.10313111936e-05
Gc15_128 0 n30 ns128 0 -0.000245079033208
Gc15_129 0 n30 ns129 0 0.000835945723728
Gc15_130 0 n30 ns130 0 6.41339204741e-05
Gc15_131 0 n30 ns131 0 0.000303783440748
Gc15_132 0 n30 ns132 0 -0.000534133205595
Gc15_133 0 n30 ns133 0 0.000218162020182
Gc15_134 0 n30 ns134 0 -0.000319902978657
Gc15_135 0 n30 ns135 0 -0.000514213009484
Gc15_136 0 n30 ns136 0 0.000561877624124
Gc15_137 0 n30 ns137 0 0.00290992201842
Gc15_138 0 n30 ns138 0 0.00291555133189
Gc15_139 0 n30 ns139 0 0.00285780679284
Gc15_140 0 n30 ns140 0 0.00252443298437
Gc15_141 0 n30 ns141 0 -0.000209754780427
Gc15_142 0 n30 ns142 0 0.00123514812541
Gc15_143 0 n30 ns143 0 -0.000305539860736
Gc15_144 0 n30 ns144 0 -0.000556569120787
Gc15_145 0 n30 ns145 0 -0.000991278033325
Gc15_146 0 n30 ns146 0 -0.0013126125891
Gc15_147 0 n30 ns147 0 -0.000519603909034
Gc15_148 0 n30 ns148 0 0.00013386464681
Gc15_149 0 n30 ns149 0 0.000239367115173
Gc15_150 0 n30 ns150 0 2.64483437e-06
Gc15_151 0 n30 ns151 0 -1.74697749183e-05
Gc15_152 0 n30 ns152 0 -4.59097526851e-05
Gc15_153 0 n30 ns153 0 -6.32273406371e-05
Gc15_154 0 n30 ns154 0 -5.00113587062e-05
Gc15_155 0 n30 ns155 0 9.65707472526e-05
Gc15_156 0 n30 ns156 0 0.00040006670508
Gc15_157 0 n30 ns157 0 9.57321473276e-05
Gc15_158 0 n30 ns158 0 0.000104516588909
Gc15_159 0 n30 ns159 0 2.62741895639e-05
Gc15_160 0 n30 ns160 0 8.73879163063e-05
Gc15_161 0 n30 ns161 0 -5.36934108316e-05
Gc15_162 0 n30 ns162 0 -0.00020209292261
Gc15_163 0 n30 ns163 0 0.000167548622352
Gc15_164 0 n30 ns164 0 -0.000113058796868
Gc15_165 0 n30 ns165 0 -0.000198880184641
Gc15_166 0 n30 ns166 0 -0.000321443295786
Gc15_167 0 n30 ns167 0 -0.000306985278008
Gc15_168 0 n30 ns168 0 0.00049776103288
Gc15_169 0 n30 ns169 0 0.000232349580131
Gc15_170 0 n30 ns170 0 -0.000427451950193
Gc15_171 0 n30 ns171 0 -0.000346605374983
Gc15_172 0 n30 ns172 0 -0.000507307348161
Gc15_173 0 n30 ns173 0 -9.44649333883e-05
Gc15_174 0 n30 ns174 0 -0.000809593486502
Gc15_175 0 n30 ns175 0 0.0022556909111
Gc15_176 0 n30 ns176 0 0.00324724224823
Gc15_177 0 n30 ns177 0 0.00231106471398
Gc15_178 0 n30 ns178 0 0.00326737234449
Gc15_179 0 n30 ns179 0 -0.00174235316568
Gc15_180 0 n30 ns180 0 -6.1118364685e-05
Gc15_181 0 n30 ns181 0 4.34076670608e-05
Gc15_182 0 n30 ns182 0 -0.0009036250303
Gc15_183 0 n30 ns183 0 3.26750248905e-05
Gc15_184 0 n30 ns184 0 -0.00111746623197
Gc15_185 0 n30 ns185 0 -0.00071342062753
Gc15_186 0 n30 ns186 0 0.001740486827
Gc15_187 0 n30 ns187 0 0.000867017681125
Gc15_188 0 n30 ns188 0 1.75792585104e-05
Gc15_189 0 n30 ns189 0 -0.000166309050646
Gc15_190 0 n30 ns190 0 3.16335584704e-05
Gc15_191 0 n30 ns191 0 0.000661096138129
Gc15_192 0 n30 ns192 0 -0.00180490698442
Gc15_193 0 n30 ns193 0 0.0018119763699
Gc15_194 0 n30 ns194 0 -0.00115684458843
Gc15_195 0 n30 ns195 0 -0.000311597615078
Gc15_196 0 n30 ns196 0 9.50022746731e-05
Gc15_197 0 n30 ns197 0 -0.000145179022415
Gc15_198 0 n30 ns198 0 -0.000140252684401
Gc15_199 0 n30 ns199 0 0.00025555697815
Gc15_200 0 n30 ns200 0 -3.42986368328e-05
Gc15_201 0 n30 ns201 0 0.00021488721634
Gc15_202 0 n30 ns202 0 -5.2672798588e-05
Gc15_203 0 n30 ns203 0 1.43813334233e-05
Gc15_204 0 n30 ns204 0 7.25703132553e-05
Gc15_205 0 n30 ns205 0 -0.000355558818741
Gc15_206 0 n30 ns206 0 -0.000836104817714
Gc15_207 0 n30 ns207 0 0.000586195855094
Gc15_208 0 n30 ns208 0 -0.000730229696818
Gc15_209 0 n30 ns209 0 0.00012604325728
Gc15_210 0 n30 ns210 0 -0.00129393450486
Gc15_211 0 n30 ns211 0 0.00180865752981
Gc15_212 0 n30 ns212 0 0.00021847910142
Gc15_213 0 n30 ns213 0 0.00300090900699
Gc15_214 0 n30 ns214 0 0.00431070248998
Gc15_215 0 n30 ns215 0 0.00256961915725
Gc15_216 0 n30 ns216 0 0.00452756654286
Gc15_217 0 n30 ns217 0 -5.2495664202e-05
Gc15_218 0 n30 ns218 0 -0.00188483066039
Gc15_219 0 n30 ns219 0 0.000671845528396
Gc15_220 0 n30 ns220 0 -0.00107295452533
Gc15_221 0 n30 ns221 0 -9.82703096189e-06
Gc15_222 0 n30 ns222 0 -0.000659912076066
Gc15_223 0 n30 ns223 0 -0.00224691313491
Gc15_224 0 n30 ns224 0 0.00216312971806
Gc15_225 0 n30 ns225 0 0.00196887361567
Gc15_226 0 n30 ns226 0 1.64234912586e-05
Gc15_227 0 n30 ns227 0 -0.000227501901962
Gc15_228 0 n30 ns228 0 7.17241454042e-05
Gc15_229 0 n30 ns229 0 0.00107527697567
Gc15_230 0 n30 ns230 0 -0.00477851940609
Gc15_231 0 n30 ns231 0 0.000813184495801
Gc15_232 0 n30 ns232 0 -0.00350062756451
Gc15_233 0 n30 ns233 0 -0.0011742171351
Gc15_234 0 n30 ns234 0 -0.000660919515914
Gc15_235 0 n30 ns235 0 0.00060908510776
Gc15_236 0 n30 ns236 0 -0.000145976212673
Gc15_237 0 n30 ns237 0 -9.91439373005e-05
Gc15_238 0 n30 ns238 0 0.00022494927752
Gc15_239 0 n30 ns239 0 0.0002867446452
Gc15_240 0 n30 ns240 0 4.86479819352e-05
Gc15_241 0 n30 ns241 0 -0.000366872713562
Gc15_242 0 n30 ns242 0 0.00059526887704
Gc15_243 0 n30 ns243 0 0.000706022665007
Gc15_244 0 n30 ns244 0 -2.66783313045e-05
Gc15_245 0 n30 ns245 0 0.000961691455112
Gc15_246 0 n30 ns246 0 -6.9611779673e-05
Gc15_247 0 n30 ns247 0 0.000356202344132
Gc15_248 0 n30 ns248 0 -0.000612784006776
Gc15_249 0 n30 ns249 0 0.000296636543583
Gc15_250 0 n30 ns250 0 0.00136517077375
Gc15_251 0 n30 ns251 0 0.00354788333051
Gc15_252 0 n30 ns252 0 0.00644143696853
Gc15_253 0 n30 ns253 0 0.0025125838664
Gc15_254 0 n30 ns254 0 0.00640960427147
Gc15_255 0 n30 ns255 0 0.00211225730376
Gc15_256 0 n30 ns256 0 0.00178777742243
Gc15_257 0 n30 ns257 0 0.00107071125474
Gc15_258 0 n30 ns258 0 -0.000943071990247
Gc15_259 0 n30 ns259 0 -0.00350540712452
Gc15_260 0 n30 ns260 0 -0.00117205048023
Gc15_261 0 n30 ns261 0 -0.000479136437145
Gc15_262 0 n30 ns262 0 -0.00201400555521
Gc15_263 0 n30 ns263 0 0.00383288218157
Gc15_264 0 n30 ns264 0 -5.29105829627e-06
Gc15_265 0 n30 ns265 0 -0.000115974197726
Gc15_266 0 n30 ns266 0 2.72384066279e-06
Gc15_267 0 n30 ns267 0 0.00105389921633
Gc15_268 0 n30 ns268 0 -0.00413160520508
Gc15_269 0 n30 ns269 0 -0.000329760746408
Gc15_270 0 n30 ns270 0 -0.00186250902406
Gc15_271 0 n30 ns271 0 -0.000942772187177
Gc15_272 0 n30 ns272 0 -0.000180598119543
Gc15_273 0 n30 ns273 0 0.00060631862293
Gc15_274 0 n30 ns274 0 -4.31749333446e-05
Gc15_275 0 n30 ns275 0 0.000293777756941
Gc15_276 0 n30 ns276 0 5.31422634252e-05
Gc15_277 0 n30 ns277 0 0.000238398626548
Gc15_278 0 n30 ns278 0 0.000115055291544
Gc15_279 0 n30 ns279 0 -0.000574959137597
Gc15_280 0 n30 ns280 0 -0.00016155979569
Gc15_281 0 n30 ns281 0 -0.000619509366694
Gc15_282 0 n30 ns282 0 0.000528716445789
Gc15_283 0 n30 ns283 0 0.000324378572969
Gc15_284 0 n30 ns284 0 0.000299344797033
Gc15_285 0 n30 ns285 0 -0.000506976267839
Gc15_286 0 n30 ns286 0 -0.000667300916544
Gc15_287 0 n30 ns287 0 -0.000460881700651
Gc15_288 0 n30 ns288 0 -0.000758131614962
Gc15_289 0 n30 ns289 0 0.00312787166841
Gc15_290 0 n30 ns290 0 0.00527807027929
Gc15_291 0 n30 ns291 0 0.00182497078277
Gc15_292 0 n30 ns292 0 0.00543127778433
Gc15_293 0 n30 ns293 0 -0.000136134694454
Gc15_294 0 n30 ns294 0 0.00455287942225
Gc15_295 0 n30 ns295 0 0.00115515693495
Gc15_296 0 n30 ns296 0 -0.000841883371911
Gc15_297 0 n30 ns297 0 -0.00525726044432
Gc15_298 0 n30 ns298 0 -0.00151994279576
Gc15_299 0 n30 ns299 0 0.00348602884601
Gc15_300 0 n30 ns300 0 -0.00472688900707
Gc15_301 0 n30 ns301 0 0.00467215539562
Gc15_302 0 n30 ns302 0 -1.54563242565e-05
Gc15_303 0 n30 ns303 0 -7.89566929299e-05
Gc15_304 0 n30 ns304 0 -1.07992782627e-05
Gc15_305 0 n30 ns305 0 0.000673467804324
Gc15_306 0 n30 ns306 0 -0.00180495088384
Gc15_307 0 n30 ns307 0 0.00136378362379
Gc15_308 0 n30 ns308 0 -0.00150698321564
Gc15_309 0 n30 ns309 0 -0.000974744672152
Gc15_310 0 n30 ns310 0 -0.00016612209808
Gc15_311 0 n30 ns311 0 0.000142058633979
Gc15_312 0 n30 ns312 0 -0.000156223310109
Gc15_313 0 n30 ns313 0 0.000532814114571
Gc15_314 0 n30 ns314 0 0.000338561753061
Gc15_315 0 n30 ns315 0 0.000135631438461
Gc15_316 0 n30 ns316 0 0.000101072279913
Gc15_317 0 n30 ns317 0 0.00035797185713
Gc15_318 0 n30 ns318 0 0.00037417720058
Gc15_319 0 n30 ns319 0 -0.000230181940121
Gc15_320 0 n30 ns320 0 -0.0015499852668
Gc15_321 0 n30 ns321 0 0.000583802707433
Gc15_322 0 n30 ns322 0 -0.000137560878784
Gc15_323 0 n30 ns323 0 0.000589110948499
Gc15_324 0 n30 ns324 0 -0.000667256649275
Gc15_325 0 n30 ns325 0 0.00230561158059
Gc15_326 0 n30 ns326 0 0.00129520857196
Gc15_327 0 n30 ns327 0 -0.000589198260896
Gc15_328 0 n30 ns328 0 0.00189889366056
Gc15_329 0 n30 ns329 0 -0.00100452484388
Gc15_330 0 n30 ns330 0 0.00237337486805
Gc15_331 0 n30 ns331 0 0.00238012393435
Gc15_332 0 n30 ns332 0 -0.00296029356369
Gc15_333 0 n30 ns333 0 0.00116445464652
Gc15_334 0 n30 ns334 0 -0.000574741884054
Gc15_335 0 n30 ns335 0 7.38727299076e-05
Gc15_336 0 n30 ns336 0 0.00057638689975
Gc15_337 0 n30 ns337 0 -0.00312822753983
Gc15_338 0 n30 ns338 0 0.00205321596364
Gc15_339 0 n30 ns339 0 0.00260163060407
Gc15_340 0 n30 ns340 0 1.72596485215e-05
Gc15_341 0 n30 ns341 0 -0.000206241378483
Gc15_342 0 n30 ns342 0 5.32121651519e-05
Gc15_343 0 n30 ns343 0 0.000203731939934
Gc15_344 0 n30 ns344 0 0.00045153947538
Gc15_345 0 n30 ns345 0 0.000930118794707
Gc15_346 0 n30 ns346 0 0.000758682293336
Gc15_347 0 n30 ns347 0 2.77474606625e-05
Gc15_348 0 n30 ns348 0 0.000193929933508
Gc15_349 0 n30 ns349 0 -1.2474014222e-05
Gc15_350 0 n30 ns350 0 -5.76502803296e-05
Gc15_351 0 n30 ns351 0 0.000260400161297
Gc15_352 0 n30 ns352 0 0.000302165839951
Gc15_353 0 n30 ns353 0 -3.1364207192e-05
Gc15_354 0 n30 ns354 0 -9.84956514095e-05
Gc15_355 0 n30 ns355 0 -0.00024672269051
Gc15_356 0 n30 ns356 0 -0.000428773456599
Gc15_357 0 n30 ns357 0 -3.83795443588e-05
Gc15_358 0 n30 ns358 0 -0.000840036079564
Gc15_359 0 n30 ns359 0 -0.000263584128407
Gc15_360 0 n30 ns360 0 -0.000524108732475
Gc15_361 0 n30 ns361 0 -0.000164108673173
Gc15_362 0 n30 ns362 0 -0.000684878226578
Gc15_363 0 n30 ns363 0 0.000669382189056
Gc15_364 0 n30 ns364 0 0.000542081302979
Gc15_365 0 n30 ns365 0 0.00296914178788
Gc15_366 0 n30 ns366 0 -4.03421839227e-05
Gc15_367 0 n30 ns367 0 0.0025971712623
Gc15_368 0 n30 ns368 0 -0.000172442305131
Gc15_369 0 n30 ns369 0 0.000741376335741
Gc15_370 0 n30 ns370 0 0.000759840501506
Gc15_371 0 n30 ns371 0 -0.000271847090056
Gc15_372 0 n30 ns372 0 -0.000215833344643
Gc15_373 0 n30 ns373 0 -0.00113893881962
Gc15_374 0 n30 ns374 0 -0.000756607626945
Gc15_375 0 n30 ns375 0 -0.000455857867602
Gc15_376 0 n30 ns376 0 -0.000639957292487
Gc15_377 0 n30 ns377 0 -4.69252507694e-05
Gc15_378 0 n30 ns378 0 3.11533799156e-05
Gc15_379 0 n30 ns379 0 -5.15758526019e-05
Gc15_380 0 n30 ns380 0 7.21177082861e-06
Gc15_381 0 n30 ns381 0 -0.000346614444482
Gc15_382 0 n30 ns382 0 0.000591414215098
Gc15_383 0 n30 ns383 0 -0.00074395579744
Gc15_384 0 n30 ns384 0 0.00142038121622
Gc15_385 0 n30 ns385 0 -0.000229472567995
Gc15_386 0 n30 ns386 0 0.000334661646866
Gc15_387 0 n30 ns387 0 9.63652933171e-05
Gc15_388 0 n30 ns388 0 -0.000241825923267
Gc15_389 0 n30 ns389 0 -0.000141285647451
Gc15_390 0 n30 ns390 0 0.000443027382444
Gc15_391 0 n30 ns391 0 7.42900619069e-05
Gc15_392 0 n30 ns392 0 -0.000153785471008
Gc15_393 0 n30 ns393 0 6.04553113358e-05
Gc15_394 0 n30 ns394 0 -0.000460864664591
Gc15_395 0 n30 ns395 0 0.000820292286626
Gc15_396 0 n30 ns396 0 -0.000464171852303
Gc15_397 0 n30 ns397 0 0.000208598797791
Gc15_398 0 n30 ns398 0 -0.000669098246073
Gc15_399 0 n30 ns399 0 0.000309249430311
Gc15_400 0 n30 ns400 0 -0.000575417916104
Gc15_401 0 n30 ns401 0 -0.000120502918859
Gc15_402 0 n30 ns402 0 0.000923185179316
Gc15_403 0 n30 ns403 0 0.00325154898498
Gc15_404 0 n30 ns404 0 0.00249015451343
Gc15_405 0 n30 ns405 0 0.0030584778422
Gc15_406 0 n30 ns406 0 0.00205002833866
Gc15_407 0 n30 ns407 0 0.000365583550827
Gc15_408 0 n30 ns408 0 0.00136115729491
Gc15_409 0 n30 ns409 0 -0.000343903022237
Gc15_410 0 n30 ns410 0 -0.000466724659551
Gc15_411 0 n30 ns411 0 -0.00126695146789
Gc15_412 0 n30 ns412 0 -0.00137242760419
Gc15_413 0 n30 ns413 0 -0.000548321234038
Gc15_414 0 n30 ns414 0 -0.000504888202466
Gc15_415 0 n30 ns415 0 4.34576913843e-05
Gc15_416 0 n30 ns416 0 2.92020320184e-06
Gc15_417 0 n30 ns417 0 -4.72251502822e-06
Gc15_418 0 n30 ns418 0 -3.69302979986e-05
Gc15_419 0 n30 ns419 0 -0.000189145431416
Gc15_420 0 n30 ns420 0 6.1788058565e-05
Gc15_421 0 n30 ns421 0 -0.000256054487378
Gc15_422 0 n30 ns422 0 0.000546521087855
Gc15_423 0 n30 ns423 0 -1.05779524076e-05
Gc15_424 0 n30 ns424 0 7.13573608053e-05
Gc15_425 0 n30 ns425 0 0.000151350969845
Gc15_426 0 n30 ns426 0 -1.35005802844e-05
Gc15_427 0 n30 ns427 0 -0.000181841298354
Gc15_428 0 n30 ns428 0 -7.62104087996e-05
Gc15_429 0 n30 ns429 0 0.000129507562577
Gc15_430 0 n30 ns430 0 -0.000132559824026
Gc15_431 0 n30 ns431 0 -0.000222577492751
Gc15_432 0 n30 ns432 0 -0.000250132345799
Gc15_433 0 n30 ns433 0 0.000158934152625
Gc15_434 0 n30 ns434 0 0.000551127611719
Gc15_435 0 n30 ns435 0 0.000239256634511
Gc15_436 0 n30 ns436 0 -0.000395655864595
Gc15_437 0 n30 ns437 0 -0.000192967372378
Gc15_438 0 n30 ns438 0 -0.000304941983772
Gc15_439 0 n30 ns439 0 -0.000508474886684
Gc15_440 0 n30 ns440 0 -0.000374493547156
Gc15_441 0 n30 ns441 0 0.00230214967762
Gc15_442 0 n30 ns442 0 0.00315305075
Gc15_443 0 n30 ns443 0 0.00238007250046
Gc15_444 0 n30 ns444 0 0.00299808051889
Gc15_445 0 n30 ns445 0 -0.0013093272161
Gc15_446 0 n30 ns446 0 0.000667486829222
Gc15_447 0 n30 ns447 0 -0.000123092815851
Gc15_448 0 n30 ns448 0 -0.000789469984828
Gc15_449 0 n30 ns449 0 -0.000342958384496
Gc15_450 0 n30 ns450 0 -0.00134302680225
Gc15_451 0 n30 ns451 0 -0.00057994233461
Gc15_452 0 n30 ns452 0 0.00102710842102
Gc15_453 0 n30 ns453 0 0.000565156052718
Gc15_454 0 n30 ns454 0 5.16476975111e-06
Gc15_455 0 n30 ns455 0 -9.8978914442e-05
Gc15_456 0 n30 ns456 0 -2.44739386449e-06
Gc15_457 0 n30 ns457 0 0.0003440900563
Gc15_458 0 n30 ns458 0 -0.00075153676625
Gc15_459 0 n30 ns459 0 0.00114568150725
Gc15_460 0 n30 ns460 0 -1.90901770826e-05
Gc15_461 0 n30 ns461 0 -7.7753311367e-05
Gc15_462 0 n30 ns462 0 0.000361585948387
Gc15_463 0 n30 ns463 0 -0.000168219079749
Gc15_464 0 n30 ns464 0 -0.000108268160488
Gc15_465 0 n30 ns465 0 0.00025440933133
Gc15_466 0 n30 ns466 0 -0.00016785920142
Gc15_467 0 n30 ns467 0 0.000185076166149
Gc15_468 0 n30 ns468 0 -8.50090244013e-05
Gc15_469 0 n30 ns469 0 1.43610991284e-05
Gc15_470 0 n30 ns470 0 -0.00027334603499
Gc15_471 0 n30 ns471 0 -0.000594684097528
Gc15_472 0 n30 ns472 0 -0.000454009014046
Gc15_473 0 n30 ns473 0 0.000384697871561
Gc15_474 0 n30 ns474 0 -0.000715148641206
Gc15_475 0 n30 ns475 0 -7.18138922741e-05
Gc15_476 0 n30 ns476 0 -0.00118140746083
Gc15_477 0 n30 ns477 0 0.00132923740278
Gc15_478 0 n30 ns478 0 -0.000457099149695
Gc15_479 0 n30 ns479 0 0.00261185823978
Gc15_480 0 n30 ns480 0 0.00397088535427
Gc15_481 0 n30 ns481 0 0.00238094985718
Gc15_482 0 n30 ns482 0 0.00410992629775
Gc15_483 0 n30 ns483 0 -0.00113363925893
Gc15_484 0 n30 ns484 0 -0.00152475965435
Gc15_485 0 n30 ns485 0 0.000423480771449
Gc15_486 0 n30 ns486 0 -0.00105426783234
Gc15_487 0 n30 ns487 0 0.000163582264051
Gc15_488 0 n30 ns488 0 -0.000795022017445
Gc15_489 0 n30 ns489 0 -0.00152077388628
Gc15_490 0 n30 ns490 0 0.0024097258675
Gc15_491 0 n30 ns491 0 0.00148756421715
Gc15_492 0 n30 ns492 0 3.28703411548e-05
Gc15_493 0 n30 ns493 0 -0.000265491176535
Gc15_494 0 n30 ns494 0 9.82684785581e-05
Gc15_495 0 n30 ns495 0 0.000240198122677
Gc15_496 0 n30 ns496 0 -0.00224038325977
Gc15_497 0 n30 ns497 0 8.05831811998e-05
Gc15_498 0 n30 ns498 0 -0.00067945946398
Gc15_499 0 n30 ns499 0 -0.000798511976601
Gc15_500 0 n30 ns500 0 0.000258449921159
Gc15_501 0 n30 ns501 0 0.000251355012549
Gc15_502 0 n30 ns502 0 -0.000518714885967
Gc15_503 0 n30 ns503 0 3.98517109852e-05
Gc15_504 0 n30 ns504 0 0.00024604651873
Gc15_505 0 n30 ns505 0 0.000291422301559
Gc15_506 0 n30 ns506 0 4.80266552452e-06
Gc15_507 0 n30 ns507 0 -0.000168222619457
Gc15_508 0 n30 ns508 0 0.00024985517418
Gc15_509 0 n30 ns509 0 0.0010277564349
Gc15_510 0 n30 ns510 0 -0.000461393737919
Gc15_511 0 n30 ns511 0 0.00117289720513
Gc15_512 0 n30 ns512 0 -0.000263650057409
Gc15_513 0 n30 ns513 0 0.000772254986052
Gc15_514 0 n30 ns514 0 -0.000616448086754
Gc15_515 0 n30 ns515 0 0.000418923453637
Gc15_516 0 n30 ns516 0 0.00217255099606
Gc15_517 0 n30 ns517 0 0.0016824020239
Gc15_518 0 n30 ns518 0 0.00566542925806
Gc15_519 0 n30 ns519 0 0.00120904561695
Gc15_520 0 n30 ns520 0 0.00573982145357
Gc15_521 0 n30 ns521 0 0.00324872552125
Gc15_522 0 n30 ns522 0 0.0003937232216
Gc15_523 0 n30 ns523 0 0.000975961072877
Gc15_524 0 n30 ns524 0 -0.000999329482199
Gc15_525 0 n30 ns525 0 -0.00153685997287
Gc15_526 0 n30 ns526 0 -0.0013386999027
Gc15_527 0 n30 ns527 0 -0.00379700889336
Gc15_528 0 n30 ns528 0 -0.000142546571683
Gc15_529 0 n30 ns529 0 0.00311022212965
Gc15_530 0 n30 ns530 0 2.11805493424e-05
Gc15_531 0 n30 ns531 0 -0.000177045261435
Gc15_532 0 n30 ns532 0 2.45106532231e-05
Gc15_533 0 n30 ns533 0 0.000532887030933
Gc15_534 0 n30 ns534 0 -0.00271120433834
Gc15_535 0 n30 ns535 0 -0.00130868914983
Gc15_536 0 n30 ns536 0 -0.000310237831663
Gc15_537 0 n30 ns537 0 -0.000477709477709
Gc15_538 0 n30 ns538 0 9.21647243916e-05
Gc15_539 0 n30 ns539 0 0.000385777912961
Gc15_540 0 n30 ns540 0 -0.000198033218907
Gc15_541 0 n30 ns541 0 6.99002684796e-05
Gc15_542 0 n30 ns542 0 -5.1134714097e-05
Gc15_543 0 n30 ns543 0 0.000270024606569
Gc15_544 0 n30 ns544 0 0.000107543079674
Gc15_545 0 n30 ns545 0 -0.000729490552561
Gc15_546 0 n30 ns546 0 -0.00015210951406
Gc15_547 0 n30 ns547 0 -9.48615919235e-05
Gc15_548 0 n30 ns548 0 0.000954045611287
Gc15_549 0 n30 ns549 0 0.000456936786693
Gc15_550 0 n30 ns550 0 0.000368481703461
Gc15_551 0 n30 ns551 0 -0.000512979907422
Gc15_552 0 n30 ns552 0 -0.000466124256246
Gc15_553 0 n30 ns553 0 -0.00116534341696
Gc15_554 0 n30 ns554 0 -0.000507869146717
Gc15_555 0 n30 ns555 0 0.00396773201481
Gc15_556 0 n30 ns556 0 0.00493611948636
Gc15_557 0 n30 ns557 0 0.00261181824187
Gc15_558 0 n30 ns558 0 0.0051883517131
Gc15_559 0 n30 ns559 0 0.000147201170315
Gc15_560 0 n30 ns560 0 0.00499467679222
Gc15_561 0 n30 ns561 0 0.0011480052858
Gc15_562 0 n30 ns562 0 -0.000807655245339
Gc15_563 0 n30 ns563 0 -0.00515860837124
Gc15_564 0 n30 ns564 0 -0.00132036768609
Gc15_565 0 n30 ns565 0 0.00297018373713
Gc15_566 0 n30 ns566 0 -0.00386435884031
Gc15_567 0 n30 ns567 0 0.00487308842028
Gc15_568 0 n30 ns568 0 -3.01879377409e-05
Gc15_569 0 n30 ns569 0 -4.01569701138e-06
Gc15_570 0 n30 ns570 0 -7.08010756238e-05
Gc15_571 0 n30 ns571 0 0.000454708692189
Gc15_572 0 n30 ns572 0 -0.00215779274015
Gc15_573 0 n30 ns573 0 0.000633426017583
Gc15_574 0 n30 ns574 0 -0.000748776665309
Gc15_575 0 n30 ns575 0 -0.000922053473226
Gc15_576 0 n30 ns576 0 0.000250087859069
Gc15_577 0 n30 ns577 0 0.000307723185093
Gc15_578 0 n30 ns578 0 -0.000360802151947
Gc15_579 0 n30 ns579 0 0.000570283905106
Gc15_580 0 n30 ns580 0 0.000296044818131
Gc15_581 0 n30 ns581 0 0.000189294436987
Gc15_582 0 n30 ns582 0 0.000110137100336
Gc15_583 0 n30 ns583 0 -0.000149040409094
Gc15_584 0 n30 ns584 0 7.54644592626e-05
Gc15_585 0 n30 ns585 0 2.06238221776e-05
Gc15_586 0 n30 ns586 0 -0.00103732294962
Gc15_587 0 n30 ns587 0 0.000714604590831
Gc15_588 0 n30 ns588 0 7.32356560101e-05
Gc15_589 0 n30 ns589 0 0.000463716976454
Gc15_590 0 n30 ns590 0 -0.0005613570255
Gc15_591 0 n30 ns591 0 0.00129227068834
Gc15_592 0 n30 ns592 0 0.001643748235
Gc15_593 0 n30 ns593 0 -0.00067595987074
Gc15_594 0 n30 ns594 0 0.00249864394656
Gc15_595 0 n30 ns595 0 -0.00115719210494
Gc15_596 0 n30 ns596 0 0.00304449757615
Gc15_597 0 n30 ns597 0 0.00349464797657
Gc15_598 0 n30 ns598 0 -0.000747975032993
Gc15_599 0 n30 ns599 0 0.00127494004761
Gc15_600 0 n30 ns600 0 -0.000745192849013
Gc15_601 0 n30 ns601 0 -0.000902668882421
Gc15_602 0 n30 ns602 0 -0.000478803324415
Gc15_603 0 n30 ns603 0 -0.00374263084899
Gc15_604 0 n30 ns604 0 5.35929516137e-05
Gc15_605 0 n30 ns605 0 0.00319777922927
Gc15_606 0 n30 ns606 0 4.12726577256e-05
Gc15_607 0 n30 ns607 0 -0.000252462547981
Gc15_608 0 n30 ns608 0 8.88784410286e-05
Gc15_609 0 n30 ns609 0 0.000301863396704
Gc15_610 0 n30 ns610 0 -0.000316277884846
Gc15_611 0 n30 ns611 0 0.000707646838787
Gc15_612 0 n30 ns612 0 -0.000513302910159
Gc15_613 0 n30 ns613 0 0.000169435843164
Gc15_614 0 n30 ns614 0 -0.000219699012012
Gc15_615 0 n30 ns615 0 -0.00015071875964
Gc15_616 0 n30 ns616 0 0.000100034624976
Gc15_617 0 n30 ns617 0 -0.000269340998502
Gc15_618 0 n30 ns618 0 -3.76782352186e-06
Gc15_619 0 n30 ns619 0 8.46149040148e-05
Gc15_620 0 n30 ns620 0 9.85831152549e-06
Gc15_621 0 n30 ns621 0 7.1182374581e-05
Gc15_622 0 n30 ns622 0 -0.000152456226934
Gc15_623 0 n30 ns623 0 -0.00036790416756
Gc15_624 0 n30 ns624 0 -0.000117299804654
Gc15_625 0 n30 ns625 0 -0.000367324673032
Gc15_626 0 n30 ns626 0 9.58159351643e-05
Gc15_627 0 n30 ns627 0 -0.000454824745514
Gc15_628 0 n30 ns628 0 0.000182682446678
Gc15_629 0 n30 ns629 0 -0.000340720207153
Gc15_630 0 n30 ns630 0 -4.03982804876e-05
Gc15_631 0 n30 ns631 0 -0.00148976659685
Gc15_632 0 n30 ns632 0 0.00130276897377
Gc15_633 0 n30 ns633 0 -0.00127321836495
Gc15_634 0 n30 ns634 0 0.0011708875408
Gc15_635 0 n30 ns635 0 0.000429107410011
Gc15_636 0 n30 ns636 0 0.000332712508419
Gc15_637 0 n30 ns637 0 -0.000144701146331
Gc15_638 0 n30 ns638 0 -7.23948440618e-05
Gc15_639 0 n30 ns639 0 -0.000564753453728
Gc15_640 0 n30 ns640 0 -0.000213432828021
Gc15_641 0 n30 ns641 0 -6.80192663767e-05
Gc15_642 0 n30 ns642 0 -0.000135978288429
Gc15_643 0 n30 ns643 0 -6.77647610331e-05
Gc15_644 0 n30 ns644 0 -1.11648116459e-05
Gc15_645 0 n30 ns645 0 1.89254615594e-05
Gc15_646 0 n30 ns646 0 8.66440845787e-06
Gc15_647 0 n30 ns647 0 3.76004848524e-05
Gc15_648 0 n30 ns648 0 0.0001456704875
Gc15_649 0 n30 ns649 0 0.000131201750073
Gc15_650 0 n30 ns650 0 -1.69233201675e-05
Gc15_651 0 n30 ns651 0 5.69176860528e-05
Gc15_652 0 n30 ns652 0 1.05093331742e-05
Gc15_653 0 n30 ns653 0 -7.54158107934e-05
Gc15_654 0 n30 ns654 0 -4.6745261325e-05
Gc15_655 0 n30 ns655 0 -0.000253192510864
Gc15_656 0 n30 ns656 0 -3.18711469822e-06
Gc15_657 0 n30 ns657 0 0.000107270856887
Gc15_658 0 n30 ns658 0 2.67688610349e-05
Gc15_659 0 n30 ns659 0 0.000187177996139
Gc15_660 0 n30 ns660 0 -0.00027293957889
Gc15_661 0 n30 ns661 0 -0.000283638090298
Gc15_662 0 n30 ns662 0 -0.000283294480909
Gc15_663 0 n30 ns663 0 -0.000390437368164
Gc15_664 0 n30 ns664 0 3.38729001903e-06
Gc15_665 0 n30 ns665 0 -0.000450675705185
Gc15_666 0 n30 ns666 0 0.000104262660412
Gc15_667 0 n30 ns667 0 -0.000465469014308
Gc15_668 0 n30 ns668 0 5.93623834831e-06
Gc15_669 0 n30 ns669 0 -0.00231086660121
Gc15_670 0 n30 ns670 0 0.00165802148769
Gc15_671 0 n30 ns671 0 -0.00198406598936
Gc15_672 0 n30 ns672 0 0.00148491163529
Gc15_673 0 n30 ns673 0 0.000605501385165
Gc15_674 0 n30 ns674 0 0.000623020628008
Gc15_675 0 n30 ns675 0 -0.000204390638593
Gc15_676 0 n30 ns676 0 -0.000119648314426
Gc15_677 0 n30 ns677 0 -0.000791067350989
Gc15_678 0 n30 ns678 0 -0.000440255802069
Gc15_679 0 n30 ns679 0 -0.000116413292589
Gc15_680 0 n30 ns680 0 -0.000366066927837
Gc15_681 0 n30 ns681 0 -0.000120558940793
Gc15_682 0 n30 ns682 0 -1.52705288983e-05
Gc15_683 0 n30 ns683 0 2.88300286561e-05
Gc15_684 0 n30 ns684 0 8.295118242e-07
Gc15_685 0 n30 ns685 0 -0.000459212760871
Gc15_686 0 n30 ns686 0 0.0010291780389
Gc15_687 0 n30 ns687 0 -0.000880164785634
Gc15_688 0 n30 ns688 0 0.000725496455011
Gc15_689 0 n30 ns689 0 -0.000190627003841
Gc15_690 0 n30 ns690 0 0.000412744497706
Gc15_691 0 n30 ns691 0 0.000173101564862
Gc15_692 0 n30 ns692 0 -0.000257001091289
Gc15_693 0 n30 ns693 0 7.56522415518e-05
Gc15_694 0 n30 ns694 0 -0.000188113840513
Gc15_695 0 n30 ns695 0 4.1513236549e-05
Gc15_696 0 n30 ns696 0 9.71500610828e-05
Gc15_697 0 n30 ns697 0 0.000292710544461
Gc15_698 0 n30 ns698 0 -9.19225892866e-05
Gc15_699 0 n30 ns699 0 0.000289728455315
Gc15_700 0 n30 ns700 0 -0.0005527631493
Gc15_701 0 n30 ns701 0 -0.000236072474939
Gc15_702 0 n30 ns702 0 -0.000433014578378
Gc15_703 0 n30 ns703 0 -0.000268327696646
Gc15_704 0 n30 ns704 0 -0.000339166100238
Gc15_705 0 n30 ns705 0 -0.000515355763358
Gc15_706 0 n30 ns706 0 -0.000136274763138
Gc15_707 0 n30 ns707 0 -0.00469317330298
Gc15_708 0 n30 ns708 0 0.000790203268903
Gc15_709 0 n30 ns709 0 -0.00412413096684
Gc15_710 0 n30 ns710 0 0.000750902408999
Gc15_711 0 n30 ns711 0 0.00077558839274
Gc15_712 0 n30 ns712 0 0.00148730951018
Gc15_713 0 n30 ns713 0 -0.000342372658711
Gc15_714 0 n30 ns714 0 -0.000331525247202
Gc15_715 0 n30 ns715 0 -0.00127300793305
Gc15_716 0 n30 ns716 0 -0.00124229590909
Gc15_717 0 n30 ns717 0 -0.00022097380997
Gc15_718 0 n30 ns718 0 -0.00106291586097
Gc15_719 0 n30 ns719 0 -0.000290090548648
Gc15_720 0 n30 ns720 0 -2.54895811087e-05
Gc15_721 0 n30 ns721 0 9.9875212189e-05
Gc15_722 0 n30 ns722 0 -2.74976709778e-05
Gc15_723 0 n30 ns723 0 0.000335026593864
Gc15_724 0 n30 ns724 0 -0.00059132498716
Gc15_725 0 n30 ns725 0 0.00116954604757
Gc15_726 0 n30 ns726 0 -0.000938921220861
Gc15_727 0 n30 ns727 0 0.000247493997486
Gc15_728 0 n30 ns728 0 -0.000186273077398
Gc15_729 0 n30 ns729 0 -0.000172974379929
Gc15_730 0 n30 ns730 0 0.000156679743489
Gc15_731 0 n30 ns731 0 0.000321666088606
Gc15_732 0 n30 ns732 0 -0.000331411381702
Gc15_733 0 n30 ns733 0 -0.000124134364013
Gc15_734 0 n30 ns734 0 0.000136629579149
Gc15_735 0 n30 ns735 0 -0.000234461545816
Gc15_736 0 n30 ns736 0 0.000549656865964
Gc15_737 0 n30 ns737 0 0.000468123734396
Gc15_738 0 n30 ns738 0 0.000276116810408
Gc15_739 0 n30 ns739 0 7.71779895742e-05
Gc15_740 0 n30 ns740 0 -0.000439791202693
Gc15_741 0 n30 ns741 0 -0.000166240711499
Gc15_742 0 n30 ns742 0 -0.000277972495137
Gc15_743 0 n30 ns743 0 -2.87447549241e-05
Gc15_744 0 n30 ns744 0 -0.000529623556866
Gc15_745 0 n30 ns745 0 -0.00502413171288
Gc15_746 0 n30 ns746 0 -0.0032257692744
Gc15_747 0 n30 ns747 0 -0.00461738782731
Gc15_748 0 n30 ns748 0 -0.00279262904124
Gc15_749 0 n30 ns749 0 7.17087032905e-05
Gc15_750 0 n30 ns750 0 0.00167448307734
Gc15_751 0 n30 ns751 0 -0.000341843563261
Gc15_752 0 n30 ns752 0 -0.000603935754518
Gc15_753 0 n30 ns753 0 -0.00114472822044
Gc15_754 0 n30 ns754 0 -0.00172416634476
Gc15_755 0 n30 ns755 0 -0.000101530291361
Gc15_756 0 n30 ns756 0 -0.00114147001573
Gc15_757 0 n30 ns757 0 -0.000371474300397
Gc15_758 0 n30 ns758 0 -9.72514701255e-06
Gc15_759 0 n30 ns759 0 8.87309901824e-05
Gc15_760 0 n30 ns760 0 -6.55138404762e-06
Gc15_761 0 n30 ns761 0 -0.000183827436629
Gc15_762 0 n30 ns762 0 -0.000323988046996
Gc15_763 0 n30 ns763 0 -0.000518019263443
Gc15_764 0 n30 ns764 0 0.000667275928688
Gc15_765 0 n30 ns765 0 -0.000166599037326
Gc15_766 0 n30 ns766 0 2.56011817053e-05
Gc15_767 0 n30 ns767 0 -3.21871791978e-05
Gc15_768 0 n30 ns768 0 -0.000102552243217
Gc15_769 0 n30 ns769 0 -3.71559405676e-05
Gc15_770 0 n30 ns770 0 0.000378945163631
Gc15_771 0 n30 ns771 0 -8.2959094825e-05
Gc15_772 0 n30 ns772 0 0.00014182292897
Gc15_773 0 n30 ns773 0 0.000414089899062
Gc15_774 0 n30 ns774 0 -0.000403003789454
Gc15_775 0 n30 ns775 0 0.000110584472436
Gc15_776 0 n30 ns776 0 0.000571295458703
Gc15_777 0 n30 ns777 0 0.000485622215353
Gc15_778 0 n30 ns778 0 -0.000263413399232
Gc15_779 0 n30 ns779 0 7.41030351297e-05
Gc15_780 0 n30 ns780 0 -7.56782123148e-05
Gc15_781 0 n30 ns781 0 -0.000291495338236
Gc15_782 0 n30 ns782 0 0.000276701196447
Gc15_783 0 n30 ns783 0 -0.00351697580907
Gc15_784 0 n30 ns784 0 -0.00494590962016
Gc15_785 0 n30 ns785 0 -0.0033733564251
Gc15_786 0 n30 ns786 0 -0.00467466164791
Gc15_787 0 n30 ns787 0 -0.000968030896403
Gc15_788 0 n30 ns788 0 0.00161123640765
Gc15_789 0 n30 ns789 0 -5.31072223828e-05
Gc15_790 0 n30 ns790 0 -0.0011142322362
Gc15_791 0 n30 ns791 0 -0.000367629991684
Gc15_792 0 n30 ns792 0 -0.00271466049142
Gc15_793 0 n30 ns793 0 0.000392523798612
Gc15_794 0 n30 ns794 0 -0.00204368965613
Gc15_795 0 n30 ns795 0 -0.000839107642275
Gc15_796 0 n30 ns796 0 -2.12323013809e-05
Gc15_797 0 n30 ns797 0 0.000107464634779
Gc15_798 0 n30 ns798 0 -1.47767925521e-05
Gc15_799 0 n30 ns799 0 -0.000881768598235
Gc15_800 0 n30 ns800 0 0.000120168905221
Gc15_801 0 n30 ns801 0 -0.00248401585354
Gc15_802 0 n30 ns802 0 0.00211460083636
Gc15_803 0 n30 ns803 0 -0.000483536519115
Gc15_804 0 n30 ns804 0 0.000889133055338
Gc15_805 0 n30 ns805 0 0.00041449265251
Gc15_806 0 n30 ns806 0 -0.000474964722193
Gc15_807 0 n30 ns807 0 -0.000260576513008
Gc15_808 0 n30 ns808 0 0.000325410074721
Gc15_809 0 n30 ns809 0 -0.000175830478705
Gc15_810 0 n30 ns810 0 9.42801918951e-05
Gc15_811 0 n30 ns811 0 0.0010588689104
Gc15_812 0 n30 ns812 0 -0.000274130623976
Gc15_813 0 n30 ns813 0 0.000162826774938
Gc15_814 0 n30 ns814 0 -0.000670979744848
Gc15_815 0 n30 ns815 0 0.000846778706979
Gc15_816 0 n30 ns816 0 -0.000564349074472
Gc15_817 0 n30 ns817 0 0.000468057485307
Gc15_818 0 n30 ns818 0 -0.000896343683911
Gc15_819 0 n30 ns819 0 -0.00155418356214
Gc15_820 0 n30 ns820 0 0.000679588451867
Gc15_821 0 n30 ns821 0 -0.00371038002906
Gc15_822 0 n30 ns822 0 -0.00271805010396
Gc15_823 0 n30 ns823 0 -0.00315339592271
Gc15_824 0 n30 ns824 0 -0.00326065161628
Gc15_825 0 n30 ns825 0 0.000447481155205
Gc15_826 0 n30 ns826 0 0.000793856484563
Gc15_827 0 n30 ns827 0 0.000577329105348
Gc15_828 0 n30 ns828 0 -0.00139549079493
Gc15_829 0 n30 ns829 0 -0.000184258948026
Gc15_830 0 n30 ns830 0 -0.00289224958045
Gc15_831 0 n30 ns831 0 0.00165623374502
Gc15_832 0 n30 ns832 0 -0.00344068281335
Gc15_833 0 n30 ns833 0 -0.00215596423516
Gc15_834 0 n30 ns834 0 -2.42406939609e-05
Gc15_835 0 n30 ns835 0 0.000138436728232
Gc15_836 0 n30 ns836 0 -2.22048194442e-05
Gc15_837 0 n30 ns837 0 0.00125367477593
Gc15_838 0 n30 ns838 0 -0.00277671641338
Gc15_839 0 n30 ns839 0 0.00233559242894
Gc15_840 0 n30 ns840 0 -0.00461562162827
Gc15_841 0 n30 ns841 0 -0.00238386560686
Gc15_842 0 n30 ns842 0 -0.0013609940617
Gc15_843 0 n30 ns843 0 0.000846349229634
Gc15_844 0 n30 ns844 0 0.000566088338437
Gc15_845 0 n30 ns845 0 -0.00019968399347
Gc15_846 0 n30 ns846 0 -0.000196071369597
Gc15_847 0 n30 ns847 0 -0.000297641728211
Gc15_848 0 n30 ns848 0 -7.9674820095e-05
Gc15_849 0 n30 ns849 0 -0.00032268083843
Gc15_850 0 n30 ns850 0 0.000136402815643
Gc15_851 0 n30 ns851 0 0.00129373113504
Gc15_852 0 n30 ns852 0 -3.28403543122e-05
Gc15_853 0 n30 ns853 0 0.00127626710872
Gc15_854 0 n30 ns854 0 0.000142856162214
Gc15_855 0 n30 ns855 0 0.000840886579291
Gc15_856 0 n30 ns856 0 -4.07127023883e-05
Gc15_857 0 n30 ns857 0 -0.000346431425442
Gc15_858 0 n30 ns858 0 -0.00203691473562
Gc15_859 0 n30 ns859 0 -0.0030934462792
Gc15_860 0 n30 ns860 0 -0.00575041171266
Gc15_861 0 n30 ns861 0 -0.00220458969101
Gc15_862 0 n30 ns862 0 -0.00582981122931
Gc15_863 0 n30 ns863 0 0.00392706057893
Gc15_864 0 n30 ns864 0 0.00360753416448
Gc15_865 0 n30 ns865 0 0.001086793963
Gc15_866 0 n30 ns866 0 -0.0011220477291
Gc15_867 0 n30 ns867 0 -0.00261168057149
Gc15_868 0 n30 ns868 0 -0.00316253090045
Gc15_869 0 n30 ns869 0 0.00234033552386
Gc15_870 0 n30 ns870 0 0.00171101901111
Gc15_871 0 n30 ns871 0 -0.00372474265153
Gc15_872 0 n30 ns872 0 1.25107608279e-05
Gc15_873 0 n30 ns873 0 0.000247439723312
Gc15_874 0 n30 ns874 0 -0.000119433342407
Gc15_875 0 n30 ns875 0 0.00226606959664
Gc15_876 0 n30 ns876 0 -0.00344224062872
Gc15_877 0 n30 ns877 0 0.00475129731743
Gc15_878 0 n30 ns878 0 -0.00707969380858
Gc15_879 0 n30 ns879 0 -0.00338405362446
Gc15_880 0 n30 ns880 0 -0.00251244819538
Gc15_881 0 n30 ns881 0 0.00108182729261
Gc15_882 0 n30 ns882 0 0.000740507837215
Gc15_883 0 n30 ns883 0 -0.000652047624744
Gc15_884 0 n30 ns884 0 -0.00012539039646
Gc15_885 0 n30 ns885 0 -0.000189835134326
Gc15_886 0 n30 ns886 0 -0.000134914960593
Gc15_887 0 n30 ns887 0 -0.000518773998696
Gc15_888 0 n30 ns888 0 -0.00076652913487
Gc15_889 0 n30 ns889 0 0.00068318775371
Gc15_890 0 n30 ns890 0 0.000552084562054
Gc15_891 0 n30 ns891 0 0.000952658106579
Gc15_892 0 n30 ns892 0 0.000965328652277
Gc15_893 0 n30 ns893 0 0.00036271213062
Gc15_894 0 n30 ns894 0 0.00119477176138
Gc15_895 0 n30 ns895 0 0.000966270302692
Gc15_896 0 n30 ns896 0 -0.00257438074925
Gc15_897 0 n30 ns897 0 0.00199742006533
Gc15_898 0 n30 ns898 0 -0.0070470103768
Gc15_899 0 n30 ns899 0 0.00220202326382
Gc15_900 0 n30 ns900 0 -0.00677902012449
Gc15_901 0 n30 ns901 0 0.0047971035909
Gc15_902 0 n30 ns902 0 0.00666425661536
Gc15_903 0 n30 ns903 0 0.00113341551535
Gc15_904 0 n30 ns904 0 -0.00105004112407
Gc15_905 0 n30 ns905 0 -0.00425049384309
Gc15_906 0 n30 ns906 0 -0.0050285525325
Gc15_907 0 n30 ns907 0 0.0017544432801
Gc15_908 0 n30 ns908 0 0.00605170482655
Gc15_909 0 n30 ns909 0 -0.00418065973187
Gc15_910 0 n30 ns910 0 -8.57391163991e-06
Gc15_911 0 n30 ns911 0 0.00037387788287
Gc15_912 0 n30 ns912 0 -0.000220815007473
Gc15_913 0 n30 ns913 0 -0.000973089785199
Gc15_914 0 n30 ns914 0 0.000219256092589
Gc15_915 0 n30 ns915 0 -0.00297854421578
Gc15_916 0 n30 ns916 0 0.00112422106519
Gc15_917 0 n30 ns917 0 -0.000118231817542
Gc15_918 0 n30 ns918 0 0.000961407892035
Gc15_919 0 n30 ns919 0 0.000237409817265
Gc15_920 0 n30 ns920 0 -0.000407110266057
Gc15_921 0 n30 ns921 0 -0.000729897161512
Gc15_922 0 n30 ns922 0 -1.67062599364e-05
Gc15_923 0 n30 ns923 0 -0.000104117977328
Gc15_924 0 n30 ns924 0 -2.50863845311e-05
Gc15_925 0 n30 ns925 0 0.00103856267039
Gc15_926 0 n30 ns926 0 0.000346170370765
Gc15_927 0 n30 ns927 0 -0.000317235822208
Gc15_928 0 n30 ns928 0 -0.0011493536577
Gc15_929 0 n30 ns929 0 0.000451372374416
Gc15_930 0 n30 ns930 0 2.58296594276e-05
Gc15_931 0 n30 ns931 0 0.000289330294336
Gc15_932 0 n30 ns932 0 -0.00053728911679
Gc15_933 0 n30 ns933 0 -0.00252167450813
Gc15_934 0 n30 ns934 0 0.000152359587775
Gc15_935 0 n30 ns935 0 -0.00161298299586
Gc15_936 0 n30 ns936 0 0.00111404158453
Gc15_937 0 n30 ns937 0 -0.000780206580991
Gc15_938 0 n30 ns938 0 7.59832644496e-05
Gc15_939 0 n30 ns939 0 0.00195768167594
Gc15_940 0 n30 ns940 0 -0.0019805553553
Gc15_941 0 n30 ns941 0 0.0012101116743
Gc15_942 0 n30 ns942 0 -0.000682663962375
Gc15_943 0 n30 ns943 0 0.000490627013046
Gc15_944 0 n30 ns944 0 3.19864650051e-05
Gc15_945 0 n30 ns945 0 0.00272046791372
Gc15_946 0 n30 ns946 0 -0.00108627313355
Gc15_947 0 n30 ns947 0 -0.00227676412071
Gc15_948 0 n30 ns948 0 -1.04864475539e-05
Gc15_949 0 n30 ns949 0 0.00022085910631
Gc15_950 0 n30 ns950 0 -7.40383309975e-05
Gc15_951 0 n30 ns951 0 -0.000306960806786
Gc15_952 0 n30 ns952 0 0.00104739693774
Gc15_953 0 n30 ns953 0 -0.000516479656647
Gc15_954 0 n30 ns954 0 0.00130846446631
Gc15_955 0 n30 ns955 0 -0.000100073036978
Gc15_956 0 n30 ns956 0 0.000500417152013
Gc15_957 0 n30 ns957 0 9.40780514681e-05
Gc15_958 0 n30 ns958 0 -0.000314002811307
Gc15_959 0 n30 ns959 0 -6.93762639903e-06
Gc15_960 0 n30 ns960 0 -1.19671617623e-05
Gc15_961 0 n30 ns961 0 0.000103461856981
Gc15_962 0 n30 ns962 0 3.62850532743e-05
Gc15_963 0 n30 ns963 0 0.000220984908334
Gc15_964 0 n30 ns964 0 -0.000463901002503
Gc15_965 0 n30 ns965 0 5.82597006422e-05
Gc15_966 0 n30 ns966 0 -0.00068669586868
Gc15_967 0 n30 ns967 0 -0.000284908934476
Gc15_968 0 n30 ns968 0 -0.000367186353886
Gc15_969 0 n30 ns969 0 -0.000253403186027
Gc15_970 0 n30 ns970 0 -0.000342316786297
Gc15_971 0 n30 ns971 0 -0.000456756010157
Gc15_972 0 n30 ns972 0 0.000163208601102
Gc15_973 0 n30 ns973 0 -0.00363670944523
Gc15_974 0 n30 ns974 0 0.0019209012223
Gc15_975 0 n30 ns975 0 -0.00316466019312
Gc15_976 0 n30 ns976 0 0.00170021793011
Gc15_977 0 n30 ns977 0 0.00102931920118
Gc15_978 0 n30 ns978 0 0.00139820989409
Gc15_979 0 n30 ns979 0 -0.000336017153897
Gc15_980 0 n30 ns980 0 -0.000270119463684
Gc15_981 0 n30 ns981 0 -0.00134469463296
Gc15_982 0 n30 ns982 0 -0.00116818677132
Gc15_983 0 n30 ns983 0 -0.000268880867351
Gc15_984 0 n30 ns984 0 -0.00119200595081
Gc15_985 0 n30 ns985 0 -0.000312941416219
Gc15_986 0 n30 ns986 0 -7.20515601392e-06
Gc15_987 0 n30 ns987 0 1.41751550046e-05
Gc15_988 0 n30 ns988 0 1.763810583e-05
Gc15_989 0 n30 ns989 0 0.000344944167486
Gc15_990 0 n30 ns990 0 -0.000178820086226
Gc15_991 0 n30 ns991 0 0.00127276600071
Gc15_992 0 n30 ns992 0 -0.000403791257458
Gc15_993 0 n30 ns993 0 0.000236368810594
Gc15_994 0 n30 ns994 0 -2.8495495198e-05
Gc15_995 0 n30 ns995 0 -7.92403926626e-05
Gc15_996 0 n30 ns996 0 5.39997895323e-05
Gc15_997 0 n30 ns997 0 0.000303669845374
Gc15_998 0 n30 ns998 0 -0.000388665237689
Gc15_999 0 n30 ns999 0 -7.29742741144e-05
Gc15_1000 0 n30 ns1000 0 0.000108827190662
Gc15_1001 0 n30 ns1001 0 -0.00018718455999
Gc15_1002 0 n30 ns1002 0 0.000396053850095
Gc15_1003 0 n30 ns1003 0 0.000410315100192
Gc15_1004 0 n30 ns1004 0 -0.000207016285724
Gc15_1005 0 n30 ns1005 0 -7.87904013324e-05
Gc15_1006 0 n30 ns1006 0 -0.000562077906747
Gc15_1007 0 n30 ns1007 0 -0.000214336392328
Gc15_1008 0 n30 ns1008 0 -0.000516240141539
Gc15_1009 0 n30 ns1009 0 -3.94494166854e-05
Gc15_1010 0 n30 ns1010 0 -0.000358577022697
Gc15_1011 0 n30 ns1011 0 -0.0047246039096
Gc15_1012 0 n30 ns1012 0 -0.00139361743859
Gc15_1013 0 n30 ns1013 0 -0.0042845558639
Gc15_1014 0 n30 ns1014 0 -0.00117194253627
Gc15_1015 0 n30 ns1015 0 0.000619392540218
Gc15_1016 0 n30 ns1016 0 0.00170395332094
Gc15_1017 0 n30 ns1017 0 -0.000386942108252
Gc15_1018 0 n30 ns1018 0 -0.000492248116502
Gc15_1019 0 n30 ns1019 0 -0.00143217922226
Gc15_1020 0 n30 ns1020 0 -0.00162889659432
Gc15_1021 0 n30 ns1021 0 -0.000240540934866
Gc15_1022 0 n30 ns1022 0 -0.00133195621289
Gc15_1023 0 n30 ns1023 0 -0.000379980834739
Gc15_1024 0 n30 ns1024 0 -2.618969975e-06
Gc15_1025 0 n30 ns1025 0 2.78845146338e-05
Gc15_1026 0 n30 ns1026 0 2.55608998883e-05
Gc15_1027 0 n30 ns1027 0 -6.5344406707e-05
Gc15_1028 0 n30 ns1028 0 -0.000322616256848
Gc15_1029 0 n30 ns1029 0 -0.000172177493284
Gc15_1030 0 n30 ns1030 0 0.000235802802323
Gc15_1031 0 n30 ns1031 0 -0.000106589878859
Gc15_1032 0 n30 ns1032 0 1.95992024667e-05
Gc15_1033 0 n30 ns1033 0 -8.18562186771e-05
Gc15_1034 0 n30 ns1034 0 -6.77286268907e-06
Gc15_1035 0 n30 ns1035 0 0.000173609912307
Gc15_1036 0 n30 ns1036 0 0.000228353762182
Gc15_1037 0 n30 ns1037 0 -6.78190704207e-05
Gc15_1038 0 n30 ns1038 0 0.000124429033591
Gc15_1039 0 n30 ns1039 0 5.97185331195e-05
Gc15_1040 0 n30 ns1040 0 -0.000200135042472
Gc15_1041 0 n30 ns1041 0 0.000350802467708
Gc15_1042 0 n30 ns1042 0 0.000581604947638
Gc15_1043 0 n30 ns1043 0 0.000382497473428
Gc15_1044 0 n30 ns1044 0 -0.000299610847418
Gc15_1045 0 n30 ns1045 0 8.94743575407e-05
Gc15_1046 0 n30 ns1046 0 -6.24789583459e-05
Gc15_1047 0 n30 ns1047 0 -9.81239726869e-05
Gc15_1048 0 n30 ns1048 0 -2.76823327763e-05
Gc15_1049 0 n30 ns1049 0 -0.00416547486253
Gc15_1050 0 n30 ns1050 0 -0.00460663052365
Gc15_1051 0 n30 ns1051 0 -0.00393332771613
Gc15_1052 0 n30 ns1052 0 -0.00419927034669
Gc15_1053 0 n30 ns1053 0 -0.00065131258935
Gc15_1054 0 n30 ns1054 0 0.00181813179159
Gc15_1055 0 n30 ns1055 0 -0.000208202071164
Gc15_1056 0 n30 ns1056 0 -0.000925619733032
Gc15_1057 0 n30 ns1057 0 -0.000717952636773
Gc15_1058 0 n30 ns1058 0 -0.00243018654389
Gc15_1059 0 n30 ns1059 0 0.000143720728715
Gc15_1060 0 n30 ns1060 0 -0.00165986790788
Gc15_1061 0 n30 ns1061 0 -0.000611502219378
Gc15_1062 0 n30 ns1062 0 -1.93051874815e-05
Gc15_1063 0 n30 ns1063 0 7.6549218814e-05
Gc15_1064 0 n30 ns1064 0 1.57691344257e-06
Gc15_1065 0 n30 ns1065 0 -0.000584695901961
Gc15_1066 0 n30 ns1066 0 0.000312766486151
Gc15_1067 0 n30 ns1067 0 -0.00135001594643
Gc15_1068 0 n30 ns1068 0 0.00256701309924
Gc15_1069 0 n30 ns1069 0 -0.00019844085073
Gc15_1070 0 n30 ns1070 0 0.000542628996423
Gc15_1071 0 n30 ns1071 0 0.00020972600883
Gc15_1072 0 n30 ns1072 0 -0.000409334098557
Gc15_1073 0 n30 ns1073 0 -0.00015077966382
Gc15_1074 0 n30 ns1074 0 0.000436198100059
Gc15_1075 0 n30 ns1075 0 -0.000114823662062
Gc15_1076 0 n30 ns1076 0 0.000110479339933
Gc15_1077 0 n30 ns1077 0 0.000913806927816
Gc15_1078 0 n30 ns1078 0 -0.000606322152739
Gc15_1079 0 n30 ns1079 0 -5.6309600903e-05
Gc15_1080 0 n30 ns1080 0 -0.000325046170634
Gc15_1081 0 n30 ns1081 0 0.000622224382225
Gc15_1082 0 n30 ns1082 0 -0.00053551509107
Gc15_1083 0 n30 ns1083 0 0.000200584551366
Gc15_1084 0 n30 ns1084 0 -0.000715560705311
Gc15_1085 0 n30 ns1085 0 -0.00100611366529
Gc15_1086 0 n30 ns1086 0 0.00098135301752
Gc15_1087 0 n30 ns1087 0 -0.00291189078054
Gc15_1088 0 n30 ns1088 0 -0.00274063567636
Gc15_1089 0 n30 ns1089 0 -0.00265060096841
Gc15_1090 0 n30 ns1090 0 -0.00313325878886
Gc15_1091 0 n30 ns1091 0 -0.000352532554602
Gc15_1092 0 n30 ns1092 0 0.00104661421031
Gc15_1093 0 n30 ns1093 0 0.000314993545478
Gc15_1094 0 n30 ns1094 0 -0.00136710519717
Gc15_1095 0 n30 ns1095 0 -0.000125203825823
Gc15_1096 0 n30 ns1096 0 -0.00308361257556
Gc15_1097 0 n30 ns1097 0 0.0010281832943
Gc15_1098 0 n30 ns1098 0 -0.00341829770219
Gc15_1099 0 n30 ns1099 0 -0.00161378245503
Gc15_1100 0 n30 ns1100 0 -2.92551494818e-05
Gc15_1101 0 n30 ns1101 0 0.000112283744754
Gc15_1102 0 n30 ns1102 0 -6.43122837898e-06
Gc15_1103 0 n30 ns1103 0 -0.000792388537759
Gc15_1104 0 n30 ns1104 0 -0.00100255032533
Gc15_1105 0 n30 ns1105 0 -0.00330166480938
Gc15_1106 0 n30 ns1106 0 -0.00169716997068
Gc15_1107 0 n30 ns1107 0 -0.00193633987708
Gc15_1108 0 n30 ns1108 0 0.00101962845215
Gc15_1109 0 n30 ns1109 0 0.000882053552446
Gc15_1110 0 n30 ns1110 0 -0.000362106276236
Gc15_1111 0 n30 ns1111 0 -0.000167315558078
Gc15_1112 0 n30 ns1112 0 0.000143861319926
Gc15_1113 0 n30 ns1113 0 -0.000265788931655
Gc15_1114 0 n30 ns1114 0 -1.88549823048e-06
Gc15_1115 0 n30 ns1115 0 0.000396068129086
Gc15_1116 0 n30 ns1116 0 0.000345627924424
Gc15_1117 0 n30 ns1117 0 0.0010960875034
Gc15_1118 0 n30 ns1118 0 -0.00061928150865
Gc15_1119 0 n30 ns1119 0 0.00134023653964
Gc15_1120 0 n30 ns1120 0 -0.000316526497566
Gc15_1121 0 n30 ns1121 0 0.0011867362786
Gc15_1122 0 n30 ns1122 0 -0.000651188411183
Gc15_1123 0 n30 ns1123 0 -0.00173458514536
Gc15_1124 0 n30 ns1124 0 -0.000900850557963
Gc15_1125 0 n30 ns1125 0 -0.00471366296621
Gc15_1126 0 n30 ns1126 0 -0.00443687865506
Gc15_1127 0 n30 ns1127 0 -0.00366373007915
Gc15_1128 0 n30 ns1128 0 -0.00470789771332
Gc15_1129 0 n30 ns1129 0 0.0030509427137
Gc15_1130 0 n30 ns1130 0 0.00180281311647
Gc15_1131 0 n30 ns1131 0 0.000949651532001
Gc15_1132 0 n30 ns1132 0 -0.00121984491384
Gc15_1133 0 n30 ns1133 0 -0.0017206844695
Gc15_1134 0 n30 ns1134 0 -0.00292271730582
Gc15_1135 0 n30 ns1135 0 0.00254680933686
Gc15_1136 0 n30 ns1136 0 -0.000548798907376
Gc15_1137 0 n30 ns1137 0 -0.00319496950303
Gc15_1138 0 n30 ns1138 0 -3.8296821797e-05
Gc15_1139 0 n30 ns1139 0 0.000337044179179
Gc15_1140 0 n30 ns1140 0 -0.000161935785214
Gc15_1141 0 n30 ns1141 0 -0.00045865900593
Gc15_1142 0 n30 ns1142 0 -0.000233520335345
Gc15_1143 0 n30 ns1143 0 0.000321232310831
Gc15_1144 0 n30 ns1144 0 0.00248983885419
Gc15_1145 0 n30 ns1145 0 0.00126629344949
Gc15_1146 0 n30 ns1146 0 -0.000984171818566
Gc15_1147 0 n30 ns1147 0 -0.000395311673916
Gc15_1148 0 n30 ns1148 0 8.18825708969e-05
Gc15_1149 0 n30 ns1149 0 0.000144877742311
Gc15_1150 0 n30 ns1150 0 0.000566777915569
Gc15_1151 0 n30 ns1151 0 -0.000127709109538
Gc15_1152 0 n30 ns1152 0 -0.000109329412569
Gc15_1153 0 n30 ns1153 0 0.00172330124921
Gc15_1154 0 n30 ns1154 0 -0.00111613479254
Gc15_1155 0 n30 ns1155 0 -0.000676129643318
Gc15_1156 0 n30 ns1156 0 0.00183540173699
Gc15_1157 0 n30 ns1157 0 -9.47129400504e-05
Gc15_1158 0 n30 ns1158 0 0.000473177197594
Gc15_1159 0 n30 ns1159 0 -0.00164971329404
Gc15_1160 0 n30 ns1160 0 -0.000795771531021
Gc15_1161 0 n30 ns1161 0 0.00325717061049
Gc15_1162 0 n30 ns1162 0 0.00409876830256
Gc15_1163 0 n30 ns1163 0 -0.00681825172886
Gc15_1164 0 n30 ns1164 0 -0.000231760228098
Gc15_1165 0 n30 ns1165 0 -0.00484642760103
Gc15_1166 0 n30 ns1166 0 -0.0015306980951
Gc15_1167 0 n30 ns1167 0 -0.0115371891305
Gc15_1168 0 n30 ns1168 0 -0.00118016448874
Gc15_1169 0 n30 ns1169 0 0.00170375342087
Gc15_1170 0 n30 ns1170 0 7.46155426711e-05
Gc15_1171 0 n30 ns1171 0 -0.00268353262197
Gc15_1172 0 n30 ns1172 0 0.00889749414533
Gc15_1173 0 n30 ns1173 0 -0.0140179623713
Gc15_1174 0 n30 ns1174 0 -0.00371210290199
Gc15_1175 0 n30 ns1175 0 -0.00619944207066
Gc15_1176 0 n30 ns1176 0 -5.93631295034e-05
Gc15_1177 0 n30 ns1177 0 -0.000410786529497
Gc15_1178 0 n30 ns1178 0 0.00060200086462
Gc15_1179 0 n30 ns1179 0 -0.00109939542317
Gc15_1180 0 n30 ns1180 0 -0.000468007017218
Gc15_1181 0 n30 ns1181 0 -0.00428135421049
Gc15_1182 0 n30 ns1182 0 -0.00163373764318
Gc15_1183 0 n30 ns1183 0 -0.00204046674471
Gc15_1184 0 n30 ns1184 0 0.000993460766701
Gc15_1185 0 n30 ns1185 0 0.000961347228891
Gc15_1186 0 n30 ns1186 0 -0.000486012736129
Gc15_1187 0 n30 ns1187 0 -0.000811438457129
Gc15_1188 0 n30 ns1188 0 0.000219490934402
Gc15_1189 0 n30 ns1189 0 -0.000113364071926
Gc15_1190 0 n30 ns1190 0 -5.69724943551e-05
Gc15_1191 0 n30 ns1191 0 0.000960756057217
Gc15_1192 0 n30 ns1192 0 4.11199753761e-07
Gc15_1193 0 n30 ns1193 0 0.000258976186036
Gc15_1194 0 n30 ns1194 0 -0.00090608163298
Gc15_1195 0 n30 ns1195 0 0.000886416444232
Gc15_1196 0 n30 ns1196 0 0.00027729128724
Gc15_1197 0 n30 ns1197 0 0.000774192510677
Gc15_1198 0 n30 ns1198 0 -7.0977139517e-05
Gc15_1199 0 n30 ns1199 0 -0.00234065967889
Gc15_1200 0 n30 ns1200 0 -0.000463894623105
Gc15_1201 0 n30 ns1201 0 -0.00164539028262
Gc15_1202 0 n30 ns1202 0 -0.000705013677072
Gc15_1203 0 n30 ns1203 0 -0.000730793863163
Gc15_1204 0 n30 ns1204 0 -0.00152798092071
Gc15_1205 0 n30 ns1205 0 0.00300941107585
Gc15_1206 0 n30 ns1206 0 0.000154065077597
Gc15_1207 0 n30 ns1207 0 0.00132094196488
Gc15_1208 0 n30 ns1208 0 -0.000893809496533
Gc15_1209 0 n30 ns1209 0 -0.000740700322733
Gc15_1210 0 n30 ns1210 0 -0.00159040714804
Gc15_1211 0 n30 ns1211 0 0.00293749637727
Gc15_1212 0 n30 ns1212 0 0.000240536439786
Gc15_1213 0 n30 ns1213 0 -0.00313626726238
Gc15_1214 0 n30 ns1214 0 -2.91905465057e-05
Gc15_1215 0 n30 ns1215 0 0.000392161017254
Gc15_1216 0 n30 ns1216 0 -0.000226722264696
Gd15_1 0 n30 ni1 0 -4.25221987142e-05
Gd15_2 0 n30 ni2 0 -2.53598646026e-05
Gd15_3 0 n30 ni3 0 0.000251818469794
Gd15_4 0 n30 ni4 0 0.000598927334656
Gd15_5 0 n30 ni5 0 0.000292597097272
Gd15_6 0 n30 ni6 0 -0.00159917269723
Gd15_7 0 n30 ni7 0 -0.00302038287113
Gd15_8 0 n30 ni8 0 -0.000858599926064
Gd15_9 0 n30 ni9 0 -0.00163078363491
Gd15_10 0 n30 ni10 0 9.79058438196e-05
Gd15_11 0 n30 ni11 0 0.000719154107237
Gd15_12 0 n30 ni12 0 0.000420419281167
Gd15_13 0 n30 ni13 0 -0.000540585950611
Gd15_14 0 n30 ni14 0 -0.00159537245261
Gd15_15 0 n30 ni15 0 0.000681350756787
Gd15_16 0 n30 ni16 0 -0.00173774945357
Gd15_17 0 n30 ni17 0 -0.000444779136136
Gd15_18 0 n30 ni18 0 1.48962188141e-05
Gd15_19 0 n30 ni19 0 0.000846175915793
Gd15_20 0 n30 ni20 0 -0.000698411757589
Gd15_21 0 n30 ni21 0 5.14066249335e-05
Gd15_22 0 n30 ni22 0 0.000710240181863
Gd15_23 0 n30 ni23 0 -0.00236826111903
Gd15_24 0 n30 ni24 0 -0.00327350788396
Gd15_25 0 n30 ni25 0 0.00069725756659
Gd15_26 0 n30 ni26 0 0.000832588384437
Gd15_27 0 n30 ni27 0 -0.000459993266253
Gd15_28 0 n30 ni28 0 -0.000103851260255
Gd15_29 0 n30 ni29 0 0.000798067505004
Gd15_30 0 n30 ni30 0 -0.000466691297286
Gd15_31 0 n30 ni31 0 0.000328410932078
Gd15_32 0 n30 ni32 0 8.38788934772e-05
Gc16_1 0 n32 ns1 0 0.000181342617627
Gc16_2 0 n32 ns2 0 6.2062206026e-05
Gc16_3 0 n32 ns3 0 0.000607722106112
Gc16_4 0 n32 ns4 0 -0.000181089151609
Gc16_5 0 n32 ns5 0 6.97360704678e-05
Gc16_6 0 n32 ns6 0 1.28502906194e-05
Gc16_7 0 n32 ns7 0 -5.3685512621e-06
Gc16_8 0 n32 ns8 0 -5.20584241974e-05
Gc16_9 0 n32 ns9 0 7.15001990995e-05
Gc16_10 0 n32 ns10 0 -0.00013384243411
Gc16_11 0 n32 ns11 0 -1.99368458869e-05
Gc16_12 0 n32 ns12 0 1.76337845282e-05
Gc16_13 0 n32 ns13 0 -0.000123196411747
Gc16_14 0 n32 ns14 0 7.22880847811e-05
Gc16_15 0 n32 ns15 0 -0.000152047530499
Gc16_16 0 n32 ns16 0 4.09947879233e-05
Gc16_17 0 n32 ns17 0 -5.45603540726e-05
Gc16_18 0 n32 ns18 0 7.80102142443e-05
Gc16_19 0 n32 ns19 0 -4.85914839242e-05
Gc16_20 0 n32 ns20 0 5.80007002021e-05
Gc16_21 0 n32 ns21 0 6.65328510782e-05
Gc16_22 0 n32 ns22 0 -4.29566668648e-05
Gc16_23 0 n32 ns23 0 -0.00019651803143
Gc16_24 0 n32 ns24 0 -0.000640346535188
Gc16_25 0 n32 ns25 0 -0.000177674730054
Gc16_26 0 n32 ns26 0 -0.000575868986776
Gc16_27 0 n32 ns27 0 0.000201722334519
Gc16_28 0 n32 ns28 0 0.000443218520783
Gc16_29 0 n32 ns29 0 -7.76759881597e-05
Gc16_30 0 n32 ns30 0 -9.30429718434e-05
Gc16_31 0 n32 ns31 0 -0.00034295702559
Gc16_32 0 n32 ns32 0 -0.000421624398919
Gc16_33 0 n32 ns33 0 -0.000172164468712
Gc16_34 0 n32 ns34 0 -0.000374797580933
Gc16_35 0 n32 ns35 0 -3.1072770082e-05
Gc16_36 0 n32 ns36 0 1.90705954791e-05
Gc16_37 0 n32 ns37 0 -3.82893605085e-05
Gc16_38 0 n32 ns38 0 1.25208662177e-05
Gc16_39 0 n32 ns39 0 6.14675126212e-05
Gc16_40 0 n32 ns40 0 0.000179432127629
Gc16_41 0 n32 ns41 0 0.000361205093338
Gc16_42 0 n32 ns42 0 -0.000153431648271
Gc16_43 0 n32 ns43 0 1.98419930941e-05
Gc16_44 0 n32 ns44 0 3.28962904718e-05
Gc16_45 0 n32 ns45 0 3.07766979533e-05
Gc16_46 0 n32 ns46 0 -4.41043114014e-05
Gc16_47 0 n32 ns47 0 0.000106320910391
Gc16_48 0 n32 ns48 0 -0.00010333631685
Gc16_49 0 n32 ns49 0 -2.51335675138e-05
Gc16_50 0 n32 ns50 0 1.71559310136e-05
Gc16_51 0 n32 ns51 0 -0.000122791888772
Gc16_52 0 n32 ns52 0 4.65796150509e-05
Gc16_53 0 n32 ns53 0 -0.00021404273674
Gc16_54 0 n32 ns54 0 3.96866978347e-05
Gc16_55 0 n32 ns55 0 -0.000114087233084
Gc16_56 0 n32 ns56 0 0.000119491666837
Gc16_57 0 n32 ns57 0 -0.00011553139448
Gc16_58 0 n32 ns58 0 0.00012418269871
Gc16_59 0 n32 ns59 0 5.15848977215e-05
Gc16_60 0 n32 ns60 0 -8.86342794484e-05
Gc16_61 0 n32 ns61 0 -0.000185466622493
Gc16_62 0 n32 ns62 0 -0.000911870672692
Gc16_63 0 n32 ns63 0 -0.000165678614598
Gc16_64 0 n32 ns64 0 -0.000813619644283
Gc16_65 0 n32 ns65 0 0.000184855343799
Gc16_66 0 n32 ns66 0 0.000416803807379
Gc16_67 0 n32 ns67 0 -9.58409892779e-05
Gc16_68 0 n32 ns68 0 -8.44231253933e-05
Gc16_69 0 n32 ns69 0 -0.00036419860256
Gc16_70 0 n32 ns70 0 -0.00033326800973
Gc16_71 0 n32 ns71 0 -0.000158053682438
Gc16_72 0 n32 ns72 0 -0.000222603796288
Gc16_73 0 n32 ns73 0 2.43787190734e-06
Gc16_74 0 n32 ns74 0 1.18683369376e-05
Gc16_75 0 n32 ns75 0 -2.38457318858e-05
Gc16_76 0 n32 ns76 0 -3.43533847986e-06
Gc16_77 0 n32 ns77 0 0.000144666268763
Gc16_78 0 n32 ns78 0 0.0003141905473
Gc16_79 0 n32 ns79 0 0.000669769782793
Gc16_80 0 n32 ns80 0 -0.000164920051667
Gc16_81 0 n32 ns81 0 9.04994070548e-06
Gc16_82 0 n32 ns82 0 4.67115266636e-05
Gc16_83 0 n32 ns83 0 3.24759089378e-05
Gc16_84 0 n32 ns84 0 9.4548371301e-06
Gc16_85 0 n32 ns85 0 0.000268346166092
Gc16_86 0 n32 ns86 0 6.15057107612e-05
Gc16_87 0 n32 ns87 0 -6.31918437998e-05
Gc16_88 0 n32 ns88 0 -3.40242617545e-05
Gc16_89 0 n32 ns89 0 -0.000280328482845
Gc16_90 0 n32 ns90 0 -0.000101824092238
Gc16_91 0 n32 ns91 0 -0.000403801177082
Gc16_92 0 n32 ns92 0 -0.000367376329782
Gc16_93 0 n32 ns93 0 -0.000405379732668
Gc16_94 0 n32 ns94 0 -0.000112228754956
Gc16_95 0 n32 ns95 0 -0.000454604114833
Gc16_96 0 n32 ns96 0 -0.00017803675721
Gc16_97 0 n32 ns97 0 0.000450449968278
Gc16_98 0 n32 ns98 0 -7.54260450682e-05
Gc16_99 0 n32 ns99 0 0.00156266621537
Gc16_100 0 n32 ns100 0 -0.00146809130896
Gc16_101 0 n32 ns101 0 0.00134046511442
Gc16_102 0 n32 ns102 0 -0.00133150962106
Gc16_103 0 n32 ns103 0 0.000277827823087
Gc16_104 0 n32 ns104 0 0.000242749277031
Gc16_105 0 n32 ns105 0 -0.00016232676243
Gc16_106 0 n32 ns106 0 -8.51311272373e-05
Gc16_107 0 n32 ns107 0 -0.000603980928703
Gc16_108 0 n32 ns108 0 -0.000141543797006
Gc16_109 0 n32 ns109 0 -0.000236656990764
Gc16_110 0 n32 ns110 0 0.000127700966242
Gc16_111 0 n32 ns111 0 0.000105937215721
Gc16_112 0 n32 ns112 0 1.23670909156e-05
Gc16_113 0 n32 ns113 0 -1.7683812166e-05
Gc16_114 0 n32 ns114 0 -1.37697564543e-05
Gc16_115 0 n32 ns115 0 0.000107822482163
Gc16_116 0 n32 ns116 0 0.000291244809655
Gc16_117 0 n32 ns117 0 0.000540173551607
Gc16_118 0 n32 ns118 0 0.000630259818542
Gc16_119 0 n32 ns119 0 -4.1931519081e-05
Gc16_120 0 n32 ns120 0 3.36804940009e-06
Gc16_121 0 n32 ns121 0 -2.64686201412e-05
Gc16_122 0 n32 ns122 0 6.41333283515e-05
Gc16_123 0 n32 ns123 0 4.04745392434e-05
Gc16_124 0 n32 ns124 0 0.000492803531599
Gc16_125 0 n32 ns125 0 1.24155281132e-06
Gc16_126 0 n32 ns126 0 -0.000141560649457
Gc16_127 0 n32 ns127 0 -5.76415024072e-05
Gc16_128 0 n32 ns128 0 -0.000452569461638
Gc16_129 0 n32 ns129 0 0.000340106669603
Gc16_130 0 n32 ns130 0 -0.000930957434634
Gc16_131 0 n32 ns131 0 -0.000154494239557
Gc16_132 0 n32 ns132 0 -0.000739620654908
Gc16_133 0 n32 ns133 0 -4.54925680646e-05
Gc16_134 0 n32 ns134 0 -0.000838923410893
Gc16_135 0 n32 ns135 0 0.0006032896275
Gc16_136 0 n32 ns136 0 0.000795089649343
Gc16_137 0 n32 ns137 0 0.00412026382936
Gc16_138 0 n32 ns138 0 0.000975221882925
Gc16_139 0 n32 ns139 0 0.00365863507161
Gc16_140 0 n32 ns140 0 0.000694837618729
Gc16_141 0 n32 ns141 0 0.00064879256101
Gc16_142 0 n32 ns142 0 0.000702169995449
Gc16_143 0 n32 ns143 0 -0.000286194372933
Gc16_144 0 n32 ns144 0 -0.000260382376592
Gc16_145 0 n32 ns145 0 -0.00117768260149
Gc16_146 0 n32 ns146 0 -0.000740193059173
Gc16_147 0 n32 ns147 0 -0.000499381327756
Gc16_148 0 n32 ns148 0 -0.000383547579738
Gc16_149 0 n32 ns149 0 4.7144076154e-05
Gc16_150 0 n32 ns150 0 1.54494437975e-05
Gc16_151 0 n32 ns151 0 -3.20555844879e-05
Gc16_152 0 n32 ns152 0 -1.03896973649e-05
Gc16_153 0 n32 ns153 0 -0.000108362119063
Gc16_154 0 n32 ns154 0 -0.000142189859412
Gc16_155 0 n32 ns155 0 -0.000270474179765
Gc16_156 0 n32 ns156 0 0.000666679433854
Gc16_157 0 n32 ns157 0 4.56541918574e-05
Gc16_158 0 n32 ns158 0 -2.47935818662e-05
Gc16_159 0 n32 ns159 0 -5.84298044683e-05
Gc16_160 0 n32 ns160 0 -8.40197096373e-05
Gc16_161 0 n32 ns161 0 -0.000518070262396
Gc16_162 0 n32 ns162 0 0.000166603917592
Gc16_163 0 n32 ns163 0 0.000122877995533
Gc16_164 0 n32 ns164 0 -0.000133119913382
Gc16_165 0 n32 ns165 0 0.000174291337387
Gc16_166 0 n32 ns166 0 -0.000102145182976
Gc16_167 0 n32 ns167 0 0.00113864498827
Gc16_168 0 n32 ns168 0 8.1214643617e-05
Gc16_169 0 n32 ns169 0 0.000520066043165
Gc16_170 0 n32 ns170 0 -0.000667243674022
Gc16_171 0 n32 ns171 0 0.000476374502352
Gc16_172 0 n32 ns172 0 -0.000477988737637
Gc16_173 0 n32 ns173 0 -0.000529718546018
Gc16_174 0 n32 ns174 0 0.000847868352244
Gc16_175 0 n32 ns175 0 0.0032646771927
Gc16_176 0 n32 ns176 0 0.00434577419632
Gc16_177 0 n32 ns177 0 0.00318276237507
Gc16_178 0 n32 ns178 0 0.00376028514051
Gc16_179 0 n32 ns179 0 -0.000106965006477
Gc16_180 0 n32 ns180 0 0.00119805471003
Gc16_181 0 n32 ns181 0 -0.000275223717259
Gc16_182 0 n32 ns182 0 -0.000578938461643
Gc16_183 0 n32 ns183 0 -0.000998544282719
Gc16_184 0 n32 ns184 0 -0.0014383530659
Gc16_185 0 n32 ns185 0 -0.000592723817753
Gc16_186 0 n32 ns186 0 -9.82867814827e-05
Gc16_187 0 n32 ns187 0 0.000211748621836
Gc16_188 0 n32 ns188 0 2.03374336975e-06
Gc16_189 0 n32 ns189 0 -6.85396390067e-05
Gc16_190 0 n32 ns190 0 -1.33879736614e-05
Gc16_191 0 n32 ns191 0 -0.000156448058829
Gc16_192 0 n32 ns192 0 -0.000602945878749
Gc16_193 0 n32 ns193 0 -0.000553554018198
Gc16_194 0 n32 ns194 0 -0.000306917065435
Gc16_195 0 n32 ns195 0 9.61940223614e-05
Gc16_196 0 n32 ns196 0 -9.99192146259e-05
Gc16_197 0 n32 ns197 0 2.97192449104e-05
Gc16_198 0 n32 ns198 0 0.0001018610697
Gc16_199 0 n32 ns199 0 -0.00037047477572
Gc16_200 0 n32 ns200 0 -0.000567304580645
Gc16_201 0 n32 ns201 0 0.000206394645564
Gc16_202 0 n32 ns202 0 -7.17151624204e-06
Gc16_203 0 n32 ns203 0 7.08805722937e-05
Gc16_204 0 n32 ns204 0 0.000162125059293
Gc16_205 0 n32 ns205 0 -9.63261218231e-05
Gc16_206 0 n32 ns206 0 0.00138254287845
Gc16_207 0 n32 ns207 0 0.000588588117255
Gc16_208 0 n32 ns208 0 4.57831033451e-05
Gc16_209 0 n32 ns209 0 -6.76604985062e-05
Gc16_210 0 n32 ns210 0 0.000167480544582
Gc16_211 0 n32 ns211 0 -0.000893128668669
Gc16_212 0 n32 ns212 0 -0.00116368253879
Gc16_213 0 n32 ns213 0 -0.000210775584103
Gc16_214 0 n32 ns214 0 0.00385550278404
Gc16_215 0 n32 ns215 0 0.000228061744866
Gc16_216 0 n32 ns216 0 0.0039143371685
Gc16_217 0 n32 ns217 0 -0.00245449841018
Gc16_218 0 n32 ns218 0 -0.000164623923485
Gc16_219 0 n32 ns219 0 0.000205809121796
Gc16_220 0 n32 ns220 0 -0.000925481538716
Gc16_221 0 n32 ns221 0 0.000747468641081
Gc16_222 0 n32 ns222 0 -0.00109595055326
Gc16_223 0 n32 ns223 0 -0.000505119001953
Gc16_224 0 n32 ns224 0 0.00201173774322
Gc16_225 0 n32 ns225 0 0.000919236892916
Gc16_226 0 n32 ns226 0 -9.4117732125e-06
Gc16_227 0 n32 ns227 0 -0.00014551077588
Gc16_228 0 n32 ns228 0 9.52630653383e-06
Gc16_229 0 n32 ns229 0 0.000764109661487
Gc16_230 0 n32 ns230 0 -0.00214166395082
Gc16_231 0 n32 ns231 0 0.00192466107038
Gc16_232 0 n32 ns232 0 -0.00158697510416
Gc16_233 0 n32 ns233 0 -0.000386627159271
Gc16_234 0 n32 ns234 0 -5.93244444653e-05
Gc16_235 0 n32 ns235 0 4.36304484088e-05
Gc16_236 0 n32 ns236 0 2.24231379866e-05
Gc16_237 0 n32 ns237 0 0.000555260743646
Gc16_238 0 n32 ns238 0 -0.000349135421998
Gc16_239 0 n32 ns239 0 0.000176332919317
Gc16_240 0 n32 ns240 0 7.48489414339e-05
Gc16_241 0 n32 ns241 0 -0.000128182760835
Gc16_242 0 n32 ns242 0 0.000193038317034
Gc16_243 0 n32 ns243 0 -0.00129859633028
Gc16_244 0 n32 ns244 0 -0.000261118927197
Gc16_245 0 n32 ns245 0 0.000378374985704
Gc16_246 0 n32 ns246 0 -1.40512693632e-05
Gc16_247 0 n32 ns247 0 -0.000238260691742
Gc16_248 0 n32 ns248 0 -0.00063442364704
Gc16_249 0 n32 ns249 0 0.00162061844627
Gc16_250 0 n32 ns250 0 -0.000908029749419
Gc16_251 0 n32 ns251 0 -0.000728057458822
Gc16_252 0 n32 ns252 0 0.00218775211184
Gc16_253 0 n32 ns253 0 -0.000789585796088
Gc16_254 0 n32 ns254 0 0.00288484076647
Gc16_255 0 n32 ns255 0 -0.000924921693076
Gc16_256 0 n32 ns256 0 -0.00260130168919
Gc16_257 0 n32 ns257 0 0.000977755250859
Gc16_258 0 n32 ns258 0 -0.000996124885821
Gc16_259 0 n32 ns259 0 0.00110959769336
Gc16_260 0 n32 ns260 0 -0.00019750603548
Gc16_261 0 n32 ns261 0 -0.00195969460838
Gc16_262 0 n32 ns262 0 0.00267878004821
Gc16_263 0 n32 ns263 0 0.00207492227514
Gc16_264 0 n32 ns264 0 1.28591014034e-05
Gc16_265 0 n32 ns265 0 -0.000278488631063
Gc16_266 0 n32 ns266 0 0.000109683984817
Gc16_267 0 n32 ns267 0 0.00139312067866
Gc16_268 0 n32 ns268 0 -0.00457156847235
Gc16_269 0 n32 ns269 0 0.00163821132746
Gc16_270 0 n32 ns270 0 -0.0035703310913
Gc16_271 0 n32 ns271 0 -0.00135657737407
Gc16_272 0 n32 ns272 0 -0.000731666534095
Gc16_273 0 n32 ns273 0 0.000581179496754
Gc16_274 0 n32 ns274 0 -3.14105259288e-05
Gc16_275 0 n32 ns275 0 0.00038651291521
Gc16_276 0 n32 ns276 0 0.000609326925324
Gc16_277 0 n32 ns277 0 0.000148488770556
Gc16_278 0 n32 ns278 0 0.000113648775942
Gc16_279 0 n32 ns279 0 -0.000249483702999
Gc16_280 0 n32 ns280 0 0.000412662136671
Gc16_281 0 n32 ns281 0 0.000113779463041
Gc16_282 0 n32 ns282 0 -0.00128101953925
Gc16_283 0 n32 ns283 0 0.000466065096774
Gc16_284 0 n32 ns284 0 -1.51372804998e-05
Gc16_285 0 n32 ns285 0 0.000247647030899
Gc16_286 0 n32 ns286 0 -0.000860974032362
Gc16_287 0 n32 ns287 0 0.00160159660328
Gc16_288 0 n32 ns288 0 0.00165559404412
Gc16_289 0 n32 ns289 0 0.0025985114575
Gc16_290 0 n32 ns290 0 0.00325151311463
Gc16_291 0 n32 ns291 0 0.00128102616159
Gc16_292 0 n32 ns292 0 0.00352740289125
Gc16_293 0 n32 ns293 0 0.00346038608755
Gc16_294 0 n32 ns294 0 0.000716494215176
Gc16_295 0 n32 ns295 0 0.00128617534133
Gc16_296 0 n32 ns296 0 -0.000545264825987
Gc16_297 0 n32 ns297 0 -0.00348859159945
Gc16_298 0 n32 ns298 0 -0.000137560238344
Gc16_299 0 n32 ns299 0 -0.000594426885562
Gc16_300 0 n32 ns300 0 -0.00233170276003
Gc16_301 0 n32 ns301 0 0.00383983354448
Gc16_302 0 n32 ns302 0 8.7755897276e-06
Gc16_303 0 n32 ns303 0 -0.00016256552669
Gc16_304 0 n32 ns304 0 4.97980748251e-05
Gc16_305 0 n32 ns305 0 0.00199734119485
Gc16_306 0 n32 ns306 0 -0.00554541488306
Gc16_307 0 n32 ns307 0 0.00165721609187
Gc16_308 0 n32 ns308 0 -0.00411598333313
Gc16_309 0 n32 ns309 0 -0.000822899629966
Gc16_310 0 n32 ns310 0 -0.000934566749564
Gc16_311 0 n32 ns311 0 0.000607845263017
Gc16_312 0 n32 ns312 0 0.000118968055616
Gc16_313 0 n32 ns313 0 -0.000110318279317
Gc16_314 0 n32 ns314 0 0.000431487395362
Gc16_315 0 n32 ns315 0 4.36512296047e-05
Gc16_316 0 n32 ns316 0 7.88315381667e-05
Gc16_317 0 n32 ns317 0 -0.000896953983393
Gc16_318 0 n32 ns318 0 0.00027025925364
Gc16_319 0 n32 ns319 0 0.000469228638709
Gc16_320 0 n32 ns320 0 -3.38601126378e-05
Gc16_321 0 n32 ns321 0 -4.39499333233e-05
Gc16_322 0 n32 ns322 0 0.000171984640337
Gc16_323 0 n32 ns323 0 -0.000449182376152
Gc16_324 0 n32 ns324 0 -0.000638768457556
Gc16_325 0 n32 ns325 0 -0.000529072804264
Gc16_326 0 n32 ns326 0 0.00114090729035
Gc16_327 0 n32 ns327 0 0.00596296133684
Gc16_328 0 n32 ns328 0 0.00370090666824
Gc16_329 0 n32 ns329 0 0.00401962071081
Gc16_330 0 n32 ns330 0 0.0034678598996
Gc16_331 0 n32 ns331 0 0.00338581972496
Gc16_332 0 n32 ns332 0 0.00627101714652
Gc16_333 0 n32 ns333 0 0.00073522381268
Gc16_334 0 n32 ns334 0 -0.000161172341942
Gc16_335 0 n32 ns335 0 -0.00746567098401
Gc16_336 0 n32 ns336 0 -0.00100287004026
Gc16_337 0 n32 ns337 0 0.00385873427636
Gc16_338 0 n32 ns338 0 -0.00795709648973
Gc16_339 0 n32 ns339 0 0.00388652893874
Gc16_340 0 n32 ns340 0 4.70372193461e-06
Gc16_341 0 n32 ns341 0 -0.00013345065919
Gc16_342 0 n32 ns342 0 2.30673431447e-05
Gc16_343 0 n32 ns343 0 9.89781147362e-05
Gc16_344 0 n32 ns344 0 0.000227842875454
Gc16_345 0 n32 ns345 0 0.000473006111669
Gc16_346 0 n32 ns346 0 -0.000453105039913
Gc16_347 0 n32 ns347 0 -5.85251180864e-05
Gc16_348 0 n32 ns348 0 -3.16737525665e-07
Gc16_349 0 n32 ns349 0 8.7663400092e-05
Gc16_350 0 n32 ns350 0 -3.61047235786e-06
Gc16_351 0 n32 ns351 0 0.000204125514514
Gc16_352 0 n32 ns352 0 -4.20750632836e-05
Gc16_353 0 n32 ns353 0 -5.12246652754e-05
Gc16_354 0 n32 ns354 0 -8.76296321513e-07
Gc16_355 0 n32 ns355 0 -0.000214245836351
Gc16_356 0 n32 ns356 0 1.17315776984e-05
Gc16_357 0 n32 ns357 0 -0.000385009646691
Gc16_358 0 n32 ns358 0 -0.000120892314349
Gc16_359 0 n32 ns359 0 -0.000307677741839
Gc16_360 0 n32 ns360 0 4.99096972272e-05
Gc16_361 0 n32 ns361 0 -0.000361022323862
Gc16_362 0 n32 ns362 0 2.75340765035e-05
Gc16_363 0 n32 ns363 0 0.000262074245586
Gc16_364 0 n32 ns364 0 -0.000174060389469
Gc16_365 0 n32 ns365 0 0.000692002665153
Gc16_366 0 n32 ns366 0 -0.00147895451431
Gc16_367 0 n32 ns367 0 0.00058509548494
Gc16_368 0 n32 ns368 0 -0.0013156773608
Gc16_369 0 n32 ns369 0 0.000170285330632
Gc16_370 0 n32 ns370 0 0.000272164923633
Gc16_371 0 n32 ns371 0 -0.000124998479095
Gc16_372 0 n32 ns372 0 -7.78555988761e-05
Gc16_373 0 n32 ns373 0 -0.000447067368662
Gc16_374 0 n32 ns374 0 -0.000173929830594
Gc16_375 0 n32 ns375 0 -0.000178842931811
Gc16_376 0 n32 ns376 0 4.59819825272e-05
Gc16_377 0 n32 ns377 0 7.16068379361e-05
Gc16_378 0 n32 ns378 0 1.02511997824e-05
Gc16_379 0 n32 ns379 0 1.89843398813e-05
Gc16_380 0 n32 ns380 0 -3.36860999851e-05
Gc16_381 0 n32 ns381 0 0.000152040330031
Gc16_382 0 n32 ns382 0 0.000340585617685
Gc16_383 0 n32 ns383 0 0.000700238422268
Gc16_384 0 n32 ns384 0 0.000358025777314
Gc16_385 0 n32 ns385 0 -3.08188109474e-05
Gc16_386 0 n32 ns386 0 9.71875199132e-05
Gc16_387 0 n32 ns387 0 4.52620981948e-06
Gc16_388 0 n32 ns388 0 7.26791964898e-06
Gc16_389 0 n32 ns389 0 0.000219305166073
Gc16_390 0 n32 ns390 0 0.000309383776011
Gc16_391 0 n32 ns391 0 -4.14452428384e-05
Gc16_392 0 n32 ns392 0 -9.06834454851e-05
Gc16_393 0 n32 ns393 0 -0.000182990364335
Gc16_394 0 n32 ns394 0 -0.00034359484526
Gc16_395 0 n32 ns395 0 -5.12275922189e-05
Gc16_396 0 n32 ns396 0 -0.00080055515301
Gc16_397 0 n32 ns397 0 -0.00031639762462
Gc16_398 0 n32 ns398 0 -0.000501547909513
Gc16_399 0 n32 ns399 0 -0.0002620247271
Gc16_400 0 n32 ns400 0 -0.000624128964483
Gc16_401 0 n32 ns401 0 0.000644324720747
Gc16_402 0 n32 ns402 0 0.000444834584465
Gc16_403 0 n32 ns403 0 0.00315559240363
Gc16_404 0 n32 ns404 0 -0.000186337039807
Gc16_405 0 n32 ns405 0 0.00276152926596
Gc16_406 0 n32 ns406 0 -0.000284609237394
Gc16_407 0 n32 ns407 0 0.000583238144328
Gc16_408 0 n32 ns408 0 0.000498429820637
Gc16_409 0 n32 ns409 0 -0.00023984395307
Gc16_410 0 n32 ns410 0 -0.000176104015089
Gc16_411 0 n32 ns411 0 -0.000988843866744
Gc16_412 0 n32 ns412 0 -0.000489452946165
Gc16_413 0 n32 ns413 0 -0.00040667274206
Gc16_414 0 n32 ns414 0 -0.000244008240297
Gc16_415 0 n32 ns415 0 5.03143037905e-05
Gc16_416 0 n32 ns416 0 1.18386070989e-05
Gc16_417 0 n32 ns417 0 -1.67976970551e-05
Gc16_418 0 n32 ns418 0 -7.29332124309e-06
Gc16_419 0 n32 ns419 0 -2.41532703798e-05
Gc16_420 0 n32 ns420 0 0.000203256236964
Gc16_421 0 n32 ns421 0 0.000123459456749
Gc16_422 0 n32 ns422 0 0.00127299361407
Gc16_423 0 n32 ns423 0 3.81690881737e-05
Gc16_424 0 n32 ns424 0 0.00021174747088
Gc16_425 0 n32 ns425 0 -9.93395660905e-05
Gc16_426 0 n32 ns426 0 -0.000167964556342
Gc16_427 0 n32 ns427 0 -0.000221271981891
Gc16_428 0 n32 ns428 0 0.00040111387646
Gc16_429 0 n32 ns429 0 6.69687975011e-05
Gc16_430 0 n32 ns430 0 -0.000166551651034
Gc16_431 0 n32 ns431 0 3.48772309023e-05
Gc16_432 0 n32 ns432 0 -0.000372080130096
Gc16_433 0 n32 ns433 0 0.000962906776103
Gc16_434 0 n32 ns434 0 -0.000575034240292
Gc16_435 0 n32 ns435 0 0.000282954543112
Gc16_436 0 n32 ns436 0 -0.000845169552925
Gc16_437 0 n32 ns437 0 0.000398053520833
Gc16_438 0 n32 ns438 0 -0.000812909063323
Gc16_439 0 n32 ns439 0 2.98471859115e-05
Gc16_440 0 n32 ns440 0 0.00115268885462
Gc16_441 0 n32 ns441 0 0.00403823857673
Gc16_442 0 n32 ns442 0 0.00352765326288
Gc16_443 0 n32 ns443 0 0.00373991689276
Gc16_444 0 n32 ns444 0 0.0029370395676
Gc16_445 0 n32 ns445 0 0.000518962878375
Gc16_446 0 n32 ns446 0 0.00120073520673
Gc16_447 0 n32 ns447 0 -0.000327612226348
Gc16_448 0 n32 ns448 0 -0.000463171119992
Gc16_449 0 n32 ns449 0 -0.00133119587811
Gc16_450 0 n32 ns450 0 -0.00135500736553
Gc16_451 0 n32 ns451 0 -0.000640712310952
Gc16_452 0 n32 ns452 0 -0.000570770723307
Gc16_453 0 n32 ns453 0 6.27316672967e-05
Gc16_454 0 n32 ns454 0 1.58448412438e-05
Gc16_455 0 n32 ns455 0 -6.76045163238e-05
Gc16_456 0 n32 ns456 0 -3.33584973072e-06
Gc16_457 0 n32 ns457 0 -0.000174303586121
Gc16_458 0 n32 ns458 0 -0.000361392970068
Gc16_459 0 n32 ns459 0 -0.000492302525226
Gc16_460 0 n32 ns460 0 0.000295931650752
Gc16_461 0 n32 ns461 0 0.000142446487265
Gc16_462 0 n32 ns462 0 -4.2937184835e-05
Gc16_463 0 n32 ns463 0 1.04137198187e-05
Gc16_464 0 n32 ns464 0 -2.59040279247e-05
Gc16_465 0 n32 ns465 0 -0.000498615623885
Gc16_466 0 n32 ns466 0 -0.000301121099787
Gc16_467 0 n32 ns467 0 0.000170678039538
Gc16_468 0 n32 ns468 0 -7.60031258214e-05
Gc16_469 0 n32 ns469 0 1.99908079824e-05
Gc16_470 0 n32 ns470 0 7.62515277697e-05
Gc16_471 0 n32 ns471 0 0.000536951345609
Gc16_472 0 n32 ns472 0 0.00105158267985
Gc16_473 0 n32 ns473 0 0.000605415860262
Gc16_474 0 n32 ns474 0 -0.000217883384719
Gc16_475 0 n32 ns475 0 0.000178553671515
Gc16_476 0 n32 ns476 0 -8.34415996911e-06
Gc16_477 0 n32 ns477 0 -0.00102239956358
Gc16_478 0 n32 ns478 0 -0.000346053748149
Gc16_479 0 n32 ns479 0 0.00105719100162
Gc16_480 0 n32 ns480 0 0.00442717529779
Gc16_481 0 n32 ns481 0 0.00135136518078
Gc16_482 0 n32 ns482 0 0.00415926078159
Gc16_483 0 n32 ns483 0 -0.00162974622512
Gc16_484 0 n32 ns484 0 0.000666029592107
Gc16_485 0 n32 ns485 0 -2.64441525794e-05
Gc16_486 0 n32 ns486 0 -0.000821752085289
Gc16_487 0 n32 ns487 0 2.15622357854e-05
Gc16_488 0 n32 ns488 0 -0.00144885644169
Gc16_489 0 n32 ns489 0 -0.000506688623685
Gc16_490 0 n32 ns490 0 0.00102212292272
Gc16_491 0 n32 ns491 0 0.000571927471875
Gc16_492 0 n32 ns492 0 -9.22716780499e-06
Gc16_493 0 n32 ns493 0 -0.000122326307002
Gc16_494 0 n32 ns494 0 3.1622837996e-06
Gc16_495 0 n32 ns495 0 0.0004324458022
Gc16_496 0 n32 ns496 0 -0.00137953808156
Gc16_497 0 n32 ns497 0 0.00107527050237
Gc16_498 0 n32 ns498 0 -0.00080579193471
Gc16_499 0 n32 ns499 0 -8.04699299902e-05
Gc16_500 0 n32 ns500 0 0.000126379581112
Gc16_501 0 n32 ns501 0 -4.40863144756e-05
Gc16_502 0 n32 ns502 0 -6.20735471324e-06
Gc16_503 0 n32 ns503 0 0.000262399797873
Gc16_504 0 n32 ns504 0 -0.000630161010199
Gc16_505 0 n32 ns505 0 0.000181247255037
Gc16_506 0 n32 ns506 0 4.71276886504e-05
Gc16_507 0 n32 ns507 0 -2.33415406708e-05
Gc16_508 0 n32 ns508 0 0.000120774259786
Gc16_509 0 n32 ns509 0 -0.00112037717443
Gc16_510 0 n32 ns510 0 0.000497398209242
Gc16_511 0 n32 ns511 0 0.000411801781781
Gc16_512 0 n32 ns512 0 1.00139127512e-05
Gc16_513 0 n32 ns513 0 -0.000249905588998
Gc16_514 0 n32 ns514 0 -0.000361388478007
Gc16_515 0 n32 ns515 0 0.000708828175864
Gc16_516 0 n32 ns516 0 -0.00146597118948
Gc16_517 0 n32 ns517 0 -0.00103213594109
Gc16_518 0 n32 ns518 0 0.00282604761989
Gc16_519 0 n32 ns519 0 -0.000805726911616
Gc16_520 0 n32 ns520 0 0.00331630393144
Gc16_521 0 n32 ns521 0 -0.00214947397305
Gc16_522 0 n32 ns522 0 -0.0019813669798
Gc16_523 0 n32 ns523 0 0.000682906774755
Gc16_524 0 n32 ns524 0 -0.00103002517752
Gc16_525 0 n32 ns525 0 0.00124212375445
Gc16_526 0 n32 ns526 0 -0.000500124639318
Gc16_527 0 n32 ns527 0 -0.00121754326338
Gc16_528 0 n32 ns528 0 0.00297484161565
Gc16_529 0 n32 ns529 0 0.00160064412191
Gc16_530 0 n32 ns530 0 1.4676557261e-05
Gc16_531 0 n32 ns531 0 -0.000301575005093
Gc16_532 0 n32 ns532 0 0.000120921907353
Gc16_533 0 n32 ns533 0 0.000454708532854
Gc16_534 0 n32 ns534 0 -0.00215779273643
Gc16_535 0 n32 ns535 0 0.000633425524962
Gc16_536 0 n32 ns536 0 -0.00074877689547
Gc16_537 0 n32 ns537 0 -0.00092205359884
Gc16_538 0 n32 ns538 0 0.0002500877957
Gc16_539 0 n32 ns539 0 0.000307723256138
Gc16_540 0 n32 ns540 0 -0.000360802116474
Gc16_541 0 n32 ns541 0 0.000570283856677
Gc16_542 0 n32 ns542 0 0.000296044830499
Gc16_543 0 n32 ns543 0 0.000189294438145
Gc16_544 0 n32 ns544 0 0.000110137114672
Gc16_545 0 n32 ns545 0 -0.000149040303371
Gc16_546 0 n32 ns546 0 7.54645183732e-05
Gc16_547 0 n32 ns547 0 2.06238518347e-05
Gc16_548 0 n32 ns548 0 -0.00103732285103
Gc16_549 0 n32 ns549 0 0.00071460459629
Gc16_550 0 n32 ns550 0 7.32357310153e-05
Gc16_551 0 n32 ns551 0 0.000463716965216
Gc16_552 0 n32 ns552 0 -0.000561356895094
Gc16_553 0 n32 ns553 0 0.00129227057833
Gc16_554 0 n32 ns554 0 0.00164374812828
Gc16_555 0 n32 ns555 0 -0.000675960097275
Gc16_556 0 n32 ns556 0 0.00249864365695
Gc16_557 0 n32 ns557 0 -0.00115719229399
Gc16_558 0 n32 ns558 0 0.00304449734021
Gc16_559 0 n32 ns559 0 0.00349464780427
Gc16_560 0 n32 ns560 0 -0.000747975116502
Gc16_561 0 n32 ns561 0 0.00127494006558
Gc16_562 0 n32 ns562 0 -0.000745192836598
Gc16_563 0 n32 ns563 0 -0.000902668759681
Gc16_564 0 n32 ns564 0 -0.00047880320135
Gc16_565 0 n32 ns565 0 -0.00374263080918
Gc16_566 0 n32 ns566 0 5.35932521507e-05
Gc16_567 0 n32 ns567 0 0.00319777930268
Gc16_568 0 n32 ns568 0 4.12726446856e-05
Gc16_569 0 n32 ns569 0 -0.000252462497897
Gc16_570 0 n32 ns570 0 8.88784255915e-05
Gc16_571 0 n32 ns571 0 0.001183589747
Gc16_572 0 n32 ns572 0 -0.00341230039257
Gc16_573 0 n32 ns573 0 -3.87839799197e-06
Gc16_574 0 n32 ns574 0 -0.00228915888196
Gc16_575 0 n32 ns575 0 -0.000763983637353
Gc16_576 0 n32 ns576 0 -0.000821694985405
Gc16_577 0 n32 ns577 0 0.000479681134506
Gc16_578 0 n32 ns578 0 0.000101977477549
Gc16_579 0 n32 ns579 0 -0.000103162896275
Gc16_580 0 n32 ns580 0 0.00050553901004
Gc16_581 0 n32 ns581 0 0.000103168266803
Gc16_582 0 n32 ns582 0 0.000143845432095
Gc16_583 0 n32 ns583 0 -0.000564390201691
Gc16_584 0 n32 ns584 0 0.000307506988504
Gc16_585 0 n32 ns585 0 0.000658571422433
Gc16_586 0 n32 ns586 0 -7.97925137343e-05
Gc16_587 0 n32 ns587 0 0.000153349698694
Gc16_588 0 n32 ns588 0 0.000356510573008
Gc16_589 0 n32 ns589 0 -0.00029610198737
Gc16_590 0 n32 ns590 0 -0.000364318850116
Gc16_591 0 n32 ns591 0 -0.000598978230103
Gc16_592 0 n32 ns592 0 0.00121507534761
Gc16_593 0 n32 ns593 0 0.00505031221578
Gc16_594 0 n32 ns594 0 0.0024264946679
Gc16_595 0 n32 ns595 0 0.00320605973779
Gc16_596 0 n32 ns596 0 0.00256893970476
Gc16_597 0 n32 ns597 0 0.00332286536214
Gc16_598 0 n32 ns598 0 0.00525225873391
Gc16_599 0 n32 ns599 0 0.00107450958172
Gc16_600 0 n32 ns600 0 -0.000147963311943
Gc16_601 0 n32 ns601 0 -0.00632611497506
Gc16_602 0 n32 ns602 0 -0.000362353529813
Gc16_603 0 n32 ns603 0 0.00283202073087
Gc16_604 0 n32 ns604 0 -0.00588558863366
Gc16_605 0 n32 ns605 0 0.00447954713274
Gc16_606 0 n32 ns606 0 -6.73124176279e-06
Gc16_607 0 n32 ns607 0 8.24498238878e-05
Gc16_608 0 n32 ns608 0 -0.000150380106555
Gc16_609 0 n32 ns609 0 0.000109156482899
Gc16_610 0 n32 ns610 0 0.000550813407624
Gc16_611 0 n32 ns611 0 0.000637548557703
Gc16_612 0 n32 ns612 0 0.000764974613886
Gc16_613 0 n32 ns613 0 5.71975844145e-05
Gc16_614 0 n32 ns614 0 0.000250260105035
Gc16_615 0 n32 ns615 0 -1.69525547362e-05
Gc16_616 0 n32 ns616 0 -9.77682227318e-05
Gc16_617 0 n32 ns617 0 0.000196626544675
Gc16_618 0 n32 ns618 0 0.000249050655735
Gc16_619 0 n32 ns619 0 3.88212498299e-05
Gc16_620 0 n32 ns620 0 -0.00011444257595
Gc16_621 0 n32 ns621 0 -0.000403031827979
Gc16_622 0 n32 ns622 0 -0.000461766096865
Gc16_623 0 n32 ns623 0 -0.000193584796254
Gc16_624 0 n32 ns624 0 -0.000200889852084
Gc16_625 0 n32 ns625 0 -5.04072780567e-05
Gc16_626 0 n32 ns626 0 -4.15569357434e-05
Gc16_627 0 n32 ns627 0 4.32599446091e-05
Gc16_628 0 n32 ns628 0 -0.000114577646642
Gc16_629 0 n32 ns629 0 5.48145333284e-05
Gc16_630 0 n32 ns630 0 0.000541237691067
Gc16_631 0 n32 ns631 0 8.24935089285e-05
Gc16_632 0 n32 ns632 0 0.00220431536655
Gc16_633 0 n32 ns633 0 8.07701724807e-05
Gc16_634 0 n32 ns634 0 0.00186348637686
Gc16_635 0 n32 ns635 0 0.00087496270488
Gc16_636 0 n32 ns636 0 0.00046730337064
Gc16_637 0 n32 ns637 0 -0.000151583644838
Gc16_638 0 n32 ns638 0 -8.24244170178e-05
Gc16_639 0 n32 ns639 0 -0.000807206196296
Gc16_640 0 n32 ns640 0 -0.000518053479876
Gc16_641 0 n32 ns641 0 -0.000209982029778
Gc16_642 0 n32 ns642 0 -0.000869537977904
Gc16_643 0 n32 ns643 0 -0.00023021771796
Gc16_644 0 n32 ns644 0 1.13894775449e-05
Gc16_645 0 n32 ns645 0 -3.5707115133e-05
Gc16_646 0 n32 ns646 0 2.21896402242e-05
Gc16_647 0 n32 ns647 0 0.000158262830432
Gc16_648 0 n32 ns648 0 0.000166724603512
Gc16_649 0 n32 ns649 0 0.000703740913621
Gc16_650 0 n32 ns650 0 -6.96559157297e-05
Gc16_651 0 n32 ns651 0 9.52833234262e-06
Gc16_652 0 n32 ns652 0 -3.13185801329e-05
Gc16_653 0 n32 ns653 0 -3.39429494598e-06
Gc16_654 0 n32 ns654 0 4.56731638858e-05
Gc16_655 0 n32 ns655 0 4.11833905879e-05
Gc16_656 0 n32 ns656 0 0.000212225092435
Gc16_657 0 n32 ns657 0 5.0680485626e-05
Gc16_658 0 n32 ns658 0 -8.73762993959e-05
Gc16_659 0 n32 ns659 0 -0.000282477990948
Gc16_660 0 n32 ns660 0 -0.000336403863221
Gc16_661 0 n32 ns661 0 -0.000287001983861
Gc16_662 0 n32 ns662 0 -9.00018315279e-05
Gc16_663 0 n32 ns663 0 -0.00015255234636
Gc16_664 0 n32 ns664 0 7.42347177474e-05
Gc16_665 0 n32 ns665 0 -0.000117319165255
Gc16_666 0 n32 ns666 0 7.38545384118e-05
Gc16_667 0 n32 ns667 0 -8.99810834516e-05
Gc16_668 0 n32 ns668 0 0.000386270257182
Gc16_669 0 n32 ns669 0 -0.000332385386728
Gc16_670 0 n32 ns670 0 0.00208634898909
Gc16_671 0 n32 ns671 0 -0.000271641055346
Gc16_672 0 n32 ns672 0 0.00178687835885
Gc16_673 0 n32 ns673 0 0.000777292946243
Gc16_674 0 n32 ns674 0 0.000414686677111
Gc16_675 0 n32 ns675 0 -0.000155189603861
Gc16_676 0 n32 ns676 0 -7.28590071275e-05
Gc16_677 0 n32 ns677 0 -0.000750037364773
Gc16_678 0 n32 ns678 0 -0.000414337102014
Gc16_679 0 n32 ns679 0 -0.000160318229406
Gc16_680 0 n32 ns680 0 -0.000733357434165
Gc16_681 0 n32 ns681 0 -0.000206116670209
Gc16_682 0 n32 ns682 0 -1.76428045033e-05
Gc16_683 0 n32 ns683 0 5.6479717841e-06
Gc16_684 0 n32 ns684 0 -1.93212565382e-06
Gc16_685 0 n32 ns685 0 4.21819375298e-05
Gc16_686 0 n32 ns686 0 0.000137490774102
Gc16_687 0 n32 ns687 0 0.0001543484484
Gc16_688 0 n32 ns688 0 -2.7048213427e-05
Gc16_689 0 n32 ns689 0 5.89476277404e-05
Gc16_690 0 n32 ns690 0 1.04181883844e-05
Gc16_691 0 n32 ns691 0 -7.63171742182e-05
Gc16_692 0 n32 ns692 0 -4.79079408197e-05
Gc16_693 0 n32 ns693 0 -0.00025196619912
Gc16_694 0 n32 ns694 0 -5.45846878372e-06
Gc16_695 0 n32 ns695 0 0.00010700475742
Gc16_696 0 n32 ns696 0 2.65456225234e-05
Gc16_697 0 n32 ns697 0 0.000182826649916
Gc16_698 0 n32 ns698 0 -0.00027215001277
Gc16_699 0 n32 ns699 0 -0.000287666691058
Gc16_700 0 n32 ns700 0 -0.000284808970794
Gc16_701 0 n32 ns701 0 -0.00039302598921
Gc16_702 0 n32 ns702 0 2.95271118876e-06
Gc16_703 0 n32 ns703 0 -0.000453740066944
Gc16_704 0 n32 ns704 0 0.000102909848487
Gc16_705 0 n32 ns705 0 -0.000463641839803
Gc16_706 0 n32 ns706 0 8.77122480935e-06
Gc16_707 0 n32 ns707 0 -0.00230943834636
Gc16_708 0 n32 ns708 0 0.00167513096947
Gc16_709 0 n32 ns709 0 -0.00198296067931
Gc16_710 0 n32 ns710 0 0.00149944547517
Gc16_711 0 n32 ns711 0 0.00061520170028
Gc16_712 0 n32 ns712 0 0.000626556172119
Gc16_713 0 n32 ns713 0 -0.000205831571764
Gc16_714 0 n32 ns714 0 -0.000120143463313
Gc16_715 0 n32 ns715 0 -0.000799583142347
Gc16_716 0 n32 ns716 0 -0.000444677134584
Gc16_717 0 n32 ns717 0 -0.00011963765012
Gc16_718 0 n32 ns718 0 -0.00037517349561
Gc16_719 0 n32 ns719 0 -0.000122315426852
Gc16_720 0 n32 ns720 0 -1.53709239333e-05
Gc16_721 0 n32 ns721 0 2.89826706238e-05
Gc16_722 0 n32 ns722 0 3.78721048138e-07
Gc16_723 0 n32 ns723 0 -0.000521676624603
Gc16_724 0 n32 ns724 0 0.000733779498962
Gc16_725 0 n32 ns725 0 -0.00128237346174
Gc16_726 0 n32 ns726 0 0.000715972039028
Gc16_727 0 n32 ns727 0 -0.000179492592518
Gc16_728 0 n32 ns728 0 0.000363956864889
Gc16_729 0 n32 ns729 0 0.000150056910543
Gc16_730 0 n32 ns730 0 -0.000256536997422
Gc16_731 0 n32 ns731 0 -5.76926763e-05
Gc16_732 0 n32 ns732 0 -0.00033453002827
Gc16_733 0 n32 ns733 0 3.64797476992e-05
Gc16_734 0 n32 ns734 0 0.000173871574414
Gc16_735 0 n32 ns735 0 0.000588919099033
Gc16_736 0 n32 ns736 0 8.42396355703e-05
Gc16_737 0 n32 ns737 0 0.000432565334132
Gc16_738 0 n32 ns738 0 -0.000562949272531
Gc16_739 0 n32 ns739 0 -0.000223890022168
Gc16_740 0 n32 ns740 0 -0.00049322648675
Gc16_741 0 n32 ns741 0 -0.000305427143818
Gc16_742 0 n32 ns742 0 -0.000375420920807
Gc16_743 0 n32 ns743 0 -0.00057980483683
Gc16_744 0 n32 ns744 0 -0.000448977724113
Gc16_745 0 n32 ns745 0 -0.00505293602875
Gc16_746 0 n32 ns746 0 -0.000403118963638
Gc16_747 0 n32 ns747 0 -0.00444074564461
Gc16_748 0 n32 ns748 0 -0.000250958814506
Gc16_749 0 n32 ns749 0 0.000295515879744
Gc16_750 0 n32 ns750 0 0.00134436118149
Gc16_751 0 n32 ns751 0 -0.000277714726924
Gc16_752 0 n32 ns752 0 -0.00032189533638
Gc16_753 0 n32 ns753 0 -0.000900043492979
Gc16_754 0 n32 ns754 0 -0.00106075773481
Gc16_755 0 n32 ns755 0 -9.37613900164e-05
Gc16_756 0 n32 ns756 0 -0.000553497857881
Gc16_757 0 n32 ns757 0 -0.000181424232037
Gc16_758 0 n32 ns758 0 -1.62052447834e-05
Gc16_759 0 n32 ns759 0 0.000108731133244
Gc16_760 0 n32 ns760 0 -2.69016391085e-05
Gc16_761 0 n32 ns761 0 -0.000256120813997
Gc16_762 0 n32 ns762 0 -2.31446996027e-05
Gc16_763 0 n32 ns763 0 -0.000432297944917
Gc16_764 0 n32 ns764 0 0.000436468430408
Gc16_765 0 n32 ns765 0 -0.000135116318391
Gc16_766 0 n32 ns766 0 0.000189846973098
Gc16_767 0 n32 ns767 0 0.000115888372885
Gc16_768 0 n32 ns768 0 -1.98440844588e-05
Gc16_769 0 n32 ns769 0 0.000548622886087
Gc16_770 0 n32 ns770 0 -0.000204616971028
Gc16_771 0 n32 ns771 0 -0.000157270663214
Gc16_772 0 n32 ns772 0 0.000140859699387
Gc16_773 0 n32 ns773 0 -6.22009320054e-05
Gc16_774 0 n32 ns774 0 0.000445368906349
Gc16_775 0 n32 ns775 0 0.000994299003313
Gc16_776 0 n32 ns776 0 0.000160178032289
Gc16_777 0 n32 ns777 0 0.000434764618
Gc16_778 0 n32 ns778 0 -0.000679575604116
Gc16_779 0 n32 ns779 0 0.00030320964738
Gc16_780 0 n32 ns780 0 -0.000581919624993
Gc16_781 0 n32 ns781 0 6.96262470003e-05
Gc16_782 0 n32 ns782 0 -0.000548717353163
Gc16_783 0 n32 ns783 0 -0.00498702532106
Gc16_784 0 n32 ns784 0 -0.00451446630704
Gc16_785 0 n32 ns785 0 -0.00459907079326
Gc16_786 0 n32 ns786 0 -0.0039254090393
Gc16_787 0 n32 ns787 0 -0.000385780701331
Gc16_788 0 n32 ns788 0 0.00183694894676
Gc16_789 0 n32 ns789 0 -0.000269151526989
Gc16_790 0 n32 ns790 0 -0.000665598664495
Gc16_791 0 n32 ns791 0 -0.000793007114635
Gc16_792 0 n32 ns792 0 -0.00193717646662
Gc16_793 0 n32 ns793 0 -5.27277671866e-06
Gc16_794 0 n32 ns794 0 -0.00112907897394
Gc16_795 0 n32 ns795 0 -0.000385401733331
Gc16_796 0 n32 ns796 0 -9.59288495623e-06
Gc16_797 0 n32 ns797 0 9.9257505338e-05
Gc16_798 0 n32 ns798 0 -1.63241721737e-05
Gc16_799 0 n32 ns799 0 9.47382694764e-05
Gc16_800 0 n32 ns800 0 -0.000882883815061
Gc16_801 0 n32 ns801 0 0.000171734590085
Gc16_802 0 n32 ns802 0 0.000275570439562
Gc16_803 0 n32 ns803 0 -7.44103035498e-05
Gc16_804 0 n32 ns804 0 -0.000235011822355
Gc16_805 0 n32 ns805 0 -9.0397161739e-05
Gc16_806 0 n32 ns806 0 0.000140561786477
Gc16_807 0 n32 ns807 0 0.00020618787636
Gc16_808 0 n32 ns808 0 0.000591196117167
Gc16_809 0 n32 ns809 0 -0.000174776190837
Gc16_810 0 n32 ns810 0 2.68880795744e-05
Gc16_811 0 n32 ns811 0 -9.87720857728e-05
Gc16_812 0 n32 ns812 0 -0.000251015736021
Gc16_813 0 n32 ns813 0 0.000148819500065
Gc16_814 0 n32 ns814 0 0.00109336037355
Gc16_815 0 n32 ns815 0 0.000846549412345
Gc16_816 0 n32 ns816 0 -7.61724634935e-05
Gc16_817 0 n32 ns817 0 0.000476782600891
Gc16_818 0 n32 ns818 0 3.05566089197e-05
Gc16_819 0 n32 ns819 0 0.000250809589975
Gc16_820 0 n32 ns820 0 0.000348881083611
Gc16_821 0 n32 ns821 0 -0.000902835392465
Gc16_822 0 n32 ns822 0 -0.0065448508425
Gc16_823 0 n32 ns823 0 -0.00114904668103
Gc16_824 0 n32 ns824 0 -0.00612744126512
Gc16_825 0 n32 ns825 0 -0.00153965294166
Gc16_826 0 n32 ns826 0 0.00100083128136
Gc16_827 0 n32 ns827 0 0.000110437206675
Gc16_828 0 n32 ns828 0 -0.00108370075703
Gc16_829 0 n32 ns829 0 0.000232637794143
Gc16_830 0 n32 ns830 0 -0.0023935664154
Gc16_831 0 n32 ns831 0 0.000558481823394
Gc16_832 0 n32 ns832 0 -0.00170227972833
Gc16_833 0 n32 ns833 0 -0.000795690418463
Gc16_834 0 n32 ns834 0 -1.05083989064e-05
Gc16_835 0 n32 ns835 0 6.18801166039e-05
Gc16_836 0 n32 ns836 0 1.74373845806e-06
Gc16_837 0 n32 ns837 0 -0.000768149984187
Gc16_838 0 n32 ns838 0 -4.62129599989e-05
Gc16_839 0 n32 ns839 0 -0.00247473514143
Gc16_840 0 n32 ns840 0 0.00144789951399
Gc16_841 0 n32 ns841 0 -0.000418205424344
Gc16_842 0 n32 ns842 0 0.000646063060558
Gc16_843 0 n32 ns843 0 0.000244036066914
Gc16_844 0 n32 ns844 0 -0.000389021035514
Gc16_845 0 n32 ns845 0 -0.000659656099438
Gc16_846 0 n32 ns846 0 0.00070400930026
Gc16_847 0 n32 ns847 0 -9.46331945388e-05
Gc16_848 0 n32 ns848 0 -3.93641159146e-05
Gc16_849 0 n32 ns849 0 0.000962093846303
Gc16_850 0 n32 ns850 0 -0.00064136272366
Gc16_851 0 n32 ns851 0 -0.000651698439407
Gc16_852 0 n32 ns852 0 -0.000144222447144
Gc16_853 0 n32 ns853 0 0.00075753808585
Gc16_854 0 n32 ns854 0 0.000197972005814
Gc16_855 0 n32 ns855 0 0.00036978818576
Gc16_856 0 n32 ns856 0 -9.42257596741e-05
Gc16_857 0 n32 ns857 0 -0.0014715860689
Gc16_858 0 n32 ns858 0 0.00108145164385
Gc16_859 0 n32 ns859 0 0.000596674902663
Gc16_860 0 n32 ns860 0 -0.00194211400161
Gc16_861 0 n32 ns861 0 0.000679135104963
Gc16_862 0 n32 ns862 0 -0.00269508191018
Gc16_863 0 n32 ns863 0 -0.000171118065046
Gc16_864 0 n32 ns864 0 -0.000711314969148
Gc16_865 0 n32 ns865 0 0.000896923924279
Gc16_866 0 n32 ns866 0 -0.00120444275137
Gc16_867 0 n32 ns867 0 0.000850950529846
Gc16_868 0 n32 ns868 0 -0.00182878008953
Gc16_869 0 n32 ns869 0 0.00198103865037
Gc16_870 0 n32 ns870 0 -0.00252824727178
Gc16_871 0 n32 ns871 0 -0.00201183215765
Gc16_872 0 n32 ns872 0 -2.58627382148e-05
Gc16_873 0 n32 ns873 0 0.000116125043763
Gc16_874 0 n32 ns874 0 -1.30413630545e-05
Gc16_875 0 n32 ns875 0 0.00093772467385
Gc16_876 0 n32 ns876 0 -0.00216473347098
Gc16_877 0 n32 ns877 0 0.00134964664194
Gc16_878 0 n32 ns878 0 -0.00440949125401
Gc16_879 0 n32 ns879 0 -0.00242846402881
Gc16_880 0 n32 ns880 0 -0.00130515693719
Gc16_881 0 n32 ns881 0 0.00101293888048
Gc16_882 0 n32 ns882 0 0.000439470592096
Gc16_883 0 n32 ns883 0 -0.000791429284217
Gc16_884 0 n32 ns884 0 -0.000482353733435
Gc16_885 0 n32 ns885 0 -0.000134246877609
Gc16_886 0 n32 ns886 0 -8.63226396265e-05
Gc16_887 0 n32 ns887 0 0.00035329218742
Gc16_888 0 n32 ns888 0 0.000128548177065
Gc16_889 0 n32 ns889 0 0.000722860352437
Gc16_890 0 n32 ns890 0 -0.000847878671012
Gc16_891 0 n32 ns891 0 0.000653120752963
Gc16_892 0 n32 ns892 0 0.000484020552908
Gc16_893 0 n32 ns893 0 0.000350823856106
Gc16_894 0 n32 ns894 0 0.000207029001545
Gc16_895 0 n32 ns895 0 -0.00120162076392
Gc16_896 0 n32 ns896 0 -0.00191231177777
Gc16_897 0 n32 ns897 0 -0.00145875130313
Gc16_898 0 n32 ns898 0 -0.000878633372373
Gc16_899 0 n32 ns899 0 -0.000418478813427
Gc16_900 0 n32 ns900 0 -0.00156116806374
Gc16_901 0 n32 ns901 0 0.00460928964887
Gc16_902 0 n32 ns902 0 0.00200379443911
Gc16_903 0 n32 ns903 0 0.0013932352092
Gc16_904 0 n32 ns904 0 -0.000646488731837
Gc16_905 0 n32 ns905 0 -0.00206859861935
Gc16_906 0 n32 ns906 0 -0.00147249500092
Gc16_907 0 n32 ns907 0 0.00261012334724
Gc16_908 0 n32 ns908 0 0.00295102553518
Gc16_909 0 n32 ns909 0 -0.00354046214434
Gc16_910 0 n32 ns910 0 -9.38229379546e-06
Gc16_911 0 n32 ns911 0 0.000292693005789
Gc16_912 0 n32 ns912 0 -0.00015235387552
Gc16_913 0 n32 ns913 0 0.00243403763558
Gc16_914 0 n32 ns914 0 -0.00367964750637
Gc16_915 0 n32 ns915 0 0.00478248504842
Gc16_916 0 n32 ns916 0 -0.00873442566426
Gc16_917 0 n32 ns917 0 -0.00381361207689
Gc16_918 0 n32 ns918 0 -0.00260494027634
Gc16_919 0 n32 ns919 0 0.00129697409033
Gc16_920 0 n32 ns920 0 0.000982341154007
Gc16_921 0 n32 ns921 0 -0.000374935267963
Gc16_922 0 n32 ns922 0 -0.000863939556932
Gc16_923 0 n32 ns923 0 -0.000110193191182
Gc16_924 0 n32 ns924 0 -0.000103672584293
Gc16_925 0 n32 ns925 0 -0.000957853111154
Gc16_926 0 n32 ns926 0 6.02737138923e-05
Gc16_927 0 n32 ns927 0 0.00168467844159
Gc16_928 0 n32 ns928 0 -2.73577635265e-05
Gc16_929 0 n32 ns929 0 0.000576503522561
Gc16_930 0 n32 ns930 0 0.000826338996048
Gc16_931 0 n32 ns931 0 0.000432994942333
Gc16_932 0 n32 ns932 0 0.00118187544847
Gc16_933 0 n32 ns933 0 0.000944903978605
Gc16_934 0 n32 ns934 0 -0.00414065785496
Gc16_935 0 n32 ns935 0 -0.000480980324276
Gc16_936 0 n32 ns936 0 -0.00486021075154
Gc16_937 0 n32 ns937 0 0.000316311978618
Gc16_938 0 n32 ns938 0 -0.00430484231314
Gc16_939 0 n32 ns939 0 0.00670121840626
Gc16_940 0 n32 ns940 0 0.00738873405122
Gc16_941 0 n32 ns941 0 0.000894428212989
Gc16_942 0 n32 ns942 0 -0.000278884375805
Gc16_943 0 n32 ns943 0 -0.00546279719609
Gc16_944 0 n32 ns944 0 -0.00357874435139
Gc16_945 0 n32 ns945 0 0.00105782932529
Gc16_946 0 n32 ns946 0 0.00890662447028
Gc16_947 0 n32 ns947 0 -0.00350033634317
Gc16_948 0 n32 ns948 0 8.42674659069e-06
Gc16_949 0 n32 ns949 0 0.000477222102109
Gc16_950 0 n32 ns950 0 -0.000317420874955
Gc16_951 0 n32 ns951 0 0.000115354657884
Gc16_952 0 n32 ns952 0 0.000193676432654
Gc16_953 0 n32 ns953 0 0.000425124232724
Gc16_954 0 n32 ns954 0 0.000123165514873
Gc16_955 0 n32 ns955 0 4.68024237732e-05
Gc16_956 0 n32 ns956 0 6.76029889156e-06
Gc16_957 0 n32 ns957 0 -5.87330650893e-05
Gc16_958 0 n32 ns958 0 -1.84480251629e-06
Gc16_959 0 n32 ns959 0 -0.000126704822814
Gc16_960 0 n32 ns960 0 0.00016542680479
Gc16_961 0 n32 ns961 0 9.87374983696e-05
Gc16_962 0 n32 ns962 0 -4.51735107908e-05
Gc16_963 0 n32 ns963 0 -6.11541050801e-05
Gc16_964 0 n32 ns964 0 -0.000409968711422
Gc16_965 0 n32 ns965 0 -0.00032808971835
Gc16_966 0 n32 ns966 0 -0.000216167158782
Gc16_967 0 n32 ns967 0 -0.000290855047545
Gc16_968 0 n32 ns968 0 4.61087605627e-05
Gc16_969 0 n32 ns969 0 -0.000295472976497
Gc16_970 0 n32 ns970 0 9.29293496688e-05
Gc16_971 0 n32 ns971 0 -0.000291119360843
Gc16_972 0 n32 ns972 0 0.000241844209761
Gc16_973 0 n32 ns973 0 -0.00130716670139
Gc16_974 0 n32 ns974 0 0.0020879457372
Gc16_975 0 n32 ns975 0 -0.00111087416353
Gc16_976 0 n32 ns976 0 0.00182009329785
Gc16_977 0 n32 ns977 0 0.000740334325876
Gc16_978 0 n32 ns978 0 0.00052767820239
Gc16_979 0 n32 ns979 0 -0.000188260644771
Gc16_980 0 n32 ns980 0 -9.59449551054e-05
Gc16_981 0 n32 ns981 0 -0.000810468715204
Gc16_982 0 n32 ns982 0 -0.000429022377576
Gc16_983 0 n32 ns983 0 -0.00014416678371
Gc16_984 0 n32 ns984 0 -0.000567728447711
Gc16_985 0 n32 ns985 0 -0.000166832725458
Gc16_986 0 n32 ns986 0 -1.1524046561e-05
Gc16_987 0 n32 ns987 0 7.61451931173e-06
Gc16_988 0 n32 ns988 0 3.36903474509e-06
Gc16_989 0 n32 ns989 0 -0.000239849629879
Gc16_990 0 n32 ns990 0 0.00066314975452
Gc16_991 0 n32 ns991 0 -0.000542636376231
Gc16_992 0 n32 ns992 0 0.00106775780315
Gc16_993 0 n32 ns993 0 -1.30619625089e-05
Gc16_994 0 n32 ns994 0 0.000369214561958
Gc16_995 0 n32 ns995 0 1.98827616487e-05
Gc16_996 0 n32 ns996 0 -0.000259116112631
Gc16_997 0 n32 ns997 0 -0.00015044231915
Gc16_998 0 n32 ns998 0 -0.000145242338733
Gc16_999 0 n32 ns999 0 0.000102113842955
Gc16_1000 0 n32 ns1000 0 9.52408852418e-05
Gc16_1001 0 n32 ns1001 0 0.000422639135863
Gc16_1002 0 n32 ns1002 0 -0.000291546309062
Gc16_1003 0 n32 ns1003 0 9.84756151418e-05
Gc16_1004 0 n32 ns1004 0 -0.000657163778723
Gc16_1005 0 n32 ns1005 0 -0.000318286084302
Gc16_1006 0 n32 ns1006 0 -0.000374303155584
Gc16_1007 0 n32 ns1007 0 -0.000344787224384
Gc16_1008 0 n32 ns1008 0 -0.000322339036521
Gc16_1009 0 n32 ns1009 0 -0.000505857914049
Gc16_1010 0 n32 ns1010 0 -0.000102029613369
Gc16_1011 0 n32 ns1011 0 -0.00386365290923
Gc16_1012 0 n32 ns1012 0 0.00103746850893
Gc16_1013 0 n32 ns1013 0 -0.00336506978411
Gc16_1014 0 n32 ns1014 0 0.000963256183763
Gc16_1015 0 n32 ns1015 0 0.00066680362878
Gc16_1016 0 n32 ns1016 0 0.0012335154203
Gc16_1017 0 n32 ns1017 0 -0.000285605573832
Gc16_1018 0 n32 ns1018 0 -0.000251036327208
Gc16_1019 0 n32 ns1019 0 -0.00105447430173
Gc16_1020 0 n32 ns1020 0 -0.000973168364446
Gc16_1021 0 n32 ns1021 0 -0.000168092886041
Gc16_1022 0 n32 ns1022 0 -0.00075833706946
Gc16_1023 0 n32 ns1023 0 -0.000219634061346
Gc16_1024 0 n32 ns1024 0 2.95546876885e-07
Gc16_1025 0 n32 ns1025 0 1.54078046281e-05
Gc16_1026 0 n32 ns1026 0 2.58009141033e-05
Gc16_1027 0 n32 ns1027 0 -0.000172828099398
Gc16_1028 0 n32 ns1028 0 0.000156545099394
Gc16_1029 0 n32 ns1029 0 -0.00019552743504
Gc16_1030 0 n32 ns1030 0 0.000565340136519
Gc16_1031 0 n32 ns1031 0 -9.54864777972e-05
Gc16_1032 0 n32 ns1032 0 0.000267557957591
Gc16_1033 0 n32 ns1033 0 0.000150170121215
Gc16_1034 0 n32 ns1034 0 -0.000121394718884
Gc16_1035 0 n32 ns1035 0 0.000373799535501
Gc16_1036 0 n32 ns1036 0 -0.000365858396185
Gc16_1037 0 n32 ns1037 0 -8.26432563178e-05
Gc16_1038 0 n32 ns1038 0 0.000155476132728
Gc16_1039 0 n32 ns1039 0 0.000127265249768
Gc16_1040 0 n32 ns1040 0 0.000350300017234
Gc16_1041 0 n32 ns1041 0 0.000823694278212
Gc16_1042 0 n32 ns1042 0 -0.000339989738983
Gc16_1043 0 n32 ns1043 0 0.000137707566203
Gc16_1044 0 n32 ns1044 0 -0.000756821386081
Gc16_1045 0 n32 ns1045 0 5.87611511248e-05
Gc16_1046 0 n32 ns1046 0 -0.000728965325484
Gc16_1047 0 n32 ns1047 0 -8.45144837111e-05
Gc16_1048 0 n32 ns1048 0 -0.000490664941382
Gc16_1049 0 n32 ns1049 0 -0.00518381009365
Gc16_1050 0 n32 ns1050 0 -0.00256173503131
Gc16_1051 0 n32 ns1051 0 -0.00468567958089
Gc16_1052 0 n32 ns1052 0 -0.00217780177038
Gc16_1053 0 n32 ns1053 0 0.000175968067667
Gc16_1054 0 n32 ns1054 0 0.00186282157143
Gc16_1055 0 n32 ns1055 0 -0.000327095798184
Gc16_1056 0 n32 ns1056 0 -0.000539222041519
Gc16_1057 0 n32 ns1057 0 -0.00109742183484
Gc16_1058 0 n32 ns1058 0 -0.0017787425045
Gc16_1059 0 n32 ns1059 0 -0.000137661478711
Gc16_1060 0 n32 ns1060 0 -0.00123434884892
Gc16_1061 0 n32 ns1061 0 -0.000372194340854
Gc16_1062 0 n32 ns1062 0 8.27288884651e-07
Gc16_1063 0 n32 ns1063 0 5.16534103167e-05
Gc16_1064 0 n32 ns1064 0 1.12756735245e-05
Gc16_1065 0 n32 ns1065 0 -6.92585123567e-05
Gc16_1066 0 n32 ns1066 0 -0.000584385083643
Gc16_1067 0 n32 ns1067 0 -0.00017320057622
Gc16_1068 0 n32 ns1068 0 0.00030532609231
Gc16_1069 0 n32 ns1069 0 -0.000237258907415
Gc16_1070 0 n32 ns1070 0 -3.64916902149e-05
Gc16_1071 0 n32 ns1071 0 5.0620252095e-05
Gc16_1072 0 n32 ns1072 0 9.36025043908e-05
Gc16_1073 0 n32 ns1073 0 0.000484558495703
Gc16_1074 0 n32 ns1074 0 0.000342270129098
Gc16_1075 0 n32 ns1075 0 -0.000164779058098
Gc16_1076 0 n32 ns1076 0 6.30619795866e-05
Gc16_1077 0 n32 ns1077 0 -0.000231897571835
Gc16_1078 0 n32 ns1078 0 -2.66787877622e-05
Gc16_1079 0 n32 ns1079 0 0.000642993734955
Gc16_1080 0 n32 ns1080 0 0.000850049638448
Gc16_1081 0 n32 ns1081 0 0.000766339904542
Gc16_1082 0 n32 ns1082 0 -0.000328899236929
Gc16_1083 0 n32 ns1083 0 0.000541321637552
Gc16_1084 0 n32 ns1084 0 -0.000184147981013
Gc16_1085 0 n32 ns1085 0 0.000324973273423
Gc16_1086 0 n32 ns1086 0 -2.64692113944e-05
Gc16_1087 0 n32 ns1087 0 -0.0026432410458
Gc16_1088 0 n32 ns1088 0 -0.00624243122485
Gc16_1089 0 n32 ns1089 0 -0.0026550860427
Gc16_1090 0 n32 ns1090 0 -0.00566085900588
Gc16_1091 0 n32 ns1091 0 -0.00114412426514
Gc16_1092 0 n32 ns1092 0 0.00157939453635
Gc16_1093 0 n32 ns1093 0 -9.01913927874e-05
Gc16_1094 0 n32 ns1094 0 -0.000944647734634
Gc16_1095 0 n32 ns1095 0 -0.000262478273233
Gc16_1096 0 n32 ns1096 0 -0.00239725723254
Gc16_1097 0 n32 ns1097 0 0.00026188689676
Gc16_1098 0 n32 ns1098 0 -0.0015630172079
Gc16_1099 0 n32 ns1099 0 -0.000617382169775
Gc16_1100 0 n32 ns1100 0 -1.40171828673e-05
Gc16_1101 0 n32 ns1101 0 6.61207545818e-05
Gc16_1102 0 n32 ns1102 0 -2.68341219923e-06
Gc16_1103 0 n32 ns1103 0 -0.000397210620608
Gc16_1104 0 n32 ns1104 0 -5.19546722225e-05
Gc16_1105 0 n32 ns1105 0 -0.00108908985649
Gc16_1106 0 n32 ns1106 0 0.00187070898602
Gc16_1107 0 n32 ns1107 0 -8.65486927762e-05
Gc16_1108 0 n32 ns1108 0 0.000263615345596
Gc16_1109 0 n32 ns1109 0 1.92077763789e-05
Gc16_1110 0 n32 ns1110 0 -0.00021217878614
Gc16_1111 0 n32 ns1111 0 -0.000254857822094
Gc16_1112 0 n32 ns1112 0 0.000829390495614
Gc16_1113 0 n32 ns1113 0 -0.000113754151258
Gc16_1114 0 n32 ns1114 0 -3.39592606581e-05
Gc16_1115 0 n32 ns1115 0 0.000527193671072
Gc16_1116 0 n32 ns1116 0 -0.000770856635905
Gc16_1117 0 n32 ns1117 0 -0.000551547401473
Gc16_1118 0 n32 ns1118 0 0.000392314861375
Gc16_1119 0 n32 ns1119 0 0.000758842978505
Gc16_1120 0 n32 ns1120 0 7.59568979466e-05
Gc16_1121 0 n32 ns1121 0 0.000330237353208
Gc16_1122 0 n32 ns1122 0 -7.66334909096e-05
Gc16_1123 0 n32 ns1123 0 -0.000665015886617
Gc16_1124 0 n32 ns1124 0 0.00122372234495
Gc16_1125 0 n32 ns1125 0 0.00100925900456
Gc16_1126 0 n32 ns1126 0 -0.00336019132379
Gc16_1127 0 n32 ns1127 0 0.000769340687712
Gc16_1128 0 n32 ns1128 0 -0.00376419214745
Gc16_1129 0 n32 ns1129 0 -0.00112303907747
Gc16_1130 0 n32 ns1130 0 -0.000218383813022
Gc16_1131 0 n32 ns1131 0 0.000587817715378
Gc16_1132 0 n32 ns1132 0 -0.00123799181643
Gc16_1133 0 n32 ns1133 0 0.000846942292427
Gc16_1134 0 n32 ns1134 0 -0.00222144027897
Gc16_1135 0 n32 ns1135 0 0.00132666007319
Gc16_1136 0 n32 ns1136 0 -0.00255910894029
Gc16_1137 0 n32 ns1137 0 -0.00146945687836
Gc16_1138 0 n32 ns1138 0 -2.13544549814e-05
Gc16_1139 0 n32 ns1139 0 8.98214917994e-05
Gc16_1140 0 n32 ns1140 0 5.16705241282e-07
Gc16_1141 0 n32 ns1141 0 -0.00110399291959
Gc16_1142 0 n32 ns1142 0 -0.000445574855418
Gc16_1143 0 n32 ns1143 0 -0.00428941641018
Gc16_1144 0 n32 ns1144 0 -0.00161086694539
Gc16_1145 0 n32 ns1145 0 -0.00203458279104
Gc16_1146 0 n32 ns1146 0 0.00100181731946
Gc16_1147 0 n32 ns1147 0 0.000957480675097
Gc16_1148 0 n32 ns1148 0 -0.000489965135116
Gc16_1149 0 n32 ns1149 0 -0.00080911387582
Gc16_1150 0 n32 ns1150 0 0.000219937027411
Gc16_1151 0 n32 ns1151 0 -0.000113321230584
Gc16_1152 0 n32 ns1152 0 -5.78426345729e-05
Gc16_1153 0 n32 ns1153 0 0.000957793151868
Gc16_1154 0 n32 ns1154 0 -2.16617600511e-06
Gc16_1155 0 n32 ns1155 0 0.000258615181639
Gc16_1156 0 n32 ns1156 0 -0.000908932999703
Gc16_1157 0 n32 ns1157 0 0.000886590536235
Gc16_1158 0 n32 ns1158 0 0.000275572005501
Gc16_1159 0 n32 ns1159 0 0.000774704880381
Gc16_1160 0 n32 ns1160 0 -7.47126139064e-05
Gc16_1161 0 n32 ns1161 0 -0.00233910615675
Gc16_1162 0 n32 ns1162 0 -0.00046200034284
Gc16_1163 0 n32 ns1163 0 -0.00163750927236
Gc16_1164 0 n32 ns1164 0 -0.000699333508512
Gc16_1165 0 n32 ns1165 0 -0.000723848974751
Gc16_1166 0 n32 ns1166 0 -0.00152377683984
Gc16_1167 0 n32 ns1167 0 0.00301324197042
Gc16_1168 0 n32 ns1168 0 0.00014724331798
Gc16_1169 0 n32 ns1169 0 0.00132042320292
Gc16_1170 0 n32 ns1170 0 -0.00089316920844
Gc16_1171 0 n32 ns1171 0 -0.000744838455638
Gc16_1172 0 n32 ns1172 0 -0.00158387578516
Gc16_1173 0 n32 ns1173 0 0.00293290059256
Gc16_1174 0 n32 ns1174 0 0.000256368444193
Gc16_1175 0 n32 ns1175 0 -0.0031295148055
Gc16_1176 0 n32 ns1176 0 -3.05121954761e-05
Gc16_1177 0 n32 ns1177 0 0.000390493529827
Gc16_1178 0 n32 ns1178 0 -0.000224647531746
Gc16_1179 0 n32 ns1179 0 -0.000421669995294
Gc16_1180 0 n32 ns1180 0 -0.000251232935748
Gc16_1181 0 n32 ns1181 0 0.000162416336945
Gc16_1182 0 n32 ns1182 0 0.0020045377409
Gc16_1183 0 n32 ns1183 0 0.00139170413987
Gc16_1184 0 n32 ns1184 0 -0.000969486093635
Gc16_1185 0 n32 ns1185 0 -0.000312745449157
Gc16_1186 0 n32 ns1186 0 0.000199448076905
Gc16_1187 0 n32 ns1187 0 5.19977809586e-05
Gc16_1188 0 n32 ns1188 0 -0.00016176028058
Gc16_1189 0 n32 ns1189 0 -3.16813372907e-05
Gc16_1190 0 n32 ns1190 0 -8.57134049694e-05
Gc16_1191 0 n32 ns1191 0 0.00177515597715
Gc16_1192 0 n32 ns1192 0 -0.000341394418278
Gc16_1193 0 n32 ns1193 0 -0.000263654052674
Gc16_1194 0 n32 ns1194 0 0.000911863575274
Gc16_1195 0 n32 ns1195 0 -0.000610996854092
Gc16_1196 0 n32 ns1196 0 0.000394877318474
Gc16_1197 0 n32 ns1197 0 -0.00180343625525
Gc16_1198 0 n32 ns1198 0 -0.000968206053119
Gc16_1199 0 n32 ns1199 0 0.00259669720939
Gc16_1200 0 n32 ns1200 0 0.00298964852483
Gc16_1201 0 n32 ns1201 0 -0.00888711417101
Gc16_1202 0 n32 ns1202 0 0.00319566807235
Gc16_1203 0 n32 ns1203 0 -0.00623938311658
Gc16_1204 0 n32 ns1204 0 0.00182887403008
Gc16_1205 0 n32 ns1205 0 -0.00948448021723
Gc16_1206 0 n32 ns1206 0 -0.00169177924273
Gc16_1207 0 n32 ns1207 0 0.00169294912533
Gc16_1208 0 n32 ns1208 0 0.000825071811763
Gc16_1209 0 n32 ns1209 0 -0.00346080466949
Gc16_1210 0 n32 ns1210 0 0.0109020041934
Gc16_1211 0 n32 ns1211 0 -0.0141493088078
Gc16_1212 0 n32 ns1212 0 -0.00130543656263
Gc16_1213 0 n32 ns1213 0 -0.00572777896003
Gc16_1214 0 n32 ns1214 0 -4.93872374987e-05
Gc16_1215 0 n32 ns1215 0 -0.000404269086277
Gc16_1216 0 n32 ns1216 0 0.000578016711955
Gd16_1 0 n32 ni1 0 -0.000107812350967
Gd16_2 0 n32 ni2 0 2.94046769325e-05
Gd16_3 0 n32 ni3 0 -1.37727766731e-05
Gd16_4 0 n32 ni4 0 8.3779388619e-05
Gd16_5 0 n32 ni5 0 0.000199132608455
Gd16_6 0 n32 ni6 0 0.000108839669932
Gd16_7 0 n32 ni7 0 -0.0017937320667
Gd16_8 0 n32 ni8 0 -0.00323659206076
Gd16_9 0 n32 ni9 0 -0.00292891924553
Gd16_10 0 n32 ni10 0 -5.49201550865e-05
Gd16_11 0 n32 ni11 0 1.80355759765e-05
Gd16_12 0 n32 ni12 0 0.000285036055746
Gd16_13 0 n32 ni13 0 0.000254639704515
Gd16_14 0 n32 ni14 0 -0.000877131802891
Gd16_15 0 n32 ni15 0 -0.00173774936144
Gd16_16 0 n32 ni16 0 -0.000560122365997
Gd16_17 0 n32 ni17 0 0.000208553929503
Gd16_18 0 n32 ni18 0 -0.000128053880114
Gd16_19 0 n32 ni19 0 4.61466415895e-06
Gd16_20 0 n32 ni20 0 0.000813958276465
Gd16_21 0 n32 ni21 0 0.000210700617567
Gd16_22 0 n32 ni22 0 -0.00044335860735
Gd16_23 0 n32 ni23 0 0.000508101154287
Gd16_24 0 n32 ni24 0 -0.00176334581994
Gd16_25 0 n32 ni25 0 -0.00359269316114
Gd16_26 0 n32 ni26 0 -2.28590905134e-05
Gd16_27 0 n32 ni27 0 0.000623823335205
Gd16_28 0 n32 ni28 0 0.000228290043579
Gd16_29 0 n32 ni29 0 -0.000213794295012
Gd16_30 0 n32 ni30 0 0.000436928923413
Gd16_31 0 n32 ni31 0 0.000101946748482
Gd16_32 0 n32 ni32 0 0.000283507838408
Gc17_1 0 n34 ns1 0 0.000109421666557
Gc17_2 0 n34 ns2 0 0.000214373210979
Gc17_3 0 n34 ns3 0 0.00235040362174
Gc17_4 0 n34 ns4 0 0.0022002223931
Gc17_5 0 n34 ns5 0 0.000951679329827
Gc17_6 0 n34 ns6 0 -0.00206475817506
Gc17_7 0 n34 ns7 0 -0.000245656138437
Gc17_8 0 n34 ns8 0 0.000527442248358
Gc17_9 0 n34 ns9 0 0.000575703106303
Gc17_10 0 n34 ns10 0 -9.07376279388e-05
Gc17_11 0 n34 ns11 0 4.32116698899e-05
Gc17_12 0 n34 ns12 0 -0.000116309573358
Gc17_13 0 n34 ns13 0 0.00109924314906
Gc17_14 0 n34 ns14 0 -0.00104544790457
Gc17_15 0 n34 ns15 0 0.000258327772734
Gc17_16 0 n34 ns16 0 0.00160916182698
Gc17_17 0 n34 ns17 0 -0.000710313515461
Gc17_18 0 n34 ns18 0 0.000569948032151
Gc17_19 0 n34 ns19 0 -0.001903926641
Gc17_20 0 n34 ns20 0 -0.000390404638384
Gc17_21 0 n34 ns21 0 0.00407587501655
Gc17_22 0 n34 ns22 0 0.00260386531853
Gc17_23 0 n34 ns23 0 -0.00837376269955
Gc17_24 0 n34 ns24 0 0.00311177079155
Gc17_25 0 n34 ns25 0 -0.00601335359278
Gc17_26 0 n34 ns26 0 0.00202465656022
Gc17_27 0 n34 ns27 0 -0.0103284953411
Gc17_28 0 n34 ns28 0 4.61387942507e-05
Gc17_29 0 n34 ns29 0 0.00129072940107
Gc17_30 0 n34 ns30 0 0.000988447931419
Gc17_31 0 n34 ns31 0 -0.0035956471663
Gc17_32 0 n34 ns32 0 0.0108530548829
Gc17_33 0 n34 ns33 0 -0.0155895004199
Gc17_34 0 n34 ns34 0 -0.00068844465149
Gc17_35 0 n34 ns35 0 -0.0049074428137
Gc17_36 0 n34 ns36 0 -4.7478146692e-05
Gc17_37 0 n34 ns37 0 -0.000369538199902
Gc17_38 0 n34 ns38 0 0.000561745831455
Gc17_39 0 n34 ns39 0 0.00248240971412
Gc17_40 0 n34 ns40 0 -0.00368694378573
Gc17_41 0 n34 ns41 0 0.00494155804831
Gc17_42 0 n34 ns42 0 -0.00870218938319
Gc17_43 0 n34 ns43 0 -0.00376758824442
Gc17_44 0 n34 ns44 0 -0.00260130065843
Gc17_45 0 n34 ns45 0 0.00127129058519
Gc17_46 0 n34 ns46 0 0.000978234720446
Gc17_47 0 n34 ns47 0 -0.000358423898125
Gc17_48 0 n34 ns48 0 -0.000878490384083
Gc17_49 0 n34 ns49 0 -0.000114131712507
Gc17_50 0 n34 ns50 0 -0.000106249250658
Gc17_51 0 n34 ns51 0 -0.000992868352897
Gc17_52 0 n34 ns52 0 6.3141280985e-05
Gc17_53 0 n34 ns53 0 0.00167205486215
Gc17_54 0 n34 ns54 0 -3.98997744539e-05
Gc17_55 0 n34 ns55 0 0.000568578187262
Gc17_56 0 n34 ns56 0 0.000811144759377
Gc17_57 0 n34 ns57 0 0.000420537520609
Gc17_58 0 n34 ns58 0 0.00115508879826
Gc17_59 0 n34 ns59 0 0.000980703766844
Gc17_60 0 n34 ns60 0 -0.00413281673651
Gc17_61 0 n34 ns61 0 -0.000427421537238
Gc17_62 0 n34 ns62 0 -0.00482986793931
Gc17_63 0 n34 ns63 0 0.000358687066755
Gc17_64 0 n34 ns64 0 -0.00428071997937
Gc17_65 0 n34 ns65 0 0.00672524150291
Gc17_66 0 n34 ns66 0 0.0073988433926
Gc17_67 0 n34 ns67 0 0.00088876374462
Gc17_68 0 n34 ns68 0 -0.000280487588743
Gc17_69 0 n34 ns69 0 -0.00548686811445
Gc17_70 0 n34 ns70 0 -0.00358697296382
Gc17_71 0 n34 ns71 0 0.0010295278243
Gc17_72 0 n34 ns72 0 0.00888205606155
Gc17_73 0 n34 ns73 0 -0.00349451694701
Gc17_74 0 n34 ns74 0 5.27470856385e-06
Gc17_75 0 n34 ns75 0 0.000470854515157
Gc17_76 0 n34 ns76 0 -0.000308231462143
Gc17_77 0 n34 ns77 0 -0.000990125753677
Gc17_78 0 n34 ns78 0 0.000232251479601
Gc17_79 0 n34 ns79 0 -0.00303202794001
Gc17_80 0 n34 ns80 0 0.00113518187663
Gc17_81 0 n34 ns81 0 -0.000130432750213
Gc17_82 0 n34 ns82 0 0.000966964077148
Gc17_83 0 n34 ns83 0 0.000243550523863
Gc17_84 0 n34 ns84 0 -0.000411273154916
Gc17_85 0 n34 ns85 0 -0.000734058358954
Gc17_86 0 n34 ns86 0 -8.01142109094e-06
Gc17_87 0 n34 ns87 0 -0.000103835236464
Gc17_88 0 n34 ns88 0 -2.49870751098e-05
Gc17_89 0 n34 ns89 0 0.00104837231725
Gc17_90 0 n34 ns90 0 0.000338193685859
Gc17_91 0 n34 ns91 0 -0.000316328585075
Gc17_92 0 n34 ns92 0 -0.00114250549542
Gc17_93 0 n34 ns93 0 0.000458504061865
Gc17_94 0 n34 ns94 0 2.85222960621e-05
Gc17_95 0 n34 ns95 0 0.00029489904099
Gc17_96 0 n34 ns96 0 -0.000532465535171
Gc17_97 0 n34 ns97 0 -0.00252328237533
Gc17_98 0 n34 ns98 0 0.000153952899462
Gc17_99 0 n34 ns99 0 -0.00161552377826
Gc17_100 0 n34 ns100 0 0.00107508911139
Gc17_101 0 n34 ns101 0 -0.000784971748404
Gc17_102 0 n34 ns102 0 4.03104356508e-05
Gc17_103 0 n34 ns103 0 0.00194642345355
Gc17_104 0 n34 ns104 0 -0.00198277141723
Gc17_105 0 n34 ns105 0 0.00120830629421
Gc17_106 0 n34 ns106 0 -0.000683993507515
Gc17_107 0 n34 ns107 0 0.000491538518531
Gc17_108 0 n34 ns108 0 3.74914958274e-05
Gc17_109 0 n34 ns109 0 0.00271975711498
Gc17_110 0 n34 ns110 0 -0.00105886181493
Gc17_111 0 n34 ns111 0 -0.00226896582715
Gc17_112 0 n34 ns112 0 -9.48529105054e-06
Gc17_113 0 n34 ns113 0 0.000223491071746
Gc17_114 0 n34 ns114 0 -7.61958512055e-05
Gc17_115 0 n34 ns115 0 -0.000318331386543
Gc17_116 0 n34 ns116 0 -0.000203576637164
Gc17_117 0 n34 ns117 0 -0.0010100659308
Gc17_118 0 n34 ns118 0 0.000813253846634
Gc17_119 0 n34 ns119 0 -0.000340872960691
Gc17_120 0 n34 ns120 0 -0.000147465392613
Gc17_121 0 n34 ns121 0 7.3609231498e-05
Gc17_122 0 n34 ns122 0 -7.85184298517e-05
Gc17_123 0 n34 ns123 0 -0.000354042677617
Gc17_124 0 n34 ns124 0 0.000858327896828
Gc17_125 0 n34 ns125 0 -5.32886090179e-05
Gc17_126 0 n34 ns126 0 -2.80987078158e-06
Gc17_127 0 n34 ns127 0 0.000552068008827
Gc17_128 0 n34 ns128 0 -0.000859237286883
Gc17_129 0 n34 ns129 0 -0.000645391392299
Gc17_130 0 n34 ns130 0 0.000859431117301
Gc17_131 0 n34 ns131 0 0.000590975919397
Gc17_132 0 n34 ns132 0 0.00035981359092
Gc17_133 0 n34 ns133 0 0.000175605855756
Gc17_134 0 n34 ns134 0 0.000441356954092
Gc17_135 0 n34 ns135 0 -0.000298230252745
Gc17_136 0 n34 ns136 0 0.00107756227678
Gc17_137 0 n34 ns137 0 0.00185386172904
Gc17_138 0 n34 ns138 0 -0.00390865720557
Gc17_139 0 n34 ns139 0 0.00141899037326
Gc17_140 0 n34 ns140 0 -0.00404656495894
Gc17_141 0 n34 ns141 0 -0.00178468253268
Gc17_142 0 n34 ns142 0 -0.000115267130819
Gc17_143 0 n34 ns143 0 0.000462694389018
Gc17_144 0 n34 ns144 0 -0.00108070908758
Gc17_145 0 n34 ns145 0 0.00106619382308
Gc17_146 0 n34 ns146 0 -0.00200011322031
Gc17_147 0 n34 ns147 0 0.000944013678743
Gc17_148 0 n34 ns148 0 -0.00179817223234
Gc17_149 0 n34 ns149 0 -0.000985788675533
Gc17_150 0 n34 ns150 0 -3.61283344161e-05
Gc17_151 0 n34 ns151 0 0.000152032763574
Gc17_152 0 n34 ns152 0 -2.96456235452e-05
Gc17_153 0 n34 ns153 0 7.85601185203e-05
Gc17_154 0 n34 ns154 0 -0.000579077020724
Gc17_155 0 n34 ns155 0 0.000197591665333
Gc17_156 0 n34 ns156 0 -1.45581540642e-05
Gc17_157 0 n34 ns157 0 -8.23283023108e-06
Gc17_158 0 n34 ns158 0 -0.000104476818987
Gc17_159 0 n34 ns159 0 -7.37841518869e-05
Gc17_160 0 n34 ns160 0 0.000223639979035
Gc17_161 0 n34 ns161 0 0.000563587511295
Gc17_162 0 n34 ns162 0 0.000190902431965
Gc17_163 0 n34 ns163 0 -0.000160859990917
Gc17_164 0 n34 ns164 0 2.79706114715e-05
Gc17_165 0 n34 ns165 0 -0.000496020718134
Gc17_166 0 n34 ns166 0 0.000234127471614
Gc17_167 0 n34 ns167 0 0.000733439737073
Gc17_168 0 n34 ns168 0 0.000826239096406
Gc17_169 0 n34 ns169 0 0.00067838432799
Gc17_170 0 n34 ns170 0 -0.000298864122885
Gc17_171 0 n34 ns171 0 0.000535791865996
Gc17_172 0 n34 ns172 0 -0.000176132880839
Gc17_173 0 n34 ns173 0 0.000465778293354
Gc17_174 0 n34 ns174 0 -0.000299841169968
Gc17_175 0 n34 ns175 0 -0.00241274142226
Gc17_176 0 n34 ns176 0 -0.00586739796588
Gc17_177 0 n34 ns177 0 -0.00241776977383
Gc17_178 0 n34 ns178 0 -0.00521335101889
Gc17_179 0 n34 ns179 0 -0.000970058773039
Gc17_180 0 n34 ns180 0 0.00127742602692
Gc17_181 0 n34 ns181 0 -0.000118164500679
Gc17_182 0 n34 ns182 0 -0.000715926866658
Gc17_183 0 n34 ns183 0 -0.000272773575495
Gc17_184 0 n34 ns184 0 -0.00176649008505
Gc17_185 0 n34 ns185 0 0.000170143435147
Gc17_186 0 n34 ns186 0 -0.00087031249351
Gc17_187 0 n34 ns187 0 -0.000380143282681
Gc17_188 0 n34 ns188 0 2.24840274218e-07
Gc17_189 0 n34 ns189 0 4.43366646694e-05
Gc17_190 0 n34 ns190 0 1.85377509671e-05
Gc17_191 0 n34 ns191 0 -0.000274075717587
Gc17_192 0 n34 ns192 0 0.00052763293228
Gc17_193 0 n34 ns193 0 -0.000552952613989
Gc17_194 0 n34 ns194 0 0.000782541956833
Gc17_195 0 n34 ns195 0 -8.09359008067e-05
Gc17_196 0 n34 ns196 0 0.000346034939505
Gc17_197 0 n34 ns197 0 0.000163705152037
Gc17_198 0 n34 ns198 0 -0.000192118070979
Gc17_199 0 n34 ns199 0 0.000271737854282
Gc17_200 0 n34 ns200 0 -0.000413671902815
Gc17_201 0 n34 ns201 0 -6.45827901336e-05
Gc17_202 0 n34 ns202 0 0.000148209443472
Gc17_203 0 n34 ns203 0 0.000263461023317
Gc17_204 0 n34 ns204 0 0.000346718158265
Gc17_205 0 n34 ns205 0 0.000742491868938
Gc17_206 0 n34 ns206 0 -0.000498117032921
Gc17_207 0 n34 ns207 0 6.05530469287e-05
Gc17_208 0 n34 ns208 0 -0.000711333788456
Gc17_209 0 n34 ns209 0 1.85338927779e-05
Gc17_210 0 n34 ns210 0 -0.00072523229452
Gc17_211 0 n34 ns211 0 -0.00012210880123
Gc17_212 0 n34 ns212 0 -0.000478951690632
Gc17_213 0 n34 ns213 0 -0.00446553894791
Gc17_214 0 n34 ns214 0 -0.00181224350186
Gc17_215 0 n34 ns215 0 -0.00400559720341
Gc17_216 0 n34 ns216 0 -0.00150560982157
Gc17_217 0 n34 ns217 0 0.000217939081372
Gc17_218 0 n34 ns218 0 0.00146371744545
Gc17_219 0 n34 ns219 0 -0.00028374691528
Gc17_220 0 n34 ns220 0 -0.000410295131612
Gc17_221 0 n34 ns221 0 -0.000975840453846
Gc17_222 0 n34 ns222 0 -0.00130442050874
Gc17_223 0 n34 ns223 0 -0.000110685142353
Gc17_224 0 n34 ns224 0 -0.000716364274386
Gc17_225 0 n34 ns225 0 -0.00024104519712
Gc17_226 0 n34 ns226 0 -1.91415650634e-06
Gc17_227 0 n34 ns227 0 5.08337191119e-05
Gc17_228 0 n34 ns228 0 1.54457515115e-05
Gc17_229 0 n34 ns229 0 -0.000489599587777
Gc17_230 0 n34 ns230 0 0.000961527402092
Gc17_231 0 n34 ns231 0 -0.00133582385689
Gc17_232 0 n34 ns232 0 0.00133699431555
Gc17_233 0 n34 ns233 0 -0.000129241280257
Gc17_234 0 n34 ns234 0 0.000457195719804
Gc17_235 0 n34 ns235 0 4.78300898461e-05
Gc17_236 0 n34 ns236 0 -0.000303076708609
Gc17_237 0 n34 ns237 0 -0.000219307484796
Gc17_238 0 n34 ns238 0 1.1178606313e-05
Gc17_239 0 n34 ns239 0 0.000129014497883
Gc17_240 0 n34 ns240 0 7.12978191673e-05
Gc17_241 0 n34 ns241 0 0.000502808377908
Gc17_242 0 n34 ns242 0 -0.000451574653702
Gc17_243 0 n34 ns243 0 4.78851164846e-05
Gc17_244 0 n34 ns244 0 -0.000566765824644
Gc17_245 0 n34 ns245 0 -0.000280411115277
Gc17_246 0 n34 ns246 0 -0.000244312070295
Gc17_247 0 n34 ns247 0 -0.000289685765704
Gc17_248 0 n34 ns248 0 -0.00016760581243
Gc17_249 0 n34 ns249 0 -0.000569321464789
Gc17_250 0 n34 ns250 0 -7.79500255044e-05
Gc17_251 0 n34 ns251 0 -0.00323181257817
Gc17_252 0 n34 ns252 0 0.00104308790601
Gc17_253 0 n34 ns253 0 -0.00278507246562
Gc17_254 0 n34 ns254 0 0.000964595942912
Gc17_255 0 n34 ns255 0 0.0004070466217
Gc17_256 0 n34 ns256 0 0.000945698548981
Gc17_257 0 n34 ns257 0 -0.000205556851188
Gc17_258 0 n34 ns258 0 -0.00018838379701
Gc17_259 0 n34 ns259 0 -0.000715241657779
Gc17_260 0 n34 ns260 0 -0.000705164661059
Gc17_261 0 n34 ns261 0 -7.9971590847e-05
Gc17_262 0 n34 ns262 0 -0.000435757702781
Gc17_263 0 n34 ns263 0 -0.000146413666574
Gc17_264 0 n34 ns264 0 -1.45518121921e-05
Gc17_265 0 n34 ns265 0 4.7260205638e-05
Gc17_266 0 n34 ns266 0 3.10430666432e-06
Gc17_267 0 n34 ns267 0 0.000339874182727
Gc17_268 0 n34 ns268 0 -0.000225561215909
Gc17_269 0 n34 ns269 0 0.000885966571438
Gc17_270 0 n34 ns270 0 -0.000488391468985
Gc17_271 0 n34 ns271 0 0.000165990156091
Gc17_272 0 n34 ns272 0 -0.000237253771688
Gc17_273 0 n34 ns273 0 -0.0001311253966
Gc17_274 0 n34 ns274 0 0.000152259818801
Gc17_275 0 n34 ns275 0 -0.000138866841907
Gc17_276 0 n34 ns276 0 9.77970768953e-05
Gc17_277 0 n34 ns277 0 6.05022879017e-05
Gc17_278 0 n34 ns278 0 -4.21813163334e-05
Gc17_279 0 n34 ns279 0 -0.000136572608353
Gc17_280 0 n34 ns280 0 -0.000178735037743
Gc17_281 0 n34 ns281 0 -0.000360964728487
Gc17_282 0 n34 ns282 0 -2.36150891565e-05
Gc17_283 0 n34 ns283 0 -0.000262722115152
Gc17_284 0 n34 ns284 0 0.000131160558489
Gc17_285 0 n34 ns285 0 -0.000308746253283
Gc17_286 0 n34 ns286 0 0.000181342881722
Gc17_287 0 n34 ns287 0 -0.000185270331884
Gc17_288 0 n34 ns288 0 0.000116852372137
Gc17_289 0 n34 ns289 0 -0.000657480504032
Gc17_290 0 n34 ns290 0 0.00148535014776
Gc17_291 0 n34 ns291 0 -0.000554305317096
Gc17_292 0 n34 ns292 0 0.00130168976603
Gc17_293 0 n34 ns293 0 0.000487507461031
Gc17_294 0 n34 ns294 0 0.000214772908624
Gc17_295 0 n34 ns295 0 -0.000126610790474
Gc17_296 0 n34 ns296 0 -4.84595408316e-05
Gc17_297 0 n34 ns297 0 -0.000543221131643
Gc17_298 0 n34 ns298 0 -0.000160930856285
Gc17_299 0 n34 ns299 0 -7.4273593639e-05
Gc17_300 0 n34 ns300 0 -0.000234935570817
Gc17_301 0 n34 ns301 0 -9.17306112051e-05
Gc17_302 0 n34 ns302 0 -8.5344532481e-06
Gc17_303 0 n34 ns303 0 7.64035891984e-06
Gc17_304 0 n34 ns304 0 5.14793692914e-06
Gc17_305 0 n34 ns305 0 -0.000226229203909
Gc17_306 0 n34 ns306 0 0.000873045168431
Gc17_307 0 n34 ns307 0 -0.000302671638762
Gc17_308 0 n34 ns308 0 0.000707223165462
Gc17_309 0 n34 ns309 0 -0.000189182897172
Gc17_310 0 n34 ns310 0 0.000304000058178
Gc17_311 0 n34 ns311 0 0.000138500539467
Gc17_312 0 n34 ns312 0 -0.000130214874153
Gc17_313 0 n34 ns313 0 0.00021483644196
Gc17_314 0 n34 ns314 0 0.000283979255145
Gc17_315 0 n34 ns315 0 2.71280115508e-05
Gc17_316 0 n34 ns316 0 -0.00010039505687
Gc17_317 0 n34 ns317 0 -0.000270409298866
Gc17_318 0 n34 ns318 0 -0.000414410616772
Gc17_319 0 n34 ns319 0 -5.84690187525e-05
Gc17_320 0 n34 ns320 0 -0.00013252744173
Gc17_321 0 n34 ns321 0 2.86706031164e-05
Gc17_322 0 n34 ns322 0 -2.25675767991e-05
Gc17_323 0 n34 ns323 0 0.000128565342944
Gc17_324 0 n34 ns324 0 -6.01729027311e-05
Gc17_325 0 n34 ns325 0 -2.83058292802e-06
Gc17_326 0 n34 ns326 0 0.000453282386854
Gc17_327 0 n34 ns327 0 5.44001394175e-05
Gc17_328 0 n34 ns328 0 0.0017075963018
Gc17_329 0 n34 ns329 0 6.18736087722e-05
Gc17_330 0 n34 ns330 0 0.00144097602746
Gc17_331 0 n34 ns331 0 0.000624604398124
Gc17_332 0 n34 ns332 0 0.000407714545984
Gc17_333 0 n34 ns333 0 -0.000112959446223
Gc17_334 0 n34 ns334 0 -7.30435158552e-05
Gc17_335 0 n34 ns335 0 -0.000577799559624
Gc17_336 0 n34 ns336 0 -0.000443801256024
Gc17_337 0 n34 ns337 0 -0.000133680347855
Gc17_338 0 n34 ns338 0 -0.000756879263275
Gc17_339 0 n34 ns339 0 -0.00021162953007
Gc17_340 0 n34 ns340 0 -1.03290127898e-05
Gc17_341 0 n34 ns341 0 4.57321869714e-05
Gc17_342 0 n34 ns342 0 -3.13839868123e-05
Gc17_343 0 n34 ns343 0 -0.00105366538786
Gc17_344 0 n34 ns344 0 -0.000298833723471
Gc17_345 0 n34 ns345 0 -0.00425068777867
Gc17_346 0 n34 ns346 0 -0.00172289736007
Gc17_347 0 n34 ns347 0 -0.00182519174054
Gc17_348 0 n34 ns348 0 0.00121090052456
Gc17_349 0 n34 ns349 0 0.000904638919181
Gc17_350 0 n34 ns350 0 -0.000418463004682
Gc17_351 0 n34 ns351 0 -0.000666117539856
Gc17_352 0 n34 ns352 0 -0.000241045885028
Gc17_353 0 n34 ns353 0 -8.56109187244e-05
Gc17_354 0 n34 ns354 0 -5.44248695043e-05
Gc17_355 0 n34 ns355 0 0.000746115894729
Gc17_356 0 n34 ns356 0 0.000518664123095
Gc17_357 0 n34 ns357 0 0.000665953944363
Gc17_358 0 n34 ns358 0 -0.00146083943893
Gc17_359 0 n34 ns359 0 0.000697354864984
Gc17_360 0 n34 ns360 0 9.24983247215e-05
Gc17_361 0 n34 ns361 0 0.000805957524688
Gc17_362 0 n34 ns362 0 -0.000336467207128
Gc17_363 0 n34 ns363 0 -0.00250268673247
Gc17_364 0 n34 ns364 0 -0.00105989767783
Gc17_365 0 n34 ns365 0 -0.00287593791041
Gc17_366 0 n34 ns366 0 0.000773351610426
Gc17_367 0 n34 ns367 0 -0.00164275296711
Gc17_368 0 n34 ns368 0 -5.48015342914e-05
Gc17_369 0 n34 ns369 0 0.00415177283467
Gc17_370 0 n34 ns370 0 0.000145223373664
Gc17_371 0 n34 ns371 0 0.00122900063385
Gc17_372 0 n34 ns372 0 -0.000541604952271
Gc17_373 0 n34 ns373 0 -0.00135354699619
Gc17_374 0 n34 ns374 0 -0.000723114939637
Gc17_375 0 n34 ns375 0 0.00270387366715
Gc17_376 0 n34 ns376 0 0.00136876709267
Gc17_377 0 n34 ns377 0 -0.00285455831945
Gc17_378 0 n34 ns378 0 -3.82365588395e-05
Gc17_379 0 n34 ns379 0 0.000371985216245
Gc17_380 0 n34 ns380 0 -0.000193731399241
Gc17_381 0 n34 ns381 0 -0.000397946980003
Gc17_382 0 n34 ns382 0 9.83915616931e-05
Gc17_383 0 n34 ns383 0 -0.00114737389314
Gc17_384 0 n34 ns384 0 0.0015101743171
Gc17_385 0 n34 ns385 0 -7.76843394313e-05
Gc17_386 0 n34 ns386 0 0.000126294859246
Gc17_387 0 n34 ns387 0 8.21602280909e-05
Gc17_388 0 n34 ns388 0 -0.000265598841057
Gc17_389 0 n34 ns389 0 -0.000694635690963
Gc17_390 0 n34 ns390 0 0.000663531114476
Gc17_391 0 n34 ns391 0 -4.06198407762e-05
Gc17_392 0 n34 ns392 0 -1.37132745669e-05
Gc17_393 0 n34 ns393 0 0.000975808739617
Gc17_394 0 n34 ns394 0 -0.000784638155588
Gc17_395 0 n34 ns395 0 -0.00102054587473
Gc17_396 0 n34 ns396 0 8.51812795223e-05
Gc17_397 0 n34 ns397 0 0.000446664008229
Gc17_398 0 n34 ns398 0 0.000291722081599
Gc17_399 0 n34 ns399 0 3.63931936125e-06
Gc17_400 0 n34 ns400 0 8.96040550783e-05
Gc17_401 0 n34 ns401 0 -0.000973942694671
Gc17_402 0 n34 ns402 0 0.00135809323235
Gc17_403 0 n34 ns403 0 0.00215249220883
Gc17_404 0 n34 ns404 0 -0.00150651072152
Gc17_405 0 n34 ns405 0 0.00188664501704
Gc17_406 0 n34 ns406 0 -0.00218066874282
Gc17_407 0 n34 ns407 0 -0.000916986825934
Gc17_408 0 n34 ns408 0 -0.000871781041251
Gc17_409 0 n34 ns409 0 0.000708378704503
Gc17_410 0 n34 ns410 0 -0.00107597427653
Gc17_411 0 n34 ns411 0 0.00108726455324
Gc17_412 0 n34 ns412 0 -0.00162059993231
Gc17_413 0 n34 ns413 0 0.00138758113037
Gc17_414 0 n34 ns414 0 -0.00215557343666
Gc17_415 0 n34 ns415 0 -0.00140345597684
Gc17_416 0 n34 ns416 0 -3.13715572513e-05
Gc17_417 0 n34 ns417 0 0.000132784761
Gc17_418 0 n34 ns418 0 -1.2376659119e-05
Gc17_419 0 n34 ns419 0 -0.000164397341858
Gc17_420 0 n34 ns420 0 -0.000393253974252
Gc17_421 0 n34 ns421 0 -0.000531853878405
Gc17_422 0 n34 ns422 0 0.000590422950349
Gc17_423 0 n34 ns423 0 -0.000203398072561
Gc17_424 0 n34 ns424 0 -2.94564171684e-05
Gc17_425 0 n34 ns425 0 -6.8782128503e-05
Gc17_426 0 n34 ns426 0 0.000116238404156
Gc17_427 0 n34 ns427 0 0.00036691805478
Gc17_428 0 n34 ns428 0 0.000687885563235
Gc17_429 0 n34 ns429 0 -0.000117073851608
Gc17_430 0 n34 ns430 0 -2.75038542673e-05
Gc17_431 0 n34 ns431 0 -0.00035377389015
Gc17_432 0 n34 ns432 0 -0.000374980462164
Gc17_433 0 n34 ns433 0 0.000386662519721
Gc17_434 0 n34 ns434 0 0.00116274142124
Gc17_435 0 n34 ns435 0 0.000853239586762
Gc17_436 0 n34 ns436 0 -1.30409631877e-05
Gc17_437 0 n34 ns437 0 0.000656052307454
Gc17_438 0 n34 ns438 0 0.000159396017084
Gc17_439 0 n34 ns439 0 0.000394477073529
Gc17_440 0 n34 ns440 0 0.000196375869517
Gc17_441 0 n34 ns441 0 -0.000944587514229
Gc17_442 0 n34 ns442 0 -0.00619033086554
Gc17_443 0 n34 ns443 0 -0.00116259641942
Gc17_444 0 n34 ns444 0 -0.00566875137587
Gc17_445 0 n34 ns445 0 -0.00144535354619
Gc17_446 0 n34 ns446 0 0.00105061715101
Gc17_447 0 n34 ns447 0 2.96016450404e-05
Gc17_448 0 n34 ns448 0 -0.0008818397351
Gc17_449 0 n34 ns449 0 0.000160572046444
Gc17_450 0 n34 ns450 0 -0.00201534762145
Gc17_451 0 n34 ns451 0 0.000373314840623
Gc17_452 0 n34 ns452 0 -0.00113623373928
Gc17_453 0 n34 ns453 0 -0.000534339160886
Gc17_454 0 n34 ns454 0 -6.76093402482e-06
Gc17_455 0 n34 ns455 0 7.65650631802e-05
Gc17_456 0 n34 ns456 0 -9.90124985098e-07
Gc17_457 0 n34 ns457 0 -8.01466871485e-05
Gc17_458 0 n34 ns458 0 6.32864257238e-07
Gc17_459 0 n34 ns459 0 2.04044318133e-05
Gc17_460 0 n34 ns460 0 0.000344303230307
Gc17_461 0 n34 ns461 0 -3.53904848217e-05
Gc17_462 0 n34 ns462 0 0.000128936032448
Gc17_463 0 n34 ns463 0 0.000129955097718
Gc17_464 0 n34 ns464 0 1.95435045878e-05
Gc17_465 0 n34 ns465 0 0.000532304872184
Gc17_466 0 n34 ns466 0 -0.000329103472578
Gc17_467 0 n34 ns467 0 -0.000149687550102
Gc17_468 0 n34 ns468 0 0.00011713311538
Gc17_469 0 n34 ns469 0 -9.9780005356e-05
Gc17_470 0 n34 ns470 0 0.000546550031606
Gc17_471 0 n34 ns471 0 0.000927843656213
Gc17_472 0 n34 ns472 0 -9.99511402002e-05
Gc17_473 0 n34 ns473 0 0.000313624882039
Gc17_474 0 n34 ns474 0 -0.000720406042175
Gc17_475 0 n34 ns475 0 0.000237172039381
Gc17_476 0 n34 ns476 0 -0.000723632638808
Gc17_477 0 n34 ns477 0 0.000155997161634
Gc17_478 0 n34 ns478 0 -0.000562504790781
Gc17_479 0 n34 ns479 0 -0.00426796638325
Gc17_480 0 n34 ns480 0 -0.00353199116115
Gc17_481 0 n34 ns481 0 -0.00392058578278
Gc17_482 0 n34 ns482 0 -0.003031434782
Gc17_483 0 n34 ns483 0 -0.000146002367719
Gc17_484 0 n34 ns484 0 0.00155494160342
Gc17_485 0 n34 ns485 0 -0.000249495246011
Gc17_486 0 n34 ns486 0 -0.000517965756357
Gc17_487 0 n34 ns487 0 -0.000783319047801
Gc17_488 0 n34 ns488 0 -0.00157569019502
Gc17_489 0 n34 ns489 0 -5.67029702729e-05
Gc17_490 0 n34 ns490 0 -0.000948191760619
Gc17_491 0 n34 ns491 0 -0.000317038859877
Gc17_492 0 n34 ns492 0 -2.40978355572e-06
Gc17_493 0 n34 ns493 0 6.94348655155e-05
Gc17_494 0 n34 ns494 0 8.01491571843e-06
Gc17_495 0 n34 ns495 0 -0.000703645138323
Gc17_496 0 n34 ns496 0 0.0013020967138
Gc17_497 0 n34 ns497 0 -0.00179625784628
Gc17_498 0 n34 ns498 0 0.00184589261776
Gc17_499 0 n34 ns499 0 -0.000243104909054
Gc17_500 0 n34 ns500 0 0.000688379174923
Gc17_501 0 n34 ns501 0 0.000172620133657
Gc17_502 0 n34 ns502 0 -0.000439758119303
Gc17_503 0 n34 ns503 0 -5.96983323271e-05
Gc17_504 0 n34 ns504 0 -0.000112842584205
Gc17_505 0 n34 ns505 0 9.34526943426e-05
Gc17_506 0 n34 ns506 0 0.000114583122474
Gc17_507 0 n34 ns507 0 0.000588757977328
Gc17_508 0 n34 ns508 0 -0.0003534393341
Gc17_509 0 n34 ns509 0 0.000347443130139
Gc17_510 0 n34 ns510 0 -0.00074285918037
Gc17_511 0 n34 ns511 0 -0.000192391403876
Gc17_512 0 n34 ns512 0 -0.000484807496311
Gc17_513 0 n34 ns513 0 -0.000179781265167
Gc17_514 0 n34 ns514 0 -0.00043388538286
Gc17_515 0 n34 ns515 0 -0.000558548496761
Gc17_516 0 n34 ns516 0 -0.000159095847485
Gc17_517 0 n34 ns517 0 -0.00418175046677
Gc17_518 0 n34 ns518 0 0.00047936636455
Gc17_519 0 n34 ns519 0 -0.00363992553891
Gc17_520 0 n34 ns520 0 0.000483936914455
Gc17_521 0 n34 ns521 0 0.000435859328486
Gc17_522 0 n34 ns522 0 0.00132572492721
Gc17_523 0 n34 ns523 0 -0.000254232750681
Gc17_524 0 n34 ns524 0 -0.000276285594091
Gc17_525 0 n34 ns525 0 -0.000879980152828
Gc17_526 0 n34 ns526 0 -0.00105388351039
Gc17_527 0 n34 ns527 0 -0.000120889152725
Gc17_528 0 n34 ns528 0 -0.000688936328207
Gc17_529 0 n34 ns529 0 -0.00020923405281
Gc17_530 0 n34 ns530 0 2.45386381412e-06
Gc17_531 0 n34 ns531 0 6.66819470514e-05
Gc17_532 0 n34 ns532 0 -7.10935263414e-06
Gc17_533 0 n34 ns533 0 0.000301863293242
Gc17_534 0 n34 ns534 0 -0.000316277890873
Gc17_535 0 n34 ns535 0 0.000707646570614
Gc17_536 0 n34 ns536 0 -0.000513303001077
Gc17_537 0 n34 ns537 0 0.00016943575268
Gc17_538 0 n34 ns538 0 -0.000219699036757
Gc17_539 0 n34 ns539 0 -0.000150718704602
Gc17_540 0 n34 ns540 0 0.000100034637983
Gc17_541 0 n34 ns541 0 -0.000269341016352
Gc17_542 0 n34 ns542 0 -3.76780177079e-06
Gc17_543 0 n34 ns543 0 8.46149069949e-05
Gc17_544 0 n34 ns544 0 9.85831565483e-06
Gc17_545 0 n34 ns545 0 7.11824269785e-05
Gc17_546 0 n34 ns546 0 -0.000152456219243
Gc17_547 0 n34 ns547 0 -0.00036790414471
Gc17_548 0 n34 ns548 0 -0.000117299764303
Gc17_549 0 n34 ns549 0 -0.000367324661792
Gc17_550 0 n34 ns550 0 9.58159688855e-05
Gc17_551 0 n34 ns551 0 -0.000454824733633
Gc17_552 0 n34 ns552 0 0.000182682506188
Gc17_553 0 n34 ns553 0 -0.000340720260173
Gc17_554 0 n34 ns554 0 -4.03983073403e-05
Gc17_555 0 n34 ns555 0 -0.00148976670414
Gc17_556 0 n34 ns556 0 0.0013027688986
Gc17_557 0 n34 ns557 0 -0.00127321845397
Gc17_558 0 n34 ns558 0 0.00117088748026
Gc17_559 0 n34 ns559 0 0.000429107353885
Gc17_560 0 n34 ns560 0 0.000332712485523
Gc17_561 0 n34 ns561 0 -0.000144701141815
Gc17_562 0 n34 ns562 0 -7.23948403142e-05
Gc17_563 0 n34 ns563 0 -0.000564753418811
Gc17_564 0 n34 ns564 0 -0.000213432785786
Gc17_565 0 n34 ns565 0 -6.80192590318e-05
Gc17_566 0 n34 ns566 0 -0.000135978158999
Gc17_567 0 n34 ns567 0 -6.77647275935e-05
Gc17_568 0 n34 ns568 0 -1.11647852438e-05
Gc17_569 0 n34 ns569 0 1.89255085164e-05
Gc17_570 0 n34 ns570 0 8.66438319385e-06
Gc17_571 0 n34 ns571 0 0.00010915666275
Gc17_572 0 n34 ns572 0 0.000550813384981
Gc17_573 0 n34 ns573 0 0.000637549182287
Gc17_574 0 n34 ns574 0 0.000764974956205
Gc17_575 0 n34 ns575 0 5.71977087471e-05
Gc17_576 0 n34 ns576 0 0.00025026019605
Gc17_577 0 n34 ns577 0 -1.6952612467e-05
Gc17_578 0 n34 ns578 0 -9.77682736268e-05
Gc17_579 0 n34 ns579 0 0.000196626627562
Gc17_580 0 n34 ns580 0 0.000249050658593
Gc17_581 0 n34 ns581 0 3.88212497754e-05
Gc17_582 0 n34 ns582 0 -0.000114442600528
Gc17_583 0 n34 ns583 0 -0.000403031981154
Gc17_584 0 n34 ns584 0 -0.000461766202152
Gc17_585 0 n34 ns585 0 -0.000193584838984
Gc17_586 0 n34 ns586 0 -0.000200889993989
Gc17_587 0 n34 ns587 0 -5.04072883595e-05
Gc17_588 0 n34 ns588 0 -4.15570410266e-05
Gc17_589 0 n34 ns589 0 4.32599567833e-05
Gc17_590 0 n34 ns590 0 -0.000114577827338
Gc17_591 0 n34 ns591 0 5.48146685237e-05
Gc17_592 0 n34 ns592 0 0.000541237836322
Gc17_593 0 n34 ns593 0 8.24937293878e-05
Gc17_594 0 n34 ns594 0 0.00220431576963
Gc17_595 0 n34 ns595 0 8.07703543863e-05
Gc17_596 0 n34 ns596 0 0.00186348670552
Gc17_597 0 n34 ns597 0 0.000874962961166
Gc17_598 0 n34 ns598 0 0.000467303513433
Gc17_599 0 n34 ns599 0 -0.00015158367391
Gc17_600 0 n34 ns600 0 -8.2424437449e-05
Gc17_601 0 n34 ns601 0 -0.000807206387399
Gc17_602 0 n34 ns602 0 -0.000518053670534
Gc17_603 0 n34 ns603 0 -0.000209982105403
Gc17_604 0 n34 ns604 0 -0.000869538384578
Gc17_605 0 n34 ns605 0 -0.000230217807961
Gc17_606 0 n34 ns606 0 1.13894777325e-05
Gc17_607 0 n34 ns607 0 -3.5707170319e-05
Gc17_608 0 n34 ns608 0 2.21896520124e-05
Gc17_609 0 n34 ns609 0 0.00144890415286
Gc17_610 0 n34 ns610 0 -0.00496766744369
Gc17_611 0 n34 ns611 0 0.000416169488233
Gc17_612 0 n34 ns612 0 -0.00385674710374
Gc17_613 0 n34 ns613 0 -0.000403486063178
Gc17_614 0 n34 ns614 0 -0.000462428766948
Gc17_615 0 n34 ns615 0 0.000485630568689
Gc17_616 0 n34 ns616 0 -5.07990359094e-05
Gc17_617 0 n34 ns617 0 -0.000183981931125
Gc17_618 0 n34 ns618 0 0.000247195980427
Gc17_619 0 n34 ns619 0 5.72819219704e-06
Gc17_620 0 n34 ns620 0 4.62549196638e-05
Gc17_621 0 n34 ns621 0 -0.00123811005295
Gc17_622 0 n34 ns622 0 0.000116385204309
Gc17_623 0 n34 ns623 0 0.000471345670027
Gc17_624 0 n34 ns624 0 0.00046869685555
Gc17_625 0 n34 ns625 0 -0.000256891383122
Gc17_626 0 n34 ns626 0 0.000219941015144
Gc17_627 0 n34 ns627 0 -0.000780642257948
Gc17_628 0 n34 ns628 0 -0.000574810168453
Gc17_629 0 n34 ns629 0 -0.000953812099609
Gc17_630 0 n34 ns630 0 0.000753525104366
Gc17_631 0 n34 ns631 0 0.00757513168575
Gc17_632 0 n34 ns632 0 0.00310655172031
Gc17_633 0 n34 ns633 0 0.00542137574233
Gc17_634 0 n34 ns634 0 0.0028710407966
Gc17_635 0 n34 ns635 0 0.00304221865685
Gc17_636 0 n34 ns636 0 0.00664458655738
Gc17_637 0 n34 ns637 0 0.000507901526417
Gc17_638 0 n34 ns638 0 1.52506419039e-05
Gc17_639 0 n34 ns639 0 -0.00788936179724
Gc17_640 0 n34 ns640 0 -0.000404714794064
Gc17_641 0 n34 ns641 0 0.00472564568074
Gc17_642 0 n34 ns642 0 -0.00729811652148
Gc17_643 0 n34 ns643 0 0.00367318229321
Gc17_644 0 n34 ns644 0 -1.83045919456e-05
Gc17_645 0 n34 ns645 0 -6.88574647859e-05
Gc17_646 0 n34 ns646 0 -6.87920426542e-06
Gc17_647 0 n34 ns647 0 0.00210299403301
Gc17_648 0 n34 ns648 0 -0.00580031427563
Gc17_649 0 n34 ns649 0 0.00192437109506
Gc17_650 0 n34 ns650 0 -0.00441256372849
Gc17_651 0 n34 ns651 0 -0.000784701702995
Gc17_652 0 n34 ns652 0 -0.00103493506686
Gc17_653 0 n34 ns653 0 0.000582913028345
Gc17_654 0 n34 ns654 0 0.000171901413107
Gc17_655 0 n34 ns655 0 -0.00013695320187
Gc17_656 0 n34 ns656 0 0.000387791341886
Gc17_657 0 n34 ns657 0 3.58364358814e-05
Gc17_658 0 n34 ns658 0 8.51255584662e-05
Gc17_659 0 n34 ns659 0 -0.000901704495275
Gc17_660 0 n34 ns660 0 0.000342800103012
Gc17_661 0 n34 ns661 0 0.000433021670529
Gc17_662 0 n34 ns662 0 3.72976354253e-06
Gc17_663 0 n34 ns663 0 -7.09876505319e-05
Gc17_664 0 n34 ns664 0 0.000185272788896
Gc17_665 0 n34 ns665 0 -0.000498695612792
Gc17_666 0 n34 ns666 0 -0.000625772200811
Gc17_667 0 n34 ns667 0 -0.000517948819113
Gc17_668 0 n34 ns668 0 0.00108282645399
Gc17_669 0 n34 ns669 0 0.0060364950968
Gc17_670 0 n34 ns670 0 0.00357828868702
Gc17_671 0 n34 ns671 0 0.00408046693085
Gc17_672 0 n34 ns672 0 0.00336592451855
Gc17_673 0 n34 ns673 0 0.00335973240784
Gc17_674 0 n34 ns674 0 0.0062345357179
Gc17_675 0 n34 ns675 0 0.000736272202433
Gc17_676 0 n34 ns676 0 -0.000154728146584
Gc17_677 0 n34 ns677 0 -0.00744834218382
Gc17_678 0 n34 ns678 0 -0.00095597222302
Gc17_679 0 n34 ns679 0 0.00386042887118
Gc17_680 0 n34 ns680 0 -0.00789525083493
Gc17_681 0 n34 ns681 0 0.00389666048779
Gc17_682 0 n34 ns682 0 1.31780911161e-05
Gc17_683 0 n34 ns683 0 -0.000122129002848
Gc17_684 0 n34 ns684 0 1.22170233356e-05
Gc17_685 0 n34 ns685 0 0.000650603501192
Gc17_686 0 n34 ns686 0 -0.00188734728903
Gc17_687 0 n34 ns687 0 0.0012930019786
Gc17_688 0 n34 ns688 0 -0.00165064418269
Gc17_689 0 n34 ns689 0 -0.00100781468709
Gc17_690 0 n34 ns690 0 -0.000208042944744
Gc17_691 0 n34 ns691 0 0.000163347281532
Gc17_692 0 n34 ns692 0 -0.000137001888431
Gc17_693 0 n34 ns693 0 0.000516709826904
Gc17_694 0 n34 ns694 0 0.000330279067661
Gc17_695 0 n34 ns695 0 0.000134505046889
Gc17_696 0 n34 ns696 0 0.000106377700887
Gc17_697 0 n34 ns697 0 0.000377591570296
Gc17_698 0 n34 ns698 0 0.000411798154316
Gc17_699 0 n34 ns699 0 -0.000234341147363
Gc17_700 0 n34 ns700 0 -0.00150503714027
Gc17_701 0 n34 ns701 0 0.000579527479015
Gc17_702 0 n34 ns702 0 -0.000109240701967
Gc17_703 0 n34 ns703 0 0.000568287466637
Gc17_704 0 n34 ns704 0 -0.0006216606847
Gc17_705 0 n34 ns705 0 0.00227167005972
Gc17_706 0 n34 ns706 0 0.00124428594773
Gc17_707 0 n34 ns707 0 -0.000634996395244
Gc17_708 0 n34 ns708 0 0.00177604105549
Gc17_709 0 n34 ns709 0 -0.00104006397809
Gc17_710 0 n34 ns710 0 0.0022752131706
Gc17_711 0 n34 ns711 0 0.00230432345456
Gc17_712 0 n34 ns712 0 -0.00298120727804
Gc17_713 0 n34 ns713 0 0.00117261421781
Gc17_714 0 n34 ns714 0 -0.000573725609698
Gc17_715 0 n34 ns715 0 0.000130500849025
Gc17_716 0 n34 ns716 0 0.000604846273589
Gc17_717 0 n34 ns717 0 -0.00310216337424
Gc17_718 0 n34 ns718 0 0.00211209483142
Gc17_719 0 n34 ns719 0 0.0026125830587
Gc17_720 0 n34 ns720 0 2.35823109829e-05
Gc17_721 0 n34 ns721 0 -0.000179230538814
Gc17_722 0 n34 ns722 0 3.26182691472e-05
Gc17_723 0 n34 ns723 0 0.000103017188041
Gc17_724 0 n34 ns724 0 -0.000422621240529
Gc17_725 0 n34 ns725 0 0.000371578106136
Gc17_726 0 n34 ns726 0 0.000382146180384
Gc17_727 0 n34 ns727 0 0.000137593214402
Gc17_728 0 n34 ns728 0 0.000220590452795
Gc17_729 0 n34 ns729 0 7.42669335577e-06
Gc17_730 0 n34 ns730 0 0.00012040843617
Gc17_731 0 n34 ns731 0 0.000243752240988
Gc17_732 0 n34 ns732 0 -0.000592612882038
Gc17_733 0 n34 ns733 0 0.00015746110312
Gc17_734 0 n34 ns734 0 3.64374268798e-05
Gc17_735 0 n34 ns735 0 -9.84634243184e-05
Gc17_736 0 n34 ns736 0 -0.000270434902578
Gc17_737 0 n34 ns737 0 -0.00122237298747
Gc17_738 0 n34 ns738 0 0.000786637390037
Gc17_739 0 n34 ns739 0 0.000248347637609
Gc17_740 0 n34 ns740 0 0.000136858309021
Gc17_741 0 n34 ns741 0 -0.000371097934765
Gc17_742 0 n34 ns742 0 -0.000171066101462
Gc17_743 0 n34 ns743 0 0.000143278131442
Gc17_744 0 n34 ns744 0 -0.00180419878673
Gc17_745 0 n34 ns745 0 -0.00177357636474
Gc17_746 0 n34 ns746 0 0.00222340629917
Gc17_747 0 n34 ns747 0 -0.0013763142207
Gc17_748 0 n34 ns748 0 0.00267511983835
Gc17_749 0 n34 ns749 0 -0.00262057252552
Gc17_750 0 n34 ns750 0 -0.00124578092071
Gc17_751 0 n34 ns751 0 0.000515789740892
Gc17_752 0 n34 ns752 0 -0.000939020681409
Gc17_753 0 n34 ns753 0 0.00134969938668
Gc17_754 0 n34 ns754 0 -0.000756071254687
Gc17_755 0 n34 ns755 0 -0.000648293067
Gc17_756 0 n34 ns756 0 0.00228012426108
Gc17_757 0 n34 ns757 0 0.00110384800826
Gc17_758 0 n34 ns758 0 3.20072251632e-05
Gc17_759 0 n34 ns759 0 -0.000330223609834
Gc17_760 0 n34 ns760 0 0.000131528746383
Gc17_761 0 n34 ns761 0 -1.11341880861e-05
Gc17_762 0 n34 ns762 0 -0.000506993615597
Gc17_763 0 n34 ns763 0 -0.000109137024017
Gc17_764 0 n34 ns764 0 6.73930410892e-05
Gc17_765 0 n34 ns765 0 0.000174069485247
Gc17_766 0 n34 ns766 0 -0.000131426354243
Gc17_767 0 n34 ns767 0 -8.33342477228e-06
Gc17_768 0 n34 ns768 0 -8.53052956995e-05
Gc17_769 0 n34 ns769 0 -0.00053915533461
Gc17_770 0 n34 ns770 0 -0.000290388856068
Gc17_771 0 n34 ns771 0 0.000129282495118
Gc17_772 0 n34 ns772 0 -6.33180696548e-05
Gc17_773 0 n34 ns773 0 -3.83222227162e-05
Gc17_774 0 n34 ns774 0 0.000261680513603
Gc17_775 0 n34 ns775 0 0.000761292528066
Gc17_776 0 n34 ns776 0 0.00102556090409
Gc17_777 0 n34 ns777 0 0.000590603700423
Gc17_778 0 n34 ns778 0 -0.000149756824584
Gc17_779 0 n34 ns779 0 0.000280692504298
Gc17_780 0 n34 ns780 0 0.00013266585957
Gc17_781 0 n34 ns781 0 -0.00114929842384
Gc17_782 0 n34 ns782 0 3.50173225603e-06
Gc17_783 0 n34 ns783 0 0.000854791843715
Gc17_784 0 n34 ns784 0 0.00424022166681
Gc17_785 0 n34 ns785 0 0.00114188622643
Gc17_786 0 n34 ns786 0 0.00386589824904
Gc17_787 0 n34 ns787 0 -0.0010757441864
Gc17_788 0 n34 ns788 0 0.000986827530891
Gc17_789 0 n34 ns789 0 -0.000107176999338
Gc17_790 0 n34 ns790 0 -0.0006742900112
Gc17_791 0 n34 ns791 0 -0.000249802168931
Gc17_792 0 n34 ns792 0 -0.00143727313097
Gc17_793 0 n34 ns793 0 -0.000404912226191
Gc17_794 0 n34 ns794 0 0.000388474322367
Gc17_795 0 n34 ns795 0 0.000327394227311
Gc17_796 0 n34 ns796 0 -2.08400541459e-05
Gc17_797 0 n34 ns797 0 -0.000100602642349
Gc17_798 0 n34 ns798 0 -1.17791608506e-05
Gc17_799 0 n34 ns799 0 -4.05596292418e-06
Gc17_800 0 n34 ns800 0 0.000257842484682
Gc17_801 0 n34 ns801 0 -2.36042239303e-05
Gc17_802 0 n34 ns802 0 0.000853988599328
Gc17_803 0 n34 ns803 0 4.57242154723e-05
Gc17_804 0 n34 ns804 0 -3.92792942229e-05
Gc17_805 0 n34 ns805 0 -0.000154984064876
Gc17_806 0 n34 ns806 0 3.61955515832e-05
Gc17_807 0 n34 ns807 0 -0.000302216762187
Gc17_808 0 n34 ns808 0 0.000446837020918
Gc17_809 0 n34 ns809 0 5.97070004002e-05
Gc17_810 0 n34 ns810 0 -0.000114926238795
Gc17_811 0 n34 ns811 0 0.00028368004872
Gc17_812 0 n34 ns812 0 -0.000316917520787
Gc17_813 0 n34 ns813 0 0.000925173330893
Gc17_814 0 n34 ns814 0 -0.000689291155605
Gc17_815 0 n34 ns815 0 0.000244878624796
Gc17_816 0 n34 ns816 0 -0.000757789015163
Gc17_817 0 n34 ns817 0 0.000437451192236
Gc17_818 0 n34 ns818 0 -0.000735519109048
Gc17_819 0 n34 ns819 0 0.000138129078619
Gc17_820 0 n34 ns820 0 0.0011658527643
Gc17_821 0 n34 ns821 0 0.00365453565128
Gc17_822 0 n34 ns822 0 0.00292755885721
Gc17_823 0 n34 ns823 0 0.00334071559907
Gc17_824 0 n34 ns824 0 0.002390803011
Gc17_825 0 n34 ns825 0 0.000793244826791
Gc17_826 0 n34 ns826 0 0.000987901277442
Gc17_827 0 n34 ns827 0 -0.000356205515607
Gc17_828 0 n34 ns828 0 -0.0003535694723
Gc17_829 0 n34 ns829 0 -0.0015075795717
Gc17_830 0 n34 ns830 0 -0.000947128644515
Gc17_831 0 n34 ns831 0 -0.000558389765136
Gc17_832 0 n34 ns832 0 -0.000192495349896
Gc17_833 0 n34 ns833 0 0.000110222966065
Gc17_834 0 n34 ns834 0 1.47088238797e-05
Gc17_835 0 n34 ns835 0 -7.68887969306e-05
Gc17_836 0 n34 ns836 0 6.636898086e-06
Gc17_837 0 n34 ns837 0 0.000447215367466
Gc17_838 0 n34 ns838 0 5.14303291097e-05
Gc17_839 0 n34 ns839 0 0.00143361727706
Gc17_840 0 n34 ns840 0 -8.02575597785e-05
Gc17_841 0 n34 ns841 0 0.000112065152922
Gc17_842 0 n34 ns842 0 -6.84708218819e-05
Gc17_843 0 n34 ns843 0 -3.57819574102e-05
Gc17_844 0 n34 ns844 0 0.000108523917543
Gc17_845 0 n34 ns845 0 0.000261528375432
Gc17_846 0 n34 ns846 0 0.000167117073295
Gc17_847 0 n34 ns847 0 -5.96211566534e-05
Gc17_848 0 n34 ns848 0 -6.74142154772e-05
Gc17_849 0 n34 ns849 0 -0.00031023987414
Gc17_850 0 n34 ns850 0 -0.000222584621993
Gc17_851 0 n34 ns851 0 -0.000288798331504
Gc17_852 0 n34 ns852 0 -0.000676502166559
Gc17_853 0 n34 ns853 0 -0.000384304602898
Gc17_854 0 n34 ns854 0 -0.000380545637023
Gc17_855 0 n34 ns855 0 -0.000382747840642
Gc17_856 0 n34 ns856 0 -0.000544998850436
Gc17_857 0 n34 ns857 0 0.000724219084002
Gc17_858 0 n34 ns858 0 0.000246137216603
Gc17_859 0 n34 ns859 0 0.00277931839854
Gc17_860 0 n34 ns860 0 -0.000596139585547
Gc17_861 0 n34 ns861 0 0.00239475019565
Gc17_862 0 n34 ns862 0 -0.000613963050666
Gc17_863 0 n34 ns863 0 0.000534685777324
Gc17_864 0 n34 ns864 0 0.000292923731266
Gc17_865 0 n34 ns865 0 -0.000190478941964
Gc17_866 0 n34 ns866 0 -0.000122169643385
Gc17_867 0 n34 ns867 0 -0.000831469867101
Gc17_868 0 n34 ns868 0 -0.000322577753228
Gc17_869 0 n34 ns869 0 -0.000341678094508
Gc17_870 0 n34 ns870 0 -0.000226259595573
Gc17_871 0 n34 ns871 0 3.45944812109e-05
Gc17_872 0 n34 ns872 0 1.22437720504e-05
Gc17_873 0 n34 ns873 0 -6.63353216975e-05
Gc17_874 0 n34 ns874 0 2.32353315202e-05
Gc17_875 0 n34 ns875 0 3.46091911833e-05
Gc17_876 0 n34 ns876 0 0.000157449272845
Gc17_877 0 n34 ns877 0 9.97528997753e-05
Gc17_878 0 n34 ns878 0 -0.000728399522845
Gc17_879 0 n34 ns879 0 -7.36368095784e-05
Gc17_880 0 n34 ns880 0 -5.98009973366e-05
Gc17_881 0 n34 ns881 0 7.897800678e-05
Gc17_882 0 n34 ns882 0 8.70749978498e-06
Gc17_883 0 n34 ns883 0 9.83332544596e-05
Gc17_884 0 n34 ns884 0 -0.000121867129803
Gc17_885 0 n34 ns885 0 -4.44865653342e-05
Gc17_886 0 n34 ns886 0 2.85102826709e-05
Gc17_887 0 n34 ns887 0 -0.000101034718668
Gc17_888 0 n34 ns888 0 0.000161273984333
Gc17_889 0 n34 ns889 0 -0.000329741722767
Gc17_890 0 n34 ns890 0 0.000101327031122
Gc17_891 0 n34 ns891 0 -0.000243021020054
Gc17_892 0 n34 ns892 0 0.00018077457995
Gc17_893 0 n34 ns893 0 -0.000323918449861
Gc17_894 0 n34 ns894 0 0.000227486129591
Gc17_895 0 n34 ns895 0 6.7179192369e-05
Gc17_896 0 n34 ns896 0 -0.000310863877513
Gc17_897 0 n34 ns897 0 0.000110269565124
Gc17_898 0 n34 ns898 0 -0.0015783554798
Gc17_899 0 n34 ns899 0 8.77310929044e-05
Gc17_900 0 n34 ns900 0 -0.00137116708217
Gc17_901 0 n34 ns901 0 -6.07780371204e-05
Gc17_902 0 n34 ns902 0 0.000119555563755
Gc17_903 0 n34 ns903 0 -7.17458864808e-05
Gc17_904 0 n34 ns904 0 -4.28115022862e-05
Gc17_905 0 n34 ns905 0 -0.00019260964303
Gc17_906 0 n34 ns906 0 1.90271894982e-06
Gc17_907 0 n34 ns907 0 -7.24202804282e-05
Gc17_908 0 n34 ns908 0 0.000293428312745
Gc17_909 0 n34 ns909 0 0.000113997075425
Gc17_910 0 n34 ns910 0 -6.95343946687e-06
Gc17_911 0 n34 ns911 0 3.29520443086e-05
Gc17_912 0 n34 ns912 0 -3.87613464261e-05
Gc17_913 0 n34 ns913 0 0.000347463809066
Gc17_914 0 n34 ns914 0 -0.000112956864043
Gc17_915 0 n34 ns915 0 0.00100271234369
Gc17_916 0 n34 ns916 0 -0.000218026151461
Gc17_917 0 n34 ns917 0 0.000195127859844
Gc17_918 0 n34 ns918 0 -6.07549116282e-05
Gc17_919 0 n34 ns919 0 -8.844747546e-05
Gc17_920 0 n34 ns920 0 -1.09114760943e-05
Gc17_921 0 n34 ns921 0 2.99838352397e-05
Gc17_922 0 n34 ns922 0 -0.000167025442079
Gc17_923 0 n34 ns923 0 -2.04997619733e-05
Gc17_924 0 n34 ns924 0 1.70947378997e-05
Gc17_925 0 n34 ns925 0 -0.000133484520628
Gc17_926 0 n34 ns926 0 0.000120216195652
Gc17_927 0 n34 ns927 0 -0.000105535403972
Gc17_928 0 n34 ns928 0 4.15298498851e-05
Gc17_929 0 n34 ns929 0 -1.17457454028e-05
Gc17_930 0 n34 ns930 0 4.58710080339e-05
Gc17_931 0 n34 ns931 0 3.26034554658e-06
Gc17_932 0 n34 ns932 0 7.56416504796e-06
Gc17_933 0 n34 ns933 0 9.09757667388e-05
Gc17_934 0 n34 ns934 0 1.74348057507e-05
Gc17_935 0 n34 ns935 0 -0.000133114855079
Gc17_936 0 n34 ns936 0 -0.000334289517365
Gc17_937 0 n34 ns937 0 -0.000124996852994
Gc17_938 0 n34 ns938 0 -0.000311602039223
Gc17_939 0 n34 ns939 0 0.000252785231397
Gc17_940 0 n34 ns940 0 0.000425729991915
Gc17_941 0 n34 ns941 0 -7.10205850162e-05
Gc17_942 0 n34 ns942 0 -8.99085788597e-05
Gc17_943 0 n34 ns943 0 -0.000350279132675
Gc17_944 0 n34 ns944 0 -0.000437496026598
Gc17_945 0 n34 ns945 0 -0.000183392956282
Gc17_946 0 n34 ns946 0 -0.000466810708997
Gc17_947 0 n34 ns947 0 -4.76018871362e-05
Gc17_948 0 n34 ns948 0 2.67016842192e-05
Gc17_949 0 n34 ns949 0 -7.30357321815e-05
Gc17_950 0 n34 ns950 0 4.51018422899e-05
Gc17_951 0 n34 ns951 0 0.000717844000532
Gc17_952 0 n34 ns952 0 -0.00260264327086
Gc17_953 0 n34 ns953 0 0.0010909576293
Gc17_954 0 n34 ns954 0 -0.00192859541051
Gc17_955 0 n34 ns955 0 -0.00110451418592
Gc17_956 0 n34 ns956 0 -0.000255114176184
Gc17_957 0 n34 ns957 0 0.000363414248263
Gc17_958 0 n34 ns958 0 -0.000291871019801
Gc17_959 0 n34 ns959 0 0.000335409802699
Gc17_960 0 n34 ns960 0 0.000665912502218
Gc17_961 0 n34 ns961 0 0.000112396170004
Gc17_962 0 n34 ns962 0 9.97660078783e-05
Gc17_963 0 n34 ns963 0 -8.56894091076e-05
Gc17_964 0 n34 ns964 0 0.000415740817545
Gc17_965 0 n34 ns965 0 0.000677975370848
Gc17_966 0 n34 ns966 0 -0.0015467550959
Gc17_967 0 n34 ns967 0 0.000638517791787
Gc17_968 0 n34 ns968 0 -9.98117663643e-06
Gc17_969 0 n34 ns969 0 0.000638832121135
Gc17_970 0 n34 ns970 0 -0.000544702721061
Gc17_971 0 n34 ns971 0 0.00149138135477
Gc17_972 0 n34 ns972 0 0.00263050674325
Gc17_973 0 n34 ns973 0 0.000585345612861
Gc17_974 0 n34 ns974 0 0.00169428862159
Gc17_975 0 n34 ns975 0 -0.000194900624795
Gc17_976 0 n34 ns976 0 0.00211865485531
Gc17_977 0 n34 ns977 0 0.00495532510743
Gc17_978 0 n34 ns978 0 -0.000433602510819
Gc17_979 0 n34 ns979 0 0.00117366850944
Gc17_980 0 n34 ns980 0 -0.000447455707503
Gc17_981 0 n34 ns981 0 -0.0015918135853
Gc17_982 0 n34 ns982 0 -9.8988621049e-05
Gc17_983 0 n34 ns983 0 -0.00370401576174
Gc17_984 0 n34 ns984 0 -0.00101262277633
Gc17_985 0 n34 ns985 0 0.00296645695817
Gc17_986 0 n34 ns986 0 3.31572542813e-05
Gc17_987 0 n34 ns987 0 -0.000156845207306
Gc17_988 0 n34 ns988 0 2.16419540886e-05
Gc17_989 0 n34 ns989 0 0.000342233204007
Gc17_990 0 n34 ns990 0 -0.000621893886535
Gc17_991 0 n34 ns991 0 0.000991886063654
Gc17_992 0 n34 ns992 0 0.000301454611654
Gc17_993 0 n34 ns993 0 -0.000188566478939
Gc17_994 0 n34 ns994 0 0.000349295652333
Gc17_995 0 n34 ns995 0 -4.44986875191e-05
Gc17_996 0 n34 ns996 0 4.77350781804e-05
Gc17_997 0 n34 ns997 0 0.000639860253949
Gc17_998 0 n34 ns998 0 -0.000269303898846
Gc17_999 0 n34 ns999 0 0.000169656315274
Gc17_1000 0 n34 ns1000 0 4.44695896481e-05
Gc17_1001 0 n34 ns1001 0 2.38535353701e-05
Gc17_1002 0 n34 ns1002 0 -0.000442649232324
Gc17_1003 0 n34 ns1003 0 -0.00155285249009
Gc17_1004 0 n34 ns1004 0 -0.00027451134635
Gc17_1005 0 n34 ns1005 0 0.000215634709172
Gc17_1006 0 n34 ns1006 0 -8.3177134665e-05
Gc17_1007 0 n34 ns1007 0 -0.000247040628623
Gc17_1008 0 n34 ns1008 0 -0.000717223885844
Gc17_1009 0 n34 ns1009 0 0.00140679567841
Gc17_1010 0 n34 ns1010 0 -0.001334069162
Gc17_1011 0 n34 ns1011 0 -0.00134449966783
Gc17_1012 0 n34 ns1012 0 0.00198289441703
Gc17_1013 0 n34 ns1013 0 -0.00124113311931
Gc17_1014 0 n34 ns1014 0 0.00256390535003
Gc17_1015 0 n34 ns1015 0 -0.00161289165384
Gc17_1016 0 n34 ns1016 0 -0.00231340751853
Gc17_1017 0 n34 ns1017 0 0.000754063886698
Gc17_1018 0 n34 ns1018 0 -0.000914438346121
Gc17_1019 0 n34 ns1019 0 0.00120536207973
Gc17_1020 0 n34 ns1020 0 -0.000260612401094
Gc17_1021 0 n34 ns1021 0 -0.00121423742322
Gc17_1022 0 n34 ns1022 0 0.00250836890037
Gc17_1023 0 n34 ns1023 0 0.00149251729933
Gc17_1024 0 n34 ns1024 0 4.30069360694e-05
Gc17_1025 0 n34 ns1025 0 -0.000325510571525
Gc17_1026 0 n34 ns1026 0 0.000127411840799
Gc17_1027 0 n34 ns1027 0 1.66975880137e-05
Gc17_1028 0 n34 ns1028 0 -0.000672030154338
Gc17_1029 0 n34 ns1029 0 7.51821902203e-06
Gc17_1030 0 n34 ns1030 0 -0.000254882711309
Gc17_1031 0 n34 ns1031 0 0.00012544414019
Gc17_1032 0 n34 ns1032 0 -0.00022284288461
Gc17_1033 0 n34 ns1033 0 0.000145477011307
Gc17_1034 0 n34 ns1034 0 8.19824480671e-05
Gc17_1035 0 n34 ns1035 0 -0.00038449230505
Gc17_1036 0 n34 ns1036 0 -0.000545149613341
Gc17_1037 0 n34 ns1037 0 0.000163319382046
Gc17_1038 0 n34 ns1038 0 -1.7030070971e-05
Gc17_1039 0 n34 ns1039 0 -0.000145325720694
Gc17_1040 0 n34 ns1040 0 0.000198064756543
Gc17_1041 0 n34 ns1041 0 0.000112624448692
Gc17_1042 0 n34 ns1042 0 0.0014690343071
Gc17_1043 0 n34 ns1043 0 0.00055181213217
Gc17_1044 0 n34 ns1044 0 0.000112378908566
Gc17_1045 0 n34 ns1045 0 1.00285086819e-06
Gc17_1046 0 n34 ns1046 0 0.000307543114182
Gc17_1047 0 n34 ns1047 0 -0.00118807530867
Gc17_1048 0 n34 ns1048 0 -0.000828051698332
Gc17_1049 0 n34 ns1049 0 -0.000499081389987
Gc17_1050 0 n34 ns1050 0 0.00390078561842
Gc17_1051 0 n34 ns1051 0 -2.22080103755e-05
Gc17_1052 0 n34 ns1052 0 0.00379200940351
Gc17_1053 0 n34 ns1053 0 -0.00190768897145
Gc17_1054 0 n34 ns1054 0 0.000505767916792
Gc17_1055 0 n34 ns1055 0 6.75583541899e-05
Gc17_1056 0 n34 ns1056 0 -0.000804955182397
Gc17_1057 0 n34 ns1057 0 0.000374930026227
Gc17_1058 0 n34 ns1058 0 -0.00136176455845
Gc17_1059 0 n34 ns1059 0 -0.000376947830054
Gc17_1060 0 n34 ns1060 0 0.00100770774734
Gc17_1061 0 n34 ns1061 0 0.00054618456434
Gc17_1062 0 n34 ns1062 0 -6.41765926491e-06
Gc17_1063 0 n34 ns1063 0 -0.00014723620376
Gc17_1064 0 n34 ns1064 0 6.24136449907e-06
Gc17_1065 0 n34 ns1065 0 -4.14518443125e-06
Gc17_1066 0 n34 ns1066 0 -2.57008850684e-05
Gc17_1067 0 n34 ns1067 0 -5.81414742101e-05
Gc17_1068 0 n34 ns1068 0 0.00102745679761
Gc17_1069 0 n34 ns1069 0 0.000113620169452
Gc17_1070 0 n34 ns1070 0 0.000130318370296
Gc17_1071 0 n34 ns1071 0 -0.000172074065005
Gc17_1072 0 n34 ns1072 0 -0.000182984169312
Gc17_1073 0 n34 ns1073 0 -0.000440179101074
Gc17_1074 0 n34 ns1074 0 0.000239327608963
Gc17_1075 0 n34 ns1075 0 9.75854407751e-05
Gc17_1076 0 n34 ns1076 0 -0.000123450500846
Gc17_1077 0 n34 ns1077 0 0.000204303828755
Gc17_1078 0 n34 ns1078 0 -0.000155764000108
Gc17_1079 0 n34 ns1079 0 0.0011837720434
Gc17_1080 0 n34 ns1080 0 -0.000244618427615
Gc17_1081 0 n34 ns1081 0 0.000492131380675
Gc17_1082 0 n34 ns1082 0 -0.0007171876673
Gc17_1083 0 n34 ns1083 0 0.000601562743122
Gc17_1084 0 n34 ns1084 0 -0.000596327623195
Gc17_1085 0 n34 ns1085 0 -0.000303188628719
Gc17_1086 0 n34 ns1086 0 0.00113390699818
Gc17_1087 0 n34 ns1087 0 0.00321914309738
Gc17_1088 0 n34 ns1088 0 0.00407235897306
Gc17_1089 0 n34 ns1089 0 0.00306371280044
Gc17_1090 0 n34 ns1090 0 0.00344146471831
Gc17_1091 0 n34 ns1091 0 0.000340703895423
Gc17_1092 0 n34 ns1092 0 0.0012424342158
Gc17_1093 0 n34 ns1093 0 -0.000284251287126
Gc17_1094 0 n34 ns1094 0 -0.00047271649487
Gc17_1095 0 n34 ns1095 0 -0.00113380085379
Gc17_1096 0 n34 ns1096 0 -0.00139501492716
Gc17_1097 0 n34 ns1097 0 -0.000546205383476
Gc17_1098 0 n34 ns1098 0 -0.000611269114473
Gc17_1099 0 n34 ns1099 0 3.39895800312e-05
Gc17_1100 0 n34 ns1100 0 -3.11482521294e-06
Gc17_1101 0 n34 ns1101 0 -9.41795480556e-05
Gc17_1102 0 n34 ns1102 0 2.03610826628e-06
Gc17_1103 0 n34 ns1103 0 0.000573442103459
Gc17_1104 0 n34 ns1104 0 -1.2429137146e-05
Gc17_1105 0 n34 ns1105 0 0.00180603159216
Gc17_1106 0 n34 ns1106 0 0.000438491954494
Gc17_1107 0 n34 ns1107 0 0.00027220183165
Gc17_1108 0 n34 ns1108 0 2.09455441413e-05
Gc17_1109 0 n34 ns1109 0 -0.000194813874497
Gc17_1110 0 n34 ns1110 0 4.98045608684e-05
Gc17_1111 0 n34 ns1111 0 0.000184165070403
Gc17_1112 0 n34 ns1112 0 0.0002607368783
Gc17_1113 0 n34 ns1113 0 -4.43897780558e-05
Gc17_1114 0 n34 ns1114 0 -0.000106266350193
Gc17_1115 0 n34 ns1115 0 -0.000275445287518
Gc17_1116 0 n34 ns1116 0 -0.000324694112054
Gc17_1117 0 n34 ns1117 0 9.71832519353e-06
Gc17_1118 0 n34 ns1118 0 -0.000949634936003
Gc17_1119 0 n34 ns1119 0 -0.00027706123232
Gc17_1120 0 n34 ns1120 0 -0.000669499467089
Gc17_1121 0 n34 ns1121 0 -0.00019867776292
Gc17_1122 0 n34 ns1122 0 -0.00087743480928
Gc17_1123 0 n34 ns1123 0 0.000830564145649
Gc17_1124 0 n34 ns1124 0 0.000654520784366
Gc17_1125 0 n34 ns1125 0 0.00376802115993
Gc17_1126 0 n34 ns1126 0 0.000551264546741
Gc17_1127 0 n34 ns1127 0 0.00328451379484
Gc17_1128 0 n34 ns1128 0 0.000334447807616
Gc17_1129 0 n34 ns1129 0 0.000821905085991
Gc17_1130 0 n34 ns1130 0 0.000519967252839
Gc17_1131 0 n34 ns1131 0 -0.000252789581824
Gc17_1132 0 n34 ns1132 0 -0.000189517178466
Gc17_1133 0 n34 ns1133 0 -0.00115368426328
Gc17_1134 0 n34 ns1134 0 -0.000608889108618
Gc17_1135 0 n34 ns1135 0 -0.000489978542824
Gc17_1136 0 n34 ns1136 0 -0.000541936840727
Gc17_1137 0 n34 ns1137 0 -6.63201964096e-06
Gc17_1138 0 n34 ns1138 0 2.71637950703e-05
Gc17_1139 0 n34 ns1139 0 -0.000128295134051
Gc17_1140 0 n34 ns1140 0 5.23012791329e-05
Gc17_1141 0 n34 ns1141 0 5.81573451435e-05
Gc17_1142 0 n34 ns1142 0 0.000243381566892
Gc17_1143 0 n34 ns1143 0 0.000236860268737
Gc17_1144 0 n34 ns1144 0 -0.000528743855594
Gc17_1145 0 n34 ns1145 0 -9.32686166075e-05
Gc17_1146 0 n34 ns1146 0 -2.76585814972e-05
Gc17_1147 0 n34 ns1147 0 0.000100979328857
Gc17_1148 0 n34 ns1148 0 2.93550234571e-05
Gc17_1149 0 n34 ns1149 0 0.000197038673566
Gc17_1150 0 n34 ns1150 0 -1.38261026458e-05
Gc17_1151 0 n34 ns1151 0 -5.52924566381e-05
Gc17_1152 0 n34 ns1152 0 -1.89043688563e-06
Gc17_1153 0 n34 ns1153 0 -0.000186430748163
Gc17_1154 0 n34 ns1154 0 2.57721611388e-05
Gc17_1155 0 n34 ns1155 0 -0.000406061855702
Gc17_1156 0 n34 ns1156 0 -0.000112138212788
Gc17_1157 0 n34 ns1157 0 -0.000353637621813
Gc17_1158 0 n34 ns1158 0 6.20058995122e-05
Gc17_1159 0 n34 ns1159 0 -0.000436140492158
Gc17_1160 0 n34 ns1160 0 6.40110628677e-05
Gc17_1161 0 n34 ns1161 0 0.000245249225383
Gc17_1162 0 n34 ns1162 0 -0.000251325827331
Gc17_1163 0 n34 ns1163 0 0.000810895515114
Gc17_1164 0 n34 ns1164 0 -0.00165542032471
Gc17_1165 0 n34 ns1165 0 0.000689814660834
Gc17_1166 0 n34 ns1166 0 -0.00145804711122
Gc17_1167 0 n34 ns1167 0 3.94027783903e-05
Gc17_1168 0 n34 ns1168 0 9.14751028988e-05
Gc17_1169 0 n34 ns1169 0 -0.000102987090081
Gc17_1170 0 n34 ns1170 0 -4.71772045909e-05
Gc17_1171 0 n34 ns1171 0 -0.000329330863746
Gc17_1172 0 n34 ns1172 0 2.99403797617e-05
Gc17_1173 0 n34 ns1173 0 -0.000118306128262
Gc17_1174 0 n34 ns1174 0 0.000339059385109
Gc17_1175 0 n34 ns1175 0 0.000133986884312
Gc17_1176 0 n34 ns1176 0 -1.0422845187e-05
Gc17_1177 0 n34 ns1177 0 6.25775272427e-06
Gc17_1178 0 n34 ns1178 0 -2.20711296045e-05
Gc17_1179 0 n34 ns1179 0 0.000183459368134
Gc17_1180 0 n34 ns1180 0 0.000102967669686
Gc17_1181 0 n34 ns1181 0 0.000620690000445
Gc17_1182 0 n34 ns1182 0 -0.00011576857959
Gc17_1183 0 n34 ns1183 0 7.55386494647e-05
Gc17_1184 0 n34 ns1184 0 3.20768054456e-05
Gc17_1185 0 n34 ns1185 0 -8.00627577388e-06
Gc17_1186 0 n34 ns1186 0 -6.08452545473e-05
Gc17_1187 0 n34 ns1187 0 7.99685357946e-05
Gc17_1188 0 n34 ns1188 0 -0.000126253705375
Gc17_1189 0 n34 ns1189 0 -1.82712784457e-05
Gc17_1190 0 n34 ns1190 0 1.47472477959e-05
Gc17_1191 0 n34 ns1191 0 -0.000132316541618
Gc17_1192 0 n34 ns1192 0 5.08325953127e-05
Gc17_1193 0 n34 ns1193 0 -0.000148909231779
Gc17_1194 0 n34 ns1194 0 2.30291171437e-05
Gc17_1195 0 n34 ns1195 0 -5.01487824634e-05
Gc17_1196 0 n34 ns1196 0 6.57234404522e-05
Gc17_1197 0 n34 ns1197 0 -3.78163006527e-05
Gc17_1198 0 n34 ns1198 0 3.84670719043e-05
Gc17_1199 0 n34 ns1199 0 7.67364861726e-05
Gc17_1200 0 n34 ns1200 0 -1.90069745765e-05
Gc17_1201 0 n34 ns1201 0 -0.000182431163172
Gc17_1202 0 n34 ns1202 0 -0.000572746411259
Gc17_1203 0 n34 ns1203 0 -0.000165906763985
Gc17_1204 0 n34 ns1204 0 -0.000520130417754
Gc17_1205 0 n34 ns1205 0 0.000235618572874
Gc17_1206 0 n34 ns1206 0 0.000462824768156
Gc17_1207 0 n34 ns1207 0 -8.21713011302e-05
Gc17_1208 0 n34 ns1208 0 -9.55141334879e-05
Gc17_1209 0 n34 ns1209 0 -0.00036964040497
Gc17_1210 0 n34 ns1210 0 -0.000444320741968
Gc17_1211 0 n34 ns1211 0 -0.000186160641432
Gc17_1212 0 n34 ns1212 0 -0.000413657437782
Gc17_1213 0 n34 ns1213 0 -3.77965794394e-05
Gc17_1214 0 n34 ns1214 0 1.48868506387e-05
Gc17_1215 0 n34 ns1215 0 -4.68859628679e-05
Gc17_1216 0 n34 ns1216 0 2.04616286742e-05
Gd17_1 0 n34 ni1 0 0.000750056217877
Gd17_2 0 n34 ni2 0 -0.00362364903252
Gd17_3 0 n34 ni3 0 0.000716542338817
Gd17_4 0 n34 ni4 0 0.000277921327277
Gd17_5 0 n34 ni5 0 -0.000333567795394
Gd17_6 0 n34 ni6 0 0.00054184157753
Gd17_7 0 n34 ni7 0 0.00100251204694
Gd17_8 0 n34 ni8 0 -0.000440885513211
Gd17_9 0 n34 ni9 0 0.000582430164015
Gd17_10 0 n34 ni10 0 0.000119720261761
Gd17_11 0 n34 ni11 0 0.000494782023025
Gd17_12 0 n34 ni12 0 3.33097584567e-05
Gd17_13 0 n34 ni13 0 8.87115952085e-05
Gd17_14 0 n34 ni14 0 0.00137615211213
Gd17_15 0 n34 ni15 0 -0.00044477907962
Gd17_16 0 n34 ni16 0 0.000208553820312
Gd17_17 0 n34 ni17 0 -0.00252344986623
Gd17_18 0 n34 ni18 0 -0.00318488582881
Gd17_19 0 n34 ni19 0 -0.00167591589167
Gd17_20 0 n34 ni20 0 8.64049173354e-05
Gd17_21 0 n34 ni21 0 1.22881600527e-05
Gd17_22 0 n34 ni22 0 0.000257301952003
Gd17_23 0 n34 ni23 0 -0.000373691224034
Gd17_24 0 n34 ni24 0 -5.10490253327e-05
Gd17_25 0 n34 ni25 0 -0.000293799784273
Gd17_26 0 n34 ni26 0 -0.0023926781168
Gd17_27 0 n34 ni27 0 -0.000305865063627
Gd17_28 0 n34 ni28 0 -5.79757344647e-05
Gd17_29 0 n34 ni29 0 0.000185983121031
Gd17_30 0 n34 ni30 0 -0.000423167698262
Gd17_31 0 n34 ni31 0 -2.16835230698e-05
Gd17_32 0 n34 ni32 0 -8.24593161174e-05
Gc18_1 0 n36 ns1 0 0.00248867152579
Gc18_2 0 n36 ns2 0 -0.00367715436682
Gc18_3 0 n36 ns3 0 0.00496188602407
Gc18_4 0 n36 ns4 0 -0.00869819394033
Gc18_5 0 n36 ns5 0 -0.00376048026526
Gc18_6 0 n36 ns6 0 -0.0025966548438
Gc18_7 0 n36 ns7 0 0.00126667608406
Gc18_8 0 n36 ns8 0 0.000975318132946
Gc18_9 0 n36 ns9 0 -0.000355750534811
Gc18_10 0 n36 ns10 0 -0.000880487419728
Gc18_11 0 n36 ns11 0 -0.000114510066519
Gc18_12 0 n36 ns12 0 -0.000106853589938
Gc18_13 0 n36 ns13 0 -0.000999143082429
Gc18_14 0 n36 ns14 0 6.30509338634e-05
Gc18_15 0 n36 ns15 0 0.00167024973703
Gc18_16 0 n36 ns16 0 -4.4258583351e-05
Gc18_17 0 n36 ns17 0 0.000567640358553
Gc18_18 0 n36 ns18 0 0.000807480433675
Gc18_19 0 n36 ns19 0 0.000419967606683
Gc18_20 0 n36 ns20 0 0.0011481030097
Gc18_21 0 n36 ns21 0 0.00098624743218
Gc18_22 0 n36 ns22 0 -0.00412998014985
Gc18_23 0 n36 ns23 0 -0.000415854355048
Gc18_24 0 n36 ns24 0 -0.00481775924082
Gc18_25 0 n36 ns25 0 0.000368649025497
Gc18_26 0 n36 ns26 0 -0.00427094006539
Gc18_27 0 n36 ns27 0 0.00673777620139
Gc18_28 0 n36 ns28 0 0.00739638697194
Gc18_29 0 n36 ns29 0 0.000887514289004
Gc18_30 0 n36 ns30 0 -0.000280256456139
Gc18_31 0 n36 ns31 0 -0.00549690863962
Gc18_32 0 n36 ns32 0 -0.00358561956871
Gc18_33 0 n36 ns33 0 0.00102672600229
Gc18_34 0 n36 ns34 0 0.00887879971293
Gc18_35 0 n36 ns35 0 -0.00349457115346
Gc18_36 0 n36 ns36 0 4.41481884002e-06
Gc18_37 0 n36 ns37 0 0.000466787910224
Gc18_38 0 n36 ns38 0 -0.000305687953096
Gc18_39 0 n36 ns39 0 -0.00051931261366
Gc18_40 0 n36 ns40 0 -0.00016838383329
Gc18_41 0 n36 ns41 0 -0.00012326365257
Gc18_42 0 n36 ns42 0 0.00206771519626
Gc18_43 0 n36 ns43 0 0.00133194489588
Gc18_44 0 n36 ns44 0 -0.000933101311721
Gc18_45 0 n36 ns45 0 -0.000276531008704
Gc18_46 0 n36 ns46 0 0.000185226654955
Gc18_47 0 n36 ns47 0 5.00608873488e-05
Gc18_48 0 n36 ns48 0 -0.000129580286833
Gc18_49 0 n36 ns49 0 -2.64131987792e-05
Gc18_50 0 n36 ns50 0 -8.35134072168e-05
Gc18_51 0 n36 ns51 0 0.00181586859598
Gc18_52 0 n36 ns52 0 -0.000360961638086
Gc18_53 0 n36 ns53 0 -0.000231883162632
Gc18_54 0 n36 ns54 0 0.000920327785553
Gc18_55 0 n36 ns55 0 -0.000590670860135
Gc18_56 0 n36 ns56 0 0.000398156244666
Gc18_57 0 n36 ns57 0 -0.00176831504594
Gc18_58 0 n36 ns58 0 -0.000952869670006
Gc18_59 0 n36 ns59 0 0.00255623245225
Gc18_60 0 n36 ns60 0 0.00299524433971
Gc18_61 0 n36 ns61 0 -0.0089661316863
Gc18_62 0 n36 ns62 0 0.00314966719487
Gc18_63 0 n36 ns63 0 -0.00630524315476
Gc18_64 0 n36 ns64 0 0.00179509694438
Gc18_65 0 n36 ns65 0 -0.00951584256157
Gc18_66 0 n36 ns66 0 -0.00168507806931
Gc18_67 0 n36 ns67 0 0.00169411164189
Gc18_68 0 n36 ns68 0 0.000825142567046
Gc18_69 0 n36 ns69 0 -0.0034412962766
Gc18_70 0 n36 ns70 0 0.010886180925
Gc18_71 0 n36 ns71 0 -0.014131399095
Gc18_72 0 n36 ns72 0 -0.00129215384781
Gc18_73 0 n36 ns73 0 -0.00572162957293
Gc18_74 0 n36 ns74 0 -4.79852003691e-05
Gc18_75 0 n36 ns75 0 -0.000397744904314
Gc18_76 0 n36 ns76 0 0.000571072907011
Gc18_77 0 n36 ns77 0 -0.00111360068679
Gc18_78 0 n36 ns78 0 -0.000417433740144
Gc18_79 0 n36 ns79 0 -0.00430710091803
Gc18_80 0 n36 ns80 0 -0.00155646943889
Gc18_81 0 n36 ns81 0 -0.00204422919669
Gc18_82 0 n36 ns82 0 0.00102092086828
Gc18_83 0 n36 ns83 0 0.00096329268655
Gc18_84 0 n36 ns84 0 -0.00050235420928
Gc18_85 0 n36 ns85 0 -0.000799738054196
Gc18_86 0 n36 ns86 0 0.00022999449597
Gc18_87 0 n36 ns87 0 -0.000112630938463
Gc18_88 0 n36 ns88 0 -6.01396050216e-05
Gc18_89 0 n36 ns89 0 0.000951955409144
Gc18_90 0 n36 ns90 0 -2.20430394752e-05
Gc18_91 0 n36 ns91 0 0.000262544831965
Gc18_92 0 n36 ns92 0 -0.000913293593035
Gc18_93 0 n36 ns93 0 0.000893319262201
Gc18_94 0 n36 ns94 0 0.000270206406531
Gc18_95 0 n36 ns95 0 0.000785016227035
Gc18_96 0 n36 ns96 0 -8.1925348289e-05
Gc18_97 0 n36 ns97 0 -0.00233093146823
Gc18_98 0 n36 ns98 0 -0.000447251163245
Gc18_99 0 n36 ns99 0 -0.00163090611953
Gc18_100 0 n36 ns100 0 -0.000689232221557
Gc18_101 0 n36 ns101 0 -0.000719895525241
Gc18_102 0 n36 ns102 0 -0.00151641440371
Gc18_103 0 n36 ns103 0 0.00302299621209
Gc18_104 0 n36 ns104 0 0.000177304220354
Gc18_105 0 n36 ns105 0 0.00131685955473
Gc18_106 0 n36 ns106 0 -0.000896496229058
Gc18_107 0 n36 ns107 0 -0.000759129134149
Gc18_108 0 n36 ns108 0 -0.00161284109075
Gc18_109 0 n36 ns109 0 0.00292885248362
Gc18_110 0 n36 ns110 0 0.000227753783543
Gc18_111 0 n36 ns111 0 -0.0031401785418
Gc18_112 0 n36 ns112 0 -2.77486589217e-05
Gc18_113 0 n36 ns113 0 0.00039318968869
Gc18_114 0 n36 ns114 0 -0.000229300827525
Gc18_115 0 n36 ns115 0 -0.000391390186014
Gc18_116 0 n36 ns116 0 -6.19725285612e-05
Gc18_117 0 n36 ns117 0 -0.00108271548064
Gc18_118 0 n36 ns118 0 0.00185691703242
Gc18_119 0 n36 ns119 0 -8.40796361374e-05
Gc18_120 0 n36 ns120 0 0.000253375812999
Gc18_121 0 n36 ns121 0 1.83346774191e-05
Gc18_122 0 n36 ns122 0 -0.000205150334619
Gc18_123 0 n36 ns123 0 -0.000260773453858
Gc18_124 0 n36 ns124 0 0.000826577854279
Gc18_125 0 n36 ns125 0 -0.000112404556829
Gc18_126 0 n36 ns126 0 -3.3696168297e-05
Gc18_127 0 n36 ns127 0 0.000531944850813
Gc18_128 0 n36 ns128 0 -0.00076568316245
Gc18_129 0 n36 ns129 0 -0.000550532116909
Gc18_130 0 n36 ns130 0 0.000390346471625
Gc18_131 0 n36 ns131 0 0.000756960502811
Gc18_132 0 n36 ns132 0 8.01647738106e-05
Gc18_133 0 n36 ns133 0 0.000331254772792
Gc18_134 0 n36 ns134 0 -7.2457249601e-05
Gc18_135 0 n36 ns135 0 -0.000671248693749
Gc18_136 0 n36 ns136 0 0.0012215114123
Gc18_137 0 n36 ns137 0 0.00102081419247
Gc18_138 0 n36 ns138 0 -0.00333582395822
Gc18_139 0 n36 ns139 0 0.000783116571299
Gc18_140 0 n36 ns140 0 -0.00374185352383
Gc18_141 0 n36 ns141 0 -0.00112439027175
Gc18_142 0 n36 ns142 0 -0.000225126271556
Gc18_143 0 n36 ns143 0 0.000592723302638
Gc18_144 0 n36 ns144 0 -0.00123479755393
Gc18_145 0 n36 ns145 0 0.000860499049288
Gc18_146 0 n36 ns146 0 -0.00221632988219
Gc18_147 0 n36 ns147 0 0.00133450194887
Gc18_148 0 n36 ns148 0 -0.00256967077269
Gc18_149 0 n36 ns149 0 -0.00147575152805
Gc18_150 0 n36 ns150 0 -2.18035399978e-05
Gc18_151 0 n36 ns151 0 8.74189289084e-05
Gc18_152 0 n36 ns152 0 2.68695234347e-06
Gc18_153 0 n36 ns153 0 -7.0751990882e-05
Gc18_154 0 n36 ns154 0 -0.000570363452774
Gc18_155 0 n36 ns155 0 -0.000180574998465
Gc18_156 0 n36 ns156 0 0.000320254664533
Gc18_157 0 n36 ns157 0 -0.000237998970762
Gc18_158 0 n36 ns158 0 -3.3180789269e-05
Gc18_159 0 n36 ns159 0 5.08280247512e-05
Gc18_160 0 n36 ns160 0 9.18874733438e-05
Gc18_161 0 n36 ns161 0 0.000483566905673
Gc18_162 0 n36 ns162 0 0.000346881200492
Gc18_163 0 n36 ns163 0 -0.0001636434706
Gc18_164 0 n36 ns164 0 6.14876164677e-05
Gc18_165 0 n36 ns165 0 -0.00023247022876
Gc18_166 0 n36 ns166 0 -3.39861450044e-05
Gc18_167 0 n36 ns167 0 0.000640964134749
Gc18_168 0 n36 ns168 0 0.000848298330097
Gc18_169 0 n36 ns169 0 0.000768040324259
Gc18_170 0 n36 ns170 0 -0.00032729435405
Gc18_171 0 n36 ns171 0 0.00054529346398
Gc18_172 0 n36 ns172 0 -0.000184266652907
Gc18_173 0 n36 ns173 0 0.000327488936484
Gc18_174 0 n36 ns174 0 -1.99315766806e-05
Gc18_175 0 n36 ns175 0 -0.0026126438342
Gc18_176 0 n36 ns176 0 -0.0062302177153
Gc18_177 0 n36 ns177 0 -0.00262770894538
Gc18_178 0 n36 ns178 0 -0.00565138454485
Gc18_179 0 n36 ns179 0 -0.00114340893844
Gc18_180 0 n36 ns180 0 0.00157668115843
Gc18_181 0 n36 ns181 0 -8.88754372179e-05
Gc18_182 0 n36 ns182 0 -0.000944307625836
Gc18_183 0 n36 ns183 0 -0.000259880065301
Gc18_184 0 n36 ns184 0 -0.00239756450455
Gc18_185 0 n36 ns185 0 0.00026152828136
Gc18_186 0 n36 ns186 0 -0.00156699461359
Gc18_187 0 n36 ns187 0 -0.000618204346214
Gc18_188 0 n36 ns188 0 -1.42180085607e-05
Gc18_189 0 n36 ns189 0 6.45876306324e-05
Gc18_190 0 n36 ns190 0 -1.86049930578e-06
Gc18_191 0 n36 ns191 0 -0.000176986474502
Gc18_192 0 n36 ns192 0 0.000162755749722
Gc18_193 0 n36 ns193 0 -0.000206450140514
Gc18_194 0 n36 ns194 0 0.000556689410268
Gc18_195 0 n36 ns195 0 -9.64227098082e-05
Gc18_196 0 n36 ns196 0 0.000261895518232
Gc18_197 0 n36 ns197 0 0.000150443886218
Gc18_198 0 n36 ns198 0 -0.000116606665834
Gc18_199 0 n36 ns199 0 0.000370933469435
Gc18_200 0 n36 ns200 0 -0.000362605154489
Gc18_201 0 n36 ns201 0 -8.21295351354e-05
Gc18_202 0 n36 ns202 0 0.000155036681105
Gc18_203 0 n36 ns203 0 0.000129394904901
Gc18_204 0 n36 ns204 0 0.000350014364421
Gc18_205 0 n36 ns205 0 0.000824714985587
Gc18_206 0 n36 ns206 0 -0.000335009123383
Gc18_207 0 n36 ns207 0 0.000140338747404
Gc18_208 0 n36 ns208 0 -0.000752261630111
Gc18_209 0 n36 ns209 0 6.29061973096e-05
Gc18_210 0 n36 ns210 0 -0.000722740915681
Gc18_211 0 n36 ns211 0 -8.65187002546e-05
Gc18_212 0 n36 ns212 0 -0.000486809110435
Gc18_213 0 n36 ns213 0 -0.00517509126935
Gc18_214 0 n36 ns214 0 -0.00255235118028
Gc18_215 0 n36 ns215 0 -0.00467764615518
Gc18_216 0 n36 ns216 0 -0.00217010744706
Gc18_217 0 n36 ns217 0 0.000174899670633
Gc18_218 0 n36 ns218 0 0.00186014209363
Gc18_219 0 n36 ns219 0 -0.000326431421922
Gc18_220 0 n36 ns220 0 -0.000538426318348
Gc18_221 0 n36 ns221 0 -0.00109373418055
Gc18_222 0 n36 ns222 0 -0.00177609795763
Gc18_223 0 n36 ns223 0 -0.000133796605317
Gc18_224 0 n36 ns224 0 -0.00124004901667
Gc18_225 0 n36 ns225 0 -0.000375489844525
Gc18_226 0 n36 ns226 0 1.49973749768e-06
Gc18_227 0 n36 ns227 0 5.46891194351e-05
Gc18_228 0 n36 ns228 0 1.02142895252e-05
Gc18_229 0 n36 ns229 0 -0.000238614850773
Gc18_230 0 n36 ns230 0 0.000665544527889
Gc18_231 0 n36 ns231 0 -0.00054210571351
Gc18_232 0 n36 ns232 0 0.00106493396642
Gc18_233 0 n36 ns233 0 -9.38962690397e-06
Gc18_234 0 n36 ns234 0 0.000366020011063
Gc18_235 0 n36 ns235 0 1.72883426912e-05
Gc18_236 0 n36 ns236 0 -0.000256103969077
Gc18_237 0 n36 ns237 0 -0.000152429647427
Gc18_238 0 n36 ns238 0 -0.000144942598015
Gc18_239 0 n36 ns239 0 0.000102276058169
Gc18_240 0 n36 ns240 0 9.52904116828e-05
Gc18_241 0 n36 ns241 0 0.000423757969386
Gc18_242 0 n36 ns242 0 -0.000290751868308
Gc18_243 0 n36 ns243 0 9.86669516398e-05
Gc18_244 0 n36 ns244 0 -0.000656539026564
Gc18_245 0 n36 ns245 0 -0.000318158294668
Gc18_246 0 n36 ns246 0 -0.000373831885731
Gc18_247 0 n36 ns247 0 -0.00034461111184
Gc18_248 0 n36 ns248 0 -0.000321695599664
Gc18_249 0 n36 ns249 0 -0.000505216483057
Gc18_250 0 n36 ns250 0 -0.000102381551591
Gc18_251 0 n36 ns251 0 -0.00385878645533
Gc18_252 0 n36 ns252 0 0.0010354489764
Gc18_253 0 n36 ns253 0 -0.00336088395342
Gc18_254 0 n36 ns254 0 0.000961557941557
Gc18_255 0 n36 ns255 0 0.000665222044053
Gc18_256 0 n36 ns256 0 0.00123127209191
Gc18_257 0 n36 ns257 0 -0.0002854318102
Gc18_258 0 n36 ns258 0 -0.000250591537601
Gc18_259 0 n36 ns259 0 -0.0010527158807
Gc18_260 0 n36 ns260 0 -0.00097064255223
Gc18_261 0 n36 ns261 0 -0.000166748661417
Gc18_262 0 n36 ns262 0 -0.000757265422749
Gc18_263 0 n36 ns263 0 -0.000219919789284
Gc18_264 0 n36 ns264 0 2.00092230897e-07
Gc18_265 0 n36 ns265 0 1.50843230567e-05
Gc18_266 0 n36 ns266 0 2.63928198704e-05
Gc18_267 0 n36 ns267 0 0.000108585390429
Gc18_268 0 n36 ns268 0 0.000194172331198
Gc18_269 0 n36 ns269 0 0.000395867861519
Gc18_270 0 n36 ns270 0 0.000104114838236
Gc18_271 0 n36 ns271 0 4.29657057568e-05
Gc18_272 0 n36 ns272 0 8.63019850003e-07
Gc18_273 0 n36 ns273 0 -5.74211853007e-05
Gc18_274 0 n36 ns274 0 1.46607554016e-06
Gc18_275 0 n36 ns275 0 -0.000131660806544
Gc18_276 0 n36 ns276 0 0.000163515666684
Gc18_277 0 n36 ns277 0 9.84200163271e-05
Gc18_278 0 n36 ns278 0 -4.34438578171e-05
Gc18_279 0 n36 ns279 0 -5.25117337483e-05
Gc18_280 0 n36 ns280 0 -0.000402094262315
Gc18_281 0 n36 ns281 0 -0.000325818585033
Gc18_282 0 n36 ns282 0 -0.000208766413994
Gc18_283 0 n36 ns283 0 -0.000290854184265
Gc18_284 0 n36 ns284 0 5.09311125375e-05
Gc18_285 0 n36 ns285 0 -0.000297526420479
Gc18_286 0 n36 ns286 0 0.000101472573716
Gc18_287 0 n36 ns287 0 -0.000297549434944
Gc18_288 0 n36 ns288 0 0.000230693754005
Gc18_289 0 n36 ns289 0 -0.00131950709471
Gc18_290 0 n36 ns290 0 0.00205219940393
Gc18_291 0 n36 ns291 0 -0.00112121355756
Gc18_292 0 n36 ns292 0 0.00179046327182
Gc18_293 0 n36 ns293 0 0.000722706381662
Gc18_294 0 n36 ns294 0 0.000520070307799
Gc18_295 0 n36 ns295 0 -0.00018619573829
Gc18_296 0 n36 ns296 0 -9.47666601649e-05
Gc18_297 0 n36 ns297 0 -0.000796432654383
Gc18_298 0 n36 ns298 0 -0.000418806575969
Gc18_299 0 n36 ns299 0 -0.000139638660544
Gc18_300 0 n36 ns300 0 -0.000546865140935
Gc18_301 0 n36 ns301 0 -0.000161763069248
Gc18_302 0 n36 ns302 0 -1.12980731721e-05
Gc18_303 0 n36 ns303 0 1.08741976021e-05
Gc18_304 0 n36 ns304 0 1.17635451562e-06
Gc18_305 0 n36 ns305 0 0.000109125482271
Gc18_306 0 n36 ns306 0 0.000546506195944
Gc18_307 0 n36 ns307 0 0.000638583979087
Gc18_308 0 n36 ns308 0 0.000759692074771
Gc18_309 0 n36 ns309 0 5.53594114488e-05
Gc18_310 0 n36 ns310 0 0.000250317346578
Gc18_311 0 n36 ns311 0 -1.56046056802e-05
Gc18_312 0 n36 ns312 0 -9.84596136546e-05
Gc18_313 0 n36 ns313 0 0.000197269414829
Gc18_314 0 n36 ns314 0 0.000248351595733
Gc18_315 0 n36 ns315 0 3.85736020592e-05
Gc18_316 0 n36 ns316 0 -0.00011433358178
Gc18_317 0 n36 ns317 0 -0.000403554818788
Gc18_318 0 n36 ns318 0 -0.000460831793498
Gc18_319 0 n36 ns319 0 -0.000194697837377
Gc18_320 0 n36 ns320 0 -0.000201164009784
Gc18_321 0 n36 ns321 0 -5.15503937236e-05
Gc18_322 0 n36 ns322 0 -4.19449820674e-05
Gc18_323 0 n36 ns323 0 4.12806413097e-05
Gc18_324 0 n36 ns324 0 -0.000115280620114
Gc18_325 0 n36 ns325 0 5.5919276958e-05
Gc18_326 0 n36 ns326 0 0.000538717604614
Gc18_327 0 n36 ns327 0 8.37218174997e-05
Gc18_328 0 n36 ns328 0 0.00219736099679
Gc18_329 0 n36 ns329 0 8.1570504702e-05
Gc18_330 0 n36 ns330 0 0.0018577049244
Gc18_331 0 n36 ns331 0 0.000872340151747
Gc18_332 0 n36 ns332 0 0.000465395318444
Gc18_333 0 n36 ns333 0 -0.000151432743312
Gc18_334 0 n36 ns334 0 -8.23181786206e-05
Gc18_335 0 n36 ns335 0 -0.000805432386409
Gc18_336 0 n36 ns336 0 -0.000516437195184
Gc18_337 0 n36 ns337 0 -0.000209623586642
Gc18_338 0 n36 ns338 0 -0.000866835688133
Gc18_339 0 n36 ns339 0 -0.000229589064701
Gc18_340 0 n36 ns340 0 1.09518443972e-05
Gc18_341 0 n36 ns341 0 -3.46502539146e-05
Gc18_342 0 n36 ns342 0 1.95327089373e-05
Gc18_343 0 n36 ns343 0 0.000945487773633
Gc18_344 0 n36 ns344 0 -0.00216341843043
Gc18_345 0 n36 ns345 0 0.00137879936442
Gc18_346 0 n36 ns346 0 -0.00440445176753
Gc18_347 0 n36 ns347 0 -0.00242289388802
Gc18_348 0 n36 ns348 0 -0.0013049962751
Gc18_349 0 n36 ns349 0 0.00100972760833
Gc18_350 0 n36 ns350 0 0.000438341845419
Gc18_351 0 n36 ns351 0 -0.000784680513515
Gc18_352 0 n36 ns352 0 -0.000483207089556
Gc18_353 0 n36 ns353 0 -0.000135388362785
Gc18_354 0 n36 ns354 0 -8.67629066843e-05
Gc18_355 0 n36 ns355 0 0.00034442114392
Gc18_356 0 n36 ns356 0 0.000128019239387
Gc18_357 0 n36 ns357 0 0.000723214889777
Gc18_358 0 n36 ns358 0 -0.000846667332415
Gc18_359 0 n36 ns359 0 0.000653558419132
Gc18_360 0 n36 ns360 0 0.000480703803393
Gc18_361 0 n36 ns361 0 0.000351450382511
Gc18_362 0 n36 ns362 0 0.000202203886338
Gc18_363 0 n36 ns363 0 -0.00118932064448
Gc18_364 0 n36 ns364 0 -0.00191112521647
Gc18_365 0 n36 ns365 0 -0.00144054875478
Gc18_366 0 n36 ns366 0 -0.000889561513696
Gc18_367 0 n36 ns367 0 -0.000404102809166
Gc18_368 0 n36 ns368 0 -0.00156992492655
Gc18_369 0 n36 ns369 0 0.00461293818022
Gc18_370 0 n36 ns370 0 0.00201239600666
Gc18_371 0 n36 ns371 0 0.00139176860156
Gc18_372 0 n36 ns372 0 -0.000646348533551
Gc18_373 0 n36 ns373 0 -0.00207448514564
Gc18_374 0 n36 ns374 0 -0.00147960387901
Gc18_375 0 n36 ns375 0 0.00260927259321
Gc18_376 0 n36 ns376 0 0.00294098313862
Gc18_377 0 n36 ns377 0 -0.00354481440679
Gc18_378 0 n36 ns378 0 -9.30797146041e-06
Gc18_379 0 n36 ns379 0 0.000292808554584
Gc18_380 0 n36 ns380 0 -0.000154818747729
Gc18_381 0 n36 ns381 0 -0.000759082506644
Gc18_382 0 n36 ns382 0 -6.52230828962e-05
Gc18_383 0 n36 ns383 0 -0.00245143628778
Gc18_384 0 n36 ns384 0 0.00143146554344
Gc18_385 0 n36 ns385 0 -0.000418081536376
Gc18_386 0 n36 ns386 0 0.000638479488983
Gc18_387 0 n36 ns387 0 0.000244858451995
Gc18_388 0 n36 ns388 0 -0.000384508184101
Gc18_389 0 n36 ns389 0 -0.000660333216349
Gc18_390 0 n36 ns390 0 0.000702476395343
Gc18_391 0 n36 ns391 0 -9.46066726338e-05
Gc18_392 0 n36 ns392 0 -3.95480517668e-05
Gc18_393 0 n36 ns393 0 0.000960449936176
Gc18_394 0 n36 ns394 0 -0.00063780050993
Gc18_395 0 n36 ns395 0 -0.000652541943412
Gc18_396 0 n36 ns396 0 -0.000145963134058
Gc18_397 0 n36 ns397 0 0.000756278702257
Gc18_398 0 n36 ns398 0 0.000198920868711
Gc18_399 0 n36 ns399 0 0.000370055849046
Gc18_400 0 n36 ns400 0 -9.45921766688e-05
Gc18_401 0 n36 ns401 0 -0.00147210318306
Gc18_402 0 n36 ns402 0 0.00108142971013
Gc18_403 0 n36 ns403 0 0.000610296622397
Gc18_404 0 n36 ns404 0 -0.00192679613639
Gc18_405 0 n36 ns405 0 0.000692968097782
Gc18_406 0 n36 ns406 0 -0.00268143873767
Gc18_407 0 n36 ns407 0 -0.000168437701268
Gc18_408 0 n36 ns408 0 -0.000713927211266
Gc18_409 0 n36 ns409 0 0.000900383384508
Gc18_410 0 n36 ns410 0 -0.00120330447442
Gc18_411 0 n36 ns411 0 0.000857785387316
Gc18_412 0 n36 ns412 0 -0.00183049375359
Gc18_413 0 n36 ns413 0 0.00198767851297
Gc18_414 0 n36 ns414 0 -0.00254684618204
Gc18_415 0 n36 ns415 0 -0.00202056407601
Gc18_416 0 n36 ns416 0 -2.61280228351e-05
Gc18_417 0 n36 ns417 0 0.000114841135254
Gc18_418 0 n36 ns418 0 -1.25042506805e-05
Gc18_419 0 n36 ns419 0 0.000100069399007
Gc18_420 0 n36 ns420 0 -0.000894395827503
Gc18_421 0 n36 ns421 0 0.000180410141301
Gc18_422 0 n36 ns422 0 0.000283339152159
Gc18_423 0 n36 ns423 0 -7.73899561106e-05
Gc18_424 0 n36 ns424 0 -0.000240811251117
Gc18_425 0 n36 ns425 0 -8.7251664189e-05
Gc18_426 0 n36 ns426 0 0.000144493048043
Gc18_427 0 n36 ns427 0 0.000202442113609
Gc18_428 0 n36 ns428 0 0.000596680298352
Gc18_429 0 n36 ns429 0 -0.000172764671587
Gc18_430 0 n36 ns430 0 2.53253021517e-05
Gc18_431 0 n36 ns431 0 -9.67779002087e-05
Gc18_432 0 n36 ns432 0 -0.000259333289104
Gc18_433 0 n36 ns433 0 0.00014747556664
Gc18_434 0 n36 ns434 0 0.00108897849637
Gc18_435 0 n36 ns435 0 0.000848387344365
Gc18_436 0 n36 ns436 0 -7.4869681453e-05
Gc18_437 0 n36 ns437 0 0.000482159242179
Gc18_438 0 n36 ns438 0 2.93735600777e-05
Gc18_439 0 n36 ns439 0 0.000252773878335
Gc18_440 0 n36 ns440 0 0.000357069568674
Gc18_441 0 n36 ns441 0 -0.000871720067315
Gc18_442 0 n36 ns442 0 -0.00652378615197
Gc18_443 0 n36 ns443 0 -0.00112057904594
Gc18_444 0 n36 ns444 0 -0.00611035389665
Gc18_445 0 n36 ns445 0 -0.00153674432095
Gc18_446 0 n36 ns446 0 0.00100052577633
Gc18_447 0 n36 ns447 0 0.00011188318272
Gc18_448 0 n36 ns448 0 -0.00108332585604
Gc18_449 0 n36 ns449 0 0.000234439621724
Gc18_450 0 n36 ns450 0 -0.00239607161524
Gc18_451 0 n36 ns451 0 0.00055766933235
Gc18_452 0 n36 ns452 0 -0.00170979086185
Gc18_453 0 n36 ns453 0 -0.000797230581145
Gc18_454 0 n36 ns454 0 -1.12209188813e-05
Gc18_455 0 n36 ns455 0 5.73462421796e-05
Gc18_456 0 n36 ns456 0 4.69884290768e-06
Gc18_457 0 n36 ns457 0 -0.000250181476907
Gc18_458 0 n36 ns458 0 -1.07452003901e-05
Gc18_459 0 n36 ns459 0 -0.000410605480656
Gc18_460 0 n36 ns460 0 0.000462142882166
Gc18_461 0 n36 ns461 0 -0.000131038564885
Gc18_462 0 n36 ns462 0 0.000197674442273
Gc18_463 0 n36 ns463 0 0.000113544104218
Gc18_464 0 n36 ns464 0 -2.35772235842e-05
Gc18_465 0 n36 ns465 0 0.000553748992495
Gc18_466 0 n36 ns466 0 -0.000198928082003
Gc18_467 0 n36 ns467 0 -0.000156644505988
Gc18_468 0 n36 ns468 0 0.000137861526812
Gc18_469 0 n36 ns469 0 -7.29959472744e-05
Gc18_470 0 n36 ns470 0 0.000434057056898
Gc18_471 0 n36 ns471 0 0.000991621894927
Gc18_472 0 n36 ns472 0 0.000154555403603
Gc18_473 0 n36 ns473 0 0.000437071725266
Gc18_474 0 n36 ns474 0 -0.000683276418766
Gc18_475 0 n36 ns475 0 0.0003082917221
Gc18_476 0 n36 ns476 0 -0.000590315201732
Gc18_477 0 n36 ns477 0 7.91537594523e-05
Gc18_478 0 n36 ns478 0 -0.00053665199566
Gc18_479 0 n36 ns479 0 -0.00495841170116
Gc18_480 0 n36 ns480 0 -0.00448985252536
Gc18_481 0 n36 ns481 0 -0.00457471400979
Gc18_482 0 n36 ns482 0 -0.00390600200872
Gc18_483 0 n36 ns483 0 -0.000372407844913
Gc18_484 0 n36 ns484 0 0.00184275808105
Gc18_485 0 n36 ns485 0 -0.000270025597904
Gc18_486 0 n36 ns486 0 -0.000666773871602
Gc18_487 0 n36 ns487 0 -0.000801600555841
Gc18_488 0 n36 ns488 0 -0.00194751228976
Gc18_489 0 n36 ns489 0 -7.41805624681e-06
Gc18_490 0 n36 ns490 0 -0.00115536086807
Gc18_491 0 n36 ns491 0 -0.000392793995183
Gc18_492 0 n36 ns492 0 -8.82599573936e-06
Gc18_493 0 n36 ns493 0 9.69828171116e-05
Gc18_494 0 n36 ns494 0 -1.42623804864e-05
Gc18_495 0 n36 ns495 0 -0.000516958201291
Gc18_496 0 n36 ns496 0 0.000747923006732
Gc18_497 0 n36 ns497 0 -0.00126105968422
Gc18_498 0 n36 ns498 0 0.00072471425231
Gc18_499 0 n36 ns499 0 -0.00017595298407
Gc18_500 0 n36 ns500 0 0.000371811997524
Gc18_501 0 n36 ns501 0 0.000148039091493
Gc18_502 0 n36 ns502 0 -0.000261696333224
Gc18_503 0 n36 ns503 0 -5.32027109961e-05
Gc18_504 0 n36 ns504 0 -0.000334618630977
Gc18_505 0 n36 ns505 0 3.64584394508e-05
Gc18_506 0 n36 ns506 0 0.00017265221979
Gc18_507 0 n36 ns507 0 0.000581119577854
Gc18_508 0 n36 ns508 0 7.91804214287e-05
Gc18_509 0 n36 ns509 0 0.00042931960225
Gc18_510 0 n36 ns510 0 -0.000569806359848
Gc18_511 0 n36 ns511 0 -0.000225430501927
Gc18_512 0 n36 ns512 0 -0.000497787135248
Gc18_513 0 n36 ns513 0 -0.000306036346283
Gc18_514 0 n36 ns514 0 -0.000383419889433
Gc18_515 0 n36 ns515 0 -0.000573688235146
Gc18_516 0 n36 ns516 0 -0.000441248782194
Gc18_517 0 n36 ns517 0 -0.00504561689753
Gc18_518 0 n36 ns518 0 -0.000375237099516
Gc18_519 0 n36 ns519 0 -0.00443485836001
Gc18_520 0 n36 ns520 0 -0.000227794345667
Gc18_521 0 n36 ns521 0 0.000312525410663
Gc18_522 0 n36 ns522 0 0.00135261078875
Gc18_523 0 n36 ns523 0 -0.000279853921868
Gc18_524 0 n36 ns524 0 -0.000323124401201
Gc18_525 0 n36 ns525 0 -0.000913461639705
Gc18_526 0 n36 ns526 0 -0.00107166161933
Gc18_527 0 n36 ns527 0 -9.82930837975e-05
Gc18_528 0 n36 ns528 0 -0.000577908365081
Gc18_529 0 n36 ns529 0 -0.000187466327855
Gc18_530 0 n36 ns530 0 -1.49922168635e-05
Gc18_531 0 n36 ns531 0 0.000107617554313
Gc18_532 0 n36 ns532 0 -2.60638295968e-05
Gc18_533 0 n36 ns533 0 3.76002429793e-05
Gc18_534 0 n36 ns534 0 0.000145670480945
Gc18_535 0 n36 ns535 0 0.000131200972303
Gc18_536 0 n36 ns536 0 -1.69236809532e-05
Gc18_537 0 n36 ns537 0 5.6917509988e-05
Gc18_538 0 n36 ns538 0 1.05092158883e-05
Gc18_539 0 n36 ns539 0 -7.54157204723e-05
Gc18_540 0 n36 ns540 0 -4.67451913943e-05
Gc18_541 0 n36 ns541 0 -0.000253192610041
Gc18_542 0 n36 ns542 0 -3.18709733122e-06
Gc18_543 0 n36 ns543 0 0.000107270860642
Gc18_544 0 n36 ns544 0 2.67688883389e-05
Gc18_545 0 n36 ns545 0 0.00018717819156
Gc18_546 0 n36 ns546 0 -0.000272939477059
Gc18_547 0 n36 ns547 0 -0.000283638022222
Gc18_548 0 n36 ns548 0 -0.000283294315148
Gc18_549 0 n36 ns549 0 -0.000390437343124
Gc18_550 0 n36 ns550 0 3.38741709428e-06
Gc18_551 0 n36 ns551 0 -0.000450675696921
Gc18_552 0 n36 ns552 0 0.000104262882599
Gc18_553 0 n36 ns553 0 -0.000465469205074
Gc18_554 0 n36 ns554 0 5.93608626868e-06
Gc18_555 0 n36 ns555 0 -0.00231086696987
Gc18_556 0 n36 ns556 0 0.00165802104029
Gc18_557 0 n36 ns557 0 -0.00198406629401
Gc18_558 0 n36 ns558 0 0.00148491127006
Gc18_559 0 n36 ns559 0 0.000605501069604
Gc18_560 0 n36 ns560 0 0.000623020552255
Gc18_561 0 n36 ns561 0 -0.000204390600647
Gc18_562 0 n36 ns562 0 -0.000119648305559
Gc18_563 0 n36 ns563 0 -0.000791067102159
Gc18_564 0 n36 ns564 0 -0.000440255680358
Gc18_565 0 n36 ns565 0 -0.00011641316927
Gc18_566 0 n36 ns566 0 -0.000366066654109
Gc18_567 0 n36 ns567 0 -0.000120558907324
Gc18_568 0 n36 ns568 0 -1.52705077327e-05
Gc18_569 0 n36 ns569 0 2.8830112173e-05
Gc18_570 0 n36 ns570 0 8.29479022669e-07
Gc18_571 0 n36 ns571 0 0.000158262672719
Gc18_572 0 n36 ns572 0 0.000166724564226
Gc18_573 0 n36 ns573 0 0.000703740419772
Gc18_574 0 n36 ns574 0 -6.96561289947e-05
Gc18_575 0 n36 ns575 0 9.52823665176e-06
Gc18_576 0 n36 ns576 0 -3.13186608322e-05
Gc18_577 0 n36 ns577 0 -3.39425135846e-06
Gc18_578 0 n36 ns578 0 4.56732161823e-05
Gc18_579 0 n36 ns579 0 4.11833179566e-05
Gc18_580 0 n36 ns580 0 0.000212225105825
Gc18_581 0 n36 ns581 0 5.06804901349e-05
Gc18_582 0 n36 ns582 0 -8.73762817168e-05
Gc18_583 0 n36 ns583 0 -0.000282477860601
Gc18_584 0 n36 ns584 0 -0.000336403801119
Gc18_585 0 n36 ns585 0 -0.000287001940192
Gc18_586 0 n36 ns586 0 -9.00017279579e-05
Gc18_587 0 n36 ns587 0 -0.000152552330783
Gc18_588 0 n36 ns588 0 7.42347970333e-05
Gc18_589 0 n36 ns589 0 -0.000117319160483
Gc18_590 0 n36 ns590 0 7.38546770861e-05
Gc18_591 0 n36 ns591 0 -8.99811919849e-05
Gc18_592 0 n36 ns592 0 0.000386270159658
Gc18_593 0 n36 ns593 0 -0.000332385546188
Gc18_594 0 n36 ns594 0 0.00208634871418
Gc18_595 0 n36 ns595 0 -0.000271641185579
Gc18_596 0 n36 ns596 0 0.00178687813537
Gc18_597 0 n36 ns597 0 0.000777292750273
Gc18_598 0 n36 ns598 0 0.000414686556633
Gc18_599 0 n36 ns599 0 -0.000155189582735
Gc18_600 0 n36 ns600 0 -7.28589895726e-05
Gc18_601 0 n36 ns601 0 -0.000750037223654
Gc18_602 0 n36 ns602 0 -0.000414336939165
Gc18_603 0 n36 ns603 0 -0.000160318187736
Gc18_604 0 n36 ns604 0 -0.00073335705513
Gc18_605 0 n36 ns605 0 -0.000206116573543
Gc18_606 0 n36 ns606 0 -1.76428010084e-05
Gc18_607 0 n36 ns607 0 5.64800070492e-06
Gc18_608 0 n36 ns608 0 -1.9321055974e-06
Gc18_609 0 n36 ns609 0 0.00210299410713
Gc18_610 0 n36 ns610 0 -0.00580031425808
Gc18_611 0 n36 ns611 0 0.00192437126401
Gc18_612 0 n36 ns612 0 -0.00441256370242
Gc18_613 0 n36 ns613 0 -0.000784701627327
Gc18_614 0 n36 ns614 0 -0.00103493506306
Gc18_615 0 n36 ns615 0 0.000582912976572
Gc18_616 0 n36 ns616 0 0.000171901411462
Gc18_617 0 n36 ns617 0 -0.000136953205778
Gc18_618 0 n36 ns618 0 0.000387791316595
Gc18_619 0 n36 ns619 0 3.58364332416e-05
Gc18_620 0 n36 ns620 0 8.51255604316e-05
Gc18_621 0 n36 ns621 0 -0.000901704512104
Gc18_622 0 n36 ns622 0 0.000342800118888
Gc18_623 0 n36 ns623 0 0.000433021661306
Gc18_624 0 n36 ns624 0 3.72975466082e-06
Gc18_625 0 n36 ns625 0 -7.09876557496e-05
Gc18_626 0 n36 ns626 0 0.000185272780545
Gc18_627 0 n36 ns627 0 -0.000498695619674
Gc18_628 0 n36 ns628 0 -0.000625772215833
Gc18_629 0 n36 ns629 0 -0.000517948811921
Gc18_630 0 n36 ns630 0 0.00108282645711
Gc18_631 0 n36 ns631 0 0.00603649508558
Gc18_632 0 n36 ns632 0 0.00357828865488
Gc18_633 0 n36 ns633 0 0.00408046692199
Gc18_634 0 n36 ns634 0 0.00336592448937
Gc18_635 0 n36 ns635 0 0.00335973237398
Gc18_636 0 n36 ns636 0 0.00623453581476
Gc18_637 0 n36 ns637 0 0.000736272214378
Gc18_638 0 n36 ns638 0 -0.000154728164241
Gc18_639 0 n36 ns639 0 -0.00744834212132
Gc18_640 0 n36 ns640 0 -0.000955972356082
Gc18_641 0 n36 ns641 0 0.00386042895017
Gc18_642 0 n36 ns642 0 -0.00789525120441
Gc18_643 0 n36 ns643 0 0.00389666035027
Gc18_644 0 n36 ns644 0 1.31780880391e-05
Gc18_645 0 n36 ns645 0 -0.000122129024789
Gc18_646 0 n36 ns646 0 1.22170153941e-05
Gc18_647 0 n36 ns647 0 0.000983417503211
Gc18_648 0 n36 ns648 0 -0.00323995274508
Gc18_649 0 n36 ns649 0 -0.000556818600055
Gc18_650 0 n36 ns650 0 -0.00213668893908
Gc18_651 0 n36 ns651 0 -0.000838778571356
Gc18_652 0 n36 ns652 0 -0.00075951561119
Gc18_653 0 n36 ns653 0 0.00052163660829
Gc18_654 0 n36 ns654 0 6.42460174084e-05
Gc18_655 0 n36 ns655 0 -0.000119650822766
Gc18_656 0 n36 ns656 0 0.000508717286722
Gc18_657 0 n36 ns657 0 0.00010236688743
Gc18_658 0 n36 ns658 0 0.000153596940384
Gc18_659 0 n36 ns659 0 -0.000482229300767
Gc18_660 0 n36 ns660 0 0.00033483552579
Gc18_661 0 n36 ns661 0 0.000715112754048
Gc18_662 0 n36 ns662 0 1.33682039474e-06
Gc18_663 0 n36 ns663 0 0.000180772891359
Gc18_664 0 n36 ns664 0 0.00042120168816
Gc18_665 0 n36 ns665 0 -0.000263265567368
Gc18_666 0 n36 ns666 0 -0.000239595256588
Gc18_667 0 n36 ns667 0 -0.000719928297102
Gc18_668 0 n36 ns668 0 0.00115053008069
Gc18_669 0 n36 ns669 0 0.00476127131301
Gc18_670 0 n36 ns670 0 0.00223027701275
Gc18_671 0 n36 ns671 0 0.00296906740021
Gc18_672 0 n36 ns672 0 0.00240424865761
Gc18_673 0 n36 ns673 0 0.00310862197787
Gc18_674 0 n36 ns674 0 0.00518648413468
Gc18_675 0 n36 ns675 0 0.00109994199913
Gc18_676 0 n36 ns676 0 -0.000137251259238
Gc18_677 0 n36 ns677 0 -0.00615388621173
Gc18_678 0 n36 ns678 0 -0.000293370924455
Gc18_679 0 n36 ns679 0 0.00290412844682
Gc18_680 0 n36 ns680 0 -0.00566857210959
Gc18_681 0 n36 ns681 0 0.00452403013494
Gc18_682 0 n36 ns682 0 -7.74924330011e-06
Gc18_683 0 n36 ns683 0 0.000119148662507
Gc18_684 0 n36 ns684 0 -0.000161585272548
Gc18_685 0 n36 ns685 0 0.000407765653874
Gc18_686 0 n36 ns686 0 -0.00221780021003
Gc18_687 0 n36 ns687 0 0.000498249877531
Gc18_688 0 n36 ns688 0 -0.000833676449119
Gc18_689 0 n36 ns689 0 -0.00096302824616
Gc18_690 0 n36 ns690 0 0.000223857606069
Gc18_691 0 n36 ns691 0 0.000333505211307
Gc18_692 0 n36 ns692 0 -0.000346642072197
Gc18_693 0 n36 ns693 0 0.000552198809441
Gc18_694 0 n36 ns694 0 0.000294679044234
Gc18_695 0 n36 ns695 0 0.000189057192886
Gc18_696 0 n36 ns696 0 0.000115311916501
Gc18_697 0 n36 ns697 0 -0.000116677881814
Gc18_698 0 n36 ns698 0 9.7289357849e-05
Gc18_699 0 n36 ns699 0 3.00162597701e-05
Gc18_700 0 n36 ns700 0 -0.000993064602833
Gc18_701 0 n36 ns701 0 0.000716558113978
Gc18_702 0 n36 ns702 0 0.000102091429647
Gc18_703 0 n36 ns703 0 0.000457791961817
Gc18_704 0 n36 ns704 0 -0.000512659552298
Gc18_705 0 n36 ns705 0 0.00124128040899
Gc18_706 0 n36 ns706 0 0.00160233994803
Gc18_707 0 n36 ns707 0 -0.000762698139404
Gc18_708 0 n36 ns708 0 0.00239510156621
Gc18_709 0 n36 ns709 0 -0.00122802321468
Gc18_710 0 n36 ns710 0 0.00296005400482
Gc18_711 0 n36 ns711 0 0.00341880155916
Gc18_712 0 n36 ns712 0 -0.000743333494817
Gc18_713 0 n36 ns713 0 0.00128273767408
Gc18_714 0 n36 ns714 0 -0.000745244133248
Gc18_715 0 n36 ns715 0 -0.000849228230154
Gc18_716 0 n36 ns716 0 -0.000469339053791
Gc18_717 0 n36 ns717 0 -0.00371665319028
Gc18_718 0 n36 ns718 0 9.7366169729e-05
Gc18_719 0 n36 ns719 0 0.00320675079829
Gc18_720 0 n36 ns720 0 5.11865156853e-05
Gc18_721 0 n36 ns721 0 -0.00022467292463
Gc18_722 0 n36 ns722 0 6.9167089546e-05
Gc18_723 0 n36 ns723 0 0.000437206195671
Gc18_724 0 n36 ns724 0 -0.00143558723064
Gc18_725 0 n36 ns725 0 0.00109431941797
Gc18_726 0 n36 ns726 0 -0.000869662731381
Gc18_727 0 n36 ns727 0 -8.48562495734e-05
Gc18_728 0 n36 ns728 0 0.000102966930055
Gc18_729 0 n36 ns729 0 -4.18447717855e-05
Gc18_730 0 n36 ns730 0 3.44462147614e-06
Gc18_731 0 n36 ns731 0 0.000258046949779
Gc18_732 0 n36 ns732 0 -0.000634610653613
Gc18_733 0 n36 ns733 0 0.000177505727286
Gc18_734 0 n36 ns734 0 5.02912102416e-05
Gc18_735 0 n36 ns735 0 -1.68140390338e-05
Gc18_736 0 n36 ns736 0 0.000143451576688
Gc18_737 0 n36 ns737 0 -0.00112303282119
Gc18_738 0 n36 ns738 0 0.000504394944804
Gc18_739 0 n36 ns739 0 0.000405721370606
Gc18_740 0 n36 ns740 0 2.3081919758e-05
Gc18_741 0 n36 ns741 0 -0.000255942979181
Gc18_742 0 n36 ns742 0 -0.000343289761611
Gc18_743 0 n36 ns743 0 0.000707119825328
Gc18_744 0 n36 ns744 0 -0.00147653449098
Gc18_745 0 n36 ns745 0 -0.00106690730879
Gc18_746 0 n36 ns746 0 0.00276106298937
Gc18_747 0 n36 ns747 0 -0.000839712136579
Gc18_748 0 n36 ns748 0 0.00326029082127
Gc18_749 0 n36 ns749 0 -0.00216623254152
Gc18_750 0 n36 ns750 0 -0.00200015766539
Gc18_751 0 n36 ns751 0 0.000690854685035
Gc18_752 0 n36 ns752 0 -0.00102601064475
Gc18_753 0 n36 ns753 0 0.00126896186865
Gc18_754 0 n36 ns754 0 -0.000485404666697
Gc18_755 0 n36 ns755 0 -0.00120609517515
Gc18_756 0 n36 ns756 0 0.00298188809471
Gc18_757 0 n36 ns757 0 0.00159957550367
Gc18_758 0 n36 ns758 0 1.96019391401e-05
Gc18_759 0 n36 ns759 0 -0.000291659052692
Gc18_760 0 n36 ns760 0 0.000112492490953
Gc18_761 0 n36 ns761 0 -0.000176980835852
Gc18_762 0 n36 ns762 0 -0.000376389687437
Gc18_763 0 n36 ns763 0 -0.000492773703383
Gc18_764 0 n36 ns764 0 0.000285745667413
Gc18_765 0 n36 ns765 0 0.000139740031805
Gc18_766 0 n36 ns766 0 -4.67485623737e-05
Gc18_767 0 n36 ns767 0 1.2764005238e-05
Gc18_768 0 n36 ns768 0 -2.27279881747e-05
Gc18_769 0 n36 ns769 0 -0.000496032511123
Gc18_770 0 n36 ns770 0 -0.000303444074078
Gc18_771 0 n36 ns771 0 0.000170074751808
Gc18_772 0 n36 ns772 0 -7.44825681299e-05
Gc18_773 0 n36 ns773 0 2.05939695437e-05
Gc18_774 0 n36 ns774 0 7.88476670066e-05
Gc18_775 0 n36 ns775 0 0.000529337859911
Gc18_776 0 n36 ns776 0 0.00105849731428
Gc18_777 0 n36 ns777 0 0.000604635708966
Gc18_778 0 n36 ns778 0 -0.000209760970268
Gc18_779 0 n36 ns779 0 0.000176696521789
Gc18_780 0 n36 ns780 0 1.06953492359e-08
Gc18_781 0 n36 ns781 0 -0.00102662645783
Gc18_782 0 n36 ns782 0 -0.000355417466359
Gc18_783 0 n36 ns783 0 0.00102448554807
Gc18_784 0 n36 ns784 0 0.00441377710314
Gc18_785 0 n36 ns785 0 0.00132232553488
Gc18_786 0 n36 ns786 0 0.00414970583213
Gc18_787 0 n36 ns787 0 -0.00164471936975
Gc18_788 0 n36 ns788 0 0.00066478116224
Gc18_789 0 n36 ns789 0 -2.26564372798e-05
Gc18_790 0 n36 ns790 0 -0.000822859431972
Gc18_791 0 n36 ns791 0 3.74850929274e-05
Gc18_792 0 n36 ns792 0 -0.00145266142513
Gc18_793 0 n36 ns793 0 -0.000497988619771
Gc18_794 0 n36 ns794 0 0.00100883545597
Gc18_795 0 n36 ns795 0 0.000565670327627
Gc18_796 0 n36 ns796 0 -8.21716683802e-06
Gc18_797 0 n36 ns797 0 -0.000118227745114
Gc18_798 0 n36 ns798 0 -2.7706608201e-07
Gc18_799 0 n36 ns799 0 -2.72767092769e-05
Gc18_800 0 n36 ns800 0 0.000196838092928
Gc18_801 0 n36 ns801 0 0.000115346975003
Gc18_802 0 n36 ns802 0 0.00126279391946
Gc18_803 0 n36 ns803 0 3.06897849967e-05
Gc18_804 0 n36 ns804 0 0.000208058774002
Gc18_805 0 n36 ns805 0 -9.35508840834e-05
Gc18_806 0 n36 ns806 0 -0.000166401341147
Gc18_807 0 n36 ns807 0 -0.00022273827234
Gc18_808 0 n36 ns808 0 0.000400938522584
Gc18_809 0 n36 ns809 0 6.77490085926e-05
Gc18_810 0 n36 ns810 0 -0.000165414468402
Gc18_811 0 n36 ns811 0 3.92134635017e-05
Gc18_812 0 n36 ns812 0 -0.000372661102077
Gc18_813 0 n36 ns813 0 0.000965248354787
Gc18_814 0 n36 ns814 0 -0.000570528347521
Gc18_815 0 n36 ns815 0 0.000286826284101
Gc18_816 0 n36 ns816 0 -0.000841813813347
Gc18_817 0 n36 ns817 0 0.000403178033133
Gc18_818 0 n36 ns818 0 -0.000808428225559
Gc18_819 0 n36 ns819 0 2.2293435377e-05
Gc18_820 0 n36 ns820 0 0.00115470410922
Gc18_821 0 n36 ns821 0 0.00400751728224
Gc18_822 0 n36 ns822 0 0.00354325207282
Gc18_823 0 n36 ns823 0 0.0037139225293
Gc18_824 0 n36 ns824 0 0.00295087729834
Gc18_825 0 n36 ns825 0 0.000519312839084
Gc18_826 0 n36 ns826 0 0.00121348388302
Gc18_827 0 n36 ns827 0 -0.000327311100709
Gc18_828 0 n36 ns828 0 -0.000465082679319
Gc18_829 0 n36 ns829 0 -0.00132812070998
Gc18_830 0 n36 ns830 0 -0.00136875023456
Gc18_831 0 n36 ns831 0 -0.000636341047339
Gc18_832 0 n36 ns832 0 -0.000605211182125
Gc18_833 0 n36 ns833 0 5.17371987259e-05
Gc18_834 0 n36 ns834 0 1.16255910546e-05
Gc18_835 0 n36 ns835 0 -6.54300911578e-05
Gc18_836 0 n36 ns836 0 -3.88769937474e-06
Gc18_837 0 n36 ns837 0 0.00015830561811
Gc18_838 0 n36 ns838 0 0.000363528487177
Gc18_839 0 n36 ns839 0 0.000723989326985
Gc18_840 0 n36 ns840 0 0.00039433752294
Gc18_841 0 n36 ns841 0 -2.37073657191e-05
Gc18_842 0 n36 ns842 0 0.000108577868976
Gc18_843 0 n36 ns843 0 3.11773255972e-07
Gc18_844 0 n36 ns844 0 1.67057995043e-06
Gc18_845 0 n36 ns845 0 0.000222981719668
Gc18_846 0 n36 ns846 0 0.000312199099863
Gc18_847 0 n36 ns847 0 -4.01408518536e-05
Gc18_848 0 n36 ns848 0 -9.19060943639e-05
Gc18_849 0 n36 ns849 0 -0.00018751814184
Gc18_850 0 n36 ns850 0 -0.000356828935135
Gc18_851 0 n36 ns851 0 -4.70819934634e-05
Gc18_852 0 n36 ns852 0 -0.000814035002588
Gc18_853 0 n36 ns853 0 -0.000311722111891
Gc18_854 0 n36 ns854 0 -0.000511196601514
Gc18_855 0 n36 ns855 0 -0.0002518158285
Gc18_856 0 n36 ns856 0 -0.000639270184938
Gc18_857 0 n36 ns857 0 0.000650897224971
Gc18_858 0 n36 ns858 0 0.000466809156395
Gc18_859 0 n36 ns859 0 0.00316058120641
Gc18_860 0 n36 ns860 0 -0.000122029851937
Gc18_861 0 n36 ns861 0 0.00276581127194
Gc18_862 0 n36 ns862 0 -0.000231501335639
Gc18_863 0 n36 ns863 0 0.000614491543588
Gc18_864 0 n36 ns864 0 0.000521793352461
Gc18_865 0 n36 ns865 0 -0.000243989399281
Gc18_866 0 n36 ns866 0 -0.000179198883634
Gc18_867 0 n36 ns867 0 -0.00101213329747
Gc18_868 0 n36 ns868 0 -0.000515792749833
Gc18_869 0 n36 ns869 0 -0.000412931414897
Gc18_870 0 n36 ns870 0 -0.000301114273552
Gc18_871 0 n36 ns871 0 3.5172663983e-05
Gc18_872 0 n36 ns872 0 7.42640151606e-06
Gc18_873 0 n36 ns873 0 -2.25376808152e-05
Gc18_874 0 n36 ns874 0 -1.35538437674e-06
Gc18_875 0 n36 ns875 0 0.00010717899595
Gc18_876 0 n36 ns876 0 0.000272698582533
Gc18_877 0 n36 ns877 0 0.000503037281112
Gc18_878 0 n36 ns878 0 -0.000401058780396
Gc18_879 0 n36 ns879 0 -4.59639955314e-05
Gc18_880 0 n36 ns880 0 1.76226736945e-05
Gc18_881 0 n36 ns881 0 7.9921323882e-05
Gc18_882 0 n36 ns882 0 -1.18591717761e-05
Gc18_883 0 n36 ns883 0 0.000211483288655
Gc18_884 0 n36 ns884 0 -3.74924551017e-05
Gc18_885 0 n36 ns885 0 -4.99039026357e-05
Gc18_886 0 n36 ns886 0 -3.59029707924e-06
Gc18_887 0 n36 ns887 0 -0.00022565512993
Gc18_888 0 n36 ns888 0 -6.49510393273e-06
Gc18_889 0 n36 ns889 0 -0.000384718597516
Gc18_890 0 n36 ns890 0 -0.000139452388489
Gc18_891 0 n36 ns891 0 -0.000305489713165
Gc18_892 0 n36 ns892 0 3.67652314713e-05
Gc18_893 0 n36 ns893 0 -0.00035372144165
Gc18_894 0 n36 ns894 0 6.28087450504e-06
Gc18_895 0 n36 ns895 0 0.000275404312325
Gc18_896 0 n36 ns896 0 -0.0001503890545
Gc18_897 0 n36 ns897 0 0.000715213333887
Gc18_898 0 n36 ns898 0 -0.00140820660317
Gc18_899 0 n36 ns899 0 0.000604534155128
Gc18_900 0 n36 ns900 0 -0.001257235895
Gc18_901 0 n36 ns901 0 0.000206048674332
Gc18_902 0 n36 ns902 0 0.000291860088826
Gc18_903 0 n36 ns903 0 -0.000129439195793
Gc18_904 0 n36 ns904 0 -8.05117584404e-05
Gc18_905 0 n36 ns905 0 -0.000473776447884
Gc18_906 0 n36 ns906 0 -0.000198675739142
Gc18_907 0 n36 ns907 0 -0.000188247374076
Gc18_908 0 n36 ns908 0 -9.60381344465e-06
Gc18_909 0 n36 ns909 0 5.76838146999e-05
Gc18_910 0 n36 ns910 0 6.93113697053e-06
Gc18_911 0 n36 ns911 0 9.90676033327e-06
Gc18_912 0 n36 ns912 0 -2.43793617026e-05
Gc18_913 0 n36 ns913 0 0.000179415424553
Gc18_914 0 n36 ns914 0 0.000103664468075
Gc18_915 0 n36 ns915 0 0.000607892277471
Gc18_916 0 n36 ns916 0 -0.000119556887034
Gc18_917 0 n36 ns917 0 7.18551872125e-05
Gc18_918 0 n36 ns918 0 3.06042572656e-05
Gc18_919 0 n36 ns919 0 -5.67368219909e-06
Gc18_920 0 n36 ns920 0 -5.99781205661e-05
Gc18_921 0 n36 ns921 0 7.9164006488e-05
Gc18_922 0 n36 ns922 0 -0.000125402902644
Gc18_923 0 n36 ns923 0 -1.82399829345e-05
Gc18_924 0 n36 ns924 0 1.4980690227e-05
Gc18_925 0 n36 ns925 0 -0.000129850997562
Gc18_926 0 n36 ns926 0 5.15796105793e-05
Gc18_927 0 n36 ns927 0 -0.000148200645439
Gc18_928 0 n36 ns928 0 2.47010590772e-05
Gc18_929 0 n36 ns929 0 -5.02677655669e-05
Gc18_930 0 n36 ns930 0 6.706564481e-05
Gc18_931 0 n36 ns931 0 -3.83790492784e-05
Gc18_932 0 n36 ns932 0 4.10951180737e-05
Gc18_933 0 n36 ns933 0 7.41933309058e-05
Gc18_934 0 n36 ns934 0 -2.12185235856e-05
Gc18_935 0 n36 ns935 0 -0.000186157065365
Gc18_936 0 n36 ns936 0 -0.00057779972585
Gc18_937 0 n36 ns937 0 -0.000168921376407
Gc18_938 0 n36 ns938 0 -0.000524164910983
Gc18_939 0 n36 ns939 0 0.000231536917161
Gc18_940 0 n36 ns940 0 0.000459856115803
Gc18_941 0 n36 ns941 0 -8.16827770334e-05
Gc18_942 0 n36 ns942 0 -9.49928160338e-05
Gc18_943 0 n36 ns943 0 -0.000366333793679
Gc18_944 0 n36 ns944 0 -0.000440428789464
Gc18_945 0 n36 ns945 0 -0.000185496698142
Gc18_946 0 n36 ns946 0 -0.000405382626789
Gc18_947 0 n36 ns947 0 -3.55251176217e-05
Gc18_948 0 n36 ns948 0 1.53201552084e-05
Gc18_949 0 n36 ns949 0 -4.51448952868e-05
Gc18_950 0 n36 ns950 0 1.88806086401e-05
Gc18_951 0 n36 ns951 0 0.00143316870151
Gc18_952 0 n36 ns952 0 -0.00474262288935
Gc18_953 0 n36 ns953 0 0.00173322023934
Gc18_954 0 n36 ns954 0 -0.00377371879604
Gc18_955 0 n36 ns955 0 -0.00134351620405
Gc18_956 0 n36 ns956 0 -0.000808565651712
Gc18_957 0 n36 ns957 0 0.000572830145651
Gc18_958 0 n36 ns958 0 9.09317772123e-06
Gc18_959 0 n36 ns959 0 0.000359550382523
Gc18_960 0 n36 ns960 0 0.000580800439671
Gc18_961 0 n36 ns961 0 0.000143012121159
Gc18_962 0 n36 ns962 0 0.0001201817368
Gc18_963 0 n36 ns963 0 -0.000235636346856
Gc18_964 0 n36 ns964 0 0.0004741523649
Gc18_965 0 n36 ns965 0 9.825967069e-05
Gc18_966 0 n36 ns966 0 -0.00123392248519
Gc18_967 0 n36 ns967 0 0.000451220745477
Gc18_968 0 n36 ns968 0 9.59387121516e-06
Gc18_969 0 n36 ns969 0 0.000216298105411
Gc18_970 0 n36 ns970 0 -0.000823619745947
Gc18_971 0 n36 ns971 0 0.00158384967954
Gc18_972 0 n36 ns972 0 0.00159671544358
Gc18_973 0 n36 ns973 0 0.00260434125941
Gc18_974 0 n36 ns974 0 0.00311943753826
Gc18_975 0 n36 ns975 0 0.00128614014714
Gc18_976 0 n36 ns976 0 0.00341709814258
Gc18_977 0 n36 ns977 0 0.00338885769889
Gc18_978 0 n36 ns978 0 0.000681765873946
Gc18_979 0 n36 ns979 0 0.00129356524137
Gc18_980 0 n36 ns980 0 -0.000538554782917
Gc18_981 0 n36 ns981 0 -0.00344286683498
Gc18_982 0 n36 ns982 0 -9.15071311428e-05
Gc18_983 0 n36 ns983 0 -0.000566958042372
Gc18_984 0 n36 ns984 0 -0.00225036494462
Gc18_985 0 n36 ns985 0 0.00385797850865
Gc18_986 0 n36 ns986 0 1.58172119165e-05
Gc18_987 0 n36 ns987 0 -0.00014223682775
Gc18_988 0 n36 ns988 0 3.18819347348e-05
Gc18_989 0 n36 ns989 0 0.000753600061995
Gc18_990 0 n36 ns990 0 -0.00220401169118
Gc18_991 0 n36 ns991 0 0.00189671840598
Gc18_992 0 n36 ns992 0 -0.00168368813078
Gc18_993 0 n36 ns993 0 -0.000399127757396
Gc18_994 0 n36 ns994 0 -8.92911702882e-05
Gc18_995 0 n36 ns995 0 5.08887146863e-05
Gc18_996 0 n36 ns996 0 3.49050919739e-05
Gc18_997 0 n36 ns997 0 0.000542913003705
Gc18_998 0 n36 ns998 0 -0.000359643465128
Gc18_999 0 n36 ns999 0 0.000172420350843
Gc18_1000 0 n36 ns1000 0 7.98774824159e-05
Gc18_1001 0 n36 ns1001 0 -0.000112705304502
Gc18_1002 0 n36 ns1002 0 0.000229360378665
Gc18_1003 0 n36 ns1003 0 -0.001298294568
Gc18_1004 0 n36 ns1004 0 -0.000232594404851
Gc18_1005 0 n36 ns1005 0 0.000372953814895
Gc18_1006 0 n36 ns1006 0 9.84921459835e-06
Gc18_1007 0 n36 ns1007 0 -0.000249800614258
Gc18_1008 0 n36 ns1008 0 -0.000596770988543
Gc18_1009 0 n36 ns1009 0 0.00159980741395
Gc18_1010 0 n36 ns1010 0 -0.000937714721012
Gc18_1011 0 n36 ns1011 0 -0.000782865672859
Gc18_1012 0 n36 ns1012 0 0.00208087414864
Gc18_1013 0 n36 ns1013 0 -0.000838119102864
Gc18_1014 0 n36 ns1014 0 0.00279545819386
Gc18_1015 0 n36 ns1015 0 -0.000970674072445
Gc18_1016 0 n36 ns1016 0 -0.00262808652338
Gc18_1017 0 n36 ns1017 0 0.000987815592597
Gc18_1018 0 n36 ns1018 0 -0.000991333159249
Gc18_1019 0 n36 ns1019 0 0.00115585434251
Gc18_1020 0 n36 ns1020 0 -0.000168129286459
Gc18_1021 0 n36 ns1021 0 -0.00194440648541
Gc18_1022 0 n36 ns1022 0 0.0027269486415
Gc18_1023 0 n36 ns1023 0 0.00208606766936
Gc18_1024 0 n36 ns1024 0 1.81882157975e-05
Gc18_1025 0 n36 ns1025 0 -0.000262814485939
Gc18_1026 0 n36 ns1026 0 9.83460383775e-05
Gc18_1027 0 n36 ns1027 0 -0.000157514403345
Gc18_1028 0 n36 ns1028 0 -0.000625623228145
Gc18_1029 0 n36 ns1029 0 -0.000539276638875
Gc18_1030 0 n36 ns1030 0 -0.000325087147425
Gc18_1031 0 n36 ns1031 0 9.13302842e-05
Gc18_1032 0 n36 ns1032 0 -0.000101341467976
Gc18_1033 0 n36 ns1033 0 3.282693791e-05
Gc18_1034 0 n36 ns1034 0 0.00010154854018
Gc18_1035 0 n36 ns1035 0 -0.000364564501555
Gc18_1036 0 n36 ns1036 0 -0.000568889185151
Gc18_1037 0 n36 ns1037 0 0.000204457990321
Gc18_1038 0 n36 ns1038 0 -6.29747955283e-06
Gc18_1039 0 n36 ns1039 0 6.77977227528e-05
Gc18_1040 0 n36 ns1040 0 0.000166098364501
Gc18_1041 0 n36 ns1041 0 -0.000105321907631
Gc18_1042 0 n36 ns1042 0 0.00138275350782
Gc18_1043 0 n36 ns1043 0 0.000584754051341
Gc18_1044 0 n36 ns1044 0 5.16232320714e-05
Gc18_1045 0 n36 ns1045 0 -7.11057307193e-05
Gc18_1046 0 n36 ns1046 0 0.000171966523635
Gc18_1047 0 n36 ns1047 0 -0.000889773873305
Gc18_1048 0 n36 ns1048 0 -0.00116879548396
Gc18_1049 0 n36 ns1049 0 -0.000233288969647
Gc18_1050 0 n36 ns1050 0 0.00384063565968
Gc18_1051 0 n36 ns1051 0 0.000206201247498
Gc18_1052 0 n36 ns1052 0 0.0039022839428
Gc18_1053 0 n36 ns1053 0 -0.0024588107018
Gc18_1054 0 n36 ns1054 0 -0.000169317727233
Gc18_1055 0 n36 ns1055 0 0.000209064910906
Gc18_1056 0 n36 ns1056 0 -0.000925360505722
Gc18_1057 0 n36 ns1057 0 0.000756182472946
Gc18_1058 0 n36 ns1058 0 -0.00109716232608
Gc18_1059 0 n36 ns1059 0 -0.000500932699763
Gc18_1060 0 n36 ns1060 0 0.00200049733598
Gc18_1061 0 n36 ns1061 0 0.000915114762225
Gc18_1062 0 n36 ns1062 0 -6.93427432452e-06
Gc18_1063 0 n36 ns1063 0 -0.000139727189632
Gc18_1064 0 n36 ns1064 0 4.4489263277e-06
Gc18_1065 0 n36 ns1065 0 -0.000105891285665
Gc18_1066 0 n36 ns1066 0 -0.00015129378247
Gc18_1067 0 n36 ns1067 0 -0.000257927775135
Gc18_1068 0 n36 ns1068 0 0.000658088691689
Gc18_1069 0 n36 ns1069 0 4.10860870975e-05
Gc18_1070 0 n36 ns1070 0 -2.32664278724e-05
Gc18_1071 0 n36 ns1071 0 -5.41030700537e-05
Gc18_1072 0 n36 ns1072 0 -8.67209180746e-05
Gc18_1073 0 n36 ns1073 0 -0.000514710829155
Gc18_1074 0 n36 ns1074 0 0.000163759774374
Gc18_1075 0 n36 ns1075 0 0.000122692276195
Gc18_1076 0 n36 ns1076 0 -0.000132845568068
Gc18_1077 0 n36 ns1077 0 0.000170040030793
Gc18_1078 0 n36 ns1078 0 -0.000101655832183
Gc18_1079 0 n36 ns1079 0 0.00113539745409
Gc18_1080 0 n36 ns1080 0 8.57295206398e-05
Gc18_1081 0 n36 ns1081 0 0.000521275528182
Gc18_1082 0 n36 ns1082 0 -0.000664051100045
Gc18_1083 0 n36 ns1083 0 0.000477345027596
Gc18_1084 0 n36 ns1084 0 -0.000475227022507
Gc18_1085 0 n36 ns1085 0 -0.000533828497421
Gc18_1086 0 n36 ns1086 0 0.000847969626591
Gc18_1087 0 n36 ns1087 0 0.00323798319132
Gc18_1088 0 n36 ns1088 0 0.00436022336422
Gc18_1089 0 n36 ns1089 0 0.00315983706905
Gc18_1090 0 n36 ns1090 0 0.00377333998809
Gc18_1091 0 n36 ns1091 0 -0.000106492480655
Gc18_1092 0 n36 ns1092 0 0.00121118136943
Gc18_1093 0 n36 ns1093 0 -0.000274282436344
Gc18_1094 0 n36 ns1094 0 -0.00058191551693
Gc18_1095 0 n36 ns1095 0 -0.000996192667247
Gc18_1096 0 n36 ns1096 0 -0.00145658948882
Gc18_1097 0 n36 ns1097 0 -0.000588590547994
Gc18_1098 0 n36 ns1098 0 -0.000137792591171
Gc18_1099 0 n36 ns1099 0 0.000199100992317
Gc18_1100 0 n36 ns1100 0 2.05579710757e-06
Gc18_1101 0 n36 ns1101 0 -6.6233507225e-05
Gc18_1102 0 n36 ns1102 0 -1.37064743194e-05
Gc18_1103 0 n36 ns1103 0 0.000112962872308
Gc18_1104 0 n36 ns1104 0 0.00032453214186
Gc18_1105 0 n36 ns1105 0 0.000564607363501
Gc18_1106 0 n36 ns1106 0 0.000679593851022
Gc18_1107 0 n36 ns1107 0 -4.58873752136e-05
Gc18_1108 0 n36 ns1108 0 1.57861016588e-05
Gc18_1109 0 n36 ns1109 0 -2.18701524466e-05
Gc18_1110 0 n36 ns1110 0 5.93144690631e-05
Gc18_1111 0 n36 ns1111 0 5.01366305514e-05
Gc18_1112 0 n36 ns1112 0 0.000507359297232
Gc18_1113 0 n36 ns1113 0 3.82586051195e-06
Gc18_1114 0 n36 ns1114 0 -0.000146295582913
Gc18_1115 0 n36 ns1115 0 -7.01658649116e-05
Gc18_1116 0 n36 ns1116 0 -0.000481111487395
Gc18_1117 0 n36 ns1117 0 0.000341815525878
Gc18_1118 0 n36 ns1118 0 -0.000954253261538
Gc18_1119 0 n36 ns1119 0 -0.000151117230568
Gc18_1120 0 n36 ns1120 0 -0.000756088112264
Gc18_1121 0 n36 ns1121 0 -3.54619945095e-05
Gc18_1122 0 n36 ns1122 0 -0.000865131806144
Gc18_1123 0 n36 ns1123 0 0.000619971974009
Gc18_1124 0 n36 ns1124 0 0.000823401629737
Gc18_1125 0 n36 ns1125 0 0.00415982087581
Gc18_1126 0 n36 ns1126 0 0.00105256294113
Gc18_1127 0 n36 ns1127 0 0.00369244342657
Gc18_1128 0 n36 ns1128 0 0.000758512166057
Gc18_1129 0 n36 ns1129 0 0.00068471326324
Gc18_1130 0 n36 ns1130 0 0.000732508708335
Gc18_1131 0 n36 ns1131 0 -0.000291929568018
Gc18_1132 0 n36 ns1132 0 -0.00026669327423
Gc18_1133 0 n36 ns1133 0 -0.00121026552088
Gc18_1134 0 n36 ns1134 0 -0.000778365610946
Gc18_1135 0 n36 ns1135 0 -0.000508490043372
Gc18_1136 0 n36 ns1136 0 -0.000453315931673
Gc18_1137 0 n36 ns1137 0 2.87124652711e-05
Gc18_1138 0 n36 ns1138 0 1.31029871395e-05
Gc18_1139 0 n36 ns1139 0 -3.68129747416e-05
Gc18_1140 0 n36 ns1140 0 -6.5638667645e-06
Gc18_1141 0 n36 ns1141 0 0.000160089571716
Gc18_1142 0 n36 ns1142 0 0.000351650272906
Gc18_1143 0 n36 ns1143 0 0.000719785229037
Gc18_1144 0 n36 ns1144 0 -0.000118336827138
Gc18_1145 0 n36 ns1145 0 2.33316450949e-05
Gc18_1146 0 n36 ns1146 0 6.5246673289e-05
Gc18_1147 0 n36 ns1147 0 2.38796443786e-05
Gc18_1148 0 n36 ns1148 0 -3.81396190119e-07
Gc18_1149 0 n36 ns1149 0 0.000276668684104
Gc18_1150 0 n36 ns1150 0 6.38111864206e-05
Gc18_1151 0 n36 ns1151 0 -6.21352610055e-05
Gc18_1152 0 n36 ns1152 0 -3.68208985377e-05
Gc18_1153 0 n36 ns1153 0 -0.000294718448648
Gc18_1154 0 n36 ns1154 0 -0.00011889604611
Gc18_1155 0 n36 ns1155 0 -0.000403446095781
Gc18_1156 0 n36 ns1156 0 -0.000387166932883
Gc18_1157 0 n36 ns1157 0 -0.000402218813166
Gc18_1158 0 n36 ns1158 0 -0.000127362392568
Gc18_1159 0 n36 ns1159 0 -0.000445984067109
Gc18_1160 0 n36 ns1160 0 -0.000203023167496
Gc18_1161 0 n36 ns1161 0 0.00046686398042
Gc18_1162 0 n36 ns1162 0 -4.793490839e-05
Gc18_1163 0 n36 ns1163 0 0.00159210865643
Gc18_1164 0 n36 ns1164 0 -0.00138087605095
Gc18_1165 0 n36 ns1165 0 0.00136508097529
Gc18_1166 0 n36 ns1166 0 -0.00125914855086
Gc18_1167 0 n36 ns1167 0 0.00032075773184
Gc18_1168 0 n36 ns1168 0 0.000264205072802
Gc18_1169 0 n36 ns1169 0 -0.000167467493999
Gc18_1170 0 n36 ns1170 0 -8.83627581052e-05
Gc18_1171 0 n36 ns1171 0 -0.000636569195443
Gc18_1172 0 n36 ns1172 0 -0.000169981315866
Gc18_1173 0 n36 ns1173 0 -0.000248068571263
Gc18_1174 0 n36 ns1174 0 6.40226513205e-05
Gc18_1175 0 n36 ns1175 0 9.01951334884e-05
Gc18_1176 0 n36 ns1176 0 8.38787086595e-06
Gc18_1177 0 n36 ns1177 0 -2.5920865174e-05
Gc18_1178 0 n36 ns1178 0 -6.95660817722e-06
Gc18_1179 0 n36 ns1179 0 6.77486751704e-05
Gc18_1180 0 n36 ns1180 0 0.000231727464244
Gc18_1181 0 n36 ns1181 0 0.000389035550301
Gc18_1182 0 n36 ns1182 0 -0.000105746260246
Gc18_1183 0 n36 ns1183 0 3.44918141704e-05
Gc18_1184 0 n36 ns1184 0 5.48041214787e-05
Gc18_1185 0 n36 ns1185 0 2.14709213212e-05
Gc18_1186 0 n36 ns1186 0 -5.57725171558e-05
Gc18_1187 0 n36 ns1187 0 0.000115278920055
Gc18_1188 0 n36 ns1188 0 -0.000103040772586
Gc18_1189 0 n36 ns1189 0 -2.49275776431e-05
Gc18_1190 0 n36 ns1190 0 1.49254302093e-05
Gc18_1191 0 n36 ns1191 0 -0.000136205341903
Gc18_1192 0 n36 ns1192 0 3.37979209528e-05
Gc18_1193 0 n36 ns1193 0 -0.000216024231205
Gc18_1194 0 n36 ns1194 0 2.44311740525e-05
Gc18_1195 0 n36 ns1195 0 -0.000113436749429
Gc18_1196 0 n36 ns1196 0 0.000108630487828
Gc18_1197 0 n36 ns1197 0 -0.000111194775999
Gc18_1198 0 n36 ns1198 0 0.000105940192866
Gc18_1199 0 n36 ns1199 0 6.45902268525e-05
Gc18_1200 0 n36 ns1200 0 -6.96096477359e-05
Gc18_1201 0 n36 ns1201 0 -0.000164061681159
Gc18_1202 0 n36 ns1202 0 -0.000853178859111
Gc18_1203 0 n36 ns1203 0 -0.000148013831617
Gc18_1204 0 n36 ns1204 0 -0.0007651735647
Gc18_1205 0 n36 ns1205 0 0.000217408824023
Gc18_1206 0 n36 ns1206 0 0.000431404457068
Gc18_1207 0 n36 ns1207 0 -9.964002843e-05
Gc18_1208 0 n36 ns1208 0 -8.61787793577e-05
Gc18_1209 0 n36 ns1209 0 -0.000388364928991
Gc18_1210 0 n36 ns1210 0 -0.00035304031563
Gc18_1211 0 n36 ns1211 0 -0.000170214996743
Gc18_1212 0 n36 ns1212 0 -0.000264397083241
Gc18_1213 0 n36 ns1213 0 -6.243873825e-06
Gc18_1214 0 n36 ns1214 0 8.46610295777e-06
Gc18_1215 0 n36 ns1215 0 -3.13958622397e-05
Gc18_1216 0 n36 ns1216 0 4.17929862626e-06
Gd18_1 0 n36 ni1 0 -0.00362329529389
Gd18_2 0 n36 ni2 0 0.000392487806684
Gd18_3 0 n36 ni3 0 0.000128465711986
Gd18_4 0 n36 ni4 0 0.000427889514266
Gd18_5 0 n36 ni5 0 -0.000203225458498
Gd18_6 0 n36 ni6 0 0.000233639905433
Gd18_7 0 n36 ni7 0 0.000624394419746
Gd18_8 0 n36 ni8 0 -1.86302800436e-05
Gd18_9 0 n36 ni9 0 0.000205167652426
Gd18_10 0 n36 ni10 0 -0.00176689238037
Gd18_11 0 n36 ni11 0 0.000490451749277
Gd18_12 0 n36 ni12 0 -0.000450976910506
Gd18_13 0 n36 ni13 0 0.000215182110441
Gd18_14 0 n36 ni14 0 0.000816718972944
Gd18_15 0 n36 ni15 0 1.4896356336e-05
Gd18_16 0 n36 ni16 0 -0.000128053798906
Gd18_17 0 n36 ni17 0 -0.00318488586527
Gd18_18 0 n36 ni18 0 -0.000252489289036
Gd18_19 0 n36 ni19 0 -0.00174729325514
Gd18_20 0 n36 ni20 0 -0.000916537579227
Gd18_21 0 n36 ni21 0 0.000247326690765
Gd18_22 0 n36 ni22 0 0.00028031635149
Gd18_23 0 n36 ni23 0 2.65169006861e-05
Gd18_24 0 n36 ni24 0 -3.43238850177e-05
Gd18_25 0 n36 ni25 0 -7.95383727057e-05
Gd18_26 0 n36 ni26 0 -0.00337258140101
Gd18_27 0 n36 ni27 0 -0.0018257953997
Gd18_28 0 n36 ni28 0 9.31328188723e-05
Gd18_29 0 n36 ni29 0 0.000189088456928
Gd18_30 0 n36 ni30 0 9.79348559988e-05
Gd18_31 0 n36 ni31 0 -3.8658509205e-06
Gd18_32 0 n36 ni32 0 5.54771970978e-05
Gc19_1 0 n38 ns1 0 -0.000986303630585
Gc19_2 0 n38 ns2 0 0.000236742689633
Gc19_3 0 n38 ns3 0 -0.00302196143105
Gc19_4 0 n38 ns4 0 0.00113026697281
Gc19_5 0 n38 ns5 0 -0.00012412276733
Gc19_6 0 n38 ns6 0 0.000963955605448
Gc19_7 0 n38 ns7 0 0.000239231052025
Gc19_8 0 n38 ns8 0 -0.000408814015608
Gc19_9 0 n38 ns9 0 -0.000734805362437
Gc19_10 0 n38 ns10 0 -9.72069956758e-06
Gc19_11 0 n38 ns11 0 -0.000103931486953
Gc19_12 0 n38 ns12 0 -2.47896305311e-05
Gc19_13 0 n38 ns13 0 0.00104730484433
Gc19_14 0 n38 ns14 0 0.000340371235319
Gc19_15 0 n38 ns15 0 -0.000317650506649
Gc19_16 0 n38 ns16 0 -0.00114258017413
Gc19_17 0 n38 ns17 0 0.000456901696431
Gc19_18 0 n38 ns18 0 2.78922542839e-05
Gc19_19 0 n38 ns19 0 0.000292295265481
Gc19_20 0 n38 ns20 0 -0.000533796594838
Gc19_21 0 n38 ns21 0 -0.00252110884606
Gc19_22 0 n38 ns22 0 0.000152629678592
Gc19_23 0 n38 ns23 0 -0.00160987086078
Gc19_24 0 n38 ns24 0 0.0010744450886
Gc19_25 0 n38 ns25 0 -0.000780214340421
Gc19_26 0 n38 ns26 0 3.98073330458e-05
Gc19_27 0 n38 ns27 0 0.00194847331093
Gc19_28 0 n38 ns28 0 -0.00198883285104
Gc19_29 0 n38 ns29 0 0.00120781295848
Gc19_30 0 n38 ns30 0 -0.000683184743276
Gc19_31 0 n38 ns31 0 0.000488544439517
Gc19_32 0 n38 ns32 0 4.3838770185e-05
Gc19_33 0 n38 ns33 0 0.00271679562388
Gc19_34 0 n38 ns34 0 -0.0010464927727
Gc19_35 0 n38 ns35 0 -0.00226393262376
Gc19_36 0 n38 ns36 0 -1.00475747723e-05
Gc19_37 0 n38 ns37 0 0.000219611456208
Gc19_38 0 n38 ns38 0 -7.29102846338e-05
Gc19_39 0 n38 ns39 0 -0.00111495967326
Gc19_40 0 n38 ns40 0 -0.000418499882558
Gc19_41 0 n38 ns41 0 -0.00431336748322
Gc19_42 0 n38 ns42 0 -0.00156475458134
Gc19_43 0 n38 ns43 0 -0.00204456686048
Gc19_44 0 n38 ns44 0 0.00101761485995
Gc19_45 0 n38 ns45 0 0.000963056422772
Gc19_46 0 n38 ns46 0 -0.000500077095849
Gc19_47 0 n38 ns47 0 -0.000800660045949
Gc19_48 0 n38 ns48 0 0.000230004176173
Gc19_49 0 n38 ns49 0 -0.000112654109991
Gc19_50 0 n38 ns50 0 -5.97498310621e-05
Gc19_51 0 n38 ns51 0 0.000952765542616
Gc19_52 0 n38 ns52 0 -1.99085885427e-05
Gc19_53 0 n38 ns53 0 0.00026280500726
Gc19_54 0 n38 ns54 0 -0.000910405427014
Gc19_55 0 n38 ns55 0 0.000892503169674
Gc19_56 0 n38 ns56 0 0.000271408892164
Gc19_57 0 n38 ns57 0 0.000783440754209
Gc19_58 0 n38 ns58 0 -7.95147281823e-05
Gc19_59 0 n38 ns59 0 -0.00233009951671
Gc19_60 0 n38 ns60 0 -0.000452043034475
Gc19_61 0 n38 ns61 0 -0.00162732653751
Gc19_62 0 n38 ns62 0 -0.00070092411746
Gc19_63 0 n38 ns63 0 -0.000716919270769
Gc19_64 0 n38 ns64 0 -0.0015255738286
Gc19_65 0 n38 ns65 0 0.0030203928654
Gc19_66 0 n38 ns66 0 0.000168331187035
Gc19_67 0 n38 ns67 0 0.00131690233527
Gc19_68 0 n38 ns68 0 -0.000894930697141
Gc19_69 0 n38 ns69 0 -0.000759355536845
Gc19_70 0 n38 ns70 0 -0.00160131904943
Gc19_71 0 n38 ns71 0 0.00292573119399
Gc19_72 0 n38 ns72 0 0.000256149758214
Gc19_73 0 n38 ns73 0 -0.0031305018378
Gc19_74 0 n38 ns74 0 -2.91809615672e-05
Gc19_75 0 n38 ns75 0 0.000391462523906
Gc19_76 0 n38 ns76 0 -0.000226824475247
Gc19_77 0 n38 ns77 0 -0.000407588950417
Gc19_78 0 n38 ns78 0 -0.000247115757912
Gc19_79 0 n38 ns79 0 0.000482191269556
Gc19_80 0 n38 ns80 0 0.00257924523846
Gc19_81 0 n38 ns81 0 0.00129982899628
Gc19_82 0 n38 ns82 0 -0.000970985654354
Gc19_83 0 n38 ns83 0 -0.000412304225551
Gc19_84 0 n38 ns84 0 7.38820573084e-05
Gc19_85 0 n38 ns85 0 0.000165365490288
Gc19_86 0 n38 ns86 0 0.000564544970318
Gc19_87 0 n38 ns87 0 -0.000130507439931
Gc19_88 0 n38 ns88 0 -0.000116350398535
Gc19_89 0 n38 ns89 0 0.00168408513912
Gc19_90 0 n38 ns90 0 -0.00113759189758
Gc19_91 0 n38 ns91 0 -0.000689918363684
Gc19_92 0 n38 ns92 0 0.00180134259119
Gc19_93 0 n38 ns93 0 -9.94919137776e-05
Gc19_94 0 n38 ns94 0 0.00044699286779
Gc19_95 0 n38 ns95 0 -0.00166118746667
Gc19_96 0 n38 ns96 0 -0.000842710888631
Gc19_97 0 n38 ns97 0 0.00329342318002
Gc19_98 0 n38 ns98 0 0.00411662188282
Gc19_99 0 n38 ns99 0 -0.00676152431704
Gc19_100 0 n38 ns100 0 -0.000174859040826
Gc19_101 0 n38 ns101 0 -0.00480086294786
Gc19_102 0 n38 ns102 0 -0.00149149904084
Gc19_103 0 n38 ns103 0 -0.0115052316879
Gc19_104 0 n38 ns104 0 -0.00118209349239
Gc19_105 0 n38 ns105 0 0.0016988812156
Gc19_106 0 n38 ns106 0 6.84348648948e-05
Gc19_107 0 n38 ns107 0 -0.00270866214204
Gc19_108 0 n38 ns108 0 0.00889921423519
Gc19_109 0 n38 ns109 0 -0.014039133405
Gc19_110 0 n38 ns110 0 -0.00375199093611
Gc19_111 0 n38 ns111 0 -0.00620181640238
Gc19_112 0 n38 ns112 0 -6.13665500758e-05
Gc19_113 0 n38 ns113 0 -0.000422244602015
Gc19_114 0 n38 ns114 0 0.000612688749061
Gc19_115 0 n38 ns115 0 -0.000787919549375
Gc19_116 0 n38 ns116 0 -0.000999531181007
Gc19_117 0 n38 ns117 0 -0.00329524252898
Gc19_118 0 n38 ns118 0 -0.00171291031195
Gc19_119 0 n38 ns119 0 -0.00194186149688
Gc19_120 0 n38 ns120 0 0.00101715356324
Gc19_121 0 n38 ns121 0 0.000885485778831
Gc19_122 0 n38 ns122 0 -0.000360942107017
Gc19_123 0 n38 ns123 0 -0.000167151391057
Gc19_124 0 n38 ns124 0 0.000144844399992
Gc19_125 0 n38 ns125 0 -0.000265302128075
Gc19_126 0 n38 ns126 0 -3.08581212348e-06
Gc19_127 0 n38 ns127 0 0.000392472678707
Gc19_128 0 n38 ns128 0 0.000344877274736
Gc19_129 0 n38 ns129 0 0.00109614398693
Gc19_130 0 n38 ns130 0 -0.000620525494026
Gc19_131 0 n38 ns131 0 0.0013411002154
Gc19_132 0 n38 ns132 0 -0.000315188107017
Gc19_133 0 n38 ns133 0 0.00119000085589
Gc19_134 0 n38 ns134 0 -0.000651731510342
Gc19_135 0 n38 ns135 0 -0.00173017822349
Gc19_136 0 n38 ns136 0 -0.000901533732297
Gc19_137 0 n38 ns137 0 -0.00469372024135
Gc19_138 0 n38 ns138 0 -0.00443136803029
Gc19_139 0 n38 ns139 0 -0.00364529562002
Gc19_140 0 n38 ns140 0 -0.00470293799647
Gc19_141 0 n38 ns141 0 0.00305711932383
Gc19_142 0 n38 ns142 0 0.0018067970725
Gc19_143 0 n38 ns143 0 0.000951088240936
Gc19_144 0 n38 ns144 0 -0.00121902722411
Gc19_145 0 n38 ns145 0 -0.00172103494696
Gc19_146 0 n38 ns146 0 -0.00292715734945
Gc19_147 0 n38 ns147 0 0.00254515972127
Gc19_148 0 n38 ns148 0 -0.000558633437052
Gc19_149 0 n38 ns149 0 -0.00319861403112
Gc19_150 0 n38 ns150 0 -3.75505741383e-05
Gc19_151 0 n38 ns151 0 0.000337713337959
Gc19_152 0 n38 ns152 0 -0.000162582181839
Gc19_153 0 n38 ns153 0 -0.000598107576387
Gc19_154 0 n38 ns154 0 0.000335871351089
Gc19_155 0 n38 ns155 0 -0.00138838280207
Gc19_156 0 n38 ns156 0 0.00258930112822
Gc19_157 0 n38 ns157 0 -0.00020788239587
Gc19_158 0 n38 ns158 0 0.000549860952585
Gc19_159 0 n38 ns159 0 0.00021561089094
Gc19_160 0 n38 ns160 0 -0.000412648164109
Gc19_161 0 n38 ns161 0 -0.000151534106563
Gc19_162 0 n38 ns162 0 0.000444537460453
Gc19_163 0 n38 ns163 0 -0.000113316241816
Gc19_164 0 n38 ns164 0 0.000109163910985
Gc19_165 0 n38 ns165 0 0.000918502792466
Gc19_166 0 n38 ns166 0 -0.000617481427582
Gc19_167 0 n38 ns167 0 -5.44043037525e-05
Gc19_168 0 n38 ns168 0 -0.00032798427671
Gc19_169 0 n38 ns169 0 0.000626171086964
Gc19_170 0 n38 ns170 0 -0.000535397320942
Gc19_171 0 n38 ns171 0 0.000207109379871
Gc19_172 0 n38 ns172 0 -0.000715734762993
Gc19_173 0 n38 ns173 0 -0.00100873479352
Gc19_174 0 n38 ns174 0 0.000990612274925
Gc19_175 0 n38 ns175 0 -0.00290515232135
Gc19_176 0 n38 ns176 0 -0.00272333110073
Gc19_177 0 n38 ns177 0 -0.00264460431868
Gc19_178 0 n38 ns178 0 -0.00311989154535
Gc19_179 0 n38 ns179 0 -0.000351691062861
Gc19_180 0 n38 ns180 0 0.00104947862254
Gc19_181 0 n38 ns181 0 0.000314769554992
Gc19_182 0 n38 ns182 0 -0.00136851424668
Gc19_183 0 n38 ns183 0 -0.000125770566005
Gc19_184 0 n38 ns184 0 -0.00308886369371
Gc19_185 0 n38 ns185 0 0.00102658473745
Gc19_186 0 n38 ns186 0 -0.00342446038464
Gc19_187 0 n38 ns187 0 -0.00161462681058
Gc19_188 0 n38 ns188 0 -2.85776694104e-05
Gc19_189 0 n38 ns189 0 0.000113925092169
Gc19_190 0 n38 ns190 0 -7.59606033889e-06
Gc19_191 0 n38 ns191 0 -7.48886493068e-05
Gc19_192 0 n38 ns192 0 -0.000304088217138
Gc19_193 0 n38 ns193 0 -0.000198602609122
Gc19_194 0 n38 ns194 0 0.000263192704794
Gc19_195 0 n38 ns195 0 -0.00011265534677
Gc19_196 0 n38 ns196 0 2.87922396181e-05
Gc19_197 0 n38 ns197 0 -7.87292815738e-05
Gc19_198 0 n38 ns198 0 -1.15900558775e-05
Gc19_199 0 n38 ns199 0 0.000175504808993
Gc19_200 0 n38 ns200 0 0.000233830653844
Gc19_201 0 n38 ns201 0 -6.66480358647e-05
Gc19_202 0 n38 ns202 0 0.000123896468314
Gc19_203 0 n38 ns203 0 6.15385489838e-05
Gc19_204 0 n38 ns204 0 -0.000209594097287
Gc19_205 0 n38 ns205 0 0.000355196070539
Gc19_206 0 n38 ns206 0 0.00057887376069
Gc19_207 0 n38 ns207 0 0.000385210910439
Gc19_208 0 n38 ns208 0 -0.000301720768258
Gc19_209 0 n38 ns209 0 9.43732019102e-05
Gc19_210 0 n38 ns210 0 -6.3730018164e-05
Gc19_211 0 n38 ns211 0 -0.000101879634281
Gc19_212 0 n38 ns212 0 -2.19178744444e-05
Gc19_213 0 n38 ns213 0 -0.00418718807875
Gc19_214 0 n38 ns214 0 -0.00459130281294
Gc19_215 0 n38 ns215 0 -0.00395227044066
Gc19_216 0 n38 ns216 0 -0.00418623516523
Gc19_217 0 n38 ns217 0 -0.000648090654254
Gc19_218 0 n38 ns218 0 0.00183016624944
Gc19_219 0 n38 ns219 0 -0.000209488642132
Gc19_220 0 n38 ns220 0 -0.000927508257869
Gc19_221 0 n38 ns221 0 -0.000721563223821
Gc19_222 0 n38 ns222 0 -0.00244155765505
Gc19_223 0 n38 ns223 0 0.000144229226075
Gc19_224 0 n38 ns224 0 -0.0016771891071
Gc19_225 0 n38 ns225 0 -0.000617010899307
Gc19_226 0 n38 ns226 0 -1.76323720103e-05
Gc19_227 0 n38 ns227 0 7.88685790701e-05
Gc19_228 0 n38 ns228 0 -1.62379171692e-07
Gc19_229 0 n38 ns229 0 0.000334053174132
Gc19_230 0 n38 ns230 0 -0.000178728122063
Gc19_231 0 n38 ns231 0 0.00123685921107
Gc19_232 0 n38 ns232 0 -0.00039955948028
Gc19_233 0 n38 ns233 0 0.000230160941614
Gc19_234 0 n38 ns234 0 -3.13223314713e-05
Gc19_235 0 n38 ns235 0 -7.56393465806e-05
Gc19_236 0 n38 ns236 0 5.67760204015e-05
Gc19_237 0 n38 ns237 0 0.00029951063501
Gc19_238 0 n38 ns238 0 -0.000387395296721
Gc19_239 0 n38 ns239 0 -7.20515101959e-05
Gc19_240 0 n38 ns240 0 0.000110395107815
Gc19_241 0 n38 ns241 0 -0.000176285268311
Gc19_242 0 n38 ns242 0 0.000396767101892
Gc19_243 0 n38 ns243 0 0.00041731810038
Gc19_244 0 n38 ns244 0 -0.000204668359061
Gc19_245 0 n38 ns245 0 -7.69513317824e-05
Gc19_246 0 n38 ns246 0 -0.000560220378267
Gc19_247 0 n38 ns247 0 -0.000211783556936
Gc19_248 0 n38 ns248 0 -0.000510253233591
Gc19_249 0 n38 ns249 0 -4.97554884108e-05
Gc19_250 0 n38 ns250 0 -0.000362414926303
Gc19_251 0 n38 ns251 0 -0.0047594493814
Gc19_252 0 n38 ns252 0 -0.00140016711404
Gc19_253 0 n38 ns253 0 -0.00431424711467
Gc19_254 0 n38 ns254 0 -0.00117643781656
Gc19_255 0 n38 ns255 0 0.000609215928586
Gc19_256 0 n38 ns256 0 0.0017075982277
Gc19_257 0 n38 ns257 0 -0.000386615123894
Gc19_258 0 n38 ns258 0 -0.000492564312166
Gc19_259 0 n38 ns259 0 -0.00142492277698
Gc19_260 0 n38 ns260 0 -0.00162863361596
Gc19_261 0 n38 ns261 0 -0.000235804671066
Gc19_262 0 n38 ns262 0 -0.00132783663087
Gc19_263 0 n38 ns263 0 -0.000380159625493
Gc19_264 0 n38 ns264 0 -3.49191901059e-06
Gc19_265 0 n38 ns265 0 2.85981767605e-05
Gc19_266 0 n38 ns266 0 2.60032926233e-05
Gc19_267 0 n38 ns267 0 -0.000309645972729
Gc19_268 0 n38 ns268 0 0.00104939073332
Gc19_269 0 n38 ns269 0 -0.00051846493564
Gc19_270 0 n38 ns270 0 0.00130020959744
Gc19_271 0 n38 ns271 0 -0.000100416366399
Gc19_272 0 n38 ns272 0 0.000502219839682
Gc19_273 0 n38 ns273 0 9.40390213904e-05
Gc19_274 0 n38 ns274 0 -0.000316032682721
Gc19_275 0 n38 ns275 0 -6.49209402761e-06
Gc19_276 0 n38 ns276 0 -1.47944733198e-05
Gc19_277 0 n38 ns277 0 0.000102895430011
Gc19_278 0 n38 ns278 0 3.68032623449e-05
Gc19_279 0 n38 ns279 0 0.000220808488978
Gc19_280 0 n38 ns280 0 -0.000460301754249
Gc19_281 0 n38 ns281 0 5.70122351465e-05
Gc19_282 0 n38 ns282 0 -0.000685231529205
Gc19_283 0 n38 ns283 0 -0.0002865310496
Gc19_284 0 n38 ns284 0 -0.000365967317741
Gc19_285 0 n38 ns285 0 -0.000256022752471
Gc19_286 0 n38 ns286 0 -0.000340176635245
Gc19_287 0 n38 ns287 0 -0.000458564602205
Gc19_288 0 n38 ns288 0 0.000160931349817
Gc19_289 0 n38 ns289 0 -0.00364436884264
Gc19_290 0 n38 ns290 0 0.00191942656541
Gc19_291 0 n38 ns291 0 -0.00317126510051
Gc19_292 0 n38 ns292 0 0.00169926927926
Gc19_293 0 n38 ns293 0 0.00102939756149
Gc19_294 0 n38 ns294 0 0.0013981332085
Gc19_295 0 n38 ns295 0 -0.00033612748781
Gc19_296 0 n38 ns296 0 -0.000269965516907
Gc19_297 0 n38 ns297 0 -0.00134465353178
Gc19_298 0 n38 ns298 0 -0.0011676843888
Gc19_299 0 n38 ns299 0 -0.000268918770938
Gc19_300 0 n38 ns300 0 -0.00119237140127
Gc19_301 0 n38 ns301 0 -0.000312961357187
Gc19_302 0 n38 ns302 0 -6.98090230664e-06
Gc19_303 0 n38 ns303 0 1.57299522779e-05
Gc19_304 0 n38 ns304 0 1.64313747194e-05
Gc19_305 0 n38 ns305 0 0.000301295060201
Gc19_306 0 n38 ns306 0 -0.000318109829046
Gc19_307 0 n38 ns307 0 0.000714640246733
Gc19_308 0 n38 ns308 0 -0.000495668452242
Gc19_309 0 n38 ns309 0 0.000169100941294
Gc19_310 0 n38 ns310 0 -0.000214806520363
Gc19_311 0 n38 ns311 0 -0.000149776846962
Gc19_312 0 n38 ns312 0 9.74067404234e-05
Gc19_313 0 n38 ns313 0 -0.000266092526258
Gc19_314 0 n38 ns314 0 -1.74521838745e-06
Gc19_315 0 n38 ns315 0 8.4872242915e-05
Gc19_316 0 n38 ns316 0 8.96503959673e-06
Gc19_317 0 n38 ns317 0 6.78953381445e-05
Gc19_318 0 n38 ns318 0 -0.000158075365893
Gc19_319 0 n38 ns319 0 -0.000367805418449
Gc19_320 0 n38 ns320 0 -0.000122353955095
Gc19_321 0 n38 ns321 0 -0.000366966052413
Gc19_322 0 n38 ns322 0 9.2391699103e-05
Gc19_323 0 n38 ns323 0 -0.00045323768349
Gc19_324 0 n38 ns324 0 0.000177299555876
Gc19_325 0 n38 ns325 0 -0.000338003455192
Gc19_326 0 n38 ns326 0 -3.57110737257e-05
Gc19_327 0 n38 ns327 0 -0.00148778782998
Gc19_328 0 n38 ns328 0 0.00131549208031
Gc19_329 0 n38 ns329 0 -0.00127170194883
Gc19_330 0 n38 ns330 0 0.00118131499654
Gc19_331 0 n38 ns331 0 0.000437385494529
Gc19_332 0 n38 ns332 0 0.000336384067321
Gc19_333 0 n38 ns333 0 -0.000146086735501
Gc19_334 0 n38 ns334 0 -7.28751840423e-05
Gc19_335 0 n38 ns335 0 -0.000572689013425
Gc19_336 0 n38 ns336 0 -0.000216949612259
Gc19_337 0 n38 ns337 0 -7.24364969976e-05
Gc19_338 0 n38 ns338 0 -0.000137171495088
Gc19_339 0 n38 ns339 0 -6.65933598947e-05
Gc19_340 0 n38 ns340 0 -1.23309283563e-05
Gc19_341 0 n38 ns341 0 1.7466154506e-05
Gc19_342 0 n38 ns342 0 9.54273851877e-06
Gc19_343 0 n38 ns343 0 0.00220558986845
Gc19_344 0 n38 ns344 0 -0.00343934848333
Gc19_345 0 n38 ns345 0 0.0045406472757
Gc19_346 0 n38 ns346 0 -0.00711342693607
Gc19_347 0 n38 ns347 0 -0.00343938460733
Gc19_348 0 n38 ns348 0 -0.00251444779372
Gc19_349 0 n38 ns349 0 0.00111245612585
Gc19_350 0 n38 ns350 0 0.000747167476175
Gc19_351 0 n38 ns351 0 -0.000671874637203
Gc19_352 0 n38 ns352 0 -0.000106899072853
Gc19_353 0 n38 ns353 0 -0.000187464334249
Gc19_354 0 n38 ns354 0 -0.00013091572491
Gc19_355 0 n38 ns355 0 -0.000471369823842
Gc19_356 0 n38 ns356 0 -0.000765159357949
Gc19_357 0 n38 ns357 0 0.000705105648078
Gc19_358 0 n38 ns358 0 0.00056553064745
Gc19_359 0 n38 ns359 0 0.000969211676406
Gc19_360 0 n38 ns360 0 0.000976837782433
Gc19_361 0 n38 ns361 0 0.000381623301772
Gc19_362 0 n38 ns362 0 0.00121757693438
Gc19_363 0 n38 ns363 0 0.000924115827003
Gc19_364 0 n38 ns364 0 -0.0025852469424
Gc19_365 0 n38 ns365 0 0.00192828312312
Gc19_366 0 n38 ns366 0 -0.00711105917989
Gc19_367 0 n38 ns367 0 0.00214479068353
Gc19_368 0 n38 ns368 0 -0.00683527665191
Gc19_369 0 n38 ns369 0 0.00475317994896
Gc19_370 0 n38 ns370 0 0.00662594356324
Gc19_371 0 n38 ns371 0 0.00113965947647
Gc19_372 0 n38 ns372 0 -0.00105012946627
Gc19_373 0 n38 ns373 0 -0.00421300109505
Gc19_374 0 n38 ns374 0 -0.0049947077068
Gc19_375 0 n38 ns375 0 0.00178036940817
Gc19_376 0 n38 ns376 0 0.0061057036523
Gc19_377 0 n38 ns377 0 -0.00416675668553
Gc19_378 0 n38 ns378 0 -1.03269137991e-05
Gc19_379 0 n38 ns379 0 0.00037669632546
Gc19_380 0 n38 ns380 0 -0.000225533898129
Gc19_381 0 n38 ns381 0 0.00127731273238
Gc19_382 0 n38 ns382 0 -0.00281894207294
Gc19_383 0 n38 ns383 0 0.00238220100996
Gc19_384 0 n38 ns384 0 -0.00469325511826
Gc19_385 0 n38 ns385 0 -0.00236964123153
Gc19_386 0 n38 ns386 0 -0.00138976496058
Gc19_387 0 n38 ns387 0 0.00083528398829
Gc19_388 0 n38 ns388 0 0.000582865226913
Gc19_389 0 n38 ns389 0 -0.00021128284594
Gc19_390 0 n38 ns390 0 -0.00020950361523
Gc19_391 0 n38 ns391 0 -0.000300686566443
Gc19_392 0 n38 ns392 0 -7.71539047312e-05
Gc19_393 0 n38 ns393 0 -0.000319597889059
Gc19_394 0 n38 ns394 0 0.000162063343214
Gc19_395 0 n38 ns395 0 0.00128989463972
Gc19_396 0 n38 ns396 0 -1.99552946613e-05
Gc19_397 0 n38 ns397 0 0.00127338355424
Gc19_398 0 n38 ns398 0 0.000151497942682
Gc19_399 0 n38 ns399 0 0.000830455593155
Gc19_400 0 n38 ns400 0 -2.97071859355e-05
Gc19_401 0 n38 ns401 0 -0.000344789751975
Gc19_402 0 n38 ns402 0 -0.00206161343114
Gc19_403 0 n38 ns403 0 -0.00308683426427
Gc19_404 0 n38 ns404 0 -0.00580919422562
Gc19_405 0 n38 ns405 0 -0.00219850596386
Gc19_406 0 n38 ns406 0 -0.00588062232161
Gc19_407 0 n38 ns407 0 0.00390245278775
Gc19_408 0 n38 ns408 0 0.00359172475555
Gc19_409 0 n38 ns409 0 0.00109313493677
Gc19_410 0 n38 ns410 0 -0.00112102430391
Gc19_411 0 n38 ns411 0 -0.0025839958194
Gc19_412 0 n38 ns412 0 -0.00314223976603
Gc19_413 0 n38 ns413 0 0.00235033633179
Gc19_414 0 n38 ns414 0 0.00171986612293
Gc19_415 0 n38 ns415 0 -0.00372604221246
Gc19_416 0 n38 ns416 0 1.27400002819e-05
Gc19_417 0 n38 ns417 0 0.000246746843749
Gc19_418 0 n38 ns418 0 -0.000119377172161
Gc19_419 0 n38 ns419 0 -0.000880905366752
Gc19_420 0 n38 ns420 0 0.000130102308081
Gc19_421 0 n38 ns421 0 -0.00248834154428
Gc19_422 0 n38 ns422 0 0.00211659530454
Gc19_423 0 n38 ns423 0 -0.000479482840327
Gc19_424 0 n38 ns424 0 0.00088680871149
Gc19_425 0 n38 ns425 0 0.000412101727572
Gc19_426 0 n38 ns426 0 -0.000472033780177
Gc19_427 0 n38 ns427 0 -0.000264130952505
Gc19_428 0 n38 ns428 0 0.000326380197122
Gc19_429 0 n38 ns429 0 -0.000175455350799
Gc19_430 0 n38 ns430 0 9.346216376e-05
Gc19_431 0 n38 ns431 0 0.00106118313616
Gc19_432 0 n38 ns432 0 -0.000274240519864
Gc19_433 0 n38 ns433 0 0.00016060445669
Gc19_434 0 n38 ns434 0 -0.000671904705146
Gc19_435 0 n38 ns435 0 0.000847543213098
Gc19_436 0 n38 ns436 0 -0.000562571162087
Gc19_437 0 n38 ns437 0 0.000468771089868
Gc19_438 0 n38 ns438 0 -0.000895910696657
Gc19_439 0 n38 ns439 0 -0.00155407740632
Gc19_440 0 n38 ns440 0 0.000682691586964
Gc19_441 0 n38 ns441 0 -0.00368884684217
Gc19_442 0 n38 ns442 0 -0.00271406726416
Gc19_443 0 n38 ns443 0 -0.00313458137403
Gc19_444 0 n38 ns444 0 -0.00325854444042
Gc19_445 0 n38 ns445 0 0.000442036046613
Gc19_446 0 n38 ns446 0 0.000785836160766
Gc19_447 0 n38 ns447 0 0.000578553404804
Gc19_448 0 n38 ns448 0 -0.00139535574611
Gc19_449 0 n38 ns449 0 -0.000178024571309
Gc19_450 0 n38 ns450 0 -0.00288786346967
Gc19_451 0 n38 ns451 0 0.00165737047028
Gc19_452 0 n38 ns452 0 -0.00343880691856
Gc19_453 0 n38 ns453 0 -0.00215505697458
Gc19_454 0 n38 ns454 0 -2.51871866563e-05
Gc19_455 0 n38 ns455 0 0.000136717303701
Gc19_456 0 n38 ns456 0 -2.1080300569e-05
Gc19_457 0 n38 ns457 0 -0.00019067491147
Gc19_458 0 n38 ns458 0 -0.000316206745856
Gc19_459 0 n38 ns459 0 -0.00054181295939
Gc19_460 0 n38 ns460 0 0.000674234343179
Gc19_461 0 n38 ns461 0 -0.000172248121309
Gc19_462 0 n38 ns462 0 2.58896952255e-05
Gc19_463 0 n38 ns463 0 -2.93832569328e-05
Gc19_464 0 n38 ns464 0 -0.000102775936713
Gc19_465 0 n38 ns465 0 -4.02659247754e-05
Gc19_466 0 n38 ns466 0 0.000383762934258
Gc19_467 0 n38 ns467 0 -8.19589692283e-05
Gc19_468 0 n38 ns468 0 0.000141875857054
Gc19_469 0 n38 ns469 0 0.000419760210614
Gc19_470 0 n38 ns470 0 -0.000408646110571
Gc19_471 0 n38 ns471 0 0.000111585581404
Gc19_472 0 n38 ns472 0 0.0005734306375
Gc19_473 0 n38 ns473 0 0.000487782991899
Gc19_474 0 n38 ns474 0 -0.000261969071976
Gc19_475 0 n38 ns475 0 7.62217390597e-05
Gc19_476 0 n38 ns476 0 -7.25475786312e-05
Gc19_477 0 n38 ns477 0 -0.000295075010815
Gc19_478 0 n38 ns478 0 0.000278216484547
Gc19_479 0 n38 ns479 0 -0.00352730805634
Gc19_480 0 n38 ns480 0 -0.004953756783
Gc19_481 0 n38 ns481 0 -0.00338281178076
Gc19_482 0 n38 ns482 0 -0.00468191752589
Gc19_483 0 n38 ns483 0 -0.000975454950418
Gc19_484 0 n38 ns484 0 0.00161529969888
Gc19_485 0 n38 ns485 0 -5.28471609477e-05
Gc19_486 0 n38 ns486 0 -0.00111572402272
Gc19_487 0 n38 ns487 0 -0.000362403607646
Gc19_488 0 n38 ns488 0 -0.0027194384578
Gc19_489 0 n38 ns489 0 0.000397028775997
Gc19_490 0 n38 ns490 0 -0.00205218783584
Gc19_491 0 n38 ns491 0 -0.000843352725881
Gc19_492 0 n38 ns492 0 -2.06138715844e-05
Gc19_493 0 n38 ns493 0 0.000107932726975
Gc19_494 0 n38 ns494 0 -1.50415463947e-05
Gc19_495 0 n38 ns495 0 0.000319550753972
Gc19_496 0 n38 ns496 0 -0.000583695788832
Gc19_497 0 n38 ns497 0 0.00112941568772
Gc19_498 0 n38 ns498 0 -0.00092202100061
Gc19_499 0 n38 ns499 0 0.000235486917436
Gc19_500 0 n38 ns500 0 -0.000182570769106
Gc19_501 0 n38 ns501 0 -0.000165372436694
Gc19_502 0 n38 ns502 0 0.00015523119194
Gc19_503 0 n38 ns503 0 0.000321905909767
Gc19_504 0 n38 ns504 0 -0.000327054826234
Gc19_505 0 n38 ns505 0 -0.000123004779717
Gc19_506 0 n38 ns506 0 0.000137477142117
Gc19_507 0 n38 ns507 0 -0.00022629768033
Gc19_508 0 n38 ns508 0 0.000544161491534
Gc19_509 0 n38 ns509 0 0.000476842069874
Gc19_510 0 n38 ns510 0 0.000273541187166
Gc19_511 0 n38 ns511 0 7.95787723976e-05
Gc19_512 0 n38 ns512 0 -0.000442440803725
Gc19_513 0 n38 ns513 0 -0.000162260559987
Gc19_514 0 n38 ns514 0 -0.000277834485037
Gc19_515 0 n38 ns515 0 -3.77718766102e-05
Gc19_516 0 n38 ns516 0 -0.000529158229593
Gc19_517 0 n38 ns517 0 -0.00506900025345
Gc19_518 0 n38 ns518 0 -0.00321735791314
Gc19_519 0 n38 ns519 0 -0.00465617962404
Gc19_520 0 n38 ns520 0 -0.00278450846194
Gc19_521 0 n38 ns521 0 7.11525901653e-05
Gc19_522 0 n38 ns522 0 0.00168646404346
Gc19_523 0 n38 ns523 0 -0.000343482400026
Gc19_524 0 n38 ns524 0 -0.000605788256387
Gc19_525 0 n38 ns525 0 -0.00114778165207
Gc19_526 0 n38 ns526 0 -0.00173253098221
Gc19_527 0 n38 ns527 0 -0.0001024043959
Gc19_528 0 n38 ns528 0 -0.00114476141701
Gc19_529 0 n38 ns529 0 -0.000371842243184
Gc19_530 0 n38 ns530 0 -1.04769896638e-05
Gc19_531 0 n38 ns531 0 8.98305176234e-05
Gc19_532 0 n38 ns532 0 -7.36305896253e-06
Gc19_533 0 n38 ns533 0 -0.000459212645979
Gc19_534 0 n38 ns534 0 0.0010291780521
Gc19_535 0 n38 ns535 0 -0.000880164334293
Gc19_536 0 n38 ns536 0 0.000725496617147
Gc19_537 0 n38 ns537 0 -0.000190626910908
Gc19_538 0 n38 ns538 0 0.000412744570472
Gc19_539 0 n38 ns539 0 0.00017310152152
Gc19_540 0 n38 ns540 0 -0.000257001140831
Gc19_541 0 n38 ns541 0 7.56523088628e-05
Gc19_542 0 n38 ns542 0 -0.000188113861415
Gc19_543 0 n38 ns543 0 4.15132303684e-05
Gc19_544 0 n38 ns544 0 9.7150045432e-05
Gc19_545 0 n38 ns545 0 0.000292710418058
Gc19_546 0 n38 ns546 0 -9.19226324065e-05
Gc19_547 0 n38 ns547 0 0.000289728403145
Gc19_548 0 n38 ns548 0 -0.00055276323802
Gc19_549 0 n38 ns549 0 -0.00023607249841
Gc19_550 0 n38 ns550 0 -0.000433014648935
Gc19_551 0 n38 ns551 0 -0.000268327718101
Gc19_552 0 n38 ns552 0 -0.000339166227175
Gc19_553 0 n38 ns553 0 -0.000515355644048
Gc19_554 0 n38 ns554 0 -0.00013627469735
Gc19_555 0 n38 ns555 0 -0.00469317308273
Gc19_556 0 n38 ns556 0 0.000790203457982
Gc19_557 0 n38 ns557 0 -0.00412413078633
Gc19_558 0 n38 ns558 0 0.000750902561444
Gc19_559 0 n38 ns559 0 0.000775588578097
Gc19_560 0 n38 ns560 0 0.00148730953789
Gc19_561 0 n38 ns561 0 -0.000342372682863
Gc19_562 0 n38 ns562 0 -0.000331525250409
Gc19_563 0 n38 ns563 0 -0.00127300809079
Gc19_564 0 n38 ns564 0 -0.00124229595963
Gc19_565 0 n38 ns565 0 -0.000220973905652
Gc19_566 0 n38 ns566 0 -0.00106291594797
Gc19_567 0 n38 ns567 0 -0.000290090534506
Gc19_568 0 n38 ns568 0 -2.54895934136e-05
Gc19_569 0 n38 ns569 0 9.98752006518e-05
Gc19_570 0 n38 ns570 0 -2.7497707841e-05
Gc19_571 0 n38 ns571 0 4.21819599205e-05
Gc19_572 0 n38 ns572 0 0.000137490792504
Gc19_573 0 n38 ns573 0 0.000154348582014
Gc19_574 0 n38 ns574 0 -2.70482036557e-05
Gc19_575 0 n38 ns575 0 5.89476617417e-05
Gc19_576 0 n38 ns576 0 1.04182130877e-05
Gc19_577 0 n38 ns577 0 -7.63171942817e-05
Gc19_578 0 n38 ns578 0 -4.79079611408e-05
Gc19_579 0 n38 ns579 0 -0.000251966181615
Gc19_580 0 n38 ns580 0 -5.45848670111e-06
Gc19_581 0 n38 ns581 0 0.000107004753274
Gc19_582 0 n38 ns582 0 2.65456200487e-05
Gc19_583 0 n38 ns583 0 0.000182826613179
Gc19_584 0 n38 ns584 0 -0.000272150007979
Gc19_585 0 n38 ns585 0 -0.000287666709341
Gc19_586 0 n38 ns586 0 -0.000284808986971
Gc19_587 0 n38 ns587 0 -0.000393025998672
Gc19_588 0 n38 ns588 0 2.95269702755e-06
Gc19_589 0 n38 ns589 0 -0.000453740079015
Gc19_590 0 n38 ns590 0 0.000102909821137
Gc19_591 0 n38 ns591 0 -0.000463641810644
Gc19_592 0 n38 ns592 0 8.77123634373e-06
Gc19_593 0 n38 ns593 0 -0.00230943829406
Gc19_594 0 n38 ns594 0 0.00167513100408
Gc19_595 0 n38 ns595 0 -0.0019829606363
Gc19_596 0 n38 ns596 0 0.0014994455026
Gc19_597 0 n38 ns597 0 0.000615201741992
Gc19_598 0 n38 ns598 0 0.000626556194564
Gc19_599 0 n38 ns599 0 -0.000205831576606
Gc19_600 0 n38 ns600 0 -0.000120143467562
Gc19_601 0 n38 ns601 0 -0.000799583175905
Gc19_602 0 n38 ns602 0 -0.000444677169346
Gc19_603 0 n38 ns603 0 -0.000119637663715
Gc19_604 0 n38 ns604 0 -0.000375173572852
Gc19_605 0 n38 ns605 0 -0.000122315444839
Gc19_606 0 n38 ns606 0 -1.53709339549e-05
Gc19_607 0 n38 ns607 0 2.89826560451e-05
Gc19_608 0 n38 ns608 0 3.78729101094e-07
Gc19_609 0 n38 ns609 0 0.000650603394615
Gc19_610 0 n38 ns610 0 -0.00188734735442
Gc19_611 0 n38 ns611 0 0.00129300156803
Gc19_612 0 n38 ns612 0 -0.00165064435497
Gc19_613 0 n38 ns613 0 -0.00100781472819
Gc19_614 0 n38 ns614 0 -0.000208043044981
Gc19_615 0 n38 ns615 0 0.000163347289098
Gc19_616 0 n38 ns616 0 -0.000137001815822
Gc19_617 0 n38 ns617 0 0.000516709740595
Gc19_618 0 n38 ns618 0 0.000330279074139
Gc19_619 0 n38 ns619 0 0.000134505052569
Gc19_620 0 n38 ns620 0 0.000106377720533
Gc19_621 0 n38 ns621 0 0.000377591705089
Gc19_622 0 n38 ns622 0 0.000411798220519
Gc19_623 0 n38 ns623 0 -0.000234341101393
Gc19_624 0 n38 ns624 0 -0.00150503704219
Gc19_625 0 n38 ns625 0 0.000579527495978
Gc19_626 0 n38 ns626 0 -0.000109240627895
Gc19_627 0 n38 ns627 0 0.00056828747391
Gc19_628 0 n38 ns628 0 -0.000621660553877
Gc19_629 0 n38 ns629 0 0.00227166995873
Gc19_630 0 n38 ns630 0 0.00124428585623
Gc19_631 0 n38 ns631 0 -0.000634996510817
Gc19_632 0 n38 ns632 0 0.00177604080588
Gc19_633 0 n38 ns633 0 -0.00104006407054
Gc19_634 0 n38 ns634 0 0.00227521296897
Gc19_635 0 n38 ns635 0 0.0023043232492
Gc19_636 0 n38 ns636 0 -0.00298120742066
Gc19_637 0 n38 ns637 0 0.0011726142416
Gc19_638 0 n38 ns638 0 -0.000573725587257
Gc19_639 0 n38 ns639 0 0.000130501007453
Gc19_640 0 n38 ns640 0 0.000604846459769
Gc19_641 0 n38 ns641 0 -0.00310216331472
Gc19_642 0 n38 ns642 0 0.00211209521221
Gc19_643 0 n38 ns643 0 0.00261258314749
Gc19_644 0 n38 ns644 0 2.35823197219e-05
Gc19_645 0 n38 ns645 0 -0.000179230548587
Gc19_646 0 n38 ns646 0 3.26183262954e-05
Gc19_647 0 n38 ns647 0 0.000407766075007
Gc19_648 0 n38 ns648 0 -0.00221780020246
Gc19_649 0 n38 ns649 0 0.000498251262684
Gc19_650 0 n38 ns650 0 -0.000833675804008
Gc19_651 0 n38 ns651 0 -0.000963027948062
Gc19_652 0 n38 ns652 0 0.000223857810891
Gc19_653 0 n38 ns653 0 0.000333505062445
Gc19_654 0 n38 ns654 0 -0.000346642197541
Gc19_655 0 n38 ns655 0 0.000552198987661
Gc19_656 0 n38 ns656 0 0.0002946790164
Gc19_657 0 n38 ns657 0 0.000189057186065
Gc19_658 0 n38 ns658 0 0.00011531186778
Gc19_659 0 n38 ns659 0 -0.000116678226481
Gc19_660 0 n38 ns660 0 9.72891749412e-05
Gc19_661 0 n38 ns661 0 3.00161455733e-05
Gc19_662 0 n38 ns662 0 -0.000993064893852
Gc19_663 0 n38 ns663 0 0.000716558075626
Gc19_664 0 n38 ns664 0 0.000102091207828
Gc19_665 0 n38 ns665 0 0.000457791957419
Gc19_666 0 n38 ns666 0 -0.000512659939761
Gc19_667 0 n38 ns667 0 0.00124128073036
Gc19_668 0 n38 ns668 0 0.0016023402218
Gc19_669 0 n38 ns669 0 -0.000762697565637
Gc19_670 0 n38 ns670 0 0.00239510232612
Gc19_671 0 n38 ns671 0 -0.00122802274131
Gc19_672 0 n38 ns672 0 0.00296005462259
Gc19_673 0 n38 ns673 0 0.00341880209865
Gc19_674 0 n38 ns674 0 -0.00074333326565
Gc19_675 0 n38 ns675 0 0.00128273761205
Gc19_676 0 n38 ns676 0 -0.000745244165601
Gc19_677 0 n38 ns677 0 -0.000849228641912
Gc19_678 0 n38 ns678 0 -0.000469339380764
Gc19_679 0 n38 ns679 0 -0.00371665337275
Gc19_680 0 n38 ns680 0 9.73654504991e-05
Gc19_681 0 n38 ns681 0 0.00320675066013
Gc19_682 0 n38 ns682 0 5.11865058579e-05
Gc19_683 0 n38 ns683 0 -0.000224673035068
Gc19_684 0 n38 ns684 0 6.91670797254e-05
Gc19_685 0 n38 ns685 0 0.000447807607488
Gc19_686 0 n38 ns686 0 -0.00260287027007
Gc19_687 0 n38 ns687 0 -0.00152619470479
Gc19_688 0 n38 ns688 0 -0.000101307189799
Gc19_689 0 n38 ns689 0 -0.000523670952425
Gc19_690 0 n38 ns690 0 0.000173707012473
Gc19_691 0 n38 ns691 0 0.000417390869294
Gc19_692 0 n38 ns692 0 -0.000255668680563
Gc19_693 0 n38 ns693 0 9.53435354796e-05
Gc19_694 0 n38 ns694 0 -4.78642771371e-05
Gc19_695 0 n38 ns695 0 0.000269188361502
Gc19_696 0 n38 ns696 0 0.000108932234323
Gc19_697 0 n38 ns697 0 -0.000724138175267
Gc19_698 0 n38 ns698 0 -0.000157553815943
Gc19_699 0 n38 ns699 0 -6.73789581993e-05
Gc19_700 0 n38 ns700 0 0.000970090407542
Gc19_701 0 n38 ns701 0 0.000476110646151
Gc19_702 0 n38 ns702 0 0.000392356868113
Gc19_703 0 n38 ns703 0 -0.0004919607086
Gc19_704 0 n38 ns704 0 -0.00042146876592
Gc19_705 0 n38 ns705 0 -0.00121698103381
Gc19_706 0 n38 ns706 0 -0.000506424685139
Gc19_707 0 n38 ns707 0 0.00378551524847
Gc19_708 0 n38 ns708 0 0.0048635974878
Gc19_709 0 n38 ns709 0 0.00246154763805
Gc19_710 0 n38 ns710 0 0.00513484679429
Gc19_711 0 n38 ns711 0 0.000103660795082
Gc19_712 0 n38 ns712 0 0.00495845489462
Gc19_713 0 n38 ns713 0 0.00116071647934
Gc19_714 0 n38 ns714 0 -0.000806254533993
Gc19_715 0 n38 ns715 0 -0.00506446275861
Gc19_716 0 n38 ns716 0 -0.001289081608
Gc19_717 0 n38 ns717 0 0.00294749087873
Gc19_718 0 n38 ns718 0 -0.00377851500588
Gc19_719 0 n38 ns719 0 0.00489159800564
Gc19_720 0 n38 ns720 0 -2.98159855645e-05
Gc19_721 0 n38 ns721 0 4.20381481979e-06
Gc19_722 0 n38 ns722 0 -6.05402975823e-05
Gc19_723 0 n38 ns723 0 0.000218195679573
Gc19_724 0 n38 ns724 0 -0.00232866469571
Gc19_725 0 n38 ns725 0 2.38844981272e-05
Gc19_726 0 n38 ns726 0 -0.000777729466267
Gc19_727 0 n38 ns727 0 -0.000834716410327
Gc19_728 0 n38 ns728 0 0.000220192151633
Gc19_729 0 n38 ns729 0 0.000277973505504
Gc19_730 0 n38 ns730 0 -0.000498605631894
Gc19_731 0 n38 ns731 0 2.69146784344e-05
Gc19_732 0 n38 ns732 0 0.000246848713813
Gc19_733 0 n38 ns733 0 0.000290119043743
Gc19_734 0 n38 ns734 0 9.40030369625e-06
Gc19_735 0 n38 ns735 0 -0.000148419918256
Gc19_736 0 n38 ns736 0 0.00026904680302
Gc19_737 0 n38 ns737 0 0.00103328949435
Gc19_738 0 n38 ns738 0 -0.000428326438461
Gc19_739 0 n38 ns739 0 0.00117261185578
Gc19_740 0 n38 ns740 0 -0.000237346527906
Gc19_741 0 n38 ns741 0 0.000768007328295
Gc19_742 0 n38 ns742 0 -0.000575976297934
Gc19_743 0 n38 ns743 0 0.000381393737111
Gc19_744 0 n38 ns744 0 0.00215084543388
Gc19_745 0 n38 ns745 0 0.00160139573806
Gc19_746 0 n38 ns746 0 0.0055905465642
Gc19_747 0 n38 ns747 0 0.00113949436994
Gc19_748 0 n38 ns748 0 0.00567756608023
Gc19_749 0 n38 ns749 0 0.00320771644144
Gc19_750 0 n38 ns750 0 0.000405830368311
Gc19_751 0 n38 ns751 0 0.000983831849165
Gc19_752 0 n38 ns752 0 -0.000999855557455
Gc19_753 0 n38 ns753 0 -0.00149980967286
Gc19_754 0 n38 ns754 0 -0.00134288153964
Gc19_755 0 n38 ns755 0 -0.00377792111063
Gc19_756 0 n38 ns756 0 -0.000146547289644
Gc19_757 0 n38 ns757 0 0.00310702071026
Gc19_758 0 n38 ns758 0 3.19513358516e-05
Gc19_759 0 n38 ns759 0 -0.000156122646798
Gc19_760 0 n38 ns760 0 1.04323275164e-05
Gc19_761 0 n38 ns761 0 0.000331426342084
Gc19_762 0 n38 ns762 0 -0.000806173440015
Gc19_763 0 n38 ns763 0 0.00111682385685
Gc19_764 0 n38 ns764 0 -9.65229751442e-05
Gc19_765 0 n38 ns765 0 -0.000106066584413
Gc19_766 0 n38 ns766 0 0.000336756615124
Gc19_767 0 n38 ns767 0 -0.000151055429026
Gc19_768 0 n38 ns768 0 -9.73012699876e-05
Gc19_769 0 n38 ns769 0 0.000249068643266
Gc19_770 0 n38 ns770 0 -0.000165697515871
Gc19_771 0 n38 ns771 0 0.00018456022408
Gc19_772 0 n38 ns772 0 -8.21139002878e-05
Gc19_773 0 n38 ns773 0 2.94132386113e-05
Gc19_774 0 n38 ns774 0 -0.000259796295994
Gc19_775 0 n38 ns775 0 -0.000595026942731
Gc19_776 0 n38 ns776 0 -0.000442321978473
Gc19_777 0 n38 ns777 0 0.000385490573738
Gc19_778 0 n38 ns778 0 -0.000703147713052
Gc19_779 0 n38 ns779 0 -7.30408737785e-05
Gc19_780 0 n38 ns780 0 -0.00116391662924
Gc19_781 0 n38 ns781 0 0.00132035942557
Gc19_782 0 n38 ns782 0 -0.000471644003122
Gc19_783 0 n38 ns783 0 0.00257706656287
Gc19_784 0 n38 ns784 0 0.00393435300687
Gc19_785 0 n38 ns785 0 0.00235104542997
Gc19_786 0 n38 ns786 0 0.00408150268255
Gc19_787 0 n38 ns787 0 -0.00115880291869
Gc19_788 0 n38 ns788 0 -0.00153040952527
Gc19_789 0 n38 ns789 0 0.000427367641976
Gc19_790 0 n38 ns790 0 -0.00105573764883
Gc19_791 0 n38 ns791 0 0.000183929757656
Gc19_792 0 n38 ns792 0 -0.000792811157374
Gc19_793 0 n38 ns793 0 -0.00151163248965
Gc19_794 0 n38 ns794 0 0.00241750682394
Gc19_795 0 n38 ns795 0 0.0014878462051
Gc19_796 0 n38 ns796 0 3.61172103645e-05
Gc19_797 0 n38 ns797 0 -0.000248583200321
Gc19_798 0 n38 ns798 0 8.64550533417e-05
Gc19_799 0 n38 ns799 0 -0.000190245531489
Gc19_800 0 n38 ns800 0 5.69432128676e-05
Gc19_801 0 n38 ns801 0 -0.000245017337334
Gc19_802 0 n38 ns802 0 0.000529211423906
Gc19_803 0 n38 ns803 0 -1.61824696597e-05
Gc19_804 0 n38 ns804 0 6.71979938091e-05
Gc19_805 0 n38 ns805 0 0.000155710514882
Gc19_806 0 n38 ns806 0 -1.0588534558e-05
Gc19_807 0 n38 ns807 0 -0.000180263358566
Gc19_808 0 n38 ns808 0 -7.44287938791e-05
Gc19_809 0 n38 ns809 0 0.00012974289304
Gc19_810 0 n38 ns810 0 -0.000132811375805
Gc19_811 0 n38 ns811 0 -0.000223492926613
Gc19_812 0 n38 ns812 0 -0.000253309018983
Gc19_813 0 n38 ns813 0 0.000156795473996
Gc19_814 0 n38 ns814 0 0.000549159652979
Gc19_815 0 n38 ns815 0 0.000239174131684
Gc19_816 0 n38 ns816 0 -0.000397092703341
Gc19_817 0 n38 ns817 0 -0.000192656916895
Gc19_818 0 n38 ns818 0 -0.000307570447104
Gc19_819 0 n38 ns819 0 -0.000507462632218
Gc19_820 0 n38 ns820 0 -0.000369957634294
Gc19_821 0 n38 ns821 0 0.0023011742742
Gc19_822 0 n38 ns822 0 0.00317062533666
Gc19_823 0 n38 ns823 0 0.00237991034433
Gc19_824 0 n38 ns824 0 0.00301282150445
Gc19_825 0 n38 ns825 0 -0.00130009844818
Gc19_826 0 n38 ns826 0 0.000682982336428
Gc19_827 0 n38 ns827 0 -0.000124701423842
Gc19_828 0 n38 ns828 0 -0.000792352734581
Gc19_829 0 n38 ns829 0 -0.000350332862708
Gc19_830 0 n38 ns830 0 -0.00136133672019
Gc19_831 0 n38 ns831 0 -0.000578503050244
Gc19_832 0 n38 ns832 0 0.000985907109012
Gc19_833 0 n38 ns833 0 0.000552830202527
Gc19_834 0 n38 ns834 0 6.19019852734e-06
Gc19_835 0 n38 ns835 0 -9.21909007375e-05
Gc19_836 0 n38 ns836 0 -7.60645556555e-06
Gc19_837 0 n38 ns837 0 -0.000342342469601
Gc19_838 0 n38 ns838 0 0.000605096330872
Gc19_839 0 n38 ns839 0 -0.000717091099501
Gc19_840 0 n38 ns840 0 0.00143535293387
Gc19_841 0 n38 ns841 0 -0.00022750414922
Gc19_842 0 n38 ns842 0 0.000338612779741
Gc19_843 0 n38 ns843 0 9.60649644865e-05
Gc19_844 0 n38 ns844 0 -0.000243099159159
Gc19_845 0 n38 ns845 0 -0.000138113556026
Gc19_846 0 n38 ns846 0 0.000448480745069
Gc19_847 0 n38 ns847 0 7.54702169947e-05
Gc19_848 0 n38 ns848 0 -0.000155811234948
Gc19_849 0 n38 ns849 0 5.45939679533e-05
Gc19_850 0 n38 ns850 0 -0.000473333819324
Gc19_851 0 n38 ns851 0 0.000823286317907
Gc19_852 0 n38 ns852 0 -0.00047742842227
Gc19_853 0 n38 ns853 0 0.000210898419895
Gc19_854 0 n38 ns854 0 -0.000679461220674
Gc19_855 0 n38 ns855 0 0.000315654425565
Gc19_856 0 n38 ns856 0 -0.000590712106494
Gc19_857 0 n38 ns857 0 -0.000111909036329
Gc19_858 0 n38 ns858 0 0.000943885677367
Gc19_859 0 n38 ns859 0 0.00327463003007
Gc19_860 0 n38 ns860 0 0.00254775171516
Gc19_861 0 n38 ns861 0 0.00307876486192
Gc19_862 0 n38 ns862 0 0.0020971092663
Gc19_863 0 n38 ns863 0 0.000397070244561
Gc19_864 0 n38 ns864 0 0.00138349652712
Gc19_865 0 n38 ns865 0 -0.000349165415529
Gc19_866 0 n38 ns866 0 -0.000470121358265
Gc19_867 0 n38 ns867 0 -0.00129408647337
Gc19_868 0 n38 ns868 0 -0.00139705078571
Gc19_869 0 n38 ns869 0 -0.00055653915745
Gc19_870 0 n38 ns870 0 -0.000554774722099
Gc19_871 0 n38 ns871 0 3.13103830303e-05
Gc19_872 0 n38 ns872 0 -1.04077247196e-06
Gc19_873 0 n38 ns873 0 -5.03735609043e-06
Gc19_874 0 n38 ns874 0 -3.50354481354e-05
Gc19_875 0 n38 ns875 0 0.000211440522835
Gc19_876 0 n38 ns876 0 0.00049274336578
Gc19_877 0 n38 ns877 0 0.000961891010869
Gc19_878 0 n38 ns878 0 0.000829137514522
Gc19_879 0 n38 ns879 0 3.83522745594e-05
Gc19_880 0 n38 ns880 0 0.000212853484795
Gc19_881 0 n38 ns881 0 -1.83465428781e-05
Gc19_882 0 n38 ns882 0 -6.57297466927e-05
Gc19_883 0 n38 ns883 0 0.000268561638505
Gc19_884 0 n38 ns884 0 0.000311200141181
Gc19_885 0 n38 ns885 0 -2.91209133987e-05
Gc19_886 0 n38 ns886 0 -0.000102086278107
Gc19_887 0 n38 ns887 0 -0.000258085590138
Gc19_888 0 n38 ns888 0 -0.000454355086855
Gc19_889 0 n38 ns889 0 -3.54464830672e-05
Gc19_890 0 n38 ns890 0 -0.000863898666486
Gc19_891 0 n38 ns891 0 -0.000259473400131
Gc19_892 0 n38 ns892 0 -0.000540670768598
Gc19_893 0 n38 ns893 0 -0.000152489528186
Gc19_894 0 n38 ns894 0 -0.000711039045106
Gc19_895 0 n38 ns895 0 0.000685228711542
Gc19_896 0 n38 ns896 0 0.000572188284849
Gc19_897 0 n38 ns897 0 0.00299994535078
Gc19_898 0 n38 ns898 0 4.13646116839e-05
Gc19_899 0 n38 ns899 0 0.00262325077828
Gc19_900 0 n38 ns900 0 -0.000105385788648
Gc19_901 0 n38 ns901 0 0.000784422287264
Gc19_902 0 n38 ns902 0 0.000784491249015
Gc19_903 0 n38 ns903 0 -0.000277967831543
Gc19_904 0 n38 ns904 0 -0.000219385477993
Gc19_905 0 n38 ns905 0 -0.00117425307093
Gc19_906 0 n38 ns906 0 -0.000785169080083
Gc19_907 0 n38 ns907 0 -0.000468481606267
Gc19_908 0 n38 ns908 0 -0.000695474357685
Gc19_909 0 n38 ns909 0 -5.97272106671e-05
Gc19_910 0 n38 ns910 0 2.74813833255e-05
Gc19_911 0 n38 ns911 0 -5.96781374045e-05
Gc19_912 0 n38 ns912 0 1.35030341729e-05
Gc19_913 0 n38 ns913 0 5.84820286129e-05
Gc19_914 0 n38 ns914 0 0.000241867451859
Gc19_915 0 n38 ns915 0 0.000234380267858
Gc19_916 0 n38 ns916 0 -0.000525772099984
Gc19_917 0 n38 ns917 0 -9.12321493513e-05
Gc19_918 0 n38 ns918 0 -2.85921479625e-05
Gc19_919 0 n38 ns919 0 9.94797422224e-05
Gc19_920 0 n38 ns920 0 3.03811339985e-05
Gc19_921 0 n38 ns921 0 0.000195746304044
Gc19_922 0 n38 ns922 0 -1.41338001352e-05
Gc19_923 0 n38 ns923 0 -5.5186885883e-05
Gc19_924 0 n38 ns924 0 -1.59925955483e-06
Gc19_925 0 n38 ns925 0 -0.000184830457228
Gc19_926 0 n38 ns926 0 2.64156011662e-05
Gc19_927 0 n38 ns927 0 -0.000405584935134
Gc19_928 0 n38 ns928 0 -0.000111631587304
Gc19_929 0 n38 ns929 0 -0.000353609596602
Gc19_930 0 n38 ns930 0 6.23630453607e-05
Gc19_931 0 n38 ns931 0 -0.000436318284477
Gc19_932 0 n38 ns932 0 6.47525527514e-05
Gc19_933 0 n38 ns933 0 0.00024469328523
Gc19_934 0 n38 ns934 0 -0.000253085193142
Gc19_935 0 n38 ns935 0 0.000811148365164
Gc19_936 0 n38 ns936 0 -0.00166175604347
Gc19_937 0 n38 ns937 0 0.000690046461379
Gc19_938 0 n38 ns938 0 -0.00146332046333
Gc19_939 0 n38 ns939 0 3.61863826491e-05
Gc19_940 0 n38 ns940 0 8.84994496659e-05
Gc19_941 0 n38 ns941 0 -0.000102746376222
Gc19_942 0 n38 ns942 0 -4.67934369061e-05
Gc19_943 0 n38 ns943 0 -0.00032766645391
Gc19_944 0 n38 ns944 0 3.37915441628e-05
Gc19_945 0 n38 ns945 0 -0.000118560665692
Gc19_946 0 n38 ns946 0 0.00034988151106
Gc19_947 0 n38 ns947 0 0.000137243147058
Gc19_948 0 n38 ns948 0 -1.13517716164e-05
Gc19_949 0 n38 ns949 0 5.87838647928e-06
Gc19_950 0 n38 ns950 0 -2.19055764731e-05
Gc19_951 0 n38 ns951 0 0.0011252315438
Gc19_952 0 n38 ns952 0 -0.00446807210149
Gc19_953 0 n38 ns953 0 -0.000170307847846
Gc19_954 0 n38 ns954 0 -0.0023006883442
Gc19_955 0 n38 ns955 0 -0.000954119074519
Gc19_956 0 n38 ns956 0 -0.000340071458101
Gc19_957 0 n38 ns957 0 0.000609331614161
Gc19_958 0 n38 ns958 0 4.46350719885e-05
Gc19_959 0 n38 ns959 0 0.000245900684604
Gc19_960 0 n38 ns960 0 2.66104306465e-05
Gc19_961 0 n38 ns961 0 0.000234451059324
Gc19_962 0 n38 ns962 0 0.000125772099599
Gc19_963 0 n38 ns963 0 -0.00053668329866
Gc19_964 0 n38 ns964 0 -7.21431937035e-05
Gc19_965 0 n38 ns965 0 -0.00064931152613
Gc19_966 0 n38 ns966 0 0.000577095133262
Gc19_967 0 n38 ns967 0 0.000305067482547
Gc19_968 0 n38 ns968 0 0.000325039665813
Gc19_969 0 n38 ns969 0 -0.000550137416399
Gc19_970 0 n38 ns970 0 -0.000633662705282
Gc19_971 0 n38 ns971 0 -0.000442732257775
Gc19_972 0 n38 ns972 0 -0.000845669677762
Gc19_973 0 n38 ns973 0 0.00321624978844
Gc19_974 0 n38 ns974 0 0.00510957628563
Gc19_975 0 n38 ns975 0 0.00189727324894
Gc19_976 0 n38 ns976 0 0.00529522457904
Gc19_977 0 n38 ns977 0 -0.000245524203385
Gc19_978 0 n38 ns978 0 0.00447311099748
Gc19_979 0 n38 ns979 0 0.00116479536393
Gc19_980 0 n38 ns980 0 -0.000838396694158
Gc19_981 0 n38 ns981 0 -0.00520964789429
Gc19_982 0 n38 ns982 0 -0.00144398599661
Gc19_983 0 n38 ns983 0 0.00354538470077
Gc19_984 0 n38 ns984 0 -0.00460712331257
Gc19_985 0 n38 ns985 0 0.00469407151136
Gc19_986 0 n38 ns986 0 -1.34709450887e-05
Gc19_987 0 n38 ns987 0 -5.15658976226e-05
Gc19_988 0 n38 ns988 0 -3.36697672563e-05
Gc19_989 0 n38 ns989 0 0.00115918412335
Gc19_990 0 n38 ns990 0 -0.00500780331826
Gc19_991 0 n38 ns991 0 0.00102874489703
Gc19_992 0 n38 ns992 0 -0.00378831854181
Gc19_993 0 n38 ns993 0 -0.00115518982382
Gc19_994 0 n38 ns994 0 -0.000769234256055
Gc19_995 0 n38 ns995 0 0.00059791697319
Gc19_996 0 n38 ns996 0 -9.06552461604e-05
Gc19_997 0 n38 ns997 0 -0.000124609772228
Gc19_998 0 n38 ns998 0 0.000193195427569
Gc19_999 0 n38 ns999 0 0.000280393823564
Gc19_1000 0 n38 ns1000 0 5.5986788381e-05
Gc19_1001 0 n38 ns1001 0 -0.000365508228182
Gc19_1002 0 n38 ns1002 0 0.000668078914645
Gc19_1003 0 n38 ns1003 0 0.000675405097805
Gc19_1004 0 n38 ns1004 0 9.30580194041e-06
Gc19_1005 0 n38 ns1005 0 0.000940069667753
Gc19_1006 0 n38 ns1006 0 -4.85175164081e-05
Gc19_1007 0 n38 ns1007 0 0.000313351310071
Gc19_1008 0 n38 ns1008 0 -0.000587830021529
Gc19_1009 0 n38 ns1009 0 0.000305409818005
Gc19_1010 0 n38 ns1010 0 0.00131099594868
Gc19_1011 0 n38 ns1011 0 0.00359104088293
Gc19_1012 0 n38 ns1012 0 0.0063133891361
Gc19_1013 0 n38 ns1013 0 0.00254614976303
Gc19_1014 0 n38 ns1014 0 0.00630515675835
Gc19_1015 0 n38 ns1015 0 0.00206729267344
Gc19_1016 0 n38 ns1016 0 0.00174560897813
Gc19_1017 0 n38 ns1017 0 0.00107925078538
Gc19_1018 0 n38 ns1018 0 -0.000938383638459
Gc19_1019 0 n38 ns1019 0 -0.00347107700681
Gc19_1020 0 n38 ns1020 0 -0.00112784018341
Gc19_1021 0 n38 ns1021 0 -0.00045197537778
Gc19_1022 0 n38 ns1022 0 -0.00197961886177
Gc19_1023 0 n38 ns1023 0 0.00383847393409
Gc19_1024 0 n38 ns1024 0 9.33207561731e-07
Gc19_1025 0 n38 ns1025 0 -0.00010132713735
Gc19_1026 0 n38 ns1026 0 -1.13555163426e-05
Gc19_1027 0 n38 ns1027 0 0.000651825032835
Gc19_1028 0 n38 ns1028 0 -0.00187662374818
Gc19_1029 0 n38 ns1029 0 0.00179114706808
Gc19_1030 0 n38 ns1030 0 -0.0012790666628
Gc19_1031 0 n38 ns1031 0 -0.000334613134688
Gc19_1032 0 n38 ns1032 0 6.08823894707e-05
Gc19_1033 0 n38 ns1033 0 -0.000130405625471
Gc19_1034 0 n38 ns1034 0 -0.000126561216633
Gc19_1035 0 n38 ns1035 0 0.000246286310587
Gc19_1036 0 n38 ns1036 0 -4.23726211362e-05
Gc19_1037 0 n38 ns1037 0 0.000211885213755
Gc19_1038 0 n38 ns1038 0 -4.80174318186e-05
Gc19_1039 0 n38 ns1039 0 2.68091120773e-05
Gc19_1040 0 n38 ns1040 0 0.000105708687599
Gc19_1041 0 n38 ns1041 0 -0.000359970912377
Gc19_1042 0 n38 ns1042 0 -0.000809406945181
Gc19_1043 0 n38 ns1043 0 0.00058129252727
Gc19_1044 0 n38 ns1044 0 -0.000708975225142
Gc19_1045 0 n38 ns1045 0 0.000113113885892
Gc19_1046 0 n38 ns1046 0 -0.00126226766812
Gc19_1047 0 n38 ns1047 0 0.00179343000371
Gc19_1048 0 n38 ns1048 0 0.000187465176527
Gc19_1049 0 n38 ns1049 0 0.00295985793338
Gc19_1050 0 n38 ns1050 0 0.0042253023797
Gc19_1051 0 n38 ns1051 0 0.00253394415235
Gc19_1052 0 n38 ns1052 0 0.00445807364728
Gc19_1053 0 n38 ns1053 0 -9.61305588269e-05
Gc19_1054 0 n38 ns1054 0 -0.00190631950865
Gc19_1055 0 n38 ns1055 0 0.000678706270262
Gc19_1056 0 n38 ns1056 0 -0.0010715010548
Gc19_1057 0 n38 ns1057 0 2.62706491123e-05
Gc19_1058 0 n38 ns1058 0 -0.000639706082236
Gc19_1059 0 n38 ns1059 0 -0.00223257141739
Gc19_1060 0 n38 ns1060 0 0.00220162056735
Gc19_1061 0 n38 ns1061 0 0.00197656528137
Gc19_1062 0 n38 ns1062 0 2.01474072521e-05
Gc19_1063 0 n38 ns1063 0 -0.000208650588008
Gc19_1064 0 n38 ns1064 0 5.94936946417e-05
Gc19_1065 0 n38 ns1065 0 -6.84219814301e-05
Gc19_1066 0 n38 ns1066 0 -6.70506187685e-05
Gc19_1067 0 n38 ns1067 0 9.83804755397e-05
Gc19_1068 0 n38 ns1068 0 0.000360327711124
Gc19_1069 0 n38 ns1069 0 8.62590804296e-05
Gc19_1070 0 n38 ns1070 0 9.93117127003e-05
Gc19_1071 0 n38 ns1071 0 3.21582923533e-05
Gc19_1072 0 n38 ns1072 0 8.9011309657e-05
Gc19_1073 0 n38 ns1073 0 -5.21256285439e-05
Gc19_1074 0 n38 ns1074 0 -0.000205138299655
Gc19_1075 0 n38 ns1075 0 0.000166778379207
Gc19_1076 0 n38 ns1076 0 -0.000112236628804
Gc19_1077 0 n38 ns1077 0 -0.000198753223072
Gc19_1078 0 n38 ns1078 0 -0.000315261200228
Gc19_1079 0 n38 ns1079 0 -0.000312689682786
Gc19_1080 0 n38 ns1080 0 0.000504616034358
Gc19_1081 0 n38 ns1081 0 0.000230706233831
Gc19_1082 0 n38 ns1082 0 -0.000422719347799
Gc19_1083 0 n38 ns1083 0 -0.000351052389011
Gc19_1084 0 n38 ns1084 0 -0.000501085210214
Gc19_1085 0 n38 ns1085 0 -9.77754928105e-05
Gc19_1086 0 n38 ns1086 0 -0.000816219419022
Gc19_1087 0 n38 ns1087 0 0.00224355964142
Gc19_1088 0 n38 ns1088 0 0.00324183364185
Gc19_1089 0 n38 ns1089 0 0.00230145919461
Gc19_1090 0 n38 ns1090 0 0.00326399734963
Gc19_1091 0 n38 ns1091 0 -0.00174717025778
Gc19_1092 0 n38 ns1092 0 -5.52854643309e-05
Gc19_1093 0 n38 ns1093 0 4.37658649211e-05
Gc19_1094 0 n38 ns1094 0 -0.000905797654417
Gc19_1095 0 n38 ns1095 0 3.5786912815e-05
Gc19_1096 0 n38 ns1096 0 -0.00112612738611
Gc19_1097 0 n38 ns1097 0 -0.000708967050444
Gc19_1098 0 n38 ns1098 0 0.00172037190852
Gc19_1099 0 n38 ns1099 0 0.000860225872362
Gc19_1100 0 n38 ns1100 0 2.0705586556e-05
Gc19_1101 0 n38 ns1101 0 -0.000155172875206
Gc19_1102 0 n38 ns1102 0 2.38563240169e-05
Gc19_1103 0 n38 ns1103 0 -0.000378666172898
Gc19_1104 0 n38 ns1104 0 0.000296768429394
Gc19_1105 0 n38 ns1105 0 -0.000872677204078
Gc19_1106 0 n38 ns1106 0 0.000868667300701
Gc19_1107 0 n38 ns1107 0 -0.000227470368561
Gc19_1108 0 n38 ns1108 0 0.000133588490949
Gc19_1109 0 n38 ns1109 0 0.000164505731476
Gc19_1110 0 n38 ns1110 0 -0.00015362968007
Gc19_1111 0 n38 ns1111 0 -0.000303570320286
Gc19_1112 0 n38 ns1112 0 0.000256153491167
Gc19_1113 0 n38 ns1113 0 0.000105170042787
Gc19_1114 0 n38 ns1114 0 -0.000144439502403
Gc19_1115 0 n38 ns1115 0 5.60956982047e-05
Gc19_1116 0 n38 ns1116 0 -0.000262196135854
Gc19_1117 0 n38 ns1117 0 0.000836186021598
Gc19_1118 0 n38 ns1118 0 4.57625226358e-05
Gc19_1119 0 n38 ns1119 0 0.000304750612577
Gc19_1120 0 n38 ns1120 0 -0.00054819261798
Gc19_1121 0 n38 ns1121 0 0.000223941004781
Gc19_1122 0 n38 ns1122 0 -0.000341219565669
Gc19_1123 0 n38 ns1123 0 -0.000501459993583
Gc19_1124 0 n38 ns1124 0 0.000588418132352
Gc19_1125 0 n38 ns1125 0 0.00293770140076
Gc19_1126 0 n38 ns1126 0 0.00298942004191
Gc19_1127 0 n38 ns1127 0 0.00288213641901
Gc19_1128 0 n38 ns1128 0 0.00258463083367
Gc19_1129 0 n38 ns1129 0 -0.000165029222941
Gc19_1130 0 n38 ns1130 0 0.00126609817079
Gc19_1131 0 n38 ns1131 0 -0.000312680427938
Gc19_1132 0 n38 ns1132 0 -0.00056112780454
Gc19_1133 0 n38 ns1133 0 -0.00102945932331
Gc19_1134 0 n38 ns1134 0 -0.00134708177748
Gc19_1135 0 n38 ns1135 0 -0.000531712687212
Gc19_1136 0 n38 ns1136 0 6.60552132363e-05
Gc19_1137 0 n38 ns1137 0 0.000223170778139
Gc19_1138 0 n38 ns1138 0 1.23273166635e-06
Gc19_1139 0 n38 ns1139 0 -1.79632997936e-05
Gc19_1140 0 n38 ns1140 0 -4.49094776145e-05
Gc19_1141 0 n38 ns1141 0 0.000102992343003
Gc19_1142 0 n38 ns1142 0 0.000523887816734
Gc19_1143 0 n38 ns1143 0 0.000663270668267
Gc19_1144 0 n38 ns1144 0 0.00112720104614
Gc19_1145 0 n38 ns1145 0 -2.74789072938e-05
Gc19_1146 0 n38 ns1146 0 0.00017844354598
Gc19_1147 0 n38 ns1147 0 -7.24933544758e-06
Gc19_1148 0 n38 ns1148 0 -5.56162597471e-05
Gc19_1149 0 n38 ns1149 0 0.00012292717176
Gc19_1150 0 n38 ns1150 0 0.000477381472909
Gc19_1151 0 n38 ns1151 0 1.05665077203e-05
Gc19_1152 0 n38 ns1152 0 -0.000148410461564
Gc19_1153 0 n38 ns1153 0 -0.00014888544484
Gc19_1154 0 n38 ns1154 0 -0.000562576364397
Gc19_1155 0 n38 ns1155 0 0.000317198529514
Gc19_1156 0 n38 ns1156 0 -0.000951723098465
Gc19_1157 0 n38 ns1157 0 -0.000110597436126
Gc19_1158 0 n38 ns1158 0 -0.000727416203153
Gc19_1159 0 n38 ns1159 0 4.81978941143e-05
Gc19_1160 0 n38 ns1160 0 -0.000859664842244
Gc19_1161 0 n38 ns1161 0 0.000599129078825
Gc19_1162 0 n38 ns1162 0 0.000877195491817
Gc19_1163 0 n38 ns1163 0 0.00371257358178
Gc19_1164 0 n38 ns1164 0 0.00101387519128
Gc19_1165 0 n38 ns1165 0 0.00330232587891
Gc19_1166 0 n38 ns1166 0 0.000712203510744
Gc19_1167 0 n38 ns1167 0 0.000845148253044
Gc19_1168 0 n38 ns1168 0 0.00105224069159
Gc19_1169 0 n38 ns1169 0 -0.000329973718207
Gc19_1170 0 n38 ns1170 0 -0.000307318980793
Gc19_1171 0 n38 ns1171 0 -0.0013671049712
Gc19_1172 0 n38 ns1172 0 -0.00107083835212
Gc19_1173 0 n38 ns1173 0 -0.000550911731358
Gc19_1174 0 n38 ns1174 0 -0.000876697529734
Gc19_1175 0 n38 ns1175 0 -7.86605078279e-05
Gc19_1176 0 n38 ns1176 0 3.12786234864e-05
Gc19_1177 0 n38 ns1177 0 -6.08144201046e-05
Gc19_1178 0 n38 ns1178 0 3.52424761695e-07
Gc19_1179 0 n38 ns1179 0 0.000158772101299
Gc19_1180 0 n38 ns1180 0 0.000354582864927
Gc19_1181 0 n38 ns1181 0 0.000718094160742
Gc19_1182 0 n38 ns1182 0 -0.000112321061665
Gc19_1183 0 n38 ns1183 0 2.1268084992e-05
Gc19_1184 0 n38 ns1184 0 6.69725931741e-05
Gc19_1185 0 n38 ns1185 0 2.5607428304e-05
Gc19_1186 0 n38 ns1186 0 -1.21580299025e-06
Gc19_1187 0 n38 ns1187 0 0.000278497346267
Gc19_1188 0 n38 ns1188 0 6.54444844178e-05
Gc19_1189 0 n38 ns1189 0 -6.20701369193e-05
Gc19_1190 0 n38 ns1190 0 -3.72194144552e-05
Gc19_1191 0 n38 ns1191 0 -0.000295985343209
Gc19_1192 0 n38 ns1192 0 -0.000121762609588
Gc19_1193 0 n38 ns1193 0 -0.000404597505213
Gc19_1194 0 n38 ns1194 0 -0.000388888359541
Gc19_1195 0 n38 ns1195 0 -0.000402950066769
Gc19_1196 0 n38 ns1196 0 -0.000127613207121
Gc19_1197 0 n38 ns1197 0 -0.000446187265276
Gc19_1198 0 n38 ns1198 0 -0.000203625522491
Gc19_1199 0 n38 ns1199 0 0.000467683625133
Gc19_1200 0 n38 ns1200 0 -4.70342528384e-05
Gc19_1201 0 n38 ns1201 0 0.00159208089958
Gc19_1202 0 n38 ns1202 0 -0.00138335868382
Gc19_1203 0 n38 ns1203 0 0.00136499680193
Gc19_1204 0 n38 ns1204 0 -0.00126159560232
Gc19_1205 0 n38 ns1205 0 0.000322704379819
Gc19_1206 0 n38 ns1206 0 0.000267924316226
Gc19_1207 0 n38 ns1207 0 -0.000168085593444
Gc19_1208 0 n38 ns1208 0 -8.89360758381e-05
Gc19_1209 0 n38 ns1209 0 -0.000639146688154
Gc19_1210 0 n38 ns1210 0 -0.000173325537299
Gc19_1211 0 n38 ns1211 0 -0.000248897286052
Gc19_1212 0 n38 ns1212 0 6.00977286047e-05
Gc19_1213 0 n38 ns1213 0 8.93294578652e-05
Gc19_1214 0 n38 ns1214 0 8.67609698882e-06
Gc19_1215 0 n38 ns1215 0 -2.54788264966e-05
Gc19_1216 0 n38 ns1216 0 -8.01799501493e-06
Gd19_1 0 n38 ni1 0 0.000716684393417
Gd19_2 0 n38 ni2 0 0.000128531638942
Gd19_3 0 n38 ni3 0 0.0003014633107
Gd19_4 0 n38 ni4 0 -0.000470612115869
Gd19_5 0 n38 ni5 0 0.000820585288484
Gd19_6 0 n38 ni6 0 -8.50204498539e-05
Gd19_7 0 n38 ni7 0 -0.000450569231481
Gd19_8 0 n38 ni8 0 0.000833722783734
Gd19_9 0 n38 ni9 0 -0.000443720822969
Gd19_10 0 n38 ni10 0 -0.00323643607587
Gd19_11 0 n38 ni11 0 -0.00241101561401
Gd19_12 0 n38 ni12 0 0.000716168673345
Gd19_13 0 n38 ni13 0 6.14362228732e-05
Gd19_14 0 n38 ni14 0 -0.00068210010177
Gd19_15 0 n38 ni15 0 0.000846175851087
Gd19_16 0 n38 ni16 0 4.61465469685e-06
Gd19_17 0 n38 ni17 0 -0.00167591584396
Gd19_18 0 n38 ni18 0 -0.00174729349661
Gd19_19 0 n38 ni19 0 0.000869094343568
Gd19_20 0 n38 ni20 0 -0.00164132817961
Gd19_21 0 n38 ni21 0 -0.000572984904222
Gd19_22 0 n38 ni22 0 0.000412466313923
Gd19_23 0 n38 ni23 0 0.000720219341224
Gd19_24 0 n38 ni24 0 0.000119131374986
Gd19_25 0 n38 ni25 0 -2.12652793628e-05
Gd19_26 0 n38 ni26 0 -0.00115442311107
Gd19_27 0 n38 ni27 0 -0.00323071125532
Gd19_28 0 n38 ni28 0 -0.00164658202928
Gd19_29 0 n38 ni29 0 0.000278899199259
Gd19_30 0 n38 ni30 0 0.000604106288145
Gd19_31 0 n38 ni31 0 0.000268699878734
Gd19_32 0 n38 ni32 0 -1.13112443145e-06
Gc20_1 0 n40 ns1 0 -0.000310436653725
Gc20_2 0 n40 ns2 0 -0.000209320235561
Gc20_3 0 n40 ns3 0 -0.000986571588649
Gc20_4 0 n40 ns4 0 0.000803319212898
Gc20_5 0 n40 ns5 0 -0.000339581495023
Gc20_6 0 n40 ns6 0 -0.000149735235753
Gc20_7 0 n40 ns7 0 7.35558821428e-05
Gc20_8 0 n40 ns8 0 -7.79628853329e-05
Gc20_9 0 n40 ns9 0 -0.000352949101053
Gc20_10 0 n40 ns10 0 0.000857201323007
Gc20_11 0 n40 ns11 0 -5.3477400252e-05
Gc20_12 0 n40 ns12 0 -3.18688422676e-06
Gc20_13 0 n40 ns13 0 0.000547814050768
Gc20_14 0 n40 ns14 0 -0.000859543641807
Gc20_15 0 n40 ns15 0 -0.000648606795539
Gc20_16 0 n40 ns16 0 0.00085700623553
Gc20_17 0 n40 ns17 0 0.000589421937719
Gc20_18 0 n40 ns18 0 0.000357845037783
Gc20_19 0 n40 ns19 0 0.000173610115725
Gc20_20 0 n40 ns20 0 0.00043727459065
Gc20_21 0 n40 ns21 0 -0.000291501435115
Gc20_22 0 n40 ns22 0 0.00108051191955
Gc20_23 0 n40 ns23 0 0.00187063760978
Gc20_24 0 n40 ns24 0 -0.00389890293988
Gc20_25 0 n40 ns25 0 0.00143283694696
Gc20_26 0 n40 ns26 0 -0.00403874639628
Gc20_27 0 n40 ns27 0 -0.00177404974692
Gc20_28 0 n40 ns28 0 -0.000119883264627
Gc20_29 0 n40 ns29 0 0.000460690455606
Gc20_30 0 n40 ns30 0 -0.00108015787118
Gc20_31 0 n40 ns31 0 0.00105402472306
Gc20_32 0 n40 ns32 0 -0.00199571553817
Gc20_33 0 n40 ns33 0 0.000933946837757
Gc20_34 0 n40 ns34 0 -0.00178115444494
Gc20_35 0 n40 ns35 0 -0.000976896739779
Gc20_36 0 n40 ns36 0 -3.65514936232e-05
Gc20_37 0 n40 ns37 0 0.000150139965859
Gc20_38 0 n40 ns38 0 -2.91399255931e-05
Gc20_39 0 n40 ns39 0 -0.000381498447946
Gc20_40 0 n40 ns40 0 -7.54662986226e-05
Gc20_41 0 n40 ns41 0 -0.00105130732052
Gc20_42 0 n40 ns42 0 0.00183969699923
Gc20_43 0 n40 ns43 0 -7.87508127926e-05
Gc20_44 0 n40 ns44 0 0.000249009243119
Gc20_45 0 n40 ns45 0 1.58333247473e-05
Gc20_46 0 n40 ns46 0 -0.000203390123524
Gc20_47 0 n40 ns47 0 -0.000259519249227
Gc20_48 0 n40 ns48 0 0.000822038354617
Gc20_49 0 n40 ns49 0 -0.000113417428868
Gc20_50 0 n40 ns50 0 -3.37184854494e-05
Gc20_51 0 n40 ns51 0 0.000526403162174
Gc20_52 0 n40 ns52 0 -0.000760111346178
Gc20_53 0 n40 ns53 0 -0.000555018707177
Gc20_54 0 n40 ns54 0 0.000390178535184
Gc20_55 0 n40 ns55 0 0.000753583552791
Gc20_56 0 n40 ns56 0 7.94997874733e-05
Gc20_57 0 n40 ns57 0 0.000325948069849
Gc20_58 0 n40 ns58 0 -7.45802671763e-05
Gc20_59 0 n40 ns59 0 -0.000665722257053
Gc20_60 0 n40 ns60 0 0.00121919259419
Gc20_61 0 n40 ns61 0 0.0010349570161
Gc20_62 0 n40 ns62 0 -0.00333838333752
Gc20_63 0 n40 ns63 0 0.000794811765134
Gc20_64 0 n40 ns64 0 -0.0037440281198
Gc20_65 0 n40 ns65 0 -0.00112062480679
Gc20_66 0 n40 ns66 0 -0.000232263758597
Gc20_67 0 n40 ns67 0 0.000592082586348
Gc20_68 0 n40 ns68 0 -0.00123398832504
Gc20_69 0 n40 ns69 0 0.000855457998442
Gc20_70 0 n40 ns70 0 -0.002209970021
Gc20_71 0 n40 ns71 0 0.00132935203095
Gc20_72 0 n40 ns72 0 -0.00255494900121
Gc20_73 0 n40 ns73 0 -0.00146932370687
Gc20_74 0 n40 ns74 0 -2.24732887894e-05
Gc20_75 0 n40 ns75 0 8.5377827606e-05
Gc20_76 0 n40 ns76 0 3.95492292716e-06
Gc20_77 0 n40 ns77 0 -0.000791243127658
Gc20_78 0 n40 ns78 0 -0.000989224879682
Gc20_79 0 n40 ns79 0 -0.0032974067388
Gc20_80 0 n40 ns80 0 -0.00169196571669
Gc20_81 0 n40 ns81 0 -0.00193952951592
Gc20_82 0 n40 ns82 0 0.00102290050112
Gc20_83 0 n40 ns83 0 0.000883968221221
Gc20_84 0 n40 ns84 0 -0.000363565019218
Gc20_85 0 n40 ns85 0 -0.00016481281737
Gc20_86 0 n40 ns86 0 0.000146254075917
Gc20_87 0 n40 ns87 0 -0.00026502725124
Gc20_88 0 n40 ns88 0 -3.80453987837e-06
Gc20_89 0 n40 ns89 0 0.000390713074015
Gc20_90 0 n40 ns90 0 0.000340903481885
Gc20_91 0 n40 ns91 0 0.00109825083403
Gc20_92 0 n40 ns92 0 -0.00062432123391
Gc20_93 0 n40 ns93 0 0.00134261571745
Gc20_94 0 n40 ns94 0 -0.000317703998964
Gc20_95 0 n40 ns95 0 0.00119306109154
Gc20_96 0 n40 ns96 0 -0.000656052331229
Gc20_97 0 n40 ns97 0 -0.00172974598457
Gc20_98 0 n40 ns98 0 -0.000897229019305
Gc20_99 0 n40 ns99 0 -0.00469422299937
Gc20_100 0 n40 ns100 0 -0.00441885098371
Gc20_101 0 n40 ns101 0 -0.0036452838946
Gc20_102 0 n40 ns102 0 -0.00469282652252
Gc20_103 0 n40 ns103 0 0.00306358260251
Gc20_104 0 n40 ns104 0 0.00180773831489
Gc20_105 0 n40 ns105 0 0.000950592278741
Gc20_106 0 n40 ns106 0 -0.00121933101425
Gc20_107 0 n40 ns107 0 -0.00172593815014
Gc20_108 0 n40 ns108 0 -0.0029286908853
Gc20_109 0 n40 ns109 0 0.00254375642855
Gc20_110 0 n40 ns110 0 -0.000561039154733
Gc20_111 0 n40 ns111 0 -0.0031987407759
Gc20_112 0 n40 ns112 0 -3.80883467042e-05
Gc20_113 0 n40 ns113 0 0.000336519338699
Gc20_114 0 n40 ns114 0 -0.000161717122677
Gc20_115 0 n40 ns115 0 -0.000647089548035
Gc20_116 0 n40 ns116 0 0.000123871112183
Gc20_117 0 n40 ns117 0 6.92812491713e-05
Gc20_118 0 n40 ns118 0 0.00311074211327
Gc20_119 0 n40 ns119 0 0.00128102948842
Gc20_120 0 n40 ns120 0 -0.000706281001107
Gc20_121 0 n40 ns121 0 -0.000301000586159
Gc20_122 0 n40 ns122 0 -0.000112815934324
Gc20_123 0 n40 ns123 0 0.000227848495679
Gc20_124 0 n40 ns124 0 0.000113933071134
Gc20_125 0 n40 ns125 0 -0.000142697349546
Gc20_126 0 n40 ns126 0 3.99759464502e-05
Gc20_127 0 n40 ns127 0 0.00208595111131
Gc20_128 0 n40 ns128 0 -0.000858378933731
Gc20_129 0 n40 ns129 0 -0.00026361732099
Gc20_130 0 n40 ns130 0 0.00117382847235
Gc20_131 0 n40 ns131 0 -0.000292481807018
Gc20_132 0 n40 ns132 0 -0.00010868938923
Gc20_133 0 n40 ns133 0 -0.00190776809165
Gc20_134 0 n40 ns134 0 -0.0014028997139
Gc20_135 0 n40 ns135 0 0.00295984983372
Gc20_136 0 n40 ns136 0 0.00365168535064
Gc20_137 0 n40 ns137 0 -0.010537073865
Gc20_138 0 n40 ns138 0 -0.000340125460822
Gc20_139 0 n40 ns139 0 -0.00810073324245
Gc20_140 0 n40 ns140 0 -0.00151698424668
Gc20_141 0 n40 ns141 0 -0.011016557487
Gc20_142 0 n40 ns142 0 -0.000150782988071
Gc20_143 0 n40 ns143 0 0.00146881421838
Gc20_144 0 n40 ns144 0 -2.03565376968e-05
Gc20_145 0 n40 ns145 0 -0.00344134565441
Gc20_146 0 n40 ns146 0 0.00830492515211
Gc20_147 0 n40 ns147 0 -0.0142168470086
Gc20_148 0 n40 ns148 0 -0.00419056081025
Gc20_149 0 n40 ns149 0 -0.00627549562281
Gc20_150 0 n40 ns150 0 -5.74515530037e-05
Gc20_151 0 n40 ns151 0 -0.000342051261727
Gc20_152 0 n40 ns152 0 0.000585671894149
Gc20_153 0 n40 ns153 0 -0.000842775689294
Gc20_154 0 n40 ns154 0 -0.000677251538374
Gc20_155 0 n40 ns155 0 -0.00343091355636
Gc20_156 0 n40 ns156 0 -0.00160729211346
Gc20_157 0 n40 ns157 0 -0.00181017236569
Gc20_158 0 n40 ns158 0 0.00112648754032
Gc20_159 0 n40 ns159 0 0.000746717389562
Gc20_160 0 n40 ns160 0 -0.000486805476548
Gc20_161 0 n40 ns161 0 -0.000471817910231
Gc20_162 0 n40 ns162 0 4.89693326285e-05
Gc20_163 0 n40 ns163 0 -0.000164352240512
Gc20_164 0 n40 ns164 0 5.63058927914e-05
Gc20_165 0 n40 ns165 0 0.000693296480804
Gc20_166 0 n40 ns166 0 0.00013795438753
Gc20_167 0 n40 ns167 0 0.00081996772823
Gc20_168 0 n40 ns168 0 -0.000889557731196
Gc20_169 0 n40 ns169 0 0.000972129367082
Gc20_170 0 n40 ns170 0 -0.000285564988754
Gc20_171 0 n40 ns171 0 0.000761284422365
Gc20_172 0 n40 ns172 0 -0.000526845623787
Gc20_173 0 n40 ns173 0 -0.002171380406
Gc20_174 0 n40 ns174 0 -0.000890472319929
Gc20_175 0 n40 ns175 0 -0.00625389675525
Gc20_176 0 n40 ns176 0 -0.00280126668525
Gc20_177 0 n40 ns177 0 -0.00495400668154
Gc20_178 0 n40 ns178 0 -0.00324714364045
Gc20_179 0 n40 ns179 0 0.00354855466715
Gc20_180 0 n40 ns180 0 0.00203325635045
Gc20_181 0 n40 ns181 0 0.000838763846853
Gc20_182 0 n40 ns182 0 -0.00119292841305
Gc20_183 0 n40 ns183 0 -0.0021591112388
Gc20_184 0 n40 ns184 0 -0.00293674433408
Gc20_185 0 n40 ns185 0 0.00244344393761
Gc20_186 0 n40 ns186 0 -0.000616373917071
Gc20_187 0 n40 ns187 0 -0.00319266667946
Gc20_188 0 n40 ns188 0 -4.43483690065e-05
Gc20_189 0 n40 ns189 0 0.000364001840623
Gc20_190 0 n40 ns190 0 -0.000157794481465
Gc20_191 0 n40 ns191 0 -8.76513618797e-05
Gc20_192 0 n40 ns192 0 -5.37590788947e-05
Gc20_193 0 n40 ns193 0 9.16864959786e-05
Gc20_194 0 n40 ns194 0 0.00156893370781
Gc20_195 0 n40 ns195 0 9.70573945092e-05
Gc20_196 0 n40 ns196 0 0.000238086566117
Gc20_197 0 n40 ns197 0 5.91703562067e-06
Gc20_198 0 n40 ns198 0 -0.000231149026679
Gc20_199 0 n40 ns199 0 -0.000217309061388
Gc20_200 0 n40 ns200 0 0.000423573597576
Gc20_201 0 n40 ns201 0 -0.000104948107564
Gc20_202 0 n40 ns202 0 6.49082283985e-05
Gc20_203 0 n40 ns203 0 0.00060823269231
Gc20_204 0 n40 ns204 0 -0.000567896001027
Gc20_205 0 n40 ns205 0 -0.000459396753839
Gc20_206 0 n40 ns206 0 -0.000187757779056
Gc20_207 0 n40 ns207 0 0.000411575218743
Gc20_208 0 n40 ns208 0 -0.000339237564543
Gc20_209 0 n40 ns209 0 -6.4012537861e-05
Gc20_210 0 n40 ns210 0 -0.00049364808298
Gc20_211 0 n40 ns211 0 -0.000987387518583
Gc20_212 0 n40 ns212 0 0.00112640201625
Gc20_213 0 n40 ns213 0 -0.00259471774461
Gc20_214 0 n40 ns214 0 -0.00154134462379
Gc20_215 0 n40 ns215 0 -0.00237219359225
Gc20_216 0 n40 ns216 0 -0.00210183095027
Gc20_217 0 n40 ns217 0 0.000118150957517
Gc20_218 0 n40 ns218 0 0.000958873279436
Gc20_219 0 n40 ns219 0 0.000251442956758
Gc20_220 0 n40 ns220 0 -0.00132994293724
Gc20_221 0 n40 ns221 0 -0.000478205527572
Gc20_222 0 n40 ns222 0 -0.00300624004419
Gc20_223 0 n40 ns223 0 0.000918201017666
Gc20_224 0 n40 ns224 0 -0.00362547077407
Gc20_225 0 n40 ns225 0 -0.00165159492363
Gc20_226 0 n40 ns226 0 -2.41727241978e-05
Gc20_227 0 n40 ns227 0 0.000103871461567
Gc20_228 0 n40 ns228 0 -2.79207285817e-06
Gc20_229 0 n40 ns229 0 -0.000128297464875
Gc20_230 0 n40 ns230 0 0.000128641279034
Gc20_231 0 n40 ns231 0 -7.90617922872e-05
Gc20_232 0 n40 ns232 0 0.000560316160988
Gc20_233 0 n40 ns233 0 -0.000176863693305
Gc20_234 0 n40 ns234 0 0.000193679046376
Gc20_235 0 n40 ns235 0 -1.41896390238e-05
Gc20_236 0 n40 ns236 0 -8.68584619901e-05
Gc20_237 0 n40 ns237 0 0.000344447385816
Gc20_238 0 n40 ns238 0 0.000361129036243
Gc20_239 0 n40 ns239 0 -6.8334875829e-05
Gc20_240 0 n40 ns240 0 6.00994614714e-05
Gc20_241 0 n40 ns241 0 -0.00017710369246
Gc20_242 0 n40 ns242 0 -0.000393288457633
Gc20_243 0 n40 ns243 0 0.00030475602823
Gc20_244 0 n40 ns244 0 0.000524815201606
Gc20_245 0 n40 ns245 0 0.000414851038886
Gc20_246 0 n40 ns246 0 -0.000312977314321
Gc20_247 0 n40 ns247 0 0.000185402299257
Gc20_248 0 n40 ns248 0 -0.00011653980884
Gc20_249 0 n40 ns249 0 -2.6634134306e-05
Gc20_250 0 n40 ns250 0 0.000264978075742
Gc20_251 0 n40 ns251 0 -0.00393534132888
Gc20_252 0 n40 ns252 0 -0.00366417180668
Gc20_253 0 n40 ns253 0 -0.00373189496399
Gc20_254 0 n40 ns254 0 -0.00341537039889
Gc20_255 0 n40 ns255 0 -0.000238983196736
Gc20_256 0 n40 ns256 0 0.00204481467411
Gc20_257 0 n40 ns257 0 -0.000262530224378
Gc20_258 0 n40 ns258 0 -0.000955116085263
Gc20_259 0 n40 ns259 0 -0.00104211098827
Gc20_260 0 n40 ns260 0 -0.00270593166754
Gc20_261 0 n40 ns261 0 3.1248323912e-05
Gc20_262 0 n40 ns262 0 -0.00224472193294
Gc20_263 0 n40 ns263 0 -0.000746269985366
Gc20_264 0 n40 ns264 0 -1.73250410113e-05
Gc20_265 0 n40 ns265 0 8.23928560177e-05
Gc20_266 0 n40 ns266 0 -1.2281209653e-05
Gc20_267 0 n40 ns267 0 0.000488215736248
Gc20_268 0 n40 ns268 0 -0.000685417303389
Gc20_269 0 n40 ns269 0 0.00149508798803
Gc20_270 0 n40 ns270 0 -0.000962338365604
Gc20_271 0 n40 ns271 0 0.000307626217033
Gc20_272 0 n40 ns272 0 -0.000223148749804
Gc20_273 0 n40 ns273 0 -0.000137317806164
Gc20_274 0 n40 ns274 0 0.000136396255431
Gc20_275 0 n40 ns275 0 0.000179442339816
Gc20_276 0 n40 ns276 0 -0.000532171950347
Gc20_277 0 n40 ns277 0 -8.4289945936e-05
Gc20_278 0 n40 ns278 0 0.000159626000907
Gc20_279 0 n40 ns279 0 -5.3155550757e-05
Gc20_280 0 n40 ns280 0 0.000613864466043
Gc20_281 0 n40 ns281 0 0.000399081245166
Gc20_282 0 n40 ns282 0 -0.000133040376613
Gc20_283 0 n40 ns283 0 -0.00013091900467
Gc20_284 0 n40 ns284 0 -0.00053259698562
Gc20_285 0 n40 ns285 0 -0.000331557466574
Gc20_286 0 n40 ns286 0 -0.000455872814982
Gc20_287 0 n40 ns287 0 -7.49397318433e-05
Gc20_288 0 n40 ns288 0 -0.000592384059586
Gc20_289 0 n40 ns289 0 -0.00487894028464
Gc20_290 0 n40 ns290 0 -0.00207523956401
Gc20_291 0 n40 ns291 0 -0.00442309932796
Gc20_292 0 n40 ns292 0 -0.00173761370149
Gc20_293 0 n40 ns293 0 0.000357589850249
Gc20_294 0 n40 ns294 0 0.00152690598505
Gc20_295 0 n40 ns295 0 -0.00035071029243
Gc20_296 0 n40 ns296 0 -0.000467406338432
Gc20_297 0 n40 ns297 0 -0.00121995053331
Gc20_298 0 n40 ns298 0 -0.00142605061711
Gc20_299 0 n40 ns299 0 -0.000164128353165
Gc20_300 0 n40 ns300 0 -0.000962238130977
Gc20_301 0 n40 ns301 0 -0.000297879061268
Gc20_302 0 n40 ns302 0 -5.46231628938e-06
Gc20_303 0 n40 ns303 0 2.7547755831e-05
Gc20_304 0 n40 ns304 0 2.93176023584e-05
Gc20_305 0 n40 ns305 0 -0.00070520919984
Gc20_306 0 n40 ns306 0 0.00129933818769
Gc20_307 0 n40 ns307 0 -0.00180610922603
Gc20_308 0 n40 ns308 0 0.00186563950373
Gc20_309 0 n40 ns309 0 -0.000240935836534
Gc20_310 0 n40 ns310 0 0.000688275051886
Gc20_311 0 n40 ns311 0 0.000171369384046
Gc20_312 0 n40 ns312 0 -0.000437936505719
Gc20_313 0 n40 ns313 0 -5.9326080329e-05
Gc20_314 0 n40 ns314 0 -0.000110462366378
Gc20_315 0 n40 ns315 0 9.34226255916e-05
Gc20_316 0 n40 ns316 0 0.000114173353098
Gc20_317 0 n40 ns317 0 0.000589427302975
Gc20_318 0 n40 ns318 0 -0.00035456558038
Gc20_319 0 n40 ns319 0 0.000350928215458
Gc20_320 0 n40 ns320 0 -0.000741602076086
Gc20_321 0 n40 ns321 0 -0.000189245045489
Gc20_322 0 n40 ns322 0 -0.000485474869919
Gc20_323 0 n40 ns323 0 -0.000176327136737
Gc20_324 0 n40 ns324 0 -0.000434946823562
Gc20_325 0 n40 ns325 0 -0.000556563671696
Gc20_326 0 n40 ns326 0 -0.00016263354898
Gc20_327 0 n40 ns327 0 -0.00416975369727
Gc20_328 0 n40 ns328 0 0.00045206832459
Gc20_329 0 n40 ns329 0 -0.0036296926154
Gc20_330 0 n40 ns330 0 0.000460396297117
Gc20_331 0 n40 ns331 0 0.000423819168954
Gc20_332 0 n40 ns332 0 0.00131862751191
Gc20_333 0 n40 ns333 0 -0.000252501918102
Gc20_334 0 n40 ns334 0 -0.000275686700597
Gc20_335 0 n40 ns335 0 -0.000871297816807
Gc20_336 0 n40 ns336 0 -0.00104650668451
Gc20_337 0 n40 ns337 0 -0.000120151279155
Gc20_338 0 n40 ns338 0 -0.000665934809463
Gc20_339 0 n40 ns339 0 -0.000202593562495
Gc20_340 0 n40 ns340 0 1.89935026336e-06
Gc20_341 0 n40 ns341 0 6.49159522215e-05
Gc20_342 0 n40 ns342 0 -6.63414018017e-06
Gc20_343 0 n40 ns343 0 -0.000715358483422
Gc20_344 0 n40 ns344 0 -0.000520299792808
Gc20_345 0 n40 ns345 0 -0.00226711513377
Gc20_346 0 n40 ns346 0 0.00100894028393
Gc20_347 0 n40 ns347 0 -0.000224605886742
Gc20_348 0 n40 ns348 0 0.000848818176452
Gc20_349 0 n40 ns349 0 0.000163101246778
Gc20_350 0 n40 ns350 0 -0.000235777967806
Gc20_351 0 n40 ns351 0 -0.000126087096009
Gc20_352 0 n40 ns352 0 0.000342431840733
Gc20_353 0 n40 ns353 0 -0.000250393618694
Gc20_354 0 n40 ns354 0 -2.12920752215e-05
Gc20_355 0 n40 ns355 0 0.000408075358913
Gc20_356 0 n40 ns356 0 0.000290468555555
Gc20_357 0 n40 ns357 0 0.000348341138495
Gc20_358 0 n40 ns358 0 -0.000318060798956
Gc20_359 0 n40 ns359 0 0.00110028698091
Gc20_360 0 n40 ns360 0 -0.000298581489076
Gc20_361 0 n40 ns361 0 0.000846844643936
Gc20_362 0 n40 ns362 0 -0.000742062239321
Gc20_363 0 n40 ns363 0 -0.00173814026054
Gc20_364 0 n40 ns364 0 2.13766856203e-05
Gc20_365 0 n40 ns365 0 -0.00337479647421
Gc20_366 0 n40 ns366 0 -0.00367338679805
Gc20_367 0 n40 ns367 0 -0.00264746763338
Gc20_368 0 n40 ns368 0 -0.00410070722525
Gc20_369 0 n40 ns369 0 0.00119282644553
Gc20_370 0 n40 ns370 0 -0.000434195563665
Gc20_371 0 n40 ns371 0 0.00094293866792
Gc20_372 0 n40 ns372 0 -0.00115700693395
Gc20_373 0 n40 ns373 0 5.98256766643e-05
Gc20_374 0 n40 ns374 0 -0.00163420983979
Gc20_375 0 n40 ns375 0 0.00254738360963
Gc20_376 0 n40 ns376 0 -0.00232633915769
Gc20_377 0 n40 ns377 0 -0.00248459945967
Gc20_378 0 n40 ns378 0 3.42315551383e-06
Gc20_379 0 n40 ns379 0 0.000130216552422
Gc20_380 0 n40 ns380 0 -2.93420248871e-05
Gc20_381 0 n40 ns381 0 0.00212960568651
Gc20_382 0 n40 ns382 0 -0.00318304770526
Gc20_383 0 n40 ns383 0 0.00466217756283
Gc20_384 0 n40 ns384 0 -0.00648606951678
Gc20_385 0 n40 ns385 0 -0.00338749089066
Gc20_386 0 n40 ns386 0 -0.00227185891351
Gc20_387 0 n40 ns387 0 0.00120438435094
Gc20_388 0 n40 ns388 0 0.000660776188923
Gc20_389 0 n40 ns389 0 -0.000280810894
Gc20_390 0 n40 ns390 0 -0.000540083832372
Gc20_391 0 n40 ns391 0 -0.000276251541654
Gc20_392 0 n40 ns392 0 6.62270904151e-06
Gc20_393 0 n40 ns393 0 -0.000398109281115
Gc20_394 0 n40 ns394 0 -0.000338764032091
Gc20_395 0 n40 ns395 0 0.00147537117242
Gc20_396 0 n40 ns396 0 5.27543485799e-05
Gc20_397 0 n40 ns397 0 0.00102651648731
Gc20_398 0 n40 ns398 0 0.000225959144263
Gc20_399 0 n40 ns399 0 0.000426478964865
Gc20_400 0 n40 ns400 0 0.000420122905686
Gc20_401 0 n40 ns401 0 0.00087659511474
Gc20_402 0 n40 ns402 0 -0.00304612762297
Gc20_403 0 n40 ns403 0 -0.00224068385712
Gc20_404 0 n40 ns404 0 -0.00807560225577
Gc20_405 0 n40 ns405 0 -0.00156979172321
Gc20_406 0 n40 ns406 0 -0.00755873689417
Gc20_407 0 n40 ns407 0 0.00536145292845
Gc20_408 0 n40 ns408 0 0.00809247938609
Gc20_409 0 n40 ns409 0 0.000821590344843
Gc20_410 0 n40 ns410 0 -0.00122174996093
Gc20_411 0 n40 ns411 0 -0.00523953007054
Gc20_412 0 n40 ns412 0 -0.00598775748462
Gc20_413 0 n40 ns413 0 0.00146575117367
Gc20_414 0 n40 ns414 0 0.00530811195989
Gc20_415 0 n40 ns415 0 -0.00429759314135
Gc20_416 0 n40 ns416 0 2.44552000724e-06
Gc20_417 0 n40 ns417 0 0.000434159289486
Gc20_418 0 n40 ns418 0 -0.000239159820664
Gc20_419 0 n40 ns419 0 0.000943396167693
Gc20_420 0 n40 ns420 0 -0.00220292666272
Gc20_421 0 n40 ns421 0 0.00153016925074
Gc20_422 0 n40 ns422 0 -0.00422199351703
Gc20_423 0 n40 ns423 0 -0.00244375356996
Gc20_424 0 n40 ns424 0 -0.00108863461187
Gc20_425 0 n40 ns425 0 0.000870807562644
Gc20_426 0 n40 ns426 0 0.000321236634666
Gc20_427 0 n40 ns427 0 -0.000466266811671
Gc20_428 0 n40 ns428 0 -0.000422367538453
Gc20_429 0 n40 ns429 0 -0.000209521552456
Gc20_430 0 n40 ns430 0 4.14177763616e-05
Gc20_431 0 n40 ns431 0 0.000216479265747
Gc20_432 0 n40 ns432 0 1.70095917805e-05
Gc20_433 0 n40 ns433 0 0.00125680966916
Gc20_434 0 n40 ns434 0 -0.000519309902398
Gc20_435 0 n40 ns435 0 0.000921453329141
Gc20_436 0 n40 ns436 0 -2.35933709765e-05
Gc20_437 0 n40 ns437 0 0.000430616185081
Gc20_438 0 n40 ns438 0 -0.000115391454818
Gc20_439 0 n40 ns439 0 -0.000915890481745
Gc20_440 0 n40 ns440 0 -0.00216101869915
Gc20_441 0 n40 ns441 0 -0.00574763555392
Gc20_442 0 n40 ns442 0 -0.004342177962
Gc20_443 0 n40 ns443 0 -0.00446311344044
Gc20_444 0 n40 ns444 0 -0.00454019906148
Gc20_445 0 n40 ns445 0 0.00443478570005
Gc20_446 0 n40 ns446 0 0.00413726667388
Gc20_447 0 n40 ns447 0 0.000938117595964
Gc20_448 0 n40 ns448 0 -0.0011373856484
Gc20_449 0 n40 ns449 0 -0.00313975868725
Gc20_450 0 n40 ns450 0 -0.00338168961757
Gc20_451 0 n40 ns451 0 0.00221508279373
Gc20_452 0 n40 ns452 0 0.0015118527
Gc20_453 0 n40 ns453 0 -0.00374589558131
Gc20_454 0 n40 ns454 0 -1.60176747159e-06
Gc20_455 0 n40 ns455 0 0.000319856833943
Gc20_456 0 n40 ns456 0 -0.000139984787896
Gc20_457 0 n40 ns457 0 -0.000296959209808
Gc20_458 0 n40 ns458 0 -0.000479036826521
Gc20_459 0 n40 ns459 0 -0.000895792858772
Gc20_460 0 n40 ns460 0 0.00080094036987
Gc20_461 0 n40 ns461 0 -0.000106351888691
Gc20_462 0 n40 ns462 0 0.000507823961214
Gc20_463 0 n40 ns463 0 0.000131885804095
Gc20_464 0 n40 ns464 0 -0.000290977742538
Gc20_465 0 n40 ns465 0 -0.000485971108163
Gc20_466 0 n40 ns466 0 0.000207569320054
Gc20_467 0 n40 ns467 0 -0.000141145142378
Gc20_468 0 n40 ns468 0 8.91683548885e-05
Gc20_469 0 n40 ns469 0 0.000894120560301
Gc20_470 0 n40 ns470 0 -0.000178721882457
Gc20_471 0 n40 ns471 0 -0.000344880146116
Gc20_472 0 n40 ns472 0 -0.000557473805066
Gc20_473 0 n40 ns473 0 0.000501523421126
Gc20_474 0 n40 ns474 0 -0.000325603086139
Gc20_475 0 n40 ns475 0 1.91787273922e-05
Gc20_476 0 n40 ns476 0 -0.000591269789221
Gc20_477 0 n40 ns477 0 -0.00166664511576
Gc20_478 0 n40 ns478 0 0.00071453202992
Gc20_479 0 n40 ns479 0 -0.00378788181179
Gc20_480 0 n40 ns480 0 -0.00140581488035
Gc20_481 0 n40 ns481 0 -0.00320453270809
Gc20_482 0 n40 ns482 0 -0.00210950923373
Gc20_483 0 n40 ns483 0 0.000914061728743
Gc20_484 0 n40 ns484 0 0.000644909406082
Gc20_485 0 n40 ns485 0 0.000508123122021
Gc20_486 0 n40 ns486 0 -0.00133526138048
Gc20_487 0 n40 ns487 0 -0.000535469345108
Gc20_488 0 n40 ns488 0 -0.00269456045258
Gc20_489 0 n40 ns489 0 0.0015556220541
Gc20_490 0 n40 ns490 0 -0.00345086555782
Gc20_491 0 n40 ns491 0 -0.00214247712131
Gc20_492 0 n40 ns492 0 -2.34029911409e-05
Gc20_493 0 n40 ns493 0 0.000132570132632
Gc20_494 0 n40 ns494 0 -1.22459580408e-05
Gc20_495 0 n40 ns495 0 -0.000117034547983
Gc20_496 0 n40 ns496 0 2.58869977339e-05
Gc20_497 0 n40 ns497 0 -4.91921576938e-05
Gc20_498 0 n40 ns498 0 0.000754487716524
Gc20_499 0 n40 ns499 0 -0.00014491324998
Gc20_500 0 n40 ns500 0 0.000105583144999
Gc20_501 0 n40 ns501 0 -2.77283460997e-05
Gc20_502 0 n40 ns502 0 -0.00011935841594
Gc20_503 0 n40 ns503 0 0.000116074731313
Gc20_504 0 n40 ns504 0 0.000517339927637
Gc20_505 0 n40 ns505 0 -8.12410163358e-05
Gc20_506 0 n40 ns506 0 6.35284551764e-05
Gc20_507 0 n40 ns507 0 9.31351971743e-05
Gc20_508 0 n40 ns508 0 -0.000584630934961
Gc20_509 0 n40 ns509 0 -3.02601569589e-05
Gc20_510 0 n40 ns510 0 0.000565762809525
Gc20_511 0 n40 ns511 0 0.000475322735577
Gc20_512 0 n40 ns512 0 -0.000219663238026
Gc20_513 0 n40 ns513 0 0.000116504286443
Gc20_514 0 n40 ns514 0 -6.28071727019e-05
Gc20_515 0 n40 ns515 0 -0.000216553032933
Gc20_516 0 n40 ns516 0 0.000610171148077
Gc20_517 0 n40 ns517 0 -0.00319818264866
Gc20_518 0 n40 ns518 0 -0.00371201154486
Gc20_519 0 n40 ns519 0 -0.00309440592534
Gc20_520 0 n40 ns520 0 -0.00364071359119
Gc20_521 0 n40 ns521 0 -0.000447225797153
Gc20_522 0 n40 ns522 0 0.00181580715047
Gc20_523 0 n40 ns523 0 -0.000122691609865
Gc20_524 0 n40 ns524 0 -0.00113600816471
Gc20_525 0 n40 ns525 0 -0.000776612315195
Gc20_526 0 n40 ns526 0 -0.00297250876462
Gc20_527 0 n40 ns527 0 0.000250122986469
Gc20_528 0 n40 ns528 0 -0.00266319115984
Gc20_529 0 n40 ns529 0 -0.000977289512884
Gc20_530 0 n40 ns530 0 -1.68348107613e-05
Gc20_531 0 n40 ns531 0 0.000105305102643
Gc20_532 0 n40 ns532 0 -2.28603240621e-05
Gc20_533 0 n40 ns533 0 0.000335026793113
Gc20_534 0 n40 ns534 0 -0.000591324958374
Gc20_535 0 n40 ns535 0 0.00116954676044
Gc20_536 0 n40 ns536 0 -0.000938920902865
Gc20_537 0 n40 ns537 0 0.000247494134063
Gc20_538 0 n40 ns538 0 -0.000186272951718
Gc20_539 0 n40 ns539 0 -0.000172974445083
Gc20_540 0 n40 ns540 0 0.000156679661949
Gc20_541 0 n40 ns541 0 0.000321666194602
Gc20_542 0 n40 ns542 0 -0.000331411396355
Gc20_543 0 n40 ns543 0 -0.000124134369422
Gc20_544 0 n40 ns544 0 0.000136629551584
Gc20_545 0 n40 ns545 0 -0.000234461739384
Gc20_546 0 n40 ns546 0 0.000549656768634
Gc20_547 0 n40 ns547 0 0.000468123667266
Gc20_548 0 n40 ns548 0 0.000276116656735
Gc20_549 0 n40 ns549 0 7.71779648513e-05
Gc20_550 0 n40 ns550 0 -0.000439791319051
Gc20_551 0 n40 ns551 0 -0.000166240720148
Gc20_552 0 n40 ns552 0 -0.000277972699297
Gc20_553 0 n40 ns553 0 -2.87445865724e-05
Gc20_554 0 n40 ns554 0 -0.000529623408443
Gc20_555 0 n40 ns555 0 -0.00502413142085
Gc20_556 0 n40 ns556 0 -0.00322576883705
Gc20_557 0 n40 ns557 0 -0.00461738758679
Gc20_558 0 n40 ns558 0 -0.00279262868438
Gc20_559 0 n40 ns559 0 7.17090123189e-05
Gc20_560 0 n40 ns560 0 0.00167448320342
Gc20_561 0 n40 ns561 0 -0.000341843600441
Gc20_562 0 n40 ns562 0 -0.000603935772182
Gc20_563 0 n40 ns563 0 -0.0011447284629
Gc20_564 0 n40 ns564 0 -0.0017241665217
Gc20_565 0 n40 ns565 0 -0.000101530399414
Gc20_566 0 n40 ns566 0 -0.00114147039245
Gc20_567 0 n40 ns567 0 -0.00037147437126
Gc20_568 0 n40 ns568 0 -9.72514901849e-06
Gc20_569 0 n40 ns569 0 8.87309368338e-05
Gc20_570 0 n40 ns570 0 -6.55136836164e-06
Gc20_571 0 n40 ns571 0 -0.000521676699318
Gc20_572 0 n40 ns572 0 0.00073377948576
Gc20_573 0 n40 ns573 0 -0.00128237364791
Gc20_574 0 n40 ns574 0 0.000715971979333
Gc20_575 0 n40 ns575 0 -0.000179492652967
Gc20_576 0 n40 ns576 0 0.000363956846769
Gc20_577 0 n40 ns577 0 0.000150056947355
Gc20_578 0 n40 ns578 0 -0.000256536987128
Gc20_579 0 n40 ns579 0 -5.7692688948e-05
Gc20_580 0 n40 ns580 0 -0.000334530013883
Gc20_581 0 n40 ns581 0 3.64797494671e-05
Gc20_582 0 n40 ns582 0 0.000173871577376
Gc20_583 0 n40 ns583 0 0.000588919135559
Gc20_584 0 n40 ns584 0 8.42396426769e-05
Gc20_585 0 n40 ns585 0 0.00043256534908
Gc20_586 0 n40 ns586 0 -0.000562949243864
Gc20_587 0 n40 ns587 0 -0.000223890015881
Gc20_588 0 n40 ns588 0 -0.00049322646334
Gc20_589 0 n40 ns589 0 -0.000305427139008
Gc20_590 0 n40 ns590 0 -0.000375420879144
Gc20_591 0 n40 ns591 0 -0.000579804877453
Gc20_592 0 n40 ns592 0 -0.000448977748624
Gc20_593 0 n40 ns593 0 -0.00505293612484
Gc20_594 0 n40 ns594 0 -0.000403119026878
Gc20_595 0 n40 ns595 0 -0.00444074572505
Gc20_596 0 n40 ns596 0 -0.000250958865503
Gc20_597 0 n40 ns597 0 0.000295515845057
Gc20_598 0 n40 ns598 0 0.00134436116072
Gc20_599 0 n40 ns599 0 -0.000277714725561
Gc20_600 0 n40 ns600 0 -0.000321895332276
Gc20_601 0 n40 ns601 0 -0.000900043476272
Gc20_602 0 n40 ns602 0 -0.00106075769412
Gc20_603 0 n40 ns603 0 -9.3761392901e-05
Gc20_604 0 n40 ns604 0 -0.000553497733486
Gc20_605 0 n40 ns605 0 -0.00018142419483
Gc20_606 0 n40 ns606 0 -1.62052512504e-05
Gc20_607 0 n40 ns607 0 0.00010873113715
Gc20_608 0 n40 ns608 0 -2.69016131992e-05
Gc20_609 0 n40 ns609 0 0.000103017262293
Gc20_610 0 n40 ns610 0 -0.000422621190197
Gc20_611 0 n40 ns611 0 0.000371578393145
Gc20_612 0 n40 ns612 0 0.00038214626926
Gc20_613 0 n40 ns613 0 0.000137593259177
Gc20_614 0 n40 ns614 0 0.000220590517888
Gc20_615 0 n40 ns615 0 7.42667382116e-06
Gc20_616 0 n40 ns616 0 0.000120408387804
Gc20_617 0 n40 ns617 0 0.000243752293232
Gc20_618 0 n40 ns618 0 -0.000592612896075
Gc20_619 0 n40 ns619 0 0.000157461098074
Gc20_620 0 n40 ns620 0 3.64374153862e-05
Gc20_621 0 n40 ns621 0 -9.84635144487e-05
Gc20_622 0 n40 ns622 0 -0.000270434932824
Gc20_623 0 n40 ns623 0 -0.00122237302291
Gc20_624 0 n40 ns624 0 0.000786637330496
Gc20_625 0 n40 ns625 0 0.00024834762287
Gc20_626 0 n40 ns626 0 0.000136858263343
Gc20_627 0 n40 ns627 0 -0.000371097945533
Gc20_628 0 n40 ns628 0 -0.000171066184353
Gc20_629 0 n40 ns629 0 0.000143278209057
Gc20_630 0 n40 ns630 0 -0.0018041987306
Gc20_631 0 n40 ns631 0 -0.00177357622906
Gc20_632 0 n40 ns632 0 0.0022234064613
Gc20_633 0 n40 ns633 0 -0.00137631410941
Gc20_634 0 n40 ns634 0 0.00267511996982
Gc20_635 0 n40 ns635 0 -0.00262057239016
Gc20_636 0 n40 ns636 0 -0.00124578086611
Gc20_637 0 n40 ns637 0 0.000515789724351
Gc20_638 0 n40 ns638 0 -0.000939020689827
Gc20_639 0 n40 ns639 0 0.00134969927739
Gc20_640 0 n40 ns640 0 -0.000756071334055
Gc20_641 0 n40 ns641 0 -0.000648293117976
Gc20_642 0 n40 ns642 0 0.00228012409498
Gc20_643 0 n40 ns643 0 0.00110384797837
Gc20_644 0 n40 ns644 0 3.20072355534e-05
Gc20_645 0 n40 ns645 0 -0.000330223604529
Gc20_646 0 n40 ns646 0 0.000131528705706
Gc20_647 0 n40 ns647 0 0.000437205932124
Gc20_648 0 n40 ns648 0 -0.00143558723985
Gc20_649 0 n40 ns649 0 0.00109431857088
Gc20_650 0 n40 ns650 0 -0.000869663148337
Gc20_651 0 n40 ns651 0 -8.48564312577e-05
Gc20_652 0 n40 ns652 0 0.000102966794391
Gc20_653 0 n40 ns653 0 -4.18446806157e-05
Gc20_654 0 n40 ns654 0 3.4447023444e-06
Gc20_655 0 n40 ns655 0 0.000258046836531
Gc20_656 0 n40 ns656 0 -0.000634610640723
Gc20_657 0 n40 ns657 0 0.000177505731008
Gc20_658 0 n40 ns658 0 5.02912416672e-05
Gc20_659 0 n40 ns659 0 -1.68138241732e-05
Gc20_660 0 n40 ns660 0 0.000143451696277
Gc20_661 0 n40 ns661 0 -0.00112303275514
Gc20_662 0 n40 ns662 0 0.000504395125901
Gc20_663 0 n40 ns663 0 0.000405721389932
Gc20_664 0 n40 ns664 0 2.30820571328e-05
Gc20_665 0 n40 ns665 0 -0.000255942984613
Gc20_666 0 n40 ns666 0 -0.000343289522444
Gc20_667 0 n40 ns667 0 0.000707119628688
Gc20_668 0 n40 ns668 0 -0.00147653467633
Gc20_669 0 n40 ns669 0 -0.00106690768647
Gc20_670 0 n40 ns670 0 0.00276106245903
Gc20_671 0 n40 ns671 0 -0.000839712450119
Gc20_672 0 n40 ns672 0 0.00326029038811
Gc20_673 0 n40 ns673 0 -0.00216623287615
Gc20_674 0 n40 ns674 0 -0.00200015780751
Gc20_675 0 n40 ns675 0 0.000690854721966
Gc20_676 0 n40 ns676 0 -0.00102601062508
Gc20_677 0 n40 ns677 0 0.00126896211611
Gc20_678 0 n40 ns678 0 -0.000485404460083
Gc20_679 0 n40 ns679 0 -0.00120609507785
Gc20_680 0 n40 ns680 0 0.00298188858018
Gc20_681 0 n40 ns681 0 0.00159957560879
Gc20_682 0 n40 ns682 0 1.96019423005e-05
Gc20_683 0 n40 ns683 0 -0.000291658978511
Gc20_684 0 n40 ns684 0 0.000112492460928
Gc20_685 0 n40 ns685 0 0.000218195523222
Gc20_686 0 n40 ns686 0 -0.00232866465805
Gc20_687 0 n40 ns687 0 2.38840415431e-05
Gc20_688 0 n40 ns688 0 -0.000777729745579
Gc20_689 0 n40 ns689 0 -0.000834716524255
Gc20_690 0 n40 ns690 0 0.000220192096774
Gc20_691 0 n40 ns691 0 0.000277973568715
Gc20_692 0 n40 ns692 0 -0.000498605608611
Gc20_693 0 n40 ns693 0 2.69146349199e-05
Gc20_694 0 n40 ns694 0 0.000246848708312
Gc20_695 0 n40 ns695 0 0.000290119041001
Gc20_696 0 n40 ns696 0 9.40032011873e-06
Gc20_697 0 n40 ns697 0 -0.000148419823545
Gc20_698 0 n40 ns698 0 0.000269046880106
Gc20_699 0 n40 ns699 0 0.00103328951294
Gc20_700 0 n40 ns700 0 -0.000428326341914
Gc20_701 0 n40 ns701 0 0.00117261185389
Gc20_702 0 n40 ns702 0 -0.000237346457525
Gc20_703 0 n40 ns703 0 0.000768007304691
Gc20_704 0 n40 ns704 0 -0.000575976178434
Gc20_705 0 n40 ns705 0 0.000381393652693
Gc20_706 0 n40 ns706 0 0.00215084531979
Gc20_707 0 n40 ns707 0 0.00160139558641
Gc20_708 0 n40 ns708 0 0.00559054625794
Gc20_709 0 n40 ns709 0 0.00113949424296
Gc20_710 0 n40 ns710 0 0.00567756582995
Gc20_711 0 n40 ns711 0 0.0032077162867
Gc20_712 0 n40 ns712 0 0.000405830254849
Gc20_713 0 n40 ns713 0 0.000983831862958
Gc20_714 0 n40 ns714 0 -0.000999855542146
Gc20_715 0 n40 ns715 0 -0.00149980957826
Gc20_716 0 n40 ns716 0 -0.00134288138896
Gc20_717 0 n40 ns717 0 -0.00377792110359
Gc20_718 0 n40 ns718 0 -0.000146546905227
Gc20_719 0 n40 ns719 0 0.00310702082161
Gc20_720 0 n40 ns720 0 3.19513151273e-05
Gc20_721 0 n40 ns721 0 -0.000156122595426
Gc20_722 0 n40 ns722 0 1.04322958627e-05
Gc20_723 0 n40 ns723 0 0.000246824637389
Gc20_724 0 n40 ns724 0 -0.0020945106902
Gc20_725 0 n40 ns725 0 -0.00191344096339
Gc20_726 0 n40 ns726 0 0.0006723332814
Gc20_727 0 n40 ns727 0 -0.000688484516384
Gc20_728 0 n40 ns728 0 0.000300725018294
Gc20_729 0 n40 ns729 0 0.000396667052455
Gc20_730 0 n40 ns730 0 -0.000274039125753
Gc20_731 0 n40 ns731 0 2.25671845795e-05
Gc20_732 0 n40 ns732 0 0.000505542258983
Gc20_733 0 n40 ns733 0 0.000296729477356
Gc20_734 0 n40 ns734 0 -1.54344294301e-05
Gc20_735 0 n40 ns735 0 -0.000534785808665
Gc20_736 0 n40 ns736 0 -0.000621071891336
Gc20_737 0 n40 ns737 0 0.000520445278974
Gc20_738 0 n40 ns738 0 4.33587302069e-05
Gc20_739 0 n40 ns739 0 0.000489544803281
Gc20_740 0 n40 ns740 0 -0.00030296703536
Gc20_741 0 n40 ns741 0 -0.000256194688636
Gc20_742 0 n40 ns742 0 -0.00117826936834
Gc20_743 0 n40 ns743 0 -0.000699352944566
Gc20_744 0 n40 ns744 0 0.000471518534883
Gc20_745 0 n40 ns745 0 0.0071962847093
Gc20_746 0 n40 ns746 0 0.00590031632167
Gc20_747 0 n40 ns747 0 0.00545755783987
Gc20_748 0 n40 ns748 0 0.00584280793952
Gc20_749 0 n40 ns749 0 0.00100515712627
Gc20_750 0 n40 ns750 0 0.00547307978407
Gc20_751 0 n40 ns751 0 0.000912092826181
Gc20_752 0 n40 ns752 0 -0.000826364431068
Gc20_753 0 n40 ns753 0 -0.00605537358666
Gc20_754 0 n40 ns754 0 -0.00157865465574
Gc20_755 0 n40 ns755 0 0.00271420740928
Gc20_756 0 n40 ns756 0 -0.00434445628778
Gc20_757 0 n40 ns757 0 0.00478426403879
Gc20_758 0 n40 ns758 0 -2.14767184655e-05
Gc20_759 0 n40 ns759 0 6.72327711331e-05
Gc20_760 0 n40 ns760 0 -8.88453860649e-05
Gc20_761 0 n40 ns761 0 0.000201878713012
Gc20_762 0 n40 ns762 0 -0.00194413960062
Gc20_763 0 n40 ns763 0 0.000203423817308
Gc20_764 0 n40 ns764 0 -0.000525100293027
Gc20_765 0 n40 ns765 0 -0.00097261128261
Gc20_766 0 n40 ns766 0 0.000304902704086
Gc20_767 0 n40 ns767 0 0.000407069460285
Gc20_768 0 n40 ns768 0 -0.000463047849188
Gc20_769 0 n40 ns769 0 0.000318789307034
Gc20_770 0 n40 ns770 0 0.000464393026869
Gc20_771 0 n40 ns771 0 0.000250737107876
Gc20_772 0 n40 ns772 0 -4.08700343348e-05
Gc20_773 0 n40 ns773 0 -0.000357396763741
Gc20_774 0 n40 ns774 0 -3.88252625349e-05
Gc20_775 0 n40 ns775 0 0.000663295709747
Gc20_776 0 n40 ns776 0 -0.000899506134131
Gc20_777 0 n40 ns777 0 0.000810314498047
Gc20_778 0 n40 ns778 0 -0.000395286777335
Gc20_779 0 n40 ns779 0 0.000395213895328
Gc20_780 0 n40 ns780 0 -0.000837227720315
Gc20_781 0 n40 ns781 0 0.000857048026215
Gc20_782 0 n40 ns782 0 0.002084102925
Gc20_783 0 n40 ns783 0 0.00272897585782
Gc20_784 0 n40 ns784 0 0.00420179401369
Gc20_785 0 n40 ns785 0 0.00206983859773
Gc20_786 0 n40 ns786 0 0.0044227341208
Gc20_787 0 n40 ns787 0 0.00346626289461
Gc20_788 0 n40 ns788 0 0.000393836436153
Gc20_789 0 n40 ns789 0 0.000902890738088
Gc20_790 0 n40 ns790 0 -0.000962763930126
Gc20_791 0 n40 ns791 0 -0.00179574388701
Gc20_792 0 n40 ns792 0 -0.00121889373372
Gc20_793 0 n40 ns793 0 -0.00384343398226
Gc20_794 0 n40 ns794 0 -9.03179134307e-05
Gc20_795 0 n40 ns795 0 0.00312110708725
Gc20_796 0 n40 ns796 0 4.18578015085e-05
Gc20_797 0 n40 ns797 0 -0.000132082793837
Gc20_798 0 n40 ns798 0 1.49253733488e-05
Gc20_799 0 n40 ns799 0 0.000119866358282
Gc20_800 0 n40 ns800 0 -0.000534181363421
Gc20_801 0 n40 ns801 0 0.000602597368347
Gc20_802 0 n40 ns802 0 4.11439314255e-05
Gc20_803 0 n40 ns803 0 -0.000286812617617
Gc20_804 0 n40 ns804 0 0.000465864159941
Gc20_805 0 n40 ns805 0 -4.36456948824e-06
Gc20_806 0 n40 ns806 0 -0.000184070284934
Gc20_807 0 n40 ns807 0 0.000352044064764
Gc20_808 0 n40 ns808 0 -0.000168645218502
Gc20_809 0 n40 ns809 0 0.00018049665833
Gc20_810 0 n40 ns810 0 -7.33460268234e-05
Gc20_811 0 n40 ns811 0 -1.44091191187e-05
Gc20_812 0 n40 ns812 0 -0.000309682140712
Gc20_813 0 n40 ns813 0 -0.000762693941865
Gc20_814 0 n40 ns814 0 -0.000343538361564
Gc20_815 0 n40 ns815 0 0.000295221309124
Gc20_816 0 n40 ns816 0 -0.000549766863965
Gc20_817 0 n40 ns817 0 -0.000187649183312
Gc20_818 0 n40 ns818 0 -0.00096655633312
Gc20_819 0 n40 ns819 0 0.00121451139587
Gc20_820 0 n40 ns820 0 -0.000689713783773
Gc20_821 0 n40 ns821 0 0.00190466448319
Gc20_822 0 n40 ns822 0 0.00295376713875
Gc20_823 0 n40 ns823 0 0.00176612458116
Gc20_824 0 n40 ns824 0 0.00324034540749
Gc20_825 0 n40 ns825 0 -0.00124905029414
Gc20_826 0 n40 ns826 0 -0.00138732704368
Gc20_827 0 n40 ns827 0 0.000407963599754
Gc20_828 0 n40 ns828 0 -0.00105370032435
Gc20_829 0 n40 ns829 0 0.0002096020973
Gc20_830 0 n40 ns830 0 -0.000800857789565
Gc20_831 0 n40 ns831 0 -0.00144817912718
Gc20_832 0 n40 ns832 0 0.00245909826695
Gc20_833 0 n40 ns833 0 0.00147630420862
Gc20_834 0 n40 ns834 0 3.24029578606e-05
Gc20_835 0 n40 ns835 0 -0.000216366534489
Gc20_836 0 n40 ns836 0 6.32933370991e-05
Gc20_837 0 n40 ns837 0 -0.000142908673684
Gc20_838 0 n40 ns838 0 0.00011609586573
Gc20_839 0 n40 ns839 0 -2.59068309973e-05
Gc20_840 0 n40 ns840 0 0.000997674112013
Gc20_841 0 n40 ns841 0 1.61475972105e-05
Gc20_842 0 n40 ns842 0 0.00016951980878
Gc20_843 0 n40 ns843 0 0.000158131235505
Gc20_844 0 n40 ns844 0 -7.98944289223e-05
Gc20_845 0 n40 ns845 0 -0.000134386766775
Gc20_846 0 n40 ns846 0 -6.59837626661e-05
Gc20_847 0 n40 ns847 0 0.000142203141773
Gc20_848 0 n40 ns848 0 -0.000142377717024
Gc20_849 0 n40 ns849 0 -0.000279979433527
Gc20_850 0 n40 ns850 0 -0.000361591517409
Gc20_851 0 n40 ns851 0 0.000185389444768
Gc20_852 0 n40 ns852 0 0.000496603616948
Gc20_853 0 n40 ns853 0 0.000302572407691
Gc20_854 0 n40 ns854 0 -0.000426953402767
Gc20_855 0 n40 ns855 0 -7.54255960874e-05
Gc20_856 0 n40 ns856 0 -0.000376045310178
Gc20_857 0 n40 ns857 0 -0.000495769299142
Gc20_858 0 n40 ns858 0 -0.000250246125465
Gc20_859 0 n40 ns859 0 0.00206408467107
Gc20_860 0 n40 ns860 0 0.00337674163935
Gc20_861 0 n40 ns861 0 0.00217362842956
Gc20_862 0 n40 ns862 0 0.00317524065768
Gc20_863 0 n40 ns863 0 -0.00112806948956
Gc20_864 0 n40 ns864 0 0.000979129416388
Gc20_865 0 n40 ns865 0 -0.000155639641025
Gc20_866 0 n40 ns866 0 -0.000837585688477
Gc20_867 0 n40 ns867 0 -0.000508265419955
Gc20_868 0 n40 ns868 0 -0.00166674370358
Gc20_869 0 n40 ns869 0 -0.000636371711681
Gc20_870 0 n40 ns870 0 0.000550263687528
Gc20_871 0 n40 ns871 0 0.000449916976087
Gc20_872 0 n40 ns872 0 2.41951988673e-05
Gc20_873 0 n40 ns873 0 -0.000135623555499
Gc20_874 0 n40 ns874 0 1.63163406692e-05
Gc20_875 0 n40 ns875 0 -0.000444514052947
Gc20_876 0 n40 ns876 0 0.000576476724648
Gc20_877 0 n40 ns877 0 -0.001083497769
Gc20_878 0 n40 ns878 0 0.00124517868481
Gc20_879 0 n40 ns879 0 -0.000300813514639
Gc20_880 0 n40 ns880 0 0.000271194133894
Gc20_881 0 n40 ns881 0 0.000130214692786
Gc20_882 0 n40 ns882 0 -0.00018715205346
Gc20_883 0 n40 ns883 0 -0.000171954701094
Gc20_884 0 n40 ns884 0 0.000482903487777
Gc20_885 0 n40 ns885 0 7.38936166692e-05
Gc20_886 0 n40 ns886 0 -0.000151817990037
Gc20_887 0 n40 ns887 0 0.000124162404764
Gc20_888 0 n40 ns888 0 -0.000439370504356
Gc20_889 0 n40 ns889 0 0.000823026355669
Gc20_890 0 n40 ns890 0 -0.000437695161056
Gc20_891 0 n40 ns891 0 0.000176689906506
Gc20_892 0 n40 ns892 0 -0.000648855568821
Gc20_893 0 n40 ns893 0 0.000249803779737
Gc20_894 0 n40 ns894 0 -0.000520247127914
Gc20_895 0 n40 ns895 0 -0.000161946927963
Gc20_896 0 n40 ns896 0 0.000851196425452
Gc20_897 0 n40 ns897 0 0.00333590008011
Gc20_898 0 n40 ns898 0 0.00236838716322
Gc20_899 0 n40 ns899 0 0.00313610033162
Gc20_900 0 n40 ns900 0 0.0019559691082
Gc20_901 0 n40 ns901 0 0.000231510749845
Gc20_902 0 n40 ns902 0 0.00116605621444
Gc20_903 0 n40 ns903 0 -0.000322112752202
Gc20_904 0 n40 ns904 0 -0.000433971445841
Gc20_905 0 n40 ns905 0 -0.00114603092199
Gc20_906 0 n40 ns906 0 -0.00115159158001
Gc20_907 0 n40 ns907 0 -0.000500308012609
Gc20_908 0 n40 ns908 0 -0.000163057372803
Gc20_909 0 n40 ns909 0 0.000124586830277
Gc20_910 0 n40 ns910 0 -1.51050816641e-05
Gc20_911 0 n40 ns911 0 1.87191411897e-05
Gc20_912 0 n40 ns912 0 -5.09940528994e-05
Gc20_913 0 n40 ns913 0 0.000579030653772
Gc20_914 0 n40 ns914 0 -9.06621395117e-06
Gc20_915 0 n40 ns915 0 0.00182066757602
Gc20_916 0 n40 ns916 0 0.000442990424282
Gc20_917 0 n40 ns917 0 0.000277346874164
Gc20_918 0 n40 ns918 0 2.21269671717e-05
Gc20_919 0 n40 ns919 0 -0.000198034113374
Gc20_920 0 n40 ns920 0 4.95543811101e-05
Gc20_921 0 n40 ns921 0 0.00018481025442
Gc20_922 0 n40 ns922 0 0.000260567386882
Gc20_923 0 n40 ns923 0 -4.41198409595e-05
Gc20_924 0 n40 ns924 0 -0.000107034063758
Gc20_925 0 n40 ns925 0 -0.000279534098154
Gc20_926 0 n40 ns926 0 -0.000326193605608
Gc20_927 0 n40 ns927 0 9.30228948977e-06
Gc20_928 0 n40 ns928 0 -0.00095086638479
Gc20_929 0 n40 ns929 0 -0.00027609586695
Gc20_930 0 n40 ns930 0 -0.000671584729779
Gc20_931 0 n40 ns931 0 -0.000197575344459
Gc20_932 0 n40 ns932 0 -0.000881366399047
Gc20_933 0 n40 ns933 0 0.000833987916136
Gc20_934 0 n40 ns934 0 0.000657892720166
Gc20_935 0 n40 ns935 0 0.0037791391627
Gc20_936 0 n40 ns936 0 0.000567501623013
Gc20_937 0 n40 ns937 0 0.00329396377299
Gc20_938 0 n40 ns938 0 0.000348409651605
Gc20_939 0 n40 ns939 0 0.000824751396378
Gc20_940 0 n40 ns940 0 0.0005207209075
Gc20_941 0 n40 ns941 0 -0.000252773153172
Gc20_942 0 n40 ns942 0 -0.000190487628725
Gc20_943 0 n40 ns943 0 -0.00115637733325
Gc20_944 0 n40 ns944 0 -0.000613123798122
Gc20_945 0 n40 ns945 0 -0.000490326252692
Gc20_946 0 n40 ns946 0 -0.000549479895456
Gc20_947 0 n40 ns947 0 -9.20091724954e-06
Gc20_948 0 n40 ns948 0 2.70089337664e-05
Gc20_949 0 n40 ns949 0 -0.000130176403769
Gc20_950 0 n40 ns950 0 5.52309975288e-05
Gc20_951 0 n40 ns951 0 0.00037359869432
Gc20_952 0 n40 ns952 0 -0.00238293951802
Gc20_953 0 n40 ns953 0 0.000536239357272
Gc20_954 0 n40 ns954 0 -0.00223417476301
Gc20_955 0 n40 ns955 0 -0.000779178771089
Gc20_956 0 n40 ns956 0 -0.000230813602849
Gc20_957 0 n40 ns957 0 0.000168022394779
Gc20_958 0 n40 ns958 0 -0.000241667246449
Gc20_959 0 n40 ns959 0 -1.6909950451e-05
Gc20_960 0 n40 ns960 0 -0.000216804947967
Gc20_961 0 n40 ns961 0 0.000225107870168
Gc20_962 0 n40 ns962 0 7.34102102523e-05
Gc20_963 0 n40 ns963 0 0.000273154224231
Gc20_964 0 n40 ns964 0 0.000893142372506
Gc20_965 0 n40 ns965 0 0.000357849414684
Gc20_966 0 n40 ns966 0 -5.41374159215e-05
Gc20_967 0 n40 ns967 0 0.00102464406922
Gc20_968 0 n40 ns968 0 -2.52797638536e-05
Gc20_969 0 n40 ns969 0 0.000596749060714
Gc20_970 0 n40 ns970 0 -0.000155187785353
Gc20_971 0 n40 ns971 0 0.000875240802186
Gc20_972 0 n40 ns972 0 0.000818360690075
Gc20_973 0 n40 ns973 0 2.59900499704e-05
Gc20_974 0 n40 ns974 0 0.00443620039229
Gc20_975 0 n40 ns975 0 -7.70336825496e-05
Gc20_976 0 n40 ns976 0 0.0046977092078
Gc20_977 0 n40 ns977 0 0.000798621841583
Gc20_978 0 n40 ns978 0 -0.00213280817323
Gc20_979 0 n40 ns979 0 0.00101539709261
Gc20_980 0 n40 ns980 0 -0.000947857805561
Gc20_981 0 n40 ns981 0 0.000301818060696
Gc20_982 0 n40 ns982 0 -0.000257484026069
Gc20_983 0 n40 ns983 0 -0.00302743931906
Gc20_984 0 n40 ns984 0 0.00284866601214
Gc20_985 0 n40 ns985 0 0.00272804624093
Gc20_986 0 n40 ns986 0 3.00131099916e-06
Gc20_987 0 n40 ns987 0 -0.000110591161887
Gc20_988 0 n40 ns988 0 -9.73714987129e-06
Gc20_989 0 n40 ns989 0 0.000988752285573
Gc20_990 0 n40 ns990 0 -0.00408983805821
Gc20_991 0 n40 ns991 0 -0.000437252420772
Gc20_992 0 n40 ns992 0 -0.00148284631664
Gc20_993 0 n40 ns993 0 -0.000929260072113
Gc20_994 0 n40 ns994 0 -0.000145980622101
Gc20_995 0 n40 ns995 0 0.000456838561044
Gc20_996 0 n40 ns996 0 -0.000125088108636
Gc20_997 0 n40 ns997 0 -4.51247256898e-05
Gc20_998 0 n40 ns998 0 0.00042027389789
Gc20_999 0 n40 ns999 0 0.000289202554232
Gc20_1000 0 n40 ns1000 0 -1.00522936526e-05
Gc20_1001 0 n40 ns1001 0 -0.000361334379687
Gc20_1002 0 n40 ns1002 0 -0.000318592447307
Gc20_1003 0 n40 ns1003 0 0.000337729150312
Gc20_1004 0 n40 ns1004 0 -6.2878904501e-05
Gc20_1005 0 n40 ns1005 0 0.000546125747448
Gc20_1006 0 n40 ns1006 0 -0.000416697439785
Gc20_1007 0 n40 ns1007 0 -0.000115590218586
Gc20_1008 0 n40 ns1008 0 -0.00132800366337
Gc20_1009 0 n40 ns1009 0 -0.000276468869648
Gc20_1010 0 n40 ns1010 0 0.000355675717078
Gc20_1011 0 n40 ns1011 0 0.00686441165712
Gc20_1012 0 n40 ns1012 0 0.00735520016147
Gc20_1013 0 n40 ns1013 0 0.00519011271265
Gc20_1014 0 n40 ns1014 0 0.00703955767081
Gc20_1015 0 n40 ns1015 0 0.000672390588556
Gc20_1016 0 n40 ns1016 0 0.00528660895062
Gc20_1017 0 n40 ns1017 0 0.000858286994945
Gc20_1018 0 n40 ns1018 0 -0.000917446876604
Gc20_1019 0 n40 ns1019 0 -0.00633517176244
Gc20_1020 0 n40 ns1020 0 -0.00197870652743
Gc20_1021 0 n40 ns1021 0 0.00324862265892
Gc20_1022 0 n40 ns1022 0 -0.00524263048609
Gc20_1023 0 n40 ns1023 0 0.00456084387837
Gc20_1024 0 n40 ns1024 0 -4.50412168643e-07
Gc20_1025 0 n40 ns1025 0 -2.04300689406e-06
Gc20_1026 0 n40 ns1026 0 -5.85199266746e-05
Gc20_1027 0 n40 ns1027 0 0.0012229503361
Gc20_1028 0 n40 ns1028 0 -0.00453622199202
Gc20_1029 0 n40 ns1029 0 0.0015039782904
Gc20_1030 0 n40 ns1030 0 -0.00304345675429
Gc20_1031 0 n40 ns1031 0 -0.00120353964637
Gc20_1032 0 n40 ns1032 0 -0.000620889981607
Gc20_1033 0 n40 ns1033 0 0.000625732523175
Gc20_1034 0 n40 ns1034 0 -6.30724186858e-05
Gc20_1035 0 n40 ns1035 0 0.000155966219552
Gc20_1036 0 n40 ns1036 0 0.00058535637477
Gc20_1037 0 n40 ns1037 0 0.000253042236189
Gc20_1038 0 n40 ns1038 0 -4.44098995526e-05
Gc20_1039 0 n40 ns1039 0 -0.000565916146332
Gc20_1040 0 n40 ns1040 0 0.000167236403807
Gc20_1041 0 n40 ns1041 0 0.000491259078492
Gc20_1042 0 n40 ns1042 0 -0.000847152905326
Gc20_1043 0 n40 ns1043 0 0.000603281436659
Gc20_1044 0 n40 ns1044 0 -0.000500202993807
Gc20_1045 0 n40 ns1045 0 5.3711278763e-05
Gc20_1046 0 n40 ns1046 0 -0.00121770139092
Gc20_1047 0 n40 ns1047 0 0.00104081031093
Gc20_1048 0 n40 ns1048 0 0.00163162685329
Gc20_1049 0 n40 ns1049 0 0.00589899115884
Gc20_1050 0 n40 ns1050 0 0.0055918572916
Gc20_1051 0 n40 ns1051 0 0.004501139515
Gc20_1052 0 n40 ns1052 0 0.00556826672217
Gc20_1053 0 n40 ns1053 0 0.0026973183644
Gc20_1054 0 n40 ns1054 0 0.00185735676554
Gc20_1055 0 n40 ns1055 0 0.000931270727904
Gc20_1056 0 n40 ns1056 0 -0.000913446879412
Gc20_1057 0 n40 ns1057 0 -0.00410185805851
Gc20_1058 0 n40 ns1058 0 -0.00113591697363
Gc20_1059 0 n40 ns1059 0 -0.000640109180661
Gc20_1060 0 n40 ns1060 0 -0.00219985315694
Gc20_1061 0 n40 ns1061 0 0.00380416172458
Gc20_1062 0 n40 ns1062 0 2.06270912161e-05
Gc20_1063 0 n40 ns1063 0 -0.000112403433441
Gc20_1064 0 n40 ns1064 0 1.69565807893e-05
Gc20_1065 0 n40 ns1065 0 0.000366034184281
Gc20_1066 0 n40 ns1066 0 -0.00148590793941
Gc20_1067 0 n40 ns1067 0 0.00109766365172
Gc20_1068 0 n40 ns1068 0 -0.00114014513759
Gc20_1069 0 n40 ns1069 0 -0.000605567318441
Gc20_1070 0 n40 ns1070 0 0.00018391287401
Gc20_1071 0 n40 ns1071 0 8.57381122192e-05
Gc20_1072 0 n40 ns1072 0 -0.000173936588571
Gc20_1073 0 n40 ns1073 0 0.000428890244111
Gc20_1074 0 n40 ns1074 0 3.92402246212e-05
Gc20_1075 0 n40 ns1075 0 0.000194572956249
Gc20_1076 0 n40 ns1076 0 -5.19256135225e-05
Gc20_1077 0 n40 ns1077 0 -5.0926189674e-05
Gc20_1078 0 n40 ns1078 0 -2.14368864746e-05
Gc20_1079 0 n40 ns1079 0 -0.000646363769399
Gc20_1080 0 n40 ns1080 0 -0.00080989699888
Gc20_1081 0 n40 ns1081 0 0.000369911436454
Gc20_1082 0 n40 ns1082 0 -0.000567653742527
Gc20_1083 0 n40 ns1083 0 -0.000141889484912
Gc20_1084 0 n40 ns1084 0 -0.0010854181372
Gc20_1085 0 n40 ns1085 0 0.00178398456283
Gc20_1086 0 n40 ns1086 0 -0.000111745347776
Gc20_1087 0 n40 ns1087 0 0.00255222732971
Gc20_1088 0 n40 ns1088 0 0.00276113385876
Gc20_1089 0 n40 ns1089 0 0.00216508159795
Gc20_1090 0 n40 ns1090 0 0.00319462119524
Gc20_1091 0 n40 ns1091 0 -0.000224794056829
Gc20_1092 0 n40 ns1092 0 -0.00188587285743
Gc20_1093 0 n40 ns1093 0 0.000658577985154
Gc20_1094 0 n40 ns1094 0 -0.0010429587245
Gc20_1095 0 n40 ns1095 0 7.21314711443e-05
Gc20_1096 0 n40 ns1096 0 -0.000492841235674
Gc20_1097 0 n40 ns1097 0 -0.00215476773823
Gc20_1098 0 n40 ns1098 0 0.00246026876192
Gc20_1099 0 n40 ns1099 0 0.00201728059529
Gc20_1100 0 n40 ns1100 0 9.0303603052e-06
Gc20_1101 0 n40 ns1101 0 -0.000163514376831
Gc20_1102 0 n40 ns1102 0 3.03252940801e-05
Gc20_1103 0 n40 ns1103 0 -9.69098644416e-05
Gc20_1104 0 n40 ns1104 0 9.89111540491e-05
Gc20_1105 0 n40 ns1105 0 0.000152516096763
Gc20_1106 0 n40 ns1106 0 0.000877623737359
Gc20_1107 0 n40 ns1107 0 7.77010885434e-05
Gc20_1108 0 n40 ns1108 0 0.000261000738034
Gc20_1109 0 n40 ns1109 0 6.4758721635e-05
Gc20_1110 0 n40 ns1110 0 -2.39158743033e-05
Gc20_1111 0 n40 ns1111 0 1.56160541176e-05
Gc20_1112 0 n40 ns1112 0 -0.000211554801096
Gc20_1113 0 n40 ns1113 0 0.000178503816543
Gc20_1114 0 n40 ns1114 0 -0.000117382132336
Gc20_1115 0 n40 ns1115 0 -0.000261442832628
Gc20_1116 0 n40 ns1116 0 -0.000425132476169
Gc20_1117 0 n40 ns1117 0 -0.000311024958161
Gc20_1118 0 n40 ns1118 0 0.000490884487005
Gc20_1119 0 n40 ns1119 0 0.00028482737265
Gc20_1120 0 n40 ns1120 0 -0.000408204498547
Gc20_1121 0 n40 ns1121 0 -0.000245120364212
Gc20_1122 0 n40 ns1122 0 -0.000509303149399
Gc20_1123 0 n40 ns1123 0 -0.000128252757575
Gc20_1124 0 n40 ns1124 0 -0.000739550604303
Gc20_1125 0 n40 ns1125 0 0.00179624937983
Gc20_1126 0 n40 ns1126 0 0.00324302656805
Gc20_1127 0 n40 ns1127 0 0.00191443298288
Gc20_1128 0 n40 ns1128 0 0.00324999781003
Gc20_1129 0 n40 ns1129 0 -0.00158623911554
Gc20_1130 0 n40 ns1130 0 0.00029722930826
Gc20_1131 0 n40 ns1131 0 5.87462693327e-06
Gc20_1132 0 n40 ns1132 0 -0.000953117890308
Gc20_1133 0 n40 ns1133 0 -0.000124172037874
Gc20_1134 0 n40 ns1134 0 -0.0014520842661
Gc20_1135 0 n40 ns1135 0 -0.000750933418417
Gc20_1136 0 n40 ns1136 0 0.00126187903932
Gc20_1137 0 n40 ns1137 0 0.000744863797997
Gc20_1138 0 n40 ns1138 0 3.52604361171e-05
Gc20_1139 0 n40 ns1139 0 -0.000193687289246
Gc20_1140 0 n40 ns1140 0 3.86963414034e-05
Gc20_1141 0 n40 ns1141 0 -0.000380700883851
Gc20_1142 0 n40 ns1142 0 0.000292675113631
Gc20_1143 0 n40 ns1143 0 -0.000888600357776
Gc20_1144 0 n40 ns1144 0 0.000868370610696
Gc20_1145 0 n40 ns1145 0 -0.000234068431483
Gc20_1146 0 n40 ns1146 0 0.000130587300111
Gc20_1147 0 n40 ns1147 0 0.00016901657827
Gc20_1148 0 n40 ns1148 0 -0.000151504809231
Gc20_1149 0 n40 ns1149 0 -0.000304351455507
Gc20_1150 0 n40 ns1150 0 0.000257978816662
Gc20_1151 0 n40 ns1151 0 0.000105852767894
Gc20_1152 0 n40 ns1152 0 -0.000143681490985
Gc20_1153 0 n40 ns1153 0 6.03575717223e-05
Gc20_1154 0 n40 ns1154 0 -0.000263915461619
Gc20_1155 0 n40 ns1155 0 0.000835974593037
Gc20_1156 0 n40 ns1156 0 4.87716710527e-05
Gc20_1157 0 n40 ns1157 0 0.000306611290126
Gc20_1158 0 n40 ns1158 0 -0.00054457669903
Gc20_1159 0 n40 ns1159 0 0.000226159006434
Gc20_1160 0 n40 ns1160 0 -0.000337185258018
Gc20_1161 0 n40 ns1161 0 -0.000505124098104
Gc20_1162 0 n40 ns1162 0 0.000584742559607
Gc20_1163 0 n40 ns1163 0 0.00291777502367
Gc20_1164 0 n40 ns1164 0 0.00298601600696
Gc20_1165 0 n40 ns1165 0 0.00286440301717
Gc20_1166 0 n40 ns1166 0 0.00258287612748
Gc20_1167 0 n40 ns1167 0 -0.000174793961246
Gc20_1168 0 n40 ns1168 0 0.00126266234782
Gc20_1169 0 n40 ns1169 0 -0.000310045208526
Gc20_1170 0 n40 ns1170 0 -0.000561269602892
Gc20_1171 0 n40 ns1171 0 -0.00101942412831
Gc20_1172 0 n40 ns1172 0 -0.00134611667586
Gc20_1173 0 n40 ns1173 0 -0.000528180774399
Gc20_1174 0 n40 ns1174 0 6.96241436254e-05
Gc20_1175 0 n40 ns1175 0 0.000223214284014
Gc20_1176 0 n40 ns1176 0 1.2012514833e-06
Gc20_1177 0 n40 ns1177 0 -1.73213685536e-05
Gc20_1178 0 n40 ns1178 0 -4.48334617119e-05
Gc20_1179 0 n40 ns1179 0 0.000113871891217
Gc20_1180 0 n40 ns1180 0 0.000318629719525
Gc20_1181 0 n40 ns1181 0 0.000570179671059
Gc20_1182 0 n40 ns1182 0 0.000676912297388
Gc20_1183 0 n40 ns1183 0 -3.1438657938e-05
Gc20_1184 0 n40 ns1184 0 2.57874510178e-05
Gc20_1185 0 n40 ns1185 0 -3.30386783575e-05
Gc20_1186 0 n40 ns1186 0 5.04057204034e-05
Gc20_1187 0 n40 ns1187 0 4.94463970214e-05
Gc20_1188 0 n40 ns1188 0 0.000491145249511
Gc20_1189 0 n40 ns1189 0 1.21649751372e-06
Gc20_1190 0 n40 ns1190 0 -0.000143079241965
Gc20_1191 0 n40 ns1191 0 -6.93710995306e-05
Gc20_1192 0 n40 ns1192 0 -0.000462916719003
Gc20_1193 0 n40 ns1193 0 0.000340047704464
Gc20_1194 0 n40 ns1194 0 -0.000942342730426
Gc20_1195 0 n40 ns1195 0 -0.000151962676961
Gc20_1196 0 n40 ns1196 0 -0.000747549108848
Gc20_1197 0 n40 ns1197 0 -3.87472335553e-05
Gc20_1198 0 n40 ns1198 0 -0.000852390987462
Gc20_1199 0 n40 ns1199 0 0.000609092675288
Gc20_1200 0 n40 ns1200 0 0.000813921214906
Gc20_1201 0 n40 ns1201 0 0.00411499541594
Gc20_1202 0 n40 ns1202 0 0.00103522474949
Gc20_1203 0 n40 ns1203 0 0.00365382315072
Gc20_1204 0 n40 ns1204 0 0.000744550355756
Gc20_1205 0 n40 ns1205 0 0.000680187186408
Gc20_1206 0 n40 ns1206 0 0.000723813272199
Gc20_1207 0 n40 ns1207 0 -0.000289662307107
Gc20_1208 0 n40 ns1208 0 -0.000262866443304
Gc20_1209 0 n40 ns1209 0 -0.00119926131938
Gc20_1210 0 n40 ns1210 0 -0.000765145922121
Gc20_1211 0 n40 ns1211 0 -0.000505655196451
Gc20_1212 0 n40 ns1212 0 -0.000440223905166
Gc20_1213 0 n40 ns1213 0 3.23450666382e-05
Gc20_1214 0 n40 ns1214 0 1.21361432196e-05
Gc20_1215 0 n40 ns1215 0 -3.74852323539e-05
Gc20_1216 0 n40 ns1216 0 -5.08702487063e-06
Gd20_1 0 n40 ni1 0 0.000267725606176
Gd20_2 0 n40 ni2 0 0.000412072987216
Gd20_3 0 n40 ni3 0 -0.000460176556587
Gd20_4 0 n40 ni4 0 0.000714737406343
Gd20_5 0 n40 ni5 0 -0.000263507857373
Gd20_6 0 n40 ni6 0 9.33066500865e-05
Gd20_7 0 n40 ni7 0 0.000136597195232
Gd20_8 0 n40 ni8 0 -0.000848707926271
Gd20_9 0 n40 ni9 0 0.00138121036762
Gd20_10 0 n40 ni10 0 9.03212243051e-05
Gd20_11 0 n40 ni11 0 -0.00300483401814
Gd20_12 0 n40 ni12 0 -0.00183107519752
Gd20_13 0 n40 ni13 0 -0.000198259401389
Gd20_14 0 n40 ni14 0 0.000113929009442
Gd20_15 0 n40 ni15 0 -0.000698411865973
Gd20_16 0 n40 ni16 0 0.000813958315429
Gd20_17 0 n40 ni17 0 8.64048859094e-05
Gd20_18 0 n40 ni18 0 -0.000916537430536
Gd20_19 0 n40 ni19 0 -0.00164132808336
Gd20_20 0 n40 ni20 0 0.00122998100124
Gd20_21 0 n40 ni21 0 -0.00147900227044
Gd20_22 0 n40 ni22 0 -0.000270842480661
Gd20_23 0 n40 ni23 0 0.000478127340147
Gd20_24 0 n40 ni24 0 0.000753888986081
Gd20_25 0 n40 ni25 0 -0.000424657887793
Gd20_26 0 n40 ni26 0 -0.00174481035376
Gd20_27 0 n40 ni27 0 -0.000852545750178
Gd20_28 0 n40 ni28 0 -0.00304276571415
Gd20_29 0 n40 ni29 0 -0.00125290528508
Gd20_30 0 n40 ni30 0 0.00045738803199
Gd20_31 0 n40 ni31 0 0.000603910916927
Gd20_32 0 n40 ni32 0 9.59639803361e-05
Gc21_1 0 n42 ns1 0 8.30380004889e-05
Gc21_2 0 n42 ns2 0 -0.000580407572335
Gc21_3 0 n42 ns3 0 0.000211087203064
Gc21_4 0 n42 ns4 0 -8.72681188202e-06
Gc21_5 0 n42 ns5 0 -3.80674740002e-06
Gc21_6 0 n42 ns6 0 -0.000104481678931
Gc21_7 0 n42 ns7 0 -7.62372658339e-05
Gc21_8 0 n42 ns8 0 0.000224238023566
Gc21_9 0 n42 ns9 0 0.000564594105963
Gc21_10 0 n42 ns10 0 0.000191327888705
Gc21_11 0 n42 ns11 0 -0.000160858876472
Gc21_12 0 n42 ns12 0 2.73475493106e-05
Gc21_13 0 n42 ns13 0 -0.00049952364089
Gc21_14 0 n42 ns14 0 0.000232551357793
Gc21_15 0 n42 ns15 0 0.000732433458573
Gc21_16 0 n42 ns16 0 0.000824459909605
Gc21_17 0 n42 ns17 0 0.000678653777683
Gc21_18 0 n42 ns18 0 -0.000300693172105
Gc21_19 0 n42 ns19 0 0.000536357530523
Gc21_20 0 n42 ns20 0 -0.000179730585461
Gc21_21 0 n42 ns21 0 0.000471016537314
Gc21_22 0 n42 ns22 0 -0.000297813931307
Gc21_23 0 n42 ns23 0 -0.00239929803197
Gc21_24 0 n42 ns24 0 -0.00586402784383
Gc21_25 0 n42 ns25 0 -0.00240669585584
Gc21_26 0 n42 ns26 0 -0.00521087079072
Gc21_27 0 n42 ns27 0 -0.000963794296125
Gc21_28 0 n42 ns28 0 0.00127234159815
Gc21_29 0 n42 ns29 0 -0.000119483546742
Gc21_30 0 n42 ns30 0 -0.000715044374019
Gc21_31 0 n42 ns31 0 -0.00028043155062
Gc21_32 0 n42 ns32 0 -0.00176051109618
Gc21_33 0 n42 ns33 0 0.000163271755949
Gc21_34 0 n42 ns34 0 -0.000851323110089
Gc21_35 0 n42 ns35 0 -0.000372265694162
Gc21_36 0 n42 ns36 0 -1.00976736484e-06
Gc21_37 0 n42 ns37 0 4.05674772814e-05
Gc21_38 0 n42 ns38 0 2.09338050061e-05
Gc21_39 0 n42 ns39 0 -6.40811464339e-05
Gc21_40 0 n42 ns40 0 -0.000582667670444
Gc21_41 0 n42 ns41 0 -0.000160044441057
Gc21_42 0 n42 ns42 0 0.00031332906076
Gc21_43 0 n42 ns43 0 -0.0002369998125
Gc21_44 0 n42 ns44 0 -3.70220571914e-05
Gc21_45 0 n42 ns45 0 5.11072930859e-05
Gc21_46 0 n42 ns46 0 9.38215492795e-05
Gc21_47 0 n42 ns47 0 0.000484098275068
Gc21_48 0 n42 ns48 0 0.000346730309065
Gc21_49 0 n42 ns49 0 -0.00016379620678
Gc21_50 0 n42 ns50 0 6.1091734374e-05
Gc21_51 0 n42 ns51 0 -0.000235350674161
Gc21_52 0 n42 ns52 0 -3.4168719142e-05
Gc21_53 0 n42 ns53 0 0.000638827072239
Gc21_54 0 n42 ns54 0 0.000846408197794
Gc21_55 0 n42 ns55 0 0.00076710372558
Gc21_56 0 n42 ns56 0 -0.000328898647526
Gc21_57 0 n42 ns57 0 0.000543988284929
Gc21_58 0 n42 ns58 0 -0.000187515227738
Gc21_59 0 n42 ns59 0 0.000331702058433
Gc21_60 0 n42 ns60 0 -1.88037343914e-05
Gc21_61 0 n42 ns61 0 -0.00260321764998
Gc21_62 0 n42 ns62 0 -0.00622737236262
Gc21_63 0 n42 ns63 0 -0.00261996079704
Gc21_64 0 n42 ns64 0 -0.00564928670824
Gc21_65 0 n42 ns65 0 -0.00113842959579
Gc21_66 0 n42 ns66 0 0.0015751530536
Gc21_67 0 n42 ns67 0 -8.97313618942e-05
Gc21_68 0 n42 ns68 0 -0.00094420120908
Gc21_69 0 n42 ns69 0 -0.000265255683894
Gc21_70 0 n42 ns70 0 -0.00239641334393
Gc21_71 0 n42 ns71 0 0.000258183407183
Gc21_72 0 n42 ns72 0 -0.00156298448777
Gc21_73 0 n42 ns73 0 -0.000615824190998
Gc21_74 0 n42 ns74 0 -1.43750328299e-05
Gc21_75 0 n42 ns75 0 6.22005669594e-05
Gc21_76 0 n42 ns76 0 -7.55017031726e-07
Gc21_77 0 n42 ns77 0 -0.000585993637751
Gc21_78 0 n42 ns78 0 0.000320022369106
Gc21_79 0 n42 ns79 0 -0.00135526661061
Gc21_80 0 n42 ns80 0 0.00256844171693
Gc21_81 0 n42 ns81 0 -0.000199162375854
Gc21_82 0 n42 ns82 0 0.000542278700147
Gc21_83 0 n42 ns83 0 0.000210568827428
Gc21_84 0 n42 ns84 0 -0.000408689188047
Gc21_85 0 n42 ns85 0 -0.000153431970511
Gc21_86 0 n42 ns86 0 0.000439171176238
Gc21_87 0 n42 ns87 0 -0.000114444748915
Gc21_88 0 n42 ns88 0 0.000109547519077
Gc21_89 0 n42 ns89 0 0.000915941282107
Gc21_90 0 n42 ns90 0 -0.000610078190828
Gc21_91 0 n42 ns91 0 -5.97398889055e-05
Gc21_92 0 n42 ns92 0 -0.000326641294927
Gc21_93 0 n42 ns93 0 0.000623249120914
Gc21_94 0 n42 ns94 0 -0.000534558530552
Gc21_95 0 n42 ns95 0 0.000201458509159
Gc21_96 0 n42 ns96 0 -0.000716143227942
Gc21_97 0 n42 ns97 0 -0.00100491534289
Gc21_98 0 n42 ns98 0 0.00098731656438
Gc21_99 0 n42 ns99 0 -0.00289148412971
Gc21_100 0 n42 ns100 0 -0.00273333103037
Gc21_101 0 n42 ns101 0 -0.00263321442627
Gc21_102 0 n42 ns102 0 -0.00312878758474
Gc21_103 0 n42 ns103 0 -0.000353182878488
Gc21_104 0 n42 ns104 0 0.00104265594275
Gc21_105 0 n42 ns105 0 0.000315055894364
Gc21_106 0 n42 ns106 0 -0.00136793806604
Gc21_107 0 n42 ns107 0 -0.000124971736554
Gc21_108 0 n42 ns108 0 -0.00308358898539
Gc21_109 0 n42 ns109 0 0.00102636794424
Gc21_110 0 n42 ns110 0 -0.00341824529501
Gc21_111 0 n42 ns111 0 -0.00161262790862
Gc21_112 0 n42 ns112 0 -2.9442252487e-05
Gc21_113 0 n42 ns113 0 0.00011205334183
Gc21_114 0 n42 ns114 0 -6.43297833948e-06
Gc21_115 0 n42 ns115 0 -0.000832767944839
Gc21_116 0 n42 ns116 0 -0.000680423556121
Gc21_117 0 n42 ns117 0 -0.00340156875862
Gc21_118 0 n42 ns118 0 -0.00159697901278
Gc21_119 0 n42 ns119 0 -0.00180096842883
Gc21_120 0 n42 ns120 0 0.00112632157384
Gc21_121 0 n42 ns121 0 0.000741409054492
Gc21_122 0 n42 ns122 0 -0.00048599305771
Gc21_123 0 n42 ns123 0 -0.000469641025357
Gc21_124 0 n42 ns124 0 4.77140910464e-05
Gc21_125 0 n42 ns125 0 -0.000164513257711
Gc21_126 0 n42 ns126 0 5.53121246091e-05
Gc21_127 0 n42 ns127 0 0.00068741513807
Gc21_128 0 n42 ns128 0 0.000137191535907
Gc21_129 0 n42 ns129 0 0.000818693950849
Gc21_130 0 n42 ns130 0 -0.000894048357115
Gc21_131 0 n42 ns131 0 0.000971652165607
Gc21_132 0 n42 ns132 0 -0.000288927527914
Gc21_133 0 n42 ns133 0 0.000761378209841
Gc21_134 0 n42 ns134 0 -0.000533915279187
Gc21_135 0 n42 ns135 0 -0.0021657129468
Gc21_136 0 n42 ns136 0 -0.000887608137762
Gc21_137 0 n42 ns137 0 -0.00623989481129
Gc21_138 0 n42 ns138 0 -0.00279233687439
Gc21_139 0 n42 ns139 0 -0.00494167452028
Gc21_140 0 n42 ns140 0 -0.00324008932064
Gc21_141 0 n42 ns141 0 0.00355747609712
Gc21_142 0 n42 ns142 0 0.00202932025822
Gc21_143 0 n42 ns143 0 0.000838280686272
Gc21_144 0 n42 ns144 0 -0.00119230505244
Gc21_145 0 n42 ns145 0 -0.00216556470097
Gc21_146 0 n42 ns146 0 -0.00293383033033
Gc21_147 0 n42 ns147 0 0.00244148773411
Gc21_148 0 n42 ns148 0 -0.000615464041036
Gc21_149 0 n42 ns149 0 -0.00319169060142
Gc21_150 0 n42 ns150 0 -4.54090191762e-05
Gc21_151 0 n42 ns151 0 0.000361895789856
Gc21_152 0 n42 ns152 0 -0.000158068603026
Gc21_153 0 n42 ns153 0 -0.000168818438389
Gc21_154 0 n42 ns154 0 -0.000177717609274
Gc21_155 0 n42 ns155 0 0.0014974304486
Gc21_156 0 n42 ns156 0 0.00220429517364
Gc21_157 0 n42 ns157 0 0.00157615371031
Gc21_158 0 n42 ns158 0 -0.000978603606312
Gc21_159 0 n42 ns159 0 -0.00050214308735
Gc21_160 0 n42 ns160 0 5.11379156703e-05
Gc21_161 0 n42 ns161 0 0.000171495696116
Gc21_162 0 n42 ns162 0 0.00011047428774
Gc21_163 0 n42 ns163 0 -0.000129812262096
Gc21_164 0 n42 ns164 0 -7.35362627151e-06
Gc21_165 0 n42 ns165 0 0.00178122433166
Gc21_166 0 n42 ns166 0 -0.000848002884758
Gc21_167 0 n42 ns167 0 -0.000644087529876
Gc21_168 0 n42 ns168 0 0.0012835617524
Gc21_169 0 n42 ns169 0 -0.000483416297182
Gc21_170 0 n42 ns170 0 7.0610077991e-05
Gc21_171 0 n42 ns171 0 -0.00213412531425
Gc21_172 0 n42 ns172 0 -0.00120818661885
Gc21_173 0 n42 ns173 0 0.00296255873056
Gc21_174 0 n42 ns174 0 0.00384260259025
Gc21_175 0 n42 ns175 0 -0.010352915358
Gc21_176 0 n42 ns176 0 0.00101359610189
Gc21_177 0 n42 ns177 0 -0.00793324951389
Gc21_178 0 n42 ns178 0 -0.000358208155181
Gc21_179 0 n42 ns179 0 -0.0104130925059
Gc21_180 0 n42 ns180 0 -0.00015320581693
Gc21_181 0 n42 ns181 0 0.00138555195002
Gc21_182 0 n42 ns182 0 8.50575704248e-06
Gc21_183 0 n42 ns183 0 -0.00391638642462
Gc21_184 0 n42 ns184 0 0.00831160246845
Gc21_185 0 n42 ns185 0 -0.0143746035085
Gc21_186 0 n42 ns186 0 -0.00444447969033
Gc21_187 0 n42 ns187 0 -0.00631937797246
Gc21_188 0 n42 ns188 0 -5.30303596889e-05
Gc21_189 0 n42 ns189 0 -0.000360686012494
Gc21_190 0 n42 ns190 0 0.000578469112276
Gc21_191 0 n42 ns191 0 -0.000915918058775
Gc21_192 0 n42 ns192 0 -0.000237281012709
Gc21_193 0 n42 ns193 0 -0.00335155181077
Gc21_194 0 n42 ns194 0 -0.00121288165529
Gc21_195 0 n42 ns195 0 -0.00189762376555
Gc21_196 0 n42 ns196 0 0.00130937611653
Gc21_197 0 n42 ns197 0 0.000827731745486
Gc21_198 0 n42 ns198 0 -0.000570943668534
Gc21_199 0 n42 ns199 0 -0.000296658018579
Gc21_200 0 n42 ns200 0 0.000198385968018
Gc21_201 0 n42 ns201 0 -0.000162844418899
Gc21_202 0 n42 ns202 0 -8.9352707835e-06
Gc21_203 0 n42 ns203 0 0.000465080582059
Gc21_204 0 n42 ns204 0 -8.33698051433e-05
Gc21_205 0 n42 ns205 0 0.000785620726842
Gc21_206 0 n42 ns206 0 -0.000962665622468
Gc21_207 0 n42 ns207 0 0.00101646770632
Gc21_208 0 n42 ns208 0 -0.000312189252298
Gc21_209 0 n42 ns209 0 0.000875129741775
Gc21_210 0 n42 ns210 0 -0.000597285186787
Gc21_211 0 n42 ns211 0 -0.002105107285
Gc21_212 0 n42 ns212 0 -0.000565169646514
Gc21_213 0 n42 ns213 0 -0.00606843361219
Gc21_214 0 n42 ns214 0 -0.00179497125166
Gc21_215 0 n42 ns215 0 -0.00479305708948
Gc21_216 0 n42 ns216 0 -0.00241364776997
Gc21_217 0 n42 ns217 0 0.0039924052445
Gc21_218 0 n42 ns218 0 0.00229513870465
Gc21_219 0 n42 ns219 0 0.000775888172399
Gc21_220 0 n42 ns220 0 -0.00123028145198
Gc21_221 0 n42 ns221 0 -0.00252012799992
Gc21_222 0 n42 ns222 0 -0.00324792603123
Gc21_223 0 n42 ns223 0 0.00231223998822
Gc21_224 0 n42 ns224 0 -0.00122881977527
Gc21_225 0 n42 ns225 0 -0.00332840542823
Gc21_226 0 n42 ns226 0 -4.50612538375e-05
Gc21_227 0 n42 ns227 0 0.000359930012254
Gc21_228 0 n42 ns228 0 -0.000173400030894
Gc21_229 0 n42 ns229 0 7.14938564871e-05
Gc21_230 0 n42 ns230 0 -0.000552956652102
Gc21_231 0 n42 ns231 0 0.000347649226011
Gc21_232 0 n42 ns232 0 0.00101609320498
Gc21_233 0 n42 ns233 0 0.000192733860025
Gc21_234 0 n42 ns234 0 5.35674133921e-05
Gc21_235 0 n42 ns235 0 -7.06816100518e-05
Gc21_236 0 n42 ns236 0 -0.000154702350382
Gc21_237 0 n42 ns237 0 -0.000339086903368
Gc21_238 0 n42 ns238 0 0.00027243509342
Gc21_239 0 n42 ns239 0 -0.000117928298756
Gc21_240 0 n42 ns240 0 0.000114207249944
Gc21_241 0 n42 ns241 0 0.000727150551135
Gc21_242 0 n42 ns242 0 -0.00034220009155
Gc21_243 0 n42 ns243 0 -0.000483236112457
Gc21_244 0 n42 ns244 0 -0.00011092365994
Gc21_245 0 n42 ns245 0 0.000352585633487
Gc21_246 0 n42 ns246 0 -0.00030897910407
Gc21_247 0 n42 ns247 0 -0.000193844766314
Gc21_248 0 n42 ns248 0 -0.000436162138028
Gc21_249 0 n42 ns249 0 -0.00101010070923
Gc21_250 0 n42 ns250 0 0.000880592121344
Gc21_251 0 n42 ns251 0 -0.00268805810596
Gc21_252 0 n42 ns252 0 -0.0022595169582
Gc21_253 0 n42 ns253 0 -0.00245878993126
Gc21_254 0 n42 ns254 0 -0.00269861214618
Gc21_255 0 n42 ns255 0 -0.000158021845567
Gc21_256 0 n42 ns256 0 0.000745428557999
Gc21_257 0 n42 ns257 0 0.00029021873992
Gc21_258 0 n42 ns258 0 -0.00130040678182
Gc21_259 0 n42 ns259 0 -0.000253903027293
Gc21_260 0 n42 ns260 0 -0.00276813855642
Gc21_261 0 n42 ns261 0 0.00100005374878
Gc21_262 0 n42 ns262 0 -0.00320823120015
Gc21_263 0 n42 ns263 0 -0.00155749355051
Gc21_264 0 n42 ns264 0 -2.40505466406e-05
Gc21_265 0 n42 ns265 0 0.000102673013984
Gc21_266 0 n42 ns266 0 2.60168289782e-06
Gc21_267 0 n42 ns267 0 -0.000571102225394
Gc21_268 0 n42 ns268 0 0.000326627098677
Gc21_269 0 n42 ns269 0 -0.00150028842221
Gc21_270 0 n42 ns270 0 0.0013138875602
Gc21_271 0 n42 ns271 0 -0.000417114678626
Gc21_272 0 n42 ns272 0 0.0003787845592
Gc21_273 0 n42 ns273 0 0.000133910667867
Gc21_274 0 n42 ns274 0 -0.000197623231865
Gc21_275 0 n42 ns275 0 0.000303018734624
Gc21_276 0 n42 ns276 0 0.000350301004375
Gc21_277 0 n42 ns277 0 -6.49906233086e-05
Gc21_278 0 n42 ns278 0 0.000124296993857
Gc21_279 0 n42 ns279 0 0.000211491450763
Gc21_280 0 n42 ns280 0 -0.000389820989267
Gc21_281 0 n42 ns281 0 0.000651944577375
Gc21_282 0 n42 ns282 0 0.000434496194288
Gc21_283 0 n42 ns283 0 0.00056558374795
Gc21_284 0 n42 ns284 0 -0.000455041672649
Gc21_285 0 n42 ns285 0 0.000354369116142
Gc21_286 0 n42 ns286 0 -0.000246329177546
Gc21_287 0 n42 ns287 0 -0.000113885326951
Gc21_288 0 n42 ns288 0 2.62077113278e-05
Gc21_289 0 n42 ns289 0 -0.00437529153888
Gc21_290 0 n42 ns290 0 -0.00497169676719
Gc21_291 0 n42 ns291 0 -0.00411395912361
Gc21_292 0 n42 ns292 0 -0.00452537728353
Gc21_293 0 n42 ns293 0 -0.000811438071563
Gc21_294 0 n42 ns294 0 0.00200016783143
Gc21_295 0 n42 ns295 0 -0.000188166971085
Gc21_296 0 n42 ns296 0 -0.000966006869533
Gc21_297 0 n42 ns297 0 -0.000603898550794
Gc21_298 0 n42 ns298 0 -0.0026118029843
Gc21_299 0 n42 ns299 0 0.000178485474111
Gc21_300 0 n42 ns300 0 -0.00176010244236
Gc21_301 0 n42 ns301 0 -0.00064234009716
Gc21_302 0 n42 ns302 0 -2.04910307385e-05
Gc21_303 0 n42 ns303 0 9.93430130185e-05
Gc21_304 0 n42 ns304 0 -2.21203446044e-05
Gc21_305 0 n42 ns305 0 -7.6204333163e-05
Gc21_306 0 n42 ns306 0 -5.2147058396e-06
Gc21_307 0 n42 ns307 0 2.63584595926e-05
Gc21_308 0 n42 ns308 0 0.000341822248821
Gc21_309 0 n42 ns309 0 -3.04492261559e-05
Gc21_310 0 n42 ns310 0 0.000126958424079
Gc21_311 0 n42 ns311 0 0.000126405612336
Gc21_312 0 n42 ns312 0 2.01234256013e-05
Gc21_313 0 n42 ns313 0 0.000528984540735
Gc21_314 0 n42 ns314 0 -0.000332187466459
Gc21_315 0 n42 ns315 0 -0.000149494332808
Gc21_316 0 n42 ns316 0 0.000117954383515
Gc21_317 0 n42 ns317 0 -9.76443651688e-05
Gc21_318 0 n42 ns318 0 0.000549083384997
Gc21_319 0 n42 ns319 0 0.000924618462173
Gc21_320 0 n42 ns320 0 -9.92521860548e-05
Gc21_321 0 n42 ns321 0 0.000310904700313
Gc21_322 0 n42 ns322 0 -0.000718933675507
Gc21_323 0 n42 ns323 0 0.000232732870146
Gc21_324 0 n42 ns324 0 -0.000721818458491
Gc21_325 0 n42 ns325 0 0.000155155003725
Gc21_326 0 n42 ns326 0 -0.000567966922947
Gc21_327 0 n42 ns327 0 -0.00426431283519
Gc21_328 0 n42 ns328 0 -0.00355017341642
Gc21_329 0 n42 ns329 0 -0.00391711549629
Gc21_330 0 n42 ns330 0 -0.00304678855782
Gc21_331 0 n42 ns331 0 -0.000153189331198
Gc21_332 0 n42 ns332 0 0.00155196300248
Gc21_333 0 n42 ns333 0 -0.000248431934184
Gc21_334 0 n42 ns334 0 -0.000517905608118
Gc21_335 0 n42 ns335 0 -0.000778656834897
Gc21_336 0 n42 ns336 0 -0.0015731689361
Gc21_337 0 n42 ns337 0 -5.74532851701e-05
Gc21_338 0 n42 ns338 0 -0.000934783747544
Gc21_339 0 n42 ns339 0 -0.000312982164539
Gc21_340 0 n42 ns340 0 -1.9438606913e-07
Gc21_341 0 n42 ns341 0 6.67458306136e-05
Gc21_342 0 n42 ns342 0 8.81948083924e-06
Gc21_343 0 n42 ns343 0 -0.000313123844584
Gc21_344 0 n42 ns344 0 -0.000111950152875
Gc21_345 0 n42 ns345 0 -0.000727634103564
Gc21_346 0 n42 ns346 0 0.00142939487017
Gc21_347 0 n42 ns347 0 -0.000347605666849
Gc21_348 0 n42 ns348 0 0.000101303508863
Gc21_349 0 n42 ns349 0 0.00021661407031
Gc21_350 0 n42 ns350 0 -0.000164922090169
Gc21_351 0 n42 ns351 0 6.1257930164e-05
Gc21_352 0 n42 ns352 0 0.000435393293429
Gc21_353 0 n42 ns353 0 -0.000131913438788
Gc21_354 0 n42 ns354 0 0.000123813003488
Gc21_355 0 n42 ns355 0 0.000589954422828
Gc21_356 0 n42 ns356 0 -0.000473516427481
Gc21_357 0 n42 ns357 0 0.000126841965436
Gc21_358 0 n42 ns358 0 0.000270781751455
Gc21_359 0 n42 ns359 0 0.000633408865594
Gc21_360 0 n42 ns360 0 -0.000411665039192
Gc21_361 0 n42 ns361 0 0.000235516738883
Gc21_362 0 n42 ns362 0 -0.000396497113482
Gc21_363 0 n42 ns363 0 -0.000334743697738
Gc21_364 0 n42 ns364 0 0.000706378738901
Gc21_365 0 n42 ns365 0 -0.00217780364862
Gc21_366 0 n42 ns366 0 -0.00446878109972
Gc21_367 0 n42 ns367 0 -0.0021627988991
Gc21_368 0 n42 ns368 0 -0.00442761586184
Gc21_369 0 n42 ns369 0 -0.00112441101837
Gc21_370 0 n42 ns370 0 0.00134241126087
Gc21_371 0 n42 ns371 0 0.000147753805974
Gc21_372 0 n42 ns372 0 -0.00127006002621
Gc21_373 0 n42 ns373 0 1.62536174947e-05
Gc21_374 0 n42 ns374 0 -0.00306324005298
Gc21_375 0 n42 ns375 0 0.000639583343019
Gc21_376 0 n42 ns376 0 -0.00283186917539
Gc21_377 0 n42 ns377 0 -0.00116635843116
Gc21_378 0 n42 ns378 0 -3.85004806947e-05
Gc21_379 0 n42 ns379 0 0.000100626029106
Gc21_380 0 n42 ns380 0 -1.00498595151e-05
Gc21_381 0 n42 ns381 0 -0.00103891523347
Gc21_382 0 n42 ns382 0 5.66495466377e-05
Gc21_383 0 n42 ns383 0 -0.00308826341443
Gc21_384 0 n42 ns384 0 0.00148441873923
Gc21_385 0 n42 ns385 0 -0.000327487950279
Gc21_386 0 n42 ns386 0 0.00113265978393
Gc21_387 0 n42 ns387 0 0.000220550353892
Gc21_388 0 n42 ns388 0 -0.000491304636822
Gc21_389 0 n42 ns389 0 -0.000375592432964
Gc21_390 0 n42 ns390 0 0.000140386759739
Gc21_391 0 n42 ns391 0 -0.000156596835051
Gc21_392 0 n42 ns392 0 9.58101662038e-05
Gc21_393 0 n42 ns393 0 0.000943333933114
Gc21_394 0 n42 ns394 0 0.000127706710579
Gc21_395 0 n42 ns395 0 0.000325666029455
Gc21_396 0 n42 ns396 0 -0.000823572551149
Gc21_397 0 n42 ns397 0 0.000751554068598
Gc21_398 0 n42 ns398 0 -0.000476378179493
Gc21_399 0 n42 ns399 0 0.000456962791075
Gc21_400 0 n42 ns400 0 -0.000828996264142
Gc21_401 0 n42 ns401 0 -0.00230922397122
Gc21_402 0 n42 ns402 0 -6.47990358491e-05
Gc21_403 0 n42 ns403 0 -0.00607050401874
Gc21_404 0 n42 ns404 0 -0.00215208098197
Gc21_405 0 n42 ns405 0 -0.0049407515867
Gc21_406 0 n42 ns406 0 -0.00271333935042
Gc21_407 0 n42 ns407 0 0.00173501642656
Gc21_408 0 n42 ns408 0 0.000165570514498
Gc21_409 0 n42 ns409 0 0.000786251573996
Gc21_410 0 n42 ns410 0 -0.00118058088284
Gc21_411 0 n42 ns411 0 -0.000503971853474
Gc21_412 0 n42 ns412 0 -0.00192601167315
Gc21_413 0 n42 ns413 0 0.00240477892648
Gc21_414 0 n42 ns414 0 -0.00261669747603
Gc21_415 0 n42 ns415 0 -0.00252541531894
Gc21_416 0 n42 ns416 0 -9.19671059496e-06
Gc21_417 0 n42 ns417 0 0.000198139025321
Gc21_418 0 n42 ns418 0 -5.19775710972e-05
Gc21_419 0 n42 ns419 0 0.00275578688982
Gc21_420 0 n42 ns420 0 -0.00383076501616
Gc21_421 0 n42 ns421 0 0.00637407476878
Gc21_422 0 n42 ns422 0 -0.00785087853297
Gc21_423 0 n42 ns423 0 -0.00296256021434
Gc21_424 0 n42 ns424 0 -0.00265573253114
Gc21_425 0 n42 ns425 0 0.000888418083323
Gc21_426 0 n42 ns426 0 0.000848054190864
Gc21_427 0 n42 ns427 0 -0.000508115168124
Gc21_428 0 n42 ns428 0 -0.000681492813692
Gc21_429 0 n42 ns429 0 -0.000246830538499
Gc21_430 0 n42 ns430 0 3.49289409203e-06
Gc21_431 0 n42 ns431 0 -0.000582858613628
Gc21_432 0 n42 ns432 0 -0.000216499074009
Gc21_433 0 n42 ns433 0 0.000953767751967
Gc21_434 0 n42 ns434 0 0.000165960510015
Gc21_435 0 n42 ns435 0 0.000674420473515
Gc21_436 0 n42 ns436 0 0.000458237922318
Gc21_437 0 n42 ns437 0 -3.82007166439e-05
Gc21_438 0 n42 ns438 0 0.000711759997453
Gc21_439 0 n42 ns439 0 0.000785651291866
Gc21_440 0 n42 ns440 0 -0.00302524627572
Gc21_441 0 n42 ns441 0 -0.00227873631351
Gc21_442 0 n42 ns442 0 -0.00679116636974
Gc21_443 0 n42 ns443 0 -0.00159022397438
Gc21_444 0 n42 ns444 0 -0.00643349330051
Gc21_445 0 n42 ns445 0 0.00585318698046
Gc21_446 0 n42 ns446 0 0.00789469159093
Gc21_447 0 n42 ns447 0 0.000750753955808
Gc21_448 0 n42 ns448 0 -0.00115444478955
Gc21_449 0 n42 ns449 0 -0.00560761073493
Gc21_450 0 n42 ns450 0 -0.00573488913787
Gc21_451 0 n42 ns451 0 0.00135946760743
Gc21_452 0 n42 ns452 0 0.00536302896117
Gc21_453 0 n42 ns453 0 -0.0042658403099
Gc21_454 0 n42 ns454 0 -2.05554554153e-06
Gc21_455 0 n42 ns455 0 0.000421384199343
Gc21_456 0 n42 ns456 0 -0.000231486115095
Gc21_457 0 n42 ns457 0 0.00105330802613
Gc21_458 0 n42 ns458 0 -0.00191509016085
Gc21_459 0 n42 ns459 0 0.00213071636131
Gc21_460 0 n42 ns460 0 -0.00414113833824
Gc21_461 0 n42 ns461 0 -0.00241478622263
Gc21_462 0 n42 ns462 0 -0.00102805964229
Gc21_463 0 n42 ns463 0 0.000876972736753
Gc21_464 0 n42 ns464 0 0.000313866411094
Gc21_465 0 n42 ns465 0 -0.00030576107263
Gc21_466 0 n42 ns466 0 -0.000282729245041
Gc21_467 0 n42 ns467 0 -0.00020733534391
Gc21_468 0 n42 ns468 0 -3.9127992307e-05
Gc21_469 0 n42 ns469 0 -0.000121194068349
Gc21_470 0 n42 ns470 0 -0.000175659427409
Gc21_471 0 n42 ns471 0 0.00110985001533
Gc21_472 0 n42 ns472 0 -0.000542531066361
Gc21_473 0 n42 ns473 0 0.000909563263881
Gc21_474 0 n42 ns474 0 7.23949205491e-06
Gc21_475 0 n42 ns475 0 0.000476165097631
Gc21_476 0 n42 ns476 0 -0.000126822480028
Gc21_477 0 n42 ns477 0 -0.000811879285654
Gc21_478 0 n42 ns478 0 -0.00180572660074
Gc21_479 0 n42 ns479 0 -0.00536229443964
Gc21_480 0 n42 ns480 0 -0.00304854085574
Gc21_481 0 n42 ns481 0 -0.00412766155706
Gc21_482 0 n42 ns482 0 -0.00345768456176
Gc21_483 0 n42 ns483 0 0.00500736624436
Gc21_484 0 n42 ns484 0 0.00434148946622
Gc21_485 0 n42 ns485 0 0.000862542808257
Gc21_486 0 n42 ns486 0 -0.00115708141527
Gc21_487 0 n42 ns487 0 -0.00359061571275
Gc21_488 0 n42 ns488 0 -0.00363733357362
Gc21_489 0 n42 ns489 0 0.00205238715931
Gc21_490 0 n42 ns490 0 0.000889363976516
Gc21_491 0 n42 ns491 0 -0.00387937365525
Gc21_492 0 n42 ns492 0 -7.11163234549e-07
Gc21_493 0 n42 ns493 0 0.000303316270815
Gc21_494 0 n42 ns494 0 -0.00014711905436
Gc21_495 0 n42 ns495 0 -0.000305213121033
Gc21_496 0 n42 ns496 0 -0.000493311477811
Gc21_497 0 n42 ns497 0 -0.000921246036415
Gc21_498 0 n42 ns498 0 0.000787894193751
Gc21_499 0 n42 ns499 0 -0.000112987859918
Gc21_500 0 n42 ns500 0 0.000504422812329
Gc21_501 0 n42 ns501 0 0.000133947847442
Gc21_502 0 n42 ns502 0 -0.000289752754309
Gc21_503 0 n42 ns503 0 -0.000488303489346
Gc21_504 0 n42 ns504 0 0.000210640415362
Gc21_505 0 n42 ns505 0 -0.000142257200359
Gc21_506 0 n42 ns506 0 9.07492696712e-05
Gc21_507 0 n42 ns507 0 0.000899993014137
Gc21_508 0 n42 ns508 0 -0.000176299908062
Gc21_509 0 n42 ns509 0 -0.000343125820095
Gc21_510 0 n42 ns510 0 -0.000544752683981
Gc21_511 0 n42 ns511 0 0.000505111544158
Gc21_512 0 n42 ns512 0 -0.000321851058205
Gc21_513 0 n42 ns513 0 1.90488860916e-05
Gc21_514 0 n42 ns514 0 -0.000582472851441
Gc21_515 0 n42 ns515 0 -0.00167103432355
Gc21_516 0 n42 ns516 0 0.000707661149132
Gc21_517 0 n42 ns517 0 -0.00381472778218
Gc21_518 0 n42 ns518 0 -0.00145325797631
Gc21_519 0 n42 ns519 0 -0.00323003457079
Gc21_520 0 n42 ns520 0 -0.00215043393888
Gc21_521 0 n42 ns521 0 0.000898729352312
Gc21_522 0 n42 ns522 0 0.000641856154002
Gc21_523 0 n42 ns523 0 0.000507407635101
Gc21_524 0 n42 ns524 0 -0.0013365879336
Gc21_525 0 n42 ns525 0 -0.000530833823937
Gc21_526 0 n42 ns526 0 -0.00268863795686
Gc21_527 0 n42 ns527 0 0.00155698316672
Gc21_528 0 n42 ns528 0 -0.00342393827408
Gc21_529 0 n42 ns529 0 -0.00213463632628
Gc21_530 0 n42 ns530 0 -2.27348036855e-05
Gc21_531 0 n42 ns531 0 0.000135946071498
Gc21_532 0 n42 ns532 0 -1.49502590637e-05
Gc21_533 0 n42 ns533 0 -0.000183827444977
Gc21_534 0 n42 ns534 0 -0.000323988092606
Gc21_535 0 n42 ns535 0 -0.00051801927937
Gc21_536 0 n42 ns536 0 0.000667276007465
Gc21_537 0 n42 ns537 0 -0.000166599056031
Gc21_538 0 n42 ns538 0 2.560117996e-05
Gc21_539 0 n42 ns539 0 -3.21871646483e-05
Gc21_540 0 n42 ns540 0 -0.000102552234474
Gc21_541 0 n42 ns541 0 -3.71559384569e-05
Gc21_542 0 n42 ns542 0 0.000378945190937
Gc21_543 0 n42 ns543 0 -8.29590892407e-05
Gc21_544 0 n42 ns544 0 0.000141822925002
Gc21_545 0 n42 ns545 0 0.000414089904575
Gc21_546 0 n42 ns546 0 -0.000403003828549
Gc21_547 0 n42 ns547 0 0.000110584485147
Gc21_548 0 n42 ns548 0 0.000571295438813
Gc21_549 0 n42 ns549 0 0.00048562222596
Gc21_550 0 n42 ns550 0 -0.000263413410576
Gc21_551 0 n42 ns551 0 7.41030569371e-05
Gc21_552 0 n42 ns552 0 -7.56782279374e-05
Gc21_553 0 n42 ns553 0 -0.00029149533318
Gc21_554 0 n42 ns554 0 0.000276701231946
Gc21_555 0 n42 ns555 0 -0.00351697577458
Gc21_556 0 n42 ns556 0 -0.00494590950393
Gc21_557 0 n42 ns557 0 -0.00337335639515
Gc21_558 0 n42 ns558 0 -0.00467466155059
Gc21_559 0 n42 ns559 0 -0.000968030854485
Gc21_560 0 n42 ns560 0 0.00161123638419
Gc21_561 0 n42 ns561 0 -5.31072303766e-05
Gc21_562 0 n42 ns562 0 -0.00111423223061
Gc21_563 0 n42 ns563 0 -0.000367630035069
Gc21_564 0 n42 ns564 0 -0.00271466045616
Gc21_565 0 n42 ns565 0 0.000392523762463
Gc21_566 0 n42 ns566 0 -0.00204368954618
Gc21_567 0 n42 ns567 0 -0.000839107598439
Gc21_568 0 n42 ns568 0 -2.12323027329e-05
Gc21_569 0 n42 ns569 0 0.00010746461071
Gc21_570 0 n42 ns570 0 -1.47767450355e-05
Gc21_571 0 n42 ns571 0 -0.000256120664594
Gc21_572 0 n42 ns572 0 -2.3144676092e-05
Gc21_573 0 n42 ns573 0 -0.000432297462571
Gc21_574 0 n42 ns574 0 0.000436468639056
Gc21_575 0 n42 ns575 0 -0.000135116211607
Gc21_576 0 n42 ns576 0 0.000189847051275
Gc21_577 0 n42 ns577 0 0.000115888315958
Gc21_578 0 n42 ns578 0 -1.98441343714e-05
Gc21_579 0 n42 ns579 0 0.0005486229465
Gc21_580 0 n42 ns580 0 -0.000204616986113
Gc21_581 0 n42 ns581 0 -0.000157270666219
Gc21_582 0 n42 ns582 0 0.000140859683703
Gc21_583 0 n42 ns583 0 -6.22010502071e-05
Gc21_584 0 n42 ns584 0 0.000445368848079
Gc21_585 0 n42 ns585 0 0.000994298964422
Gc21_586 0 n42 ns586 0 0.000160177932329
Gc21_587 0 n42 ns587 0 0.000434764605556
Gc21_588 0 n42 ns588 0 -0.000679575680691
Gc21_589 0 n42 ns589 0 0.000303209647114
Gc21_590 0 n42 ns590 0 -0.00058191975904
Gc21_591 0 n42 ns591 0 6.96263591318e-05
Gc21_592 0 n42 ns592 0 -0.000548717255476
Gc21_593 0 n42 ns593 0 -0.00498702511595
Gc21_594 0 n42 ns594 0 -0.00451446604041
Gc21_595 0 n42 ns595 0 -0.00459907062353
Gc21_596 0 n42 ns596 0 -0.00392540882282
Gc21_597 0 n42 ns597 0 -0.000385780519605
Gc21_598 0 n42 ns598 0 0.001836949042
Gc21_599 0 n42 ns599 0 -0.000269151546643
Gc21_600 0 n42 ns600 0 -0.000665598679025
Gc21_601 0 n42 ns601 0 -0.000793007248207
Gc21_602 0 n42 ns602 0 -0.00193717660341
Gc21_603 0 n42 ns603 0 -5.27282486621e-06
Gc21_604 0 n42 ns604 0 -0.00112907928864
Gc21_605 0 n42 ns605 0 -0.000385401807604
Gc21_606 0 n42 ns606 0 -9.59288833196e-06
Gc21_607 0 n42 ns607 0 9.92574630309e-05
Gc21_608 0 n42 ns608 0 -1.63241751721e-05
Gc21_609 0 n42 ns609 0 -1.11344562857e-05
Gc21_610 0 n42 ns610 0 -0.000506993579286
Gc21_611 0 n42 ns611 0 -0.00010913779662
Gc21_612 0 n42 ns612 0 6.73926990395e-05
Gc21_613 0 n42 ns613 0 0.000174069257904
Gc21_614 0 n42 ns614 0 -0.000131426428636
Gc21_615 0 n42 ns615 0 -8.33329324802e-06
Gc21_616 0 n42 ns616 0 -8.53052613238e-05
Gc21_617 0 n42 ns617 0 -0.000539155398049
Gc21_618 0 n42 ns618 0 -0.000290388830972
Gc21_619 0 n42 ns619 0 0.000129282497071
Gc21_620 0 n42 ns620 0 -6.33180474847e-05
Gc21_621 0 n42 ns621 0 -3.83220559177e-05
Gc21_622 0 n42 ns622 0 0.000261680588083
Gc21_623 0 n42 ns623 0 0.000761292589009
Gc21_624 0 n42 ns624 0 0.00102556104169
Gc21_625 0 n42 ns625 0 0.000590603722385
Gc21_626 0 n42 ns626 0 -0.000149756716835
Gc21_627 0 n42 ns627 0 0.000280692513314
Gc21_628 0 n42 ns628 0 0.00013266604997
Gc21_629 0 n42 ns629 0 -0.00114929860164
Gc21_630 0 n42 ns630 0 3.50160554354e-06
Gc21_631 0 n42 ns631 0 0.00085479143296
Gc21_632 0 n42 ns632 0 0.00424022129298
Gc21_633 0 n42 ns633 0 0.00114188588413
Gc21_634 0 n42 ns634 0 0.00386589794313
Gc21_635 0 n42 ns635 0 -0.00107574442035
Gc21_636 0 n42 ns636 0 0.000986827519357
Gc21_637 0 n42 ns637 0 -0.000107176974298
Gc21_638 0 n42 ns638 0 -0.000674290012662
Gc21_639 0 n42 ns639 0 -0.000249801998474
Gc21_640 0 n42 ns640 0 -0.0014372730797
Gc21_641 0 n42 ns641 0 -0.000404912147539
Gc21_642 0 n42 ns642 0 0.000388474517393
Gc21_643 0 n42 ns643 0 0.00032739425476
Gc21_644 0 n42 ns644 0 -2.0840068016e-05
Gc21_645 0 n42 ns645 0 -0.000100602539174
Gc21_646 0 n42 ns646 0 -1.17792208131e-05
Gc21_647 0 n42 ns647 0 -0.000176981031658
Gc21_648 0 n42 ns648 0 -0.000376389658999
Gc21_649 0 n42 ns649 0 -0.000492774270783
Gc21_650 0 n42 ns650 0 0.000285745337917
Gc21_651 0 n42 ns651 0 0.000139739908533
Gc21_652 0 n42 ns652 0 -4.67486300994e-05
Gc21_653 0 n42 ns653 0 1.27640644129e-05
Gc21_654 0 n42 ns654 0 -2.27279548956e-05
Gc21_655 0 n42 ns655 0 -0.000496032576277
Gc21_656 0 n42 ns656 0 -0.00030344407787
Gc21_657 0 n42 ns657 0 0.000170074750564
Gc21_658 0 n42 ns658 0 -7.44825483752e-05
Gc21_659 0 n42 ns659 0 2.05940930198e-05
Gc21_660 0 n42 ns660 0 7.88477624277e-05
Gc21_661 0 n42 ns661 0 0.000529337889837
Gc21_662 0 n42 ns662 0 0.00105849744364
Gc21_663 0 n42 ns663 0 0.000604635714228
Gc21_664 0 n42 ns664 0 -0.000209760874252
Gc21_665 0 n42 ns665 0 0.000176696505218
Gc21_666 0 n42 ns666 0 1.08573735646e-08
Gc21_667 0 n42 ns667 0 -0.0010266265698
Gc21_668 0 n42 ns668 0 -0.000355417595282
Gc21_669 0 n42 ns669 0 0.00102448537552
Gc21_670 0 n42 ns670 0 0.00441377675777
Gc21_671 0 n42 ns671 0 0.00132232539223
Gc21_672 0 n42 ns672 0 0.00414970555071
Gc21_673 0 n42 ns673 0 -0.00164471956981
Gc21_674 0 n42 ns674 0 0.000664781011755
Gc21_675 0 n42 ns675 0 -2.26564175453e-05
Gc21_676 0 n42 ns676 0 -0.000822859410129
Gc21_677 0 n42 ns677 0 3.74852264565e-05
Gc21_678 0 n42 ns678 0 -0.00145266122582
Gc21_679 0 n42 ns679 0 -0.000497988587746
Gc21_680 0 n42 ns680 0 0.00100883591408
Gc21_681 0 n42 ns681 0 0.000565670450292
Gc21_682 0 n42 ns682 0 -8.21714012896e-06
Gc21_683 0 n42 ns683 0 -0.000118227667576
Gc21_684 0 n42 ns684 0 -2.77086919504e-07
Gc21_685 0 n42 ns685 0 0.000331425922878
Gc21_686 0 n42 ns686 0 -0.000806173422093
Gc21_687 0 n42 ns687 0 0.00111682252156
Gc21_688 0 n42 ns688 0 -9.65236493798e-05
Gc21_689 0 n42 ns689 0 -0.000106066875608
Gc21_690 0 n42 ns690 0 0.000336756423694
Gc21_691 0 n42 ns691 0 -0.000151055282635
Gc21_692 0 n42 ns692 0 -9.73011598303e-05
Gc21_693 0 n42 ns693 0 0.000249068477946
Gc21_694 0 n42 ns694 0 -0.000165697502873
Gc21_695 0 n42 ns695 0 0.000184560226473
Gc21_696 0 n42 ns696 0 -8.21138522353e-05
Gc21_697 0 n42 ns697 0 2.94135613141e-05
Gc21_698 0 n42 ns698 0 -0.000259796099203
Gc21_699 0 n42 ns699 0 -0.00059502684386
Gc21_700 0 n42 ns700 0 -0.000442321688724
Gc21_701 0 n42 ns701 0 0.000385490601973
Gc21_702 0 n42 ns702 0 -0.000703147494106
Gc21_703 0 n42 ns703 0 -7.30408855087e-05
Gc21_704 0 n42 ns704 0 -0.00116391624974
Gc21_705 0 n42 ns705 0 0.00132035912126
Gc21_706 0 n42 ns706 0 -0.00047164428795
Gc21_707 0 n42 ns707 0 0.00257706602236
Gc21_708 0 n42 ns708 0 0.00393435220049
Gc21_709 0 n42 ns709 0 0.0023510449839
Gc21_710 0 n42 ns710 0 0.00408150202468
Gc21_711 0 n42 ns711 0 -0.00115880345245
Gc21_712 0 n42 ns712 0 -0.00153040974248
Gc21_713 0 n42 ns713 0 0.000427367702645
Gc21_714 0 n42 ns714 0 -0.0010557376204
Gc21_715 0 n42 ns715 0 0.00018393015823
Gc21_716 0 n42 ns716 0 -0.000792810850521
Gc21_717 0 n42 ns717 0 -0.00151163232322
Gc21_718 0 n42 ns718 0 0.00241750752334
Gc21_719 0 n42 ns719 0 0.00148784634763
Gc21_720 0 n42 ns720 0 3.61172165129e-05
Gc21_721 0 n42 ns721 0 -0.000248583068982
Gc21_722 0 n42 ns722 0 8.64550249425e-05
Gc21_723 0 n42 ns723 0 0.000201878358094
Gc21_724 0 n42 ns724 0 -0.00194413957101
Gc21_725 0 n42 ns725 0 0.000203422689175
Gc21_726 0 n42 ns726 0 -0.00052510087143
Gc21_727 0 n42 ns727 0 -0.0009726115378
Gc21_728 0 n42 ns728 0 0.000304902548213
Gc21_729 0 n42 ns729 0 0.00040706959035
Gc21_730 0 n42 ns730 0 -0.00046304776237
Gc21_731 0 n42 ns731 0 0.000318789172235
Gc21_732 0 n42 ns732 0 0.000464393038449
Gc21_733 0 n42 ns733 0 0.000250737109504
Gc21_734 0 n42 ns734 0 -4.0869994303e-05
Gc21_735 0 n42 ns735 0 -0.000357396495811
Gc21_736 0 n42 ns736 0 -3.88250997013e-05
Gc21_737 0 n42 ns737 0 0.000663295789622
Gc21_738 0 n42 ns738 0 -0.000899505894964
Gc21_739 0 n42 ns739 0 0.000810314519646
Gc21_740 0 n42 ns740 0 -0.000395286596858
Gc21_741 0 n42 ns741 0 0.000395213882629
Gc21_742 0 n42 ns742 0 -0.000837227407998
Gc21_743 0 n42 ns743 0 0.000857047780982
Gc21_744 0 n42 ns744 0 0.00208410268351
Gc21_745 0 n42 ns745 0 0.00272897543105
Gc21_746 0 n42 ns746 0 0.00420179332056
Gc21_747 0 n42 ns747 0 0.0020698382457
Gc21_748 0 n42 ns748 0 0.00442273355433
Gc21_749 0 n42 ns749 0 0.00346626245205
Gc21_750 0 n42 ns750 0 0.000393836245797
Gc21_751 0 n42 ns751 0 0.000902890788005
Gc21_752 0 n42 ns752 0 -0.000962763905379
Gc21_753 0 n42 ns753 0 -0.00179574355876
Gc21_754 0 n42 ns754 0 -0.00121889346892
Gc21_755 0 n42 ns755 0 -0.00384343385516
Gc21_756 0 n42 ns756 0 -9.0317302062e-05
Gc21_757 0 n42 ns757 0 0.00312110722195
Gc21_758 0 n42 ns758 0 4.18578042907e-05
Gc21_759 0 n42 ns759 0 -0.00013208265797
Gc21_760 0 n42 ns760 0 1.49253137169e-05
Gc21_761 0 n42 ns761 0 3.67016074756e-05
Gc21_762 0 n42 ns762 0 -0.00187329930298
Gc21_763 0 n42 ns763 0 -0.00242412789124
Gc21_764 0 n42 ns764 0 0.000828813640204
Gc21_765 0 n42 ns765 0 -0.000898457851251
Gc21_766 0 n42 ns766 0 0.000425862176426
Gc21_767 0 n42 ns767 0 0.000565966650635
Gc21_768 0 n42 ns768 0 -0.000359883185421
Gc21_769 0 n42 ns769 0 0.000132670829706
Gc21_770 0 n42 ns770 0 0.00051670859219
Gc21_771 0 n42 ns771 0 0.000294065729809
Gc21_772 0 n42 ns772 0 -8.26603998662e-06
Gc21_773 0 n42 ns773 0 -0.000576249850418
Gc21_774 0 n42 ns774 0 -0.000688291475063
Gc21_775 0 n42 ns775 0 0.00035876377407
Gc21_776 0 n42 ns776 0 0.000130299347165
Gc21_777 0 n42 ns777 0 0.000405167870249
Gc21_778 0 n42 ns778 0 -0.000152827767075
Gc21_779 0 n42 ns779 0 -0.000357925711131
Gc21_780 0 n42 ns780 0 -0.000986257827416
Gc21_781 0 n42 ns781 0 -0.000810049583937
Gc21_782 0 n42 ns782 0 0.00026898526266
Gc21_783 0 n42 ns783 0 0.00647180211674
Gc21_784 0 n42 ns784 0 0.00494411793568
Gc21_785 0 n42 ns785 0 0.00482737750387
Gc21_786 0 n42 ns786 0 0.00502227742507
Gc21_787 0 n42 ns787 0 0.000918940055842
Gc21_788 0 n42 ns788 0 0.00567465147431
Gc21_789 0 n42 ns789 0 0.000895596175558
Gc21_790 0 n42 ns790 0 -0.000839208273001
Gc21_791 0 n42 ns791 0 -0.00603565712296
Gc21_792 0 n42 ns792 0 -0.00166414593538
Gc21_793 0 n42 ns793 0 0.00277344330799
Gc21_794 0 n42 ns794 0 -0.00439788172752
Gc21_795 0 n42 ns795 0 0.0047472480547
Gc21_796 0 n42 ns796 0 -1.77509758413e-05
Gc21_797 0 n42 ns797 0 0.000109004501454
Gc21_798 0 n42 ns798 0 -0.000124543225711
Gc21_799 0 n42 ns799 0 0.000264105173104
Gc21_800 0 n42 ns800 0 -0.00187954110119
Gc21_801 0 n42 ns801 0 0.000500415116315
Gc21_802 0 n42 ns802 0 -7.8519685721e-05
Gc21_803 0 n42 ns803 0 -0.000917600362722
Gc21_804 0 n42 ns804 0 0.000410378275101
Gc21_805 0 n42 ns805 0 0.000395327850103
Gc21_806 0 n42 ns806 0 -0.000535882177099
Gc21_807 0 n42 ns807 0 0.000368198845487
Gc21_808 0 n42 ns808 0 0.000458781231393
Gc21_809 0 n42 ns809 0 0.000262121797632
Gc21_810 0 n42 ns810 0 -5.123083702e-05
Gc21_811 0 n42 ns811 0 -0.000429430532127
Gc21_812 0 n42 ns812 0 -0.000138313685627
Gc21_813 0 n42 ns813 0 0.000680366572439
Gc21_814 0 n42 ns814 0 -0.000954200280202
Gc21_815 0 n42 ns815 0 0.000869607385386
Gc21_816 0 n42 ns816 0 -0.000434309595074
Gc21_817 0 n42 ns817 0 0.000501174279633
Gc21_818 0 n42 ns818 0 -0.000920350710553
Gc21_819 0 n42 ns819 0 0.000881972162279
Gc21_820 0 n42 ns820 0 0.00219989440211
Gc21_821 0 n42 ns821 0 0.00252970016432
Gc21_822 0 n42 ns822 0 0.0044262134771
Gc21_823 0 n42 ns823 0 0.00189842979423
Gc21_824 0 n42 ns824 0 0.00460200764772
Gc21_825 0 n42 ns825 0 0.0036495661141
Gc21_826 0 n42 ns826 0 0.000702074008929
Gc21_827 0 n42 ns827 0 0.000867434952503
Gc21_828 0 n42 ns828 0 -0.00101242780491
Gc21_829 0 n42 ns829 0 -0.00196917961826
Gc21_830 0 n42 ns830 0 -0.00154212952652
Gc21_831 0 n42 ns831 0 -0.00390060993842
Gc21_832 0 n42 ns832 0 -0.000570444089617
Gc21_833 0 n42 ns833 0 0.00300451081467
Gc21_834 0 n42 ns834 0 5.63073564062e-05
Gc21_835 0 n42 ns835 0 -0.0001770120164
Gc21_836 0 n42 ns836 0 3.86671306102e-05
Gc21_837 0 n42 ns837 0 1.69350048068e-05
Gc21_838 0 n42 ns838 0 -0.00057812021719
Gc21_839 0 n42 ns839 0 0.000194528608866
Gc21_840 0 n42 ns840 0 -0.000231266060823
Gc21_841 0 n42 ns841 0 -0.0003662704966
Gc21_842 0 n42 ns842 0 0.000368324417111
Gc21_843 0 n42 ns843 0 3.19307024156e-05
Gc21_844 0 n42 ns844 0 -0.000111182036233
Gc21_845 0 n42 ns845 0 0.000302223654525
Gc21_846 0 n42 ns846 0 -0.00013977975071
Gc21_847 0 n42 ns847 0 0.000178088748906
Gc21_848 0 n42 ns848 0 -6.52568552345e-05
Gc21_849 0 n42 ns849 0 7.40017432393e-05
Gc21_850 0 n42 ns850 0 -0.000251225646517
Gc21_851 0 n42 ns851 0 -0.000762481145026
Gc21_852 0 n42 ns852 0 -0.000280494831629
Gc21_853 0 n42 ns853 0 0.000258522891168
Gc21_854 0 n42 ns854 0 -0.000502483729178
Gc21_855 0 n42 ns855 0 -0.000261791395389
Gc21_856 0 n42 ns856 0 -0.000868881084581
Gc21_857 0 n42 ns857 0 0.00114898210921
Gc21_858 0 n42 ns858 0 -0.000808941504279
Gc21_859 0 n42 ns859 0 0.00194546225439
Gc21_860 0 n42 ns860 0 0.00270398724098
Gc21_861 0 n42 ns861 0 0.00180669569329
Gc21_862 0 n42 ns862 0 0.00304185038819
Gc21_863 0 n42 ns863 0 -0.00146364523965
Gc21_864 0 n42 ns864 0 -0.00162128226472
Gc21_865 0 n42 ns865 0 0.000440624051088
Gc21_866 0 n42 ns866 0 -0.00101813068615
Gc21_867 0 n42 ns867 0 0.000393679804366
Gc21_868 0 n42 ns868 0 -0.00054104771182
Gc21_869 0 n42 ns869 0 -0.00137834127415
Gc21_870 0 n42 ns870 0 0.00288773326271
Gc21_871 0 n42 ns871 0 0.00157529660879
Gc21_872 0 n42 ns872 0 1.99035518118e-05
Gc21_873 0 n42 ns873 0 -0.000178093778144
Gc21_874 0 n42 ns874 0 4.91705812262e-05
Gc21_875 0 n42 ns875 0 8.49587232033e-05
Gc21_876 0 n42 ns876 0 -0.000244192301558
Gc21_877 0 n42 ns877 0 0.000503105459189
Gc21_878 0 n42 ns878 0 0.000497547353713
Gc21_879 0 n42 ns879 0 0.000183353582786
Gc21_880 0 n42 ns880 0 -2.30500071318e-05
Gc21_881 0 n42 ns881 0 1.88043115576e-05
Gc21_882 0 n42 ns882 0 4.07298330344e-05
Gc21_883 0 n42 ns883 0 -0.000236174089858
Gc21_884 0 n42 ns884 0 -9.89993943041e-05
Gc21_885 0 n42 ns885 0 0.000132865544976
Gc21_886 0 n42 ns886 0 -0.000143226583985
Gc21_887 0 n42 ns887 0 -0.000255121881075
Gc21_888 0 n42 ns888 0 -0.000231724064326
Gc21_889 0 n42 ns889 0 0.000249117314151
Gc21_890 0 n42 ns890 0 0.000448198130644
Gc21_891 0 n42 ns891 0 0.000302090375637
Gc21_892 0 n42 ns892 0 -0.000531916595972
Gc21_893 0 n42 ns893 0 -0.000106371210422
Gc21_894 0 n42 ns894 0 -0.000504649814897
Gc21_895 0 n42 ns895 0 -0.000380822152777
Gc21_896 0 n42 ns896 0 -0.000186771027312
Gc21_897 0 n42 ns897 0 0.00278417512965
Gc21_898 0 n42 ns898 0 0.003878206477
Gc21_899 0 n42 ns899 0 0.00279494657692
Gc21_900 0 n42 ns900 0 0.00361221284057
Gc21_901 0 n42 ns901 0 -0.00113479557729
Gc21_902 0 n42 ns902 0 0.000683480575606
Gc21_903 0 n42 ns903 0 -0.000128051686458
Gc21_904 0 n42 ns904 0 -0.00080708825965
Gc21_905 0 n42 ns905 0 -0.000459928232654
Gc21_906 0 n42 ns906 0 -0.00146237935722
Gc21_907 0 n42 ns907 0 -0.000658873598753
Gc21_908 0 n42 ns908 0 0.000782986083622
Gc21_909 0 n42 ns909 0 0.000522553783751
Gc21_910 0 n42 ns910 0 2.07446583398e-05
Gc21_911 0 n42 ns911 0 -0.000138013830677
Gc21_912 0 n42 ns912 0 2.28069629839e-05
Gc21_913 0 n42 ns913 0 -4.67970342628e-07
Gc21_914 0 n42 ns914 0 -1.53292578071e-05
Gc21_915 0 n42 ns915 0 -4.31059174436e-05
Gc21_916 0 n42 ns916 0 0.0010594338256
Gc21_917 0 n42 ns917 0 0.000119074849301
Gc21_918 0 n42 ns918 0 0.000140502921267
Gc21_919 0 n42 ns919 0 -0.000175092142266
Gc21_920 0 n42 ns920 0 -0.000187749038741
Gc21_921 0 n42 ns921 0 -0.000433954626639
Gc21_922 0 n42 ns922 0 0.000241039465244
Gc21_923 0 n42 ns923 0 9.75070926879e-05
Gc21_924 0 n42 ns924 0 -0.000124816658932
Gc21_925 0 n42 ns925 0 0.000196852749141
Gc21_926 0 n42 ns926 0 -0.000163564712078
Gc21_927 0 n42 ns927 0 0.00118078034688
Gc21_928 0 n42 ns928 0 -0.000251591270722
Gc21_929 0 n42 ns929 0 0.000491494507199
Gc21_930 0 n42 ns930 0 -0.000720934696598
Gc21_931 0 n42 ns931 0 0.000602466696963
Gc21_932 0 n42 ns932 0 -0.000603335270469
Gc21_933 0 n42 ns933 0 -0.000298162424524
Gc21_934 0 n42 ns934 0 0.00113985734261
Gc21_935 0 n42 ns935 0 0.00322328992652
Gc21_936 0 n42 ns936 0 0.0040877642323
Gc21_937 0 n42 ns937 0 0.00306683817788
Gc21_938 0 n42 ns938 0 0.00345412524997
Gc21_939 0 n42 ns939 0 0.00034808605768
Gc21_940 0 n42 ns940 0 0.00124999430527
Gc21_941 0 n42 ns941 0 -0.000284592671178
Gc21_942 0 n42 ns942 0 -0.000474314005647
Gc21_943 0 n42 ns943 0 -0.00113891987407
Gc21_944 0 n42 ns944 0 -0.00140609109581
Gc21_945 0 n42 ns945 0 -0.000546015796266
Gc21_946 0 n42 ns946 0 -0.000632738442647
Gc21_947 0 n42 ns947 0 2.69258473064e-05
Gc21_948 0 n42 ns948 0 -7.37555371818e-07
Gc21_949 0 n42 ns949 0 -9.87817250671e-05
Gc21_950 0 n42 ns950 0 6.06782605593e-06
Gc21_951 0 n42 ns951 0 -2.9876760466e-05
Gc21_952 0 n42 ns952 0 -0.000283799328756
Gc21_953 0 n42 ns953 0 7.78766477495e-05
Gc21_954 0 n42 ns954 0 0.000399701256733
Gc21_955 0 n42 ns955 0 0.000181251604703
Gc21_956 0 n42 ns956 0 0.00031487841486
Gc21_957 0 n42 ns957 0 -0.000181236490105
Gc21_958 0 n42 ns958 0 -3.82647897146e-05
Gc21_959 0 n42 ns959 0 -8.52300984224e-05
Gc21_960 0 n42 ns960 0 -0.000331600513351
Gc21_961 0 n42 ns961 0 0.000165672994358
Gc21_962 0 n42 ns962 0 -6.95716605427e-05
Gc21_963 0 n42 ns963 0 9.43640609237e-05
Gc21_964 0 n42 ns964 0 -0.000208222662577
Gc21_965 0 n42 ns965 0 -0.000297215206225
Gc21_966 0 n42 ns966 0 0.000305903252494
Gc21_967 0 n42 ns967 0 0.000409868014522
Gc21_968 0 n42 ns968 0 -0.000477739213656
Gc21_969 0 n42 ns969 0 -7.30623380919e-05
Gc21_970 0 n42 ns970 0 -0.000682533605532
Gc21_971 0 n42 ns971 0 0.000289601307666
Gc21_972 0 n42 ns972 0 -0.000838239499623
Gc21_973 0 n42 ns973 0 0.0017713138681
Gc21_974 0 n42 ns974 0 0.00383115585604
Gc21_975 0 n42 ns975 0 0.00180714322734
Gc21_976 0 n42 ns976 0 0.00388791801371
Gc21_977 0 n42 ns977 0 -0.00202289300387
Gc21_978 0 n42 ns978 0 -0.000729344930195
Gc21_979 0 n42 ns979 0 0.000260093703118
Gc21_980 0 n42 ns980 0 -0.00100813635458
Gc21_981 0 n42 ns981 0 0.000454710599304
Gc21_982 0 n42 ns982 0 -0.00107180783024
Gc21_983 0 n42 ns983 0 -0.000912572591698
Gc21_984 0 n42 ns984 0 0.00216272602948
Gc21_985 0 n42 ns985 0 0.00109800648377
Gc21_986 0 n42 ns986 0 2.91373660507e-05
Gc21_987 0 n42 ns987 0 -0.000230310375553
Gc21_988 0 n42 ns988 0 8.26361645479e-05
Gc21_989 0 n42 ns989 0 0.000460317851031
Gc21_990 0 n42 ns990 0 -0.00188856643416
Gc21_991 0 n42 ns991 0 0.00112152188479
Gc21_992 0 n42 ns992 0 -0.00153685885098
Gc21_993 0 n42 ns993 0 -0.000786586494015
Gc21_994 0 n42 ns994 0 -7.31340952325e-05
Gc21_995 0 n42 ns995 0 0.000170909275057
Gc21_996 0 n42 ns996 0 -0.000221916576381
Gc21_997 0 n42 ns997 0 0.000271540377579
Gc21_998 0 n42 ns998 0 0.000153965899001
Gc21_999 0 n42 ns999 0 0.000191253909428
Gc21_1000 0 n42 ns1000 0 -2.79080397186e-05
Gc21_1001 0 n42 ns1001 0 4.12009614019e-05
Gc21_1002 0 n42 ns1002 0 0.000413842265124
Gc21_1003 0 n42 ns1003 0 0.000160689830616
Gc21_1004 0 n42 ns1004 0 -0.000907430480502
Gc21_1005 0 n42 ns1005 0 0.000679133810494
Gc21_1006 0 n42 ns1006 0 -0.00047832668768
Gc21_1007 0 n42 ns1007 0 0.000326140538741
Gc21_1008 0 n42 ns1008 0 -0.000793306783301
Gc21_1009 0 n42 ns1009 0 0.00162958284942
Gc21_1010 0 n42 ns1010 0 0.00115080839989
Gc21_1011 0 n42 ns1011 0 0.00239713479508
Gc21_1012 0 n42 ns1012 0 0.0037732364782
Gc21_1013 0 n42 ns1013 0 0.00192915582151
Gc21_1014 0 n42 ns1014 0 0.00400813308651
Gc21_1015 0 n42 ns1015 0 0.00146892365169
Gc21_1016 0 n42 ns1016 0 -0.00202849212254
Gc21_1017 0 n42 ns1017 0 0.000861818986663
Gc21_1018 0 n42 ns1018 0 -0.000920773332233
Gc21_1019 0 n42 ns1019 0 -0.000364924482305
Gc21_1020 0 n42 ns1020 0 -0.000260643445004
Gc21_1021 0 n42 ns1021 0 -0.00322182779914
Gc21_1022 0 n42 ns1022 0 0.00260591304236
Gc21_1023 0 n42 ns1023 0 0.00268783454866
Gc21_1024 0 n42 ns1024 0 2.83563342072e-05
Gc21_1025 0 n42 ns1025 0 -0.000118187205334
Gc21_1026 0 n42 ns1026 0 1.76143873961e-05
Gc21_1027 0 n42 ns1027 0 0.000708929340417
Gc21_1028 0 n42 ns1028 0 -0.0038033887835
Gc21_1029 0 n42 ns1029 0 -0.00115477073459
Gc21_1030 0 n42 ns1030 0 -0.00139430379273
Gc21_1031 0 n42 ns1031 0 -0.00125315121188
Gc21_1032 0 n42 ns1032 0 -6.57754413887e-05
Gc21_1033 0 n42 ns1033 0 0.000708452235357
Gc21_1034 0 n42 ns1034 0 -0.000148745638703
Gc21_1035 0 n42 ns1035 0 0.000126152131479
Gc21_1036 0 n42 ns1036 0 0.000525322851895
Gc21_1037 0 n42 ns1037 0 0.000278392381817
Gc21_1038 0 n42 ns1038 0 -1.39937342174e-05
Gc21_1039 0 n42 ns1039 0 -0.00041552691343
Gc21_1040 0 n42 ns1040 0 -0.000461374170702
Gc21_1041 0 n42 ns1041 0 5.98210390481e-05
Gc21_1042 0 n42 ns1042 0 -6.78479627258e-05
Gc21_1043 0 n42 ns1043 0 0.000340242193515
Gc21_1044 0 n42 ns1044 0 -0.000277525615956
Gc21_1045 0 n42 ns1045 0 -0.000366603988374
Gc21_1046 0 n42 ns1046 0 -0.00115072588973
Gc21_1047 0 n42 ns1047 0 -0.000297643359084
Gc21_1048 0 n42 ns1048 0 5.20811230891e-05
Gc21_1049 0 n42 ns1049 0 0.00642037496215
Gc21_1050 0 n42 ns1050 0 0.0058668781323
Gc21_1051 0 n42 ns1051 0 0.00479170066294
Gc21_1052 0 n42 ns1052 0 0.00575876573986
Gc21_1053 0 n42 ns1053 0 0.000532353920547
Gc21_1054 0 n42 ns1054 0 0.00533885085974
Gc21_1055 0 n42 ns1055 0 0.000838326678174
Gc21_1056 0 n42 ns1056 0 -0.000897198020081
Gc21_1057 0 n42 ns1057 0 -0.00629155503468
Gc21_1058 0 n42 ns1058 0 -0.00185710603594
Gc21_1059 0 n42 ns1059 0 0.00332862463849
Gc21_1060 0 n42 ns1060 0 -0.00500438237812
Gc21_1061 0 n42 ns1061 0 0.00460371935804
Gc21_1062 0 n42 ns1062 0 -1.64325482829e-05
Gc21_1063 0 n42 ns1063 0 5.24183741371e-05
Gc21_1064 0 n42 ns1064 0 -8.9478531071e-05
Gc21_1065 0 n42 ns1065 0 0.00119992555263
Gc21_1066 0 n42 ns1066 0 -0.00436696638899
Gc21_1067 0 n42 ns1067 0 0.00157840060441
Gc21_1068 0 n42 ns1068 0 -0.00255236050119
Gc21_1069 0 n42 ns1069 0 -0.00119692016884
Gc21_1070 0 n42 ns1070 0 -0.00045575974184
Gc21_1071 0 n42 ns1071 0 0.000649038786531
Gc21_1072 0 n42 ns1072 0 -0.000178573156825
Gc21_1073 0 n42 ns1073 0 0.000225157649035
Gc21_1074 0 n42 ns1074 0 0.00056423940904
Gc21_1075 0 n42 ns1075 0 0.000261190787371
Gc21_1076 0 n42 ns1076 0 -4.77646715031e-05
Gc21_1077 0 n42 ns1077 0 -0.000635217867071
Gc21_1078 0 n42 ns1078 0 7.34169742845e-05
Gc21_1079 0 n42 ns1079 0 0.000482616042874
Gc21_1080 0 n42 ns1080 0 -0.0008475870353
Gc21_1081 0 n42 ns1081 0 0.000650726620602
Gc21_1082 0 n42 ns1082 0 -0.000477359823684
Gc21_1083 0 n42 ns1083 0 0.000147055756299
Gc21_1084 0 n42 ns1084 0 -0.00121545450367
Gc21_1085 0 n42 ns1085 0 0.00100054927448
Gc21_1086 0 n42 ns1086 0 0.00169208805456
Gc21_1087 0 n42 ns1087 0 0.00541192092896
Gc21_1088 0 n42 ns1088 0 0.00556494323563
Gc21_1089 0 n42 ns1089 0 0.00407992621517
Gc21_1090 0 n42 ns1090 0 0.00553184224593
Gc21_1091 0 n42 ns1091 0 0.00284777646826
Gc21_1092 0 n42 ns1092 0 0.00221657800582
Gc21_1093 0 n42 ns1093 0 0.000896532822422
Gc21_1094 0 n42 ns1094 0 -0.000962870557895
Gc21_1095 0 n42 ns1095 0 -0.0042489290373
Gc21_1096 0 n42 ns1096 0 -0.00147372292875
Gc21_1097 0 n42 ns1097 0 -0.000687449440554
Gc21_1098 0 n42 ns1098 0 -0.0026710906013
Gc21_1099 0 n42 ns1099 0 0.00368742350185
Gc21_1100 0 n42 ns1100 0 3.40409081157e-05
Gc21_1101 0 n42 ns1101 0 -0.000150304661975
Gc21_1102 0 n42 ns1102 0 2.90694041826e-05
Gc21_1103 0 n42 ns1103 0 0.000359747827485
Gc21_1104 0 n42 ns1104 0 -0.00148082177792
Gc21_1105 0 n42 ns1105 0 0.00108351207523
Gc21_1106 0 n42 ns1106 0 -0.00113098100783
Gc21_1107 0 n42 ns1107 0 -0.000604485696094
Gc21_1108 0 n42 ns1108 0 0.000185896914174
Gc21_1109 0 n42 ns1109 0 8.55681256922e-05
Gc21_1110 0 n42 ns1110 0 -0.000174540744603
Gc21_1111 0 n42 ns1111 0 0.000426407982965
Gc21_1112 0 n42 ns1112 0 3.63251998547e-05
Gc21_1113 0 n42 ns1113 0 0.000196161671656
Gc21_1114 0 n42 ns1114 0 -5.2091297417e-05
Gc21_1115 0 n42 ns1115 0 -5.00054201889e-05
Gc21_1116 0 n42 ns1116 0 -2.13340279538e-05
Gc21_1117 0 n42 ns1117 0 -0.00064492167854
Gc21_1118 0 n42 ns1118 0 -0.000800952121645
Gc21_1119 0 n42 ns1119 0 0.000372950888172
Gc21_1120 0 n42 ns1120 0 -0.000566748768864
Gc21_1121 0 n42 ns1121 0 -0.00014258704724
Gc21_1122 0 n42 ns1122 0 -0.00108169785267
Gc21_1123 0 n42 ns1123 0 0.00177443074162
Gc21_1124 0 n42 ns1124 0 -0.000117242581155
Gc21_1125 0 n42 ns1125 0 0.00254812619564
Gc21_1126 0 n42 ns1126 0 0.00276638708193
Gc21_1127 0 n42 ns1127 0 0.0021646906926
Gc21_1128 0 n42 ns1128 0 0.00320087746094
Gc21_1129 0 n42 ns1129 0 -0.000234641770862
Gc21_1130 0 n42 ns1130 0 -0.0018808155827
Gc21_1131 0 n42 ns1131 0 0.000657659567933
Gc21_1132 0 n42 ns1132 0 -0.00104497699312
Gc21_1133 0 n42 ns1133 0 7.53474256129e-05
Gc21_1134 0 n42 ns1134 0 -0.000495695442448
Gc21_1135 0 n42 ns1135 0 -0.00215463224947
Gc21_1136 0 n42 ns1136 0 0.00246731127937
Gc21_1137 0 n42 ns1137 0 0.00201945536704
Gc21_1138 0 n42 ns1138 0 9.02114573149e-06
Gc21_1139 0 n42 ns1139 0 -0.000162901984087
Gc21_1140 0 n42 ns1140 0 3.0281268799e-05
Gc21_1141 0 n42 ns1141 0 -6.58708279771e-05
Gc21_1142 0 n42 ns1142 0 -7.77299785214e-05
Gc21_1143 0 n42 ns1143 0 0.000101953271031
Gc21_1144 0 n42 ns1144 0 0.000377793683181
Gc21_1145 0 n42 ns1145 0 8.74283048441e-05
Gc21_1146 0 n42 ns1146 0 9.93490872003e-05
Gc21_1147 0 n42 ns1147 0 3.12903663901e-05
Gc21_1148 0 n42 ns1148 0 8.90871885468e-05
Gc21_1149 0 n42 ns1149 0 -5.33450716887e-05
Gc21_1150 0 n42 ns1150 0 -0.00020222692531
Gc21_1151 0 n42 ns1151 0 0.000167219451382
Gc21_1152 0 n42 ns1152 0 -0.000112592956636
Gc21_1153 0 n42 ns1153 0 -0.00019696383559
Gc21_1154 0 n42 ns1154 0 -0.00031847088559
Gc21_1155 0 n42 ns1155 0 -0.000307684166917
Gc21_1156 0 n42 ns1156 0 0.0005001112397
Gc21_1157 0 n42 ns1157 0 0.000232634128767
Gc21_1158 0 n42 ns1158 0 -0.000424893798689
Gc21_1159 0 n42 ns1159 0 -0.00034638809106
Gc21_1160 0 n42 ns1160 0 -0.000503595311639
Gc21_1161 0 n42 ns1161 0 -9.76557948883e-05
Gc21_1162 0 n42 ns1162 0 -0.000809869061571
Gc21_1163 0 n42 ns1163 0 0.00224105218005
Gc21_1164 0 n42 ns1164 0 0.0032490745182
Gc21_1165 0 n42 ns1165 0 0.00229863853532
Gc21_1166 0 n42 ns1166 0 0.0032692983506
Gc21_1167 0 n42 ns1167 0 -0.00174421370396
Gc21_1168 0 n42 ns1168 0 -5.3251971177e-05
Gc21_1169 0 n42 ns1169 0 4.4118319104e-05
Gc21_1170 0 n42 ns1170 0 -0.000905544479669
Gc21_1171 0 n42 ns1171 0 3.50832242893e-05
Gc21_1172 0 n42 ns1172 0 -0.00112782119622
Gc21_1173 0 n42 ns1173 0 -0.00070949842201
Gc21_1174 0 n42 ns1174 0 0.00171909243301
Gc21_1175 0 n42 ns1175 0 0.000859894024055
Gc21_1176 0 n42 ns1176 0 1.9671074938e-05
Gc21_1177 0 n42 ns1177 0 -0.000157863068441
Gc21_1178 0 n42 ns1178 0 2.59794425099e-05
Gc21_1179 0 n42 ns1179 0 -0.000108991946889
Gc21_1180 0 n42 ns1180 0 -0.000149312901803
Gc21_1181 0 n42 ns1181 0 -0.000260214380198
Gc21_1182 0 n42 ns1182 0 0.000687513093932
Gc21_1183 0 n42 ns1183 0 4.19454816046e-05
Gc21_1184 0 n42 ns1184 0 -1.9148778895e-05
Gc21_1185 0 n42 ns1185 0 -5.48324333479e-05
Gc21_1186 0 n42 ns1186 0 -8.71998933569e-05
Gc21_1187 0 n42 ns1187 0 -0.000513810568555
Gc21_1188 0 n42 ns1188 0 0.000170294853483
Gc21_1189 0 n42 ns1189 0 0.000123576430219
Gc21_1190 0 n42 ns1190 0 -0.000134263022923
Gc21_1191 0 n42 ns1191 0 0.000170600469195
Gc21_1192 0 n42 ns1192 0 -0.000111392150205
Gc21_1193 0 n42 ns1193 0 0.00113952059205
Gc21_1194 0 n42 ns1194 0 7.59190406022e-05
Gc21_1195 0 n42 ns1195 0 0.000522236768767
Gc21_1196 0 n42 ns1196 0 -0.000670304976247
Gc21_1197 0 n42 ns1197 0 0.000481317998025
Gc21_1198 0 n42 ns1198 0 -0.000483078878631
Gc21_1199 0 n42 ns1199 0 -0.000530218426397
Gc21_1200 0 n42 ns1200 0 0.000857068307566
Gc21_1201 0 n42 ns1201 0 0.00325211386122
Gc21_1202 0 n42 ns1202 0 0.00437283868996
Gc21_1203 0 n42 ns1203 0 0.00317221910919
Gc21_1204 0 n42 ns1204 0 0.00378280621627
Gc21_1205 0 n42 ns1205 0 -9.8335764958e-05
Gc21_1206 0 n42 ns1206 0 0.0012173599661
Gc21_1207 0 n42 ns1207 0 -0.000275896134322
Gc21_1208 0 n42 ns1208 0 -0.000582265191674
Gc21_1209 0 n42 ns1209 0 -0.00100280907998
Gc21_1210 0 n42 ns1210 0 -0.00146108952367
Gc21_1211 0 n42 ns1211 0 -0.000588944816188
Gc21_1212 0 n42 ns1212 0 -0.000148505870024
Gc21_1213 0 n42 ns1213 0 0.000195604551669
Gc21_1214 0 n42 ns1214 0 1.7801753037e-06
Gc21_1215 0 n42 ns1215 0 -6.79033048871e-05
Gc21_1216 0 n42 ns1216 0 -1.33944795147e-05
Gd21_1 0 n42 ni1 0 -0.000335965874397
Gd21_2 0 n42 ni2 0 -0.000215365063623
Gd21_3 0 n42 ni3 0 0.000802376701402
Gd21_4 0 n42 ni4 0 -0.000269881947599
Gd21_5 0 n42 ni5 0 5.56899222567e-05
Gd21_6 0 n42 ni6 0 -1.6103114705e-05
Gd21_7 0 n42 ni7 0 -0.000298047258725
Gd21_8 0 n42 ni8 0 0.000713002383742
Gd21_9 0 n42 ni9 0 8.44032322197e-05
Gd21_10 0 n42 ni10 0 0.000339511598198
Gd21_11 0 n42 ni11 0 0.000643994689866
Gd21_12 0 n42 ni12 0 -0.00397297041016
Gd21_13 0 n42 ni13 0 -0.0018332534676
Gd21_14 0 n42 ni14 0 -0.000201154139943
Gd21_15 0 n42 ni15 0 5.14066191363e-05
Gd21_16 0 n42 ni16 0 0.000210700538125
Gd21_17 0 n42 ni17 0 1.22883209351e-05
Gd21_18 0 n42 ni18 0 0.000247326809794
Gd21_19 0 n42 ni19 0 -0.00057298465904
Gd21_20 0 n42 ni20 0 -0.00147900205933
Gd21_21 0 n42 ni21 0 0.00149730610551
Gd21_22 0 n42 ni22 0 -0.0014235747204
Gd21_23 0 n42 ni23 0 -0.000252524149474
Gd21_24 0 n42 ni24 0 6.86595802184e-05
Gd21_25 0 n42 ni25 0 0.000192643515737
Gd21_26 0 n42 ni26 0 0.0001307803119
Gd21_27 0 n42 ni27 0 -0.0015731627197
Gd21_28 0 n42 ni28 0 -0.000524208433136
Gd21_29 0 n42 ni29 0 -0.00287063834239
Gd21_30 0 n42 ni30 0 -0.00124192231957
Gd21_31 0 n42 ni31 0 0.000274423186976
Gd21_32 0 n42 ni32 0 0.000195561890158
Gc22_1 0 n44 ns1 0 -0.000267678027436
Gc22_2 0 n44 ns2 0 0.000533711312286
Gc22_3 0 n44 ns3 0 -0.000530986761314
Gc22_4 0 n44 ns4 0 0.000782943524548
Gc22_5 0 n44 ns5 0 -7.4535620938e-05
Gc22_6 0 n44 ns6 0 0.000349587154422
Gc22_7 0 n44 ns7 0 0.000159876469793
Gc22_8 0 n44 ns8 0 -0.000194839832811
Gc22_9 0 n44 ns9 0 0.000274917112189
Gc22_10 0 n44 ns10 0 -0.000416354108926
Gc22_11 0 n44 ns11 0 -6.53802718297e-05
Gc22_12 0 n44 ns12 0 0.000147570007322
Gc22_13 0 n44 ns13 0 0.000256276809917
Gc22_14 0 n44 ns14 0 0.000347855855154
Gc22_15 0 n44 ns15 0 0.000738667059719
Gc22_16 0 n44 ns16 0 -0.000500229152103
Gc22_17 0 n44 ns17 0 5.85782807351e-05
Gc22_18 0 n44 ns18 0 -0.000713527077106
Gc22_19 0 n44 ns19 0 1.57002812059e-05
Gc22_20 0 n44 ns20 0 -0.000729776586842
Gc22_21 0 n44 ns21 0 -0.000115806074993
Gc22_22 0 n44 ns22 0 -0.000478169585631
Gc22_23 0 n44 ns23 0 -0.00445191874318
Gc22_24 0 n44 ns24 0 -0.00180856100318
Gc22_25 0 n44 ns25 0 -0.00399445342007
Gc22_26 0 n44 ns26 0 -0.00150274795569
Gc22_27 0 n44 ns27 0 0.000225056280941
Gc22_28 0 n44 ns28 0 0.00146127336451
Gc22_29 0 n44 ns29 0 -0.000284627431898
Gc22_30 0 n44 ns30 0 -0.000409832465776
Gc22_31 0 n44 ns31 0 -0.000982009628757
Gc22_32 0 n44 ns32 0 -0.00130316928805
Gc22_33 0 n44 ns33 0 -0.000114415505756
Gc22_34 0 n44 ns34 0 -0.00071526099746
Gc22_35 0 n44 ns35 0 -0.000239690685899
Gc22_36 0 n44 ns36 0 -2.76977499632e-06
Gc22_37 0 n44 ns37 0 4.57548277999e-05
Gc22_38 0 n44 ns38 0 1.94662807015e-05
Gc22_39 0 n44 ns39 0 -0.000170700823074
Gc22_40 0 n44 ns40 0 0.000159461203727
Gc22_41 0 n44 ns41 0 -0.000186723626518
Gc22_42 0 n44 ns42 0 0.000568828590332
Gc22_43 0 n44 ns43 0 -9.26196978906e-05
Gc22_44 0 n44 ns44 0 0.000267285809093
Gc22_45 0 n44 ns45 0 0.000148085776619
Gc22_46 0 n44 ns46 0 -0.000120317887828
Gc22_47 0 n44 ns47 0 0.000373962924987
Gc22_48 0 n44 ns48 0 -0.000362735605012
Gc22_49 0 n44 ns49 0 -8.21225100729e-05
Gc22_50 0 n44 ns50 0 0.000154112620524
Gc22_51 0 n44 ns51 0 0.000123282296981
Gc22_52 0 n44 ns52 0 0.00034615571003
Gc22_53 0 n44 ns53 0 0.00082124114851
Gc22_54 0 n44 ns54 0 -0.000339822169206
Gc22_55 0 n44 ns55 0 0.000138451108334
Gc22_56 0 n44 ns56 0 -0.000755814767318
Gc22_57 0 n44 ns57 0 6.06655154274e-05
Gc22_58 0 n44 ns58 0 -0.00072906294882
Gc22_59 0 n44 ns59 0 -8.08004515624e-05
Gc22_60 0 n44 ns60 0 -0.000484790569674
Gc22_61 0 n44 ns61 0 -0.00516353907241
Gc22_62 0 n44 ns62 0 -0.00254509882674
Gc22_63 0 n44 ns63 0 -0.00466819897671
Gc22_64 0 n44 ns64 0 -0.0021642165745
Gc22_65 0 n44 ns65 0 0.000182418839664
Gc22_66 0 n44 ns66 0 0.00185765617862
Gc22_67 0 n44 ns67 0 -0.000327509889659
Gc22_68 0 n44 ns68 0 -0.000538073216743
Gc22_69 0 n44 ns69 0 -0.00110123224779
Gc22_70 0 n44 ns70 0 -0.00177395058684
Gc22_71 0 n44 ns71 0 -0.000139049712989
Gc22_72 0 n44 ns72 0 -0.00123231747197
Gc22_73 0 n44 ns73 0 -0.000371191228088
Gc22_74 0 n44 ns74 0 3.13980841368e-07
Gc22_75 0 n44 ns75 0 5.05872331295e-05
Gc22_76 0 n44 ns76 0 1.21948141397e-05
Gc22_77 0 n44 ns77 0 -7.24565998365e-05
Gc22_78 0 n44 ns78 0 -0.000315282553752
Gc22_79 0 n44 ns79 0 -0.00019140573977
Gc22_80 0 n44 ns80 0 0.000246933733574
Gc22_81 0 n44 ns81 0 -0.000111844144845
Gc22_82 0 n44 ns82 0 2.26801254869e-05
Gc22_83 0 n44 ns83 0 -7.91018648678e-05
Gc22_84 0 n44 ns84 0 -8.35214530761e-06
Gc22_85 0 n44 ns85 0 0.000173381837998
Gc22_86 0 n44 ns86 0 0.000232445957166
Gc22_87 0 n44 ns87 0 -6.70480193416e-05
Gc22_88 0 n44 ns88 0 0.00012431177076
Gc22_89 0 n44 ns89 0 6.24463308711e-05
Gc22_90 0 n44 ns90 0 -0.000205718683602
Gc22_91 0 n44 ns91 0 0.000353071015878
Gc22_92 0 n44 ns92 0 0.000581544115246
Gc22_93 0 n44 ns93 0 0.000384083377228
Gc22_94 0 n44 ns94 0 -0.000300008343888
Gc22_95 0 n44 ns95 0 9.16911173565e-05
Gc22_96 0 n44 ns96 0 -6.16549207395e-05
Gc22_97 0 n44 ns97 0 -0.000101462763803
Gc22_98 0 n44 ns98 0 -2.54297774944e-05
Gc22_99 0 n44 ns99 0 -0.00418345357482
Gc22_100 0 n44 ns100 0 -0.00460053526185
Gc22_101 0 n44 ns101 0 -0.00394925448289
Gc22_102 0 n44 ns102 0 -0.00419401124662
Gc22_103 0 n44 ns103 0 -0.000650709378723
Gc22_104 0 n44 ns104 0 0.00182292033416
Gc22_105 0 n44 ns105 0 -0.000209299374154
Gc22_106 0 n44 ns106 0 -0.000926387293704
Gc22_107 0 n44 ns107 0 -0.000720047419836
Gc22_108 0 n44 ns108 0 -0.00243336538953
Gc22_109 0 n44 ns109 0 0.000143516095389
Gc22_110 0 n44 ns110 0 -0.00166257884413
Gc22_111 0 n44 ns111 0 -0.000612125073328
Gc22_112 0 n44 ns112 0 -1.7663474405e-05
Gc22_113 0 n44 ns113 0 7.72061209526e-05
Gc22_114 0 n44 ns114 0 1.47535456984e-06
Gc22_115 0 n44 ns115 0 -8.18978822879e-05
Gc22_116 0 n44 ns116 0 -6.26958506499e-05
Gc22_117 0 n44 ns117 0 0.000107235594605
Gc22_118 0 n44 ns118 0 0.00155400369916
Gc22_119 0 n44 ns119 0 0.000102279124779
Gc22_120 0 n44 ns120 0 0.00023245382711
Gc22_121 0 n44 ns121 0 2.98194977031e-06
Gc22_122 0 n44 ns122 0 -0.000227739161253
Gc22_123 0 n44 ns123 0 -0.000218858481017
Gc22_124 0 n44 ns124 0 0.000420044837207
Gc22_125 0 n44 ns125 0 -0.000105462714339
Gc22_126 0 n44 ns126 0 6.51315643738e-05
Gc22_127 0 n44 ns127 0 0.000606986718606
Gc22_128 0 n44 ns128 0 -0.000562110965677
Gc22_129 0 n44 ns129 0 -0.000462217983348
Gc22_130 0 n44 ns130 0 -0.000186574692967
Gc22_131 0 n44 ns131 0 0.00040950127061
Gc22_132 0 n44 ns132 0 -0.000338121437098
Gc22_133 0 n44 ns133 0 -6.75544780191e-05
Gc22_134 0 n44 ns134 0 -0.000493182687764
Gc22_135 0 n44 ns135 0 -0.000985130265593
Gc22_136 0 n44 ns136 0 0.00112257632822
Gc22_137 0 n44 ns137 0 -0.00258317443651
Gc22_138 0 n44 ns138 0 -0.00154758781973
Gc22_139 0 n44 ns139 0 -0.00236231566669
Gc22_140 0 n44 ns140 0 -0.0021070183654
Gc22_141 0 n44 ns141 0 0.000117858183284
Gc22_142 0 n44 ns142 0 0.00094788542441
Gc22_143 0 n44 ns143 0 0.000251497326563
Gc22_144 0 n44 ns144 0 -0.00132813258143
Gc22_145 0 n44 ns145 0 -0.000478599981218
Gc22_146 0 n44 ns146 0 -0.00299425591683
Gc22_147 0 n44 ns147 0 0.000915521720949
Gc22_148 0 n44 ns148 0 -0.00360356245937
Gc22_149 0 n44 ns149 0 -0.00164395816874
Gc22_150 0 n44 ns150 0 -2.58460458149e-05
Gc22_151 0 n44 ns151 0 0.000100729747393
Gc22_152 0 n44 ns152 0 6.68751071004e-07
Gc22_153 0 n44 ns153 0 -0.000917782666076
Gc22_154 0 n44 ns154 0 -0.000242738076705
Gc22_155 0 n44 ns155 0 -0.00335937205895
Gc22_156 0 n44 ns156 0 -0.00122124276698
Gc22_157 0 n44 ns157 0 -0.00189865056415
Gc22_158 0 n44 ns158 0 0.00130556053435
Gc22_159 0 n44 ns159 0 0.00082775214728
Gc22_160 0 n44 ns160 0 -0.000568327820961
Gc22_161 0 n44 ns161 0 -0.000298356235857
Gc22_162 0 n44 ns162 0 0.000198713685092
Gc22_163 0 n44 ns163 0 -0.000162554172421
Gc22_164 0 n44 ns164 0 -8.41642436884e-06
Gc22_165 0 n44 ns165 0 0.000466778641297
Gc22_166 0 n44 ns166 0 -8.14829302489e-05
Gc22_167 0 n44 ns167 0 0.00078653507996
Gc22_168 0 n44 ns168 0 -0.000959646060461
Gc22_169 0 n44 ns169 0 0.00101608166639
Gc22_170 0 n44 ns170 0 -0.000310643300561
Gc22_171 0 n44 ns171 0 0.000874656384947
Gc22_172 0 n44 ns172 0 -0.000594462551464
Gc22_173 0 n44 ns173 0 -0.00210405061386
Gc22_174 0 n44 ns174 0 -0.000570756547904
Gc22_175 0 n44 ns175 0 -0.00606217624374
Gc22_176 0 n44 ns176 0 -0.00180985253153
Gc22_177 0 n44 ns177 0 -0.00478753323847
Gc22_178 0 n44 ns178 0 -0.00242531939758
Gc22_179 0 n44 ns179 0 0.00398962214154
Gc22_180 0 n44 ns180 0 0.00228384228717
Gc22_181 0 n44 ns181 0 0.000776284539341
Gc22_182 0 n44 ns182 0 -0.00122803618811
Gc22_183 0 n44 ns183 0 -0.00251958441302
Gc22_184 0 n44 ns184 0 -0.00323317732623
Gc22_185 0 n44 ns185 0 0.00230988410572
Gc22_186 0 n44 ns186 0 -0.00119510819717
Gc22_187 0 n44 ns187 0 -0.00331754470906
Gc22_188 0 n44 ns188 0 -4.61042400883e-05
Gc22_189 0 n44 ns189 0 0.000359013713613
Gc22_190 0 n44 ns190 0 -0.000172617081647
Gc22_191 0 n44 ns191 0 3.82917454046e-05
Gc22_192 0 n44 ns192 0 -0.000720006640863
Gc22_193 0 n44 ns193 0 0.00189576700726
Gc22_194 0 n44 ns194 0 0.00171395588076
Gc22_195 0 n44 ns195 0 0.00165420231107
Gc22_196 0 n44 ns196 0 -0.00118208893018
Gc22_197 0 n44 ns197 0 -0.000561338278638
Gc22_198 0 n44 ns198 0 0.000135547321494
Gc22_199 0 n44 ns199 0 6.00905217211e-05
Gc22_200 0 n44 ns200 0 -2.48787590585e-05
Gc22_201 0 n44 ns201 0 -0.000141856791074
Gc22_202 0 n44 ns202 0 3.83499081886e-05
Gc22_203 0 n44 ns203 0 0.00189404098193
Gc22_204 0 n44 ns204 0 -0.000665694358681
Gc22_205 0 n44 ns205 0 -0.000646923331141
Gc22_206 0 n44 ns206 0 0.00133430490985
Gc22_207 0 n44 ns207 0 -0.000520785502863
Gc22_208 0 n44 ns208 0 8.42637786084e-05
Gc22_209 0 n44 ns209 0 -0.00223157632273
Gc22_210 0 n44 ns210 0 -0.00117213782966
Gc22_211 0 n44 ns211 0 0.00293304707398
Gc22_212 0 n44 ns212 0 0.00367993716926
Gc22_213 0 n44 ns213 0 -0.0105683486211
Gc22_214 0 n44 ns214 0 0.000563608270335
Gc22_215 0 n44 ns215 0 -0.00812583825083
Gc22_216 0 n44 ns216 0 -0.000740106731214
Gc22_217 0 n44 ns217 0 -0.0106120146543
Gc22_218 0 n44 ns218 0 -0.000233501058915
Gc22_219 0 n44 ns219 0 0.00141031570429
Gc22_220 0 n44 ns220 0 8.78253156491e-06
Gc22_221 0 n44 ns221 0 -0.00375329426445
Gc22_222 0 n44 ns222 0 0.0084095475211
Gc22_223 0 n44 ns223 0 -0.0143320208156
Gc22_224 0 n44 ns224 0 -0.00431559951991
Gc22_225 0 n44 ns225 0 -0.00628324249421
Gc22_226 0 n44 ns226 0 -5.48343740305e-05
Gc22_227 0 n44 ns227 0 -0.000361896114789
Gc22_228 0 n44 ns228 0 0.000584415652365
Gc22_229 0 n44 ns229 0 -0.0013590852927
Gc22_230 0 n44 ns230 0 -4.86214539439e-05
Gc22_231 0 n44 ns231 0 -0.00479587479331
Gc22_232 0 n44 ns232 0 -0.000499406274495
Gc22_233 0 n44 ns233 0 -0.00212889880431
Gc22_234 0 n44 ns234 0 0.0014916559221
Gc22_235 0 n44 ns235 0 0.000966714536238
Gc22_236 0 n44 ns236 0 -0.000681049539205
Gc22_237 0 n44 ns237 0 -0.000347617041318
Gc22_238 0 n44 ns238 0 0.000175560748601
Gc22_239 0 n44 ns239 0 -0.000161664832854
Gc22_240 0 n44 ns240 0 5.81429675522e-05
Gc22_241 0 n44 ns241 0 0.00085904739657
Gc22_242 0 n44 ns242 0 -5.69523711541e-05
Gc22_243 0 n44 ns243 0 0.00112439150515
Gc22_244 0 n44 ns244 0 -0.00103768153144
Gc22_245 0 n44 ns245 0 0.00115913576044
Gc22_246 0 n44 ns246 0 -0.000443484699545
Gc22_247 0 n44 ns247 0 0.00102578678537
Gc22_248 0 n44 ns248 0 -0.000709815539475
Gc22_249 0 n44 ns249 0 -0.00220303873918
Gc22_250 0 n44 ns250 0 -0.000839759936692
Gc22_251 0 n44 ns251 0 -0.00651802897479
Gc22_252 0 n44 ns252 0 -0.00319458887503
Gc22_253 0 n44 ns253 0 -0.00518317346552
Gc22_254 0 n44 ns254 0 -0.00359971250553
Gc22_255 0 n44 ns255 0 0.00337158252848
Gc22_256 0 n44 ns256 0 0.00222971564173
Gc22_257 0 n44 ns257 0 0.00085747122251
Gc22_258 0 n44 ns258 0 -0.00123957199753
Gc22_259 0 n44 ns259 0 -0.00204186614869
Gc22_260 0 n44 ns260 0 -0.00313020854404
Gc22_261 0 n44 ns261 0 0.00248341301456
Gc22_262 0 n44 ns262 0 -0.000706913181316
Gc22_263 0 n44 ns263 0 -0.00322430954842
Gc22_264 0 n44 ns264 0 -4.72079026732e-05
Gc22_265 0 n44 ns265 0 0.000381669940134
Gc22_266 0 n44 ns266 0 -0.000177241454902
Gc22_267 0 n44 ns267 0 -0.000439977082974
Gc22_268 0 n44 ns268 0 0.000100318797563
Gc22_269 0 n44 ns269 0 -0.000959039034356
Gc22_270 0 n44 ns270 0 0.00246121063875
Gc22_271 0 n44 ns271 0 -0.000137142269463
Gc22_272 0 n44 ns272 0 0.000414580288993
Gc22_273 0 n44 ns273 0 0.000193709654436
Gc22_274 0 n44 ns274 0 -0.000271990442352
Gc22_275 0 n44 ns275 0 1.7713655019e-05
Gc22_276 0 n44 ns276 0 0.000519398904421
Gc22_277 0 n44 ns277 0 -0.000171951619625
Gc22_278 0 n44 ns278 0 5.61483855423e-05
Gc22_279 0 n44 ns279 0 0.000648114763892
Gc22_280 0 n44 ns280 0 -0.000498358498659
Gc22_281 0 n44 ns281 0 2.94120358772e-05
Gc22_282 0 n44 ns282 0 -0.000131339429113
Gc22_283 0 n44 ns283 0 0.000813877868705
Gc22_284 0 n44 ns284 0 -0.000521382101461
Gc22_285 0 n44 ns285 0 0.000416475558494
Gc22_286 0 n44 ns286 0 -0.000762068323713
Gc22_287 0 n44 ns287 0 -0.000714579288125
Gc22_288 0 n44 ns288 0 0.00100179609372
Gc22_289 0 n44 ns289 0 -0.00183145248554
Gc22_290 0 n44 ns290 0 -0.00352970239576
Gc22_291 0 n44 ns291 0 -0.00174363027722
Gc22_292 0 n44 ns292 0 -0.0038448803067
Gc22_293 0 n44 ns293 0 -0.00057461427301
Gc22_294 0 n44 ns294 0 0.000819826560651
Gc22_295 0 n44 ns295 0 0.000372915963032
Gc22_296 0 n44 ns296 0 -0.00136069669338
Gc22_297 0 n44 ns297 0 9.4484042902e-05
Gc22_298 0 n44 ns298 0 -0.00297631599303
Gc22_299 0 n44 ns299 0 0.00108867305594
Gc22_300 0 n44 ns300 0 -0.00332326102977
Gc22_301 0 n44 ns301 0 -0.00160435754404
Gc22_302 0 n44 ns302 0 -2.36199418339e-05
Gc22_303 0 n44 ns303 0 8.28671079032e-05
Gc22_304 0 n44 ns304 0 5.33866478423e-06
Gc22_305 0 n44 ns305 0 -0.000163340701642
Gc22_306 0 n44 ns306 0 -0.000385223170475
Gc22_307 0 n44 ns307 0 -0.000520156418228
Gc22_308 0 n44 ns308 0 0.000592073277133
Gc22_309 0 n44 ns309 0 -0.000203308692293
Gc22_310 0 n44 ns310 0 -2.53699602154e-05
Gc22_311 0 n44 ns311 0 -6.78220119254e-05
Gc22_312 0 n44 ns312 0 0.000113315895199
Gc22_313 0 n44 ns313 0 0.000369775391204
Gc22_314 0 n44 ns314 0 0.000686122268248
Gc22_315 0 n44 ns315 0 -0.000116975091376
Gc22_316 0 n44 ns316 0 -2.75979488201e-05
Gc22_317 0 n44 ns317 0 -0.000356571998217
Gc22_318 0 n44 ns318 0 -0.00037681976409
Gc22_319 0 n44 ns319 0 0.000385956601173
Gc22_320 0 n44 ns320 0 0.00115638341212
Gc22_321 0 n44 ns321 0 0.00085142852545
Gc22_322 0 n44 ns322 0 -1.68522108613e-05
Gc22_323 0 n44 ns323 0 0.000655083578377
Gc22_324 0 n44 ns324 0 0.00015382496422
Gc22_325 0 n44 ns325 0 0.000395800302379
Gc22_326 0 n44 ns326 0 0.000202141420963
Gc22_327 0 n44 ns327 0 -0.000950007259197
Gc22_328 0 n44 ns328 0 -0.00616390314354
Gc22_329 0 n44 ns329 0 -0.00116719551457
Gc22_330 0 n44 ns330 0 -0.00564651994512
Gc22_331 0 n44 ns331 0 -0.00142930351794
Gc22_332 0 n44 ns332 0 0.00105942746304
Gc22_333 0 n44 ns333 0 2.73083385856e-05
Gc22_334 0 n44 ns334 0 -0.000882955563199
Gc22_335 0 n44 ns335 0 0.000146843891738
Gc22_336 0 n44 ns336 0 -0.00202487696045
Gc22_337 0 n44 ns337 0 0.00036843233284
Gc22_338 0 n44 ns338 0 -0.00115219760721
Gc22_339 0 n44 ns339 0 -0.000538059690465
Gc22_340 0 n44 ns340 0 -5.83909254853e-06
Gc22_341 0 n44 ns341 0 7.69941850579e-05
Gc22_342 0 n44 ns342 0 -1.60332492191e-06
Gc22_343 0 n44 ns343 0 -0.000105352447759
Gc22_344 0 n44 ns344 0 -0.000124621495103
Gc22_345 0 n44 ns345 0 -0.000258144132795
Gc22_346 0 n44 ns346 0 0.000260289009773
Gc22_347 0 n44 ns347 0 -4.63837386723e-05
Gc22_348 0 n44 ns348 0 0.000126606605251
Gc22_349 0 n44 ns349 0 -5.06459477473e-05
Gc22_350 0 n44 ns350 0 -1.10434329067e-05
Gc22_351 0 n44 ns351 0 0.000293942265433
Gc22_352 0 n44 ns352 0 -4.3559745234e-05
Gc22_353 0 n44 ns353 0 -6.64292194424e-05
Gc22_354 0 n44 ns354 0 0.000141118114882
Gc22_355 0 n44 ns355 0 -9.0493455193e-07
Gc22_356 0 n44 ns356 0 9.14236613111e-05
Gc22_357 0 n44 ns357 0 0.000638326868264
Gc22_358 0 n44 ns358 0 0.000296872662359
Gc22_359 0 n44 ns359 0 0.000292033799919
Gc22_360 0 n44 ns360 0 -0.000472021406149
Gc22_361 0 n44 ns361 0 0.00010222164989
Gc22_362 0 n44 ns362 0 -0.000281973274537
Gc22_363 0 n44 ns363 0 -4.09218841214e-05
Gc22_364 0 n44 ns364 0 -0.000361069315335
Gc22_365 0 n44 ns365 0 -0.00484488981396
Gc22_366 0 n44 ns366 0 -0.00424625214426
Gc22_367 0 n44 ns367 0 -0.00448309968426
Gc22_368 0 n44 ns368 0 -0.00374656092372
Gc22_369 0 n44 ns369 0 -0.0003701617074
Gc22_370 0 n44 ns370 0 0.00186439177997
Gc22_371 0 n44 ns371 0 -0.000289718463389
Gc22_372 0 n44 ns372 0 -0.000743194578123
Gc22_373 0 n44 ns373 0 -0.0009029647075
Gc22_374 0 n44 ns374 0 -0.00206784984466
Gc22_375 0 n44 ns375 0 1.79491825673e-05
Gc22_376 0 n44 ns376 0 -0.00125137226159
Gc22_377 0 n44 ns377 0 -0.000439042401475
Gc22_378 0 n44 ns378 0 -1.07157236633e-05
Gc22_379 0 n44 ns379 0 4.19746139181e-05
Gc22_380 0 n44 ns380 0 1.39154757278e-05
Gc22_381 0 n44 ns381 0 0.000290351210148
Gc22_382 0 n44 ns382 0 -0.000726873148467
Gc22_383 0 n44 ns383 0 0.000895686860662
Gc22_384 0 n44 ns384 0 5.9311756832e-05
Gc22_385 0 n44 ns385 0 4.61810523458e-05
Gc22_386 0 n44 ns386 0 -0.00029493370943
Gc22_387 0 n44 ns387 0 -7.80957630375e-05
Gc22_388 0 n44 ns388 0 2.64671924937e-05
Gc22_389 0 n44 ns389 0 -0.00016800854057
Gc22_390 0 n44 ns390 0 0.000305337549817
Gc22_391 0 n44 ns391 0 -0.000100335734333
Gc22_392 0 n44 ns392 0 0.000121296406968
Gc22_393 0 n44 ns393 0 0.000420737538787
Gc22_394 0 n44 ns394 0 -0.000355499174683
Gc22_395 0 n44 ns395 0 -0.000389107113732
Gc22_396 0 n44 ns396 0 0.000397408229436
Gc22_397 0 n44 ns397 0 0.000278962901897
Gc22_398 0 n44 ns398 0 -0.000169845476327
Gc22_399 0 n44 ns399 0 -0.000232336384785
Gc22_400 0 n44 ns400 0 -8.430534253e-05
Gc22_401 0 n44 ns401 0 -0.000444170150744
Gc22_402 0 n44 ns402 0 0.000714329799583
Gc22_403 0 n44 ns403 0 -0.00227134580712
Gc22_404 0 n44 ns404 0 -0.00321682472914
Gc22_405 0 n44 ns405 0 -0.00223052903117
Gc22_406 0 n44 ns406 0 -0.00332464988143
Gc22_407 0 n44 ns407 0 -0.000678986003635
Gc22_408 0 n44 ns408 0 0.00117486385915
Gc22_409 0 n44 ns409 0 7.90503859645e-05
Gc22_410 0 n44 ns410 0 -0.001207292288
Gc22_411 0 n44 ns411 0 -0.000323938401536
Gc22_412 0 n44 ns412 0 -0.00284236753281
Gc22_413 0 n44 ns413 0 0.000544089968908
Gc22_414 0 n44 ns414 0 -0.00280115737859
Gc22_415 0 n44 ns415 0 -0.00114288128156
Gc22_416 0 n44 ns416 0 -3.3558525606e-05
Gc22_417 0 n44 ns417 0 9.53840306166e-05
Gc22_418 0 n44 ns418 0 -1.34717288767e-06
Gc22_419 0 n44 ns419 0 -0.000972153404383
Gc22_420 0 n44 ns420 0 0.000376297138696
Gc22_421 0 n44 ns421 0 -0.00260797462506
Gc22_422 0 n44 ns422 0 0.00159702709982
Gc22_423 0 n44 ns423 0 -0.000329910161557
Gc22_424 0 n44 ns424 0 0.0012118135554
Gc22_425 0 n44 ns425 0 0.000245695706281
Gc22_426 0 n44 ns426 0 -0.000510111852444
Gc22_427 0 n44 ns427 0 -0.000218611952709
Gc22_428 0 n44 ns428 0 0.000292578885163
Gc22_429 0 n44 ns429 0 -0.000153395899476
Gc22_430 0 n44 ns430 0 1.62024164642e-05
Gc22_431 0 n44 ns431 0 0.000626765559972
Gc22_432 0 n44 ns432 0 -7.7680339052e-05
Gc22_433 0 n44 ns433 0 0.000186489841132
Gc22_434 0 n44 ns434 0 -0.000844297783874
Gc22_435 0 n44 ns435 0 0.000748117211307
Gc22_436 0 n44 ns436 0 -0.000443679565807
Gc22_437 0 n44 ns437 0 0.00050996191458
Gc22_438 0 n44 ns438 0 -0.000832168522747
Gc22_439 0 n44 ns439 0 -0.0022284615109
Gc22_440 0 n44 ns440 0 0.000296009626899
Gc22_441 0 n44 ns441 0 -0.00575533652031
Gc22_442 0 n44 ns442 0 -0.00086839478726
Gc22_443 0 n44 ns443 0 -0.0046676733301
Gc22_444 0 n44 ns444 0 -0.00164148948573
Gc22_445 0 n44 ns445 0 0.00229193755734
Gc22_446 0 n44 ns446 0 0.00039082119745
Gc22_447 0 n44 ns447 0 0.000708382331597
Gc22_448 0 n44 ns448 0 -0.00120723793764
Gc22_449 0 n44 ns449 0 -0.000953709469077
Gc22_450 0 n44 ns450 0 -0.00220417707413
Gc22_451 0 n44 ns451 0 0.00223843963629
Gc22_452 0 n44 ns452 0 -0.00323529484615
Gc22_453 0 n44 ns453 0 -0.00265580901394
Gc22_454 0 n44 ns454 0 -7.54316057049e-06
Gc22_455 0 n44 ns455 0 0.000187599076909
Gc22_456 0 n44 ns456 0 -5.96027418026e-05
Gc22_457 0 n44 ns457 0 0.00272544648417
Gc22_458 0 n44 ns458 0 -0.00384235254815
Gc22_459 0 n44 ns459 0 0.00627210425007
Gc22_460 0 n44 ns460 0 -0.00782448773942
Gc22_461 0 n44 ns461 0 -0.00299017719474
Gc22_462 0 n44 ns462 0 -0.00264766684477
Gc22_463 0 n44 ns463 0 0.000903221137769
Gc22_464 0 n44 ns464 0 0.00084775213113
Gc22_465 0 n44 ns465 0 -0.000514213681962
Gc22_466 0 n44 ns466 0 -0.000664242273472
Gc22_467 0 n44 ns467 0 -0.000244480460672
Gc22_468 0 n44 ns468 0 4.93966099269e-06
Gc22_469 0 n44 ns469 0 -0.000561346516473
Gc22_470 0 n44 ns470 0 -0.000230061393457
Gc22_471 0 n44 ns471 0 0.000968415329394
Gc22_472 0 n44 ns472 0 0.000168148955819
Gc22_473 0 n44 ns473 0 0.000686751098356
Gc22_474 0 n44 ns474 0 0.00045753315009
Gc22_475 0 n44 ns475 0 -2.26533927306e-05
Gc22_476 0 n44 ns476 0 0.000716176880012
Gc22_477 0 n44 ns477 0 0.000764328297676
Gc22_478 0 n44 ns478 0 -0.00301861509406
Gc22_479 0 n44 ns479 0 -0.00233667753401
Gc22_480 0 n44 ns480 0 -0.00680568376872
Gc22_481 0 n44 ns481 0 -0.00164082911001
Gc22_482 0 n44 ns482 0 -0.00644807580503
Gc22_483 0 n44 ns483 0 0.00583513516511
Gc22_484 0 n44 ns484 0 0.0078869754298
Gc22_485 0 n44 ns485 0 0.000749418629643
Gc22_486 0 n44 ns486 0 -0.00115815713119
Gc22_487 0 n44 ns487 0 -0.0055976917439
Gc22_488 0 n44 ns488 0 -0.00572888279045
Gc22_489 0 n44 ns489 0 0.00136272559921
Gc22_490 0 n44 ns490 0 0.00537123765875
Gc22_491 0 n44 ns491 0 -0.00425528153803
Gc22_492 0 n44 ns492 0 -1.75985467637e-06
Gc22_493 0 n44 ns493 0 0.000419661930728
Gc22_494 0 n44 ns494 0 -0.000230137518959
Gc22_495 0 n44 ns495 0 0.000904620588643
Gc22_496 0 n44 ns496 0 -0.0022178190762
Gc22_497 0 n44 ns497 0 0.00140696747622
Gc22_498 0 n44 ns498 0 -0.00419116312378
Gc22_499 0 n44 ns499 0 -0.00248240365597
Gc22_500 0 n44 ns500 0 -0.00108470819291
Gc22_501 0 n44 ns501 0 0.000892149734246
Gc22_502 0 n44 ns502 0 0.000320629736312
Gc22_503 0 n44 ns503 0 -0.000476672511085
Gc22_504 0 n44 ns504 0 -0.000405925723797
Gc22_505 0 n44 ns505 0 -0.000207598277686
Gc22_506 0 n44 ns506 0 4.4277032555e-05
Gc22_507 0 n44 ns507 0 0.000249050161456
Gc22_508 0 n44 ns508 0 1.16349120775e-06
Gc22_509 0 n44 ns509 0 0.00127470677551
Gc22_510 0 n44 ns510 0 -0.00051578204629
Gc22_511 0 n44 ns511 0 0.000935764781535
Gc22_512 0 n44 ns512 0 -2.10604847974e-05
Gc22_513 0 n44 ns513 0 0.000444421350741
Gc22_514 0 n44 ns514 0 -0.000103456484355
Gc22_515 0 n44 ns515 0 -0.00094545857677
Gc22_516 0 n44 ns516 0 -0.00215923994963
Gc22_517 0 n44 ns517 0 -0.00583973776346
Gc22_518 0 n44 ns518 0 -0.00436778386765
Gc22_519 0 n44 ns519 0 -0.00454336833688
Gc22_520 0 n44 ns520 0 -0.00456634151319
Gc22_521 0 n44 ns521 0 0.00441417442924
Gc22_522 0 n44 ns522 0 0.00415584330561
Gc22_523 0 n44 ns523 0 0.000937068187416
Gc22_524 0 n44 ns524 0 -0.00114524485328
Gc22_525 0 n44 ns525 0 -0.00313362585548
Gc22_526 0 n44 ns526 0 -0.0033913359857
Gc22_527 0 n44 ns527 0 0.00221871561644
Gc22_528 0 n44 ns528 0 0.0015314415931
Gc22_529 0 n44 ns529 0 -0.00374151227486
Gc22_530 0 n44 ns530 0 -8.79883346181e-07
Gc22_531 0 n44 ns531 0 0.000324769874057
Gc22_532 0 n44 ns532 0 -0.000145905495005
Gc22_533 0 n44 ns533 0 -0.000881768470397
Gc22_534 0 n44 ns534 0 0.000120168871828
Gc22_535 0 n44 ns535 0 -0.00248401544408
Gc22_536 0 n44 ns536 0 0.00211460105139
Gc22_537 0 n44 ns537 0 -0.000483536417008
Gc22_538 0 n44 ns538 0 0.000889133103207
Gc22_539 0 n44 ns539 0 0.000414492598527
Gc22_540 0 n44 ns540 0 -0.000474964746237
Gc22_541 0 n44 ns541 0 -0.000260576469959
Gc22_542 0 n44 ns542 0 0.000325410070042
Gc22_543 0 n44 ns543 0 -0.000175830478741
Gc22_544 0 n44 ns544 0 9.42801784425e-05
Gc22_545 0 n44 ns545 0 0.00105886881863
Gc22_546 0 n44 ns546 0 -0.000274130680911
Gc22_547 0 n44 ns547 0 0.000162826745784
Gc22_548 0 n44 ns548 0 -0.000670979832422
Gc22_549 0 n44 ns549 0 0.000846778697436
Gc22_550 0 n44 ns550 0 -0.000564349141904
Gc22_551 0 n44 ns551 0 0.00046805748582
Gc22_552 0 n44 ns552 0 -0.000896343799998
Gc22_553 0 n44 ns553 0 -0.00155418346587
Gc22_554 0 n44 ns554 0 0.00067958853052
Gc22_555 0 n44 ns555 0 -0.00371037983766
Gc22_556 0 n44 ns556 0 -0.00271804987358
Gc22_557 0 n44 ns557 0 -0.00315339576445
Gc22_558 0 n44 ns558 0 -0.00326065142792
Gc22_559 0 n44 ns559 0 0.000447481312597
Gc22_560 0 n44 ns560 0 0.000793856509586
Gc22_561 0 n44 ns561 0 0.00057732908503
Gc22_562 0 n44 ns562 0 -0.00139549079665
Gc22_563 0 n44 ns563 0 -0.000184259076108
Gc22_564 0 n44 ns564 0 -0.00289224962157
Gc22_565 0 n44 ns565 0 0.00165623367411
Gc22_566 0 n44 ns566 0 -0.00344068289681
Gc22_567 0 n44 ns567 0 -0.00215596423141
Gc22_568 0 n44 ns568 0 -2.42407204593e-05
Gc22_569 0 n44 ns569 0 0.000138436654297
Gc22_570 0 n44 ns570 0 -2.22047691009e-05
Gc22_571 0 n44 ns571 0 9.47383654548e-05
Gc22_572 0 n44 ns572 0 -0.00088288383075
Gc22_573 0 n44 ns573 0 0.000171734885499
Gc22_574 0 n44 ns574 0 0.000275570568401
Gc22_575 0 n44 ns575 0 -7.44102175898e-05
Gc22_576 0 n44 ns576 0 -0.00023501179167
Gc22_577 0 n44 ns577 0 -9.03972111959e-05
Gc22_578 0 n44 ns578 0 0.000140561772039
Gc22_579 0 n44 ns579 0 0.000206187902505
Gc22_580 0 n44 ns580 0 0.000591196106842
Gc22_581 0 n44 ns581 0 -0.00017477619179
Gc22_582 0 n44 ns582 0 2.68880715417e-05
Gc22_583 0 n44 ns583 0 -9.87721504695e-05
Gc22_584 0 n44 ns584 0 -0.000251015765583
Gc22_585 0 n44 ns585 0 0.000148819474365
Gc22_586 0 n44 ns586 0 0.00109336031736
Gc22_587 0 n44 ns587 0 0.000846549401512
Gc22_588 0 n44 ns588 0 -7.61725074587e-05
Gc22_589 0 n44 ns589 0 0.000476782593971
Gc22_590 0 n44 ns590 0 3.05565318184e-05
Gc22_591 0 n44 ns591 0 0.000250809663456
Gc22_592 0 n44 ns592 0 0.000348881133346
Gc22_593 0 n44 ns593 0 -0.000902835218189
Gc22_594 0 n44 ns594 0 -0.0065448506798
Gc22_595 0 n44 ns595 0 -0.00114904653616
Gc22_596 0 n44 ns596 0 -0.00612744113124
Gc22_597 0 n44 ns597 0 -0.00153965283733
Gc22_598 0 n44 ns598 0 0.00100083126045
Gc22_599 0 n44 ns599 0 0.000110437193621
Gc22_600 0 n44 ns600 0 -0.0010837007521
Gc22_601 0 n44 ns601 0 0.000232637709732
Gc22_602 0 n44 ns602 0 -0.00239356640433
Gc22_603 0 n44 ns603 0 0.000558481775428
Gc22_604 0 n44 ns604 0 -0.00170227972607
Gc22_605 0 n44 ns605 0 -0.000795690401751
Gc22_606 0 n44 ns606 0 -1.05084202271e-05
Gc22_607 0 n44 ns607 0 6.18800592924e-05
Gc22_608 0 n44 ns608 0 1.74378662737e-06
Gc22_609 0 n44 ns609 0 -4.05612126345e-06
Gc22_610 0 n44 ns610 0 0.000257842524912
Gc22_611 0 n44 ns611 0 -2.3604691511e-05
Gc22_612 0 n44 ns612 0 0.000853988331789
Gc22_613 0 n44 ns613 0 4.57240960427e-05
Gc22_614 0 n44 ns614 0 -3.92793389823e-05
Gc22_615 0 n44 ns615 0 -0.000154983998474
Gc22_616 0 n44 ns616 0 3.61955681214e-05
Gc22_617 0 n44 ns617 0 -0.000302216801188
Gc22_618 0 n44 ns618 0 0.000446837014398
Gc22_619 0 n44 ns619 0 5.97069969531e-05
Gc22_620 0 n44 ns620 0 -0.000114926222696
Gc22_621 0 n44 ns621 0 0.000283680141382
Gc22_622 0 n44 ns622 0 -0.00031691744246
Gc22_623 0 n44 ns623 0 0.000925173350577
Gc22_624 0 n44 ns624 0 -0.000689291055141
Gc22_625 0 n44 ns625 0 0.000244878622961
Gc22_626 0 n44 ns626 0 -0.000757788942069
Gc22_627 0 n44 ns627 0 0.000437451167189
Gc22_628 0 n44 ns628 0 -0.000735518984036
Gc22_629 0 n44 ns629 0 0.000138128977243
Gc22_630 0 n44 ns630 0 0.0011658526386
Gc22_631 0 n44 ns631 0 0.00365453541822
Gc22_632 0 n44 ns632 0 0.00292755848364
Gc22_633 0 n44 ns633 0 0.00334071540355
Gc22_634 0 n44 ns634 0 0.00239080270309
Gc22_635 0 n44 ns635 0 0.000793244637503
Gc22_636 0 n44 ns636 0 0.000987901229812
Gc22_637 0 n44 ns637 0 -0.000356205494128
Gc22_638 0 n44 ns638 0 -0.000353569468354
Gc22_639 0 n44 ns639 0 -0.0015075794332
Gc22_640 0 n44 ns640 0 -0.000947128573306
Gc22_641 0 n44 ns641 0 -0.000558389718076
Gc22_642 0 n44 ns642 0 -0.00019249514911
Gc22_643 0 n44 ns643 0 0.000110223011629
Gc22_644 0 n44 ns644 0 1.47087921144e-05
Gc22_645 0 n44 ns645 0 -7.68887397788e-05
Gc22_646 0 n44 ns646 0 6.63684078699e-06
Gc22_647 0 n44 ns647 0 -2.72764663239e-05
Gc22_648 0 n44 ns648 0 0.000196838113964
Gc22_649 0 n44 ns649 0 0.000115347772254
Gc22_650 0 n44 ns650 0 0.00126279431848
Gc22_651 0 n44 ns651 0 3.06899481302e-05
Gc22_652 0 n44 ns652 0 0.000208058901641
Gc22_653 0 n44 ns653 0 -9.35509670561e-05
Gc22_654 0 n44 ns654 0 -0.000166401418313
Gc22_655 0 n44 ns655 0 -0.000222738169891
Gc22_656 0 n44 ns656 0 0.000400938515106
Gc22_657 0 n44 ns657 0 6.77490067305e-05
Gc22_658 0 n44 ns658 0 -0.000165414496667
Gc22_659 0 n44 ns659 0 3.92132727962e-05
Gc22_660 0 n44 ns660 0 -0.000372661223167
Gc22_661 0 n44 ns661 0 0.000965248304635
Gc22_662 0 n44 ns662 0 -0.000570528521742
Gc22_663 0 n44 ns663 0 0.000286826276272
Gc22_664 0 n44 ns664 0 -0.000841813942615
Gc22_665 0 n44 ns665 0 0.000403178057484
Gc22_666 0 n44 ns666 0 -0.000808428448927
Gc22_667 0 n44 ns667 0 2.22936056187e-05
Gc22_668 0 n44 ns668 0 0.00115470430709
Gc22_669 0 n44 ns669 0 0.00400751757346
Gc22_670 0 n44 ns670 0 0.00354325262195
Gc22_671 0 n44 ns671 0 0.00371392277134
Gc22_672 0 n44 ns672 0 0.0029508777466
Gc22_673 0 n44 ns673 0 0.000519313163269
Gc22_674 0 n44 ns674 0 0.00121348409746
Gc22_675 0 n44 ns675 0 -0.000327311134944
Gc22_676 0 n44 ns676 0 -0.000465082711326
Gc22_677 0 n44 ns677 0 -0.00132812093907
Gc22_678 0 n44 ns678 0 -0.00136875052242
Gc22_679 0 n44 ns679 0 -0.000636341107915
Gc22_680 0 n44 ns680 0 -0.000605211846533
Gc22_681 0 n44 ns681 0 5.17370239177e-05
Gc22_682 0 n44 ns682 0 1.16256223368e-05
Gc22_683 0 n44 ns683 0 -6.54301522455e-05
Gc22_684 0 n44 ns684 0 -3.88768654491e-06
Gc22_685 0 n44 ns685 0 -0.000190245352745
Gc22_686 0 n44 ns686 0 5.69431829198e-05
Gc22_687 0 n44 ns687 0 -0.000245016798607
Gc22_688 0 n44 ns688 0 0.000529211691486
Gc22_689 0 n44 ns689 0 -1.61823302918e-05
Gc22_690 0 n44 ns690 0 6.71980565407e-05
Gc22_691 0 n44 ns691 0 0.000155710440601
Gc22_692 0 n44 ns692 0 -1.05885663707e-05
Gc22_693 0 n44 ns693 0 -0.000180263301257
Gc22_694 0 n44 ns694 0 -7.44288047629e-05
Gc22_695 0 n44 ns695 0 0.000129742891657
Gc22_696 0 n44 ns696 0 -0.000132811393281
Gc22_697 0 n44 ns697 0 -0.00022349305101
Gc22_698 0 n44 ns698 0 -0.000253309085739
Gc22_699 0 n44 ns699 0 0.000156795430645
Gc22_700 0 n44 ns700 0 0.000549159544652
Gc22_701 0 n44 ns701 0 0.000239174116453
Gc22_702 0 n44 ns702 0 -0.000397092786889
Gc22_703 0 n44 ns703 0 -0.00019265692099
Gc22_704 0 n44 ns704 0 -0.000307570593597
Gc22_705 0 n44 ns705 0 -0.000507462501479
Gc22_706 0 n44 ns706 0 -0.000369957542998
Gc22_707 0 n44 ns707 0 0.00230117454706
Gc22_708 0 n44 ns708 0 0.00317062557795
Gc22_709 0 n44 ns709 0 0.00237991057081
Gc22_710 0 n44 ns710 0 0.00301282169985
Gc22_711 0 n44 ns711 0 -0.00130009827163
Gc22_712 0 n44 ns712 0 0.000682982373293
Gc22_713 0 n44 ns713 0 -0.000124701443885
Gc22_714 0 n44 ns714 0 -0.000792352739011
Gc22_715 0 n44 ns715 0 -0.000350332997928
Gc22_716 0 n44 ns716 0 -0.00136133678789
Gc22_717 0 n44 ns717 0 -0.000578503123033
Gc22_718 0 n44 ns718 0 0.000985906947042
Gc22_719 0 n44 ns719 0 0.00055283018741
Gc22_720 0 n44 ns720 0 6.19018994277e-06
Gc22_721 0 n44 ns721 0 -9.21909443374e-05
Gc22_722 0 n44 ns722 0 -7.60645364128e-06
Gc22_723 0 n44 ns723 0 0.000119866187682
Gc22_724 0 n44 ns724 0 -0.000534181293351
Gc22_725 0 n44 ns725 0 0.000602596809209
Gc22_726 0 n44 ns726 0 4.11435998125e-05
Gc22_727 0 n44 ns727 0 -0.000286812748659
Gc22_728 0 n44 ns728 0 0.000465864096484
Gc22_729 0 n44 ns729 0 -4.36450419603e-06
Gc22_730 0 n44 ns730 0 -0.00018407025646
Gc22_731 0 n44 ns731 0 0.000352044004191
Gc22_732 0 n44 ns732 0 -0.000168645223094
Gc22_733 0 n44 ns733 0 0.000180496656107
Gc22_734 0 n44 ns734 0 -7.33460066878e-05
Gc22_735 0 n44 ns735 0 -1.44089958337e-05
Gc22_736 0 n44 ns736 0 -0.000309682046031
Gc22_737 0 n44 ns737 0 -0.000762693909045
Gc22_738 0 n44 ns738 0 -0.000343538234712
Gc22_739 0 n44 ns739 0 0.000295221315172
Gc22_740 0 n44 ns740 0 -0.000549766768978
Gc22_741 0 n44 ns741 0 -0.000187649198167
Gc22_742 0 n44 ns742 0 -0.00096655617034
Gc22_743 0 n44 ns743 0 0.00121451126477
Gc22_744 0 n44 ns744 0 -0.000689713910223
Gc22_745 0 n44 ns745 0 0.00190466422224
Gc22_746 0 n44 ns746 0 0.00295376677738
Gc22_747 0 n44 ns747 0 0.00176612436497
Gc22_748 0 n44 ns748 0 0.00324034511178
Gc22_749 0 n44 ns749 0 -0.00124905052784
Gc22_750 0 n44 ns750 0 -0.00138732708604
Gc22_751 0 n44 ns751 0 0.000407963629441
Gc22_752 0 n44 ns752 0 -0.00105370032165
Gc22_753 0 n44 ns753 0 0.000209602286016
Gc22_754 0 n44 ns754 0 -0.000800857726524
Gc22_755 0 n44 ns755 0 -0.00144817902205
Gc22_756 0 n44 ns756 0 0.00245909838299
Gc22_757 0 n44 ns757 0 0.00147630420215
Gc22_758 0 n44 ns758 0 3.24029661369e-05
Gc22_759 0 n44 ns759 0 -0.000216366458717
Gc22_760 0 n44 ns760 0 6.32932981657e-05
Gc22_761 0 n44 ns761 0 0.000264104992768
Gc22_762 0 n44 ns762 0 -0.00187954109272
Gc22_763 0 n44 ns763 0 0.000500414577657
Gc22_764 0 n44 ns764 0 -7.85198958297e-05
Gc22_765 0 n44 ns765 0 -0.000917600523247
Gc22_766 0 n44 ns766 0 0.000410378207614
Gc22_767 0 n44 ns767 0 0.000395327943769
Gc22_768 0 n44 ns768 0 -0.000535882138991
Gc22_769 0 n44 ns769 0 0.000368198792712
Gc22_770 0 n44 ns770 0 0.000458781264664
Gc22_771 0 n44 ns771 0 0.000262121803526
Gc22_772 0 n44 ns772 0 -5.12308233984e-05
Gc22_773 0 n44 ns773 0 -0.000429430406995
Gc22_774 0 n44 ns774 0 -0.000138313653303
Gc22_775 0 n44 ns775 0 0.000680366623941
Gc22_776 0 n44 ns776 0 -0.000954200192106
Gc22_777 0 n44 ns777 0 0.00086960740837
Gc22_778 0 n44 ns778 0 -0.000434309524075
Gc22_779 0 n44 ns779 0 0.000501174300311
Gc22_780 0 n44 ns780 0 -0.000920350583183
Gc22_781 0 n44 ns781 0 0.000881972038151
Gc22_782 0 n44 ns782 0 0.00219989433328
Gc22_783 0 n44 ns783 0 0.00252969989307
Gc22_784 0 n44 ns784 0 0.00442621327935
Gc22_785 0 n44 ns785 0 0.00189842956936
Gc22_786 0 n44 ns786 0 0.00460200748748
Gc22_787 0 n44 ns787 0 0.00364956596234
Gc22_788 0 n44 ns788 0 0.000702074000433
Gc22_789 0 n44 ns789 0 0.000867434968881
Gc22_790 0 n44 ns790 0 -0.0010124278052
Gc22_791 0 n44 ns791 0 -0.00196917950585
Gc22_792 0 n44 ns792 0 -0.00154212948952
Gc22_793 0 n44 ns793 0 -0.00390060988523
Gc22_794 0 n44 ns794 0 -0.000570443955263
Gc22_795 0 n44 ns795 0 0.00300451083301
Gc22_796 0 n44 ns796 0 5.6307355943e-05
Gc22_797 0 n44 ns797 0 -0.000177011954486
Gc22_798 0 n44 ns798 0 3.86671062104e-05
Gc22_799 0 n44 ns799 0 -7.64570463016e-06
Gc22_800 0 n44 ns800 0 -0.00191270617441
Gc22_801 0 n44 ns801 0 -0.00262837238045
Gc22_802 0 n44 ns802 0 0.000664340586917
Gc22_803 0 n44 ns803 0 -0.000979601138058
Gc22_804 0 n44 ns804 0 0.000359833095295
Gc22_805 0 n44 ns805 0 0.000617660671291
Gc22_806 0 n44 ns806 0 -0.000310269430574
Gc22_807 0 n44 ns807 0 0.000123701174388
Gc22_808 0 n44 ns808 0 0.000558300220887
Gc22_809 0 n44 ns809 0 0.000294765325601
Gc22_810 0 n44 ns810 0 -1.18626178374e-05
Gc22_811 0 n44 ns811 0 -0.000553221630076
Gc22_812 0 n44 ns812 0 -0.0006764994871
Gc22_813 0 n44 ns813 0 0.000351015292613
Gc22_814 0 n44 ns814 0 0.000143921207201
Gc22_815 0 n44 ns815 0 0.000372102920399
Gc22_816 0 n44 ns816 0 -0.000141301077689
Gc22_817 0 n44 ns817 0 -0.000426322294625
Gc22_818 0 n44 ns818 0 -0.000947195784852
Gc22_819 0 n44 ns819 0 -0.000839233880446
Gc22_820 0 n44 ns820 0 0.000223287270426
Gc22_821 0 n44 ns821 0 0.00656185201628
Gc22_822 0 n44 ns822 0 0.00484640430747
Gc22_823 0 n44 ns823 0 0.00491335358292
Gc22_824 0 n44 ns824 0 0.00495439663191
Gc22_825 0 n44 ns825 0 0.000839721562404
Gc22_826 0 n44 ns826 0 0.00550158715151
Gc22_827 0 n44 ns827 0 0.000913090071752
Gc22_828 0 n44 ns828 0 -0.000815584033043
Gc22_829 0 n44 ns829 0 -0.00590710384931
Gc22_830 0 n44 ns830 0 -0.00147783278271
Gc22_831 0 n44 ns831 0 0.00279536270375
Gc22_832 0 n44 ns832 0 -0.00416945968363
Gc22_833 0 n44 ns833 0 0.00477437467604
Gc22_834 0 n44 ns834 0 -1.78064961196e-05
Gc22_835 0 n44 ns835 0 0.000129703192903
Gc22_836 0 n44 ns836 0 -0.000134977734021
Gc22_837 0 n44 ns837 0 0.000491942952929
Gc22_838 0 n44 ns838 0 -0.00225856025247
Gc22_839 0 n44 ns839 0 0.00100665844967
Gc22_840 0 n44 ns840 0 -0.000642966161957
Gc22_841 0 n44 ns841 0 -0.000764747523152
Gc22_842 0 n44 ns842 0 0.000195929508025
Gc22_843 0 n44 ns843 0 0.000263627529726
Gc22_844 0 n44 ns844 0 -0.000402881332867
Gc22_845 0 n44 ns845 0 0.000259073944942
Gc22_846 0 n44 ns846 0 0.000427328268722
Gc22_847 0 n44 ns847 0 0.000253177391055
Gc22_848 0 n44 ns848 0 -5.0395921001e-05
Gc22_849 0 n44 ns849 0 -0.000394034508502
Gc22_850 0 n44 ns850 0 1.86655988327e-06
Gc22_851 0 n44 ns851 0 0.000741151008119
Gc22_852 0 n44 ns852 0 -0.000993225601811
Gc22_853 0 n44 ns853 0 0.000866992598541
Gc22_854 0 n44 ns854 0 -0.00053032650777
Gc22_855 0 n44 ns855 0 0.000464449185044
Gc22_856 0 n44 ns856 0 -0.00103589795769
Gc22_857 0 n44 ns857 0 0.00099666226694
Gc22_858 0 n44 ns858 0 0.00225190753253
Gc22_859 0 n44 ns859 0 0.00327135096488
Gc22_860 0 n44 ns860 0 0.00488590686618
Gc22_861 0 n44 ns861 0 0.00253798925479
Gc22_862 0 n44 ns862 0 0.00500595432159
Gc22_863 0 n44 ns863 0 0.00362947557339
Gc22_864 0 n44 ns864 0 0.000393668790397
Gc22_865 0 n44 ns865 0 0.000894840688893
Gc22_866 0 n44 ns866 0 -0.00098113479683
Gc22_867 0 n44 ns867 0 -0.00191662083397
Gc22_868 0 n44 ns868 0 -0.00131645137262
Gc22_869 0 n44 ns869 0 -0.00391852093462
Gc22_870 0 n44 ns870 0 -0.000302116332888
Gc22_871 0 n44 ns871 0 0.00308747643637
Gc22_872 0 n44 ns872 0 5.65583664992e-05
Gc22_873 0 n44 ns873 0 -0.000167385771533
Gc22_874 0 n44 ns874 0 4.72204233159e-05
Gc22_875 0 n44 ns875 0 0.00023710612198
Gc22_876 0 n44 ns876 0 -0.00108236350133
Gc22_877 0 n44 ns877 0 0.000616477472284
Gc22_878 0 n44 ns878 0 -0.000509016208124
Gc22_879 0 n44 ns879 0 -0.000126635255743
Gc22_880 0 n44 ns880 0 0.00024362020108
Gc22_881 0 n44 ns881 0 -0.000167201355604
Gc22_882 0 n44 ns882 0 -0.000110621912629
Gc22_883 0 n44 ns883 0 2.68583889716e-05
Gc22_884 0 n44 ns884 0 -0.000337081063197
Gc22_885 0 n44 ns885 0 0.00020955519299
Gc22_886 0 n44 ns886 0 -2.7150344021e-05
Gc22_887 0 n44 ns887 0 0.000247155739424
Gc22_888 0 n44 ns888 0 9.73764476041e-06
Gc22_889 0 n44 ns889 0 -0.000379825796315
Gc22_890 0 n44 ns890 0 -2.50748815087e-05
Gc22_891 0 n44 ns891 0 0.000595704331804
Gc22_892 0 n44 ns892 0 -0.000504812076959
Gc22_893 0 n44 ns893 0 0.000115958473329
Gc22_894 0 n44 ns894 0 -0.000841912947125
Gc22_895 0 n44 ns895 0 0.000908458323434
Gc22_896 0 n44 ns896 0 -0.000576626223542
Gc22_897 0 n44 ns897 0 0.00157250391368
Gc22_898 0 n44 ns898 0 0.00430548952869
Gc22_899 0 n44 ns899 0 0.00151803437808
Gc22_900 0 n44 ns900 0 0.00444943321913
Gc22_901 0 n44 ns901 0 -0.00149581436873
Gc22_902 0 n44 ns902 0 -0.00155254074028
Gc22_903 0 n44 ns903 0 0.000490964569059
Gc22_904 0 n44 ns904 0 -0.0010669427716
Gc22_905 0 n44 ns905 0 0.000496598707751
Gc22_906 0 n44 ns906 0 -0.000778783365961
Gc22_907 0 n44 ns907 0 -0.00140811075109
Gc22_908 0 n44 ns908 0 0.00258631908437
Gc22_909 0 n44 ns909 0 0.00151829187028
Gc22_910 0 n44 ns910 0 2.3452451771e-05
Gc22_911 0 n44 ns911 0 -0.00021676205801
Gc22_912 0 n44 ns912 0 6.90083121572e-05
Gc22_913 0 n44 ns913 0 5.88422262119e-06
Gc22_914 0 n44 ns914 0 -0.000671835723198
Gc22_915 0 n44 ns915 0 -2.38599901372e-05
Gc22_916 0 n44 ns916 0 -0.000226122529311
Gc22_917 0 n44 ns917 0 0.000116155747947
Gc22_918 0 n44 ns918 0 -0.000218916219042
Gc22_919 0 n44 ns919 0 0.000151011256783
Gc22_920 0 n44 ns920 0 8.08520387062e-05
Gc22_921 0 n44 ns921 0 -0.000383988109904
Gc22_922 0 n44 ns922 0 -0.000536859631887
Gc22_923 0 n44 ns923 0 0.000164272856333
Gc22_924 0 n44 ns924 0 -1.79120059431e-05
Gc22_925 0 n44 ns925 0 -0.000140053896041
Gc22_926 0 n44 ns926 0 0.000189206403624
Gc22_927 0 n44 ns927 0 0.000118169889372
Gc22_928 0 n44 ns928 0 0.00146450384678
Gc22_929 0 n44 ns929 0 0.000554202502809
Gc22_930 0 n44 ns930 0 0.000110957084868
Gc22_931 0 n44 ns931 0 6.26152162606e-06
Gc22_932 0 n44 ns932 0 0.000307107284021
Gc22_933 0 n44 ns933 0 -0.00119126230838
Gc22_934 0 n44 ns934 0 -0.000824871371623
Gc22_935 0 n44 ns935 0 -0.000506262770624
Gc22_936 0 n44 ns936 0 0.00389905347724
Gc22_937 0 n44 ns937 0 -2.80236745939e-05
Gc22_938 0 n44 ns938 0 0.00379028731431
Gc22_939 0 n44 ns939 0 -0.0019117729789
Gc22_940 0 n44 ns940 0 0.000508802719128
Gc22_941 0 n44 ns941 0 6.7759593635e-05
Gc22_942 0 n44 ns942 0 -0.000805491955274
Gc22_943 0 n44 ns943 0 0.000377525912004
Gc22_944 0 n44 ns944 0 -0.00136288143352
Gc22_945 0 n44 ns945 0 -0.000376819001604
Gc22_946 0 n44 ns946 0 0.00101359204337
Gc22_947 0 n44 ns947 0 0.000548389928757
Gc22_948 0 n44 ns948 0 -7.19059064882e-06
Gc22_949 0 n44 ns949 0 -0.000147183067857
Gc22_950 0 n44 ns950 0 7.89785140323e-06
Gc22_951 0 n44 ns951 0 -6.95243454663e-05
Gc22_952 0 n44 ns952 0 -1.64963051594e-05
Gc22_953 0 n44 ns953 0 3.9873519998e-05
Gc22_954 0 n44 ns954 0 0.000566633858747
Gc22_955 0 n44 ns955 0 2.87918002143e-05
Gc22_956 0 n44 ns956 0 8.17327316892e-06
Gc22_957 0 n44 ns957 0 7.06733290914e-05
Gc22_958 0 n44 ns958 0 -5.49271078678e-05
Gc22_959 0 n44 ns959 0 -0.000247431794046
Gc22_960 0 n44 ns960 0 0.000106529235049
Gc22_961 0 n44 ns961 0 8.86186970675e-05
Gc22_962 0 n44 ns962 0 -0.000155713724875
Gc22_963 0 n44 ns963 0 -0.000208558970525
Gc22_964 0 n44 ns964 0 -0.000181590618526
Gc22_965 0 n44 ns965 0 0.000550981221557
Gc22_966 0 n44 ns966 0 0.000231428985294
Gc22_967 0 n44 ns967 0 0.000232652880871
Gc22_968 0 n44 ns968 0 -0.000532949854211
Gc22_969 0 n44 ns969 0 -1.2178603777e-05
Gc22_970 0 n44 ns970 0 -0.0004051477209
Gc22_971 0 n44 ns971 0 -0.000447509416419
Gc22_972 0 n44 ns972 0 0.00023836821356
Gc22_973 0 n44 ns973 0 0.00309589743535
Gc22_974 0 n44 ns974 0 0.00332694837843
Gc22_975 0 n44 ns975 0 0.0030324843778
Gc22_976 0 n44 ns976 0 0.00297413070854
Gc22_977 0 n44 ns977 0 -0.000613712759726
Gc22_978 0 n44 ns978 0 0.000991738435761
Gc22_979 0 n44 ns979 0 -0.000235425987444
Gc22_980 0 n44 ns980 0 -0.000651536895144
Gc22_981 0 n44 ns981 0 -0.000768372422413
Gc22_982 0 n44 ns982 0 -0.00136956940348
Gc22_983 0 n44 ns983 0 -0.000568818686272
Gc22_984 0 n44 ns984 0 0.000381499775506
Gc22_985 0 n44 ns985 0 0.000338956297109
Gc22_986 0 n44 ns986 0 -4.71864465183e-06
Gc22_987 0 n44 ns987 0 -5.19661534682e-05
Gc22_988 0 n44 ns988 0 -2.04804088951e-05
Gc22_989 0 n44 ns989 0 -0.000323352218463
Gc22_990 0 n44 ns990 0 0.000124337334345
Gc22_991 0 n44 ns991 0 -0.000633293388584
Gc22_992 0 n44 ns992 0 0.000518332871643
Gc22_993 0 n44 ns993 0 -0.000109155469518
Gc22_994 0 n44 ns994 0 0.00043442695043
Gc22_995 0 n44 ns995 0 4.76665441129e-05
Gc22_996 0 n44 ns996 0 -8.40872891378e-05
Gc22_997 0 n44 ns997 0 9.89320536988e-05
Gc22_998 0 n44 ns998 0 -0.000241063675517
Gc22_999 0 n44 ns999 0 0.000150242976381
Gc22_1000 0 n44 ns1000 0 -7.52086616543e-05
Gc22_1001 0 n44 ns1001 0 1.68963317312e-05
Gc22_1002 0 n44 ns1002 0 -0.00034458016844
Gc22_1003 0 n44 ns1003 0 -0.000581969127575
Gc22_1004 0 n44 ns1004 0 0.000300022857642
Gc22_1005 0 n44 ns1005 0 0.000199405049005
Gc22_1006 0 n44 ns1006 0 -0.000342092144555
Gc22_1007 0 n44 ns1007 0 -0.000327404855687
Gc22_1008 0 n44 ns1008 0 -0.000512316127689
Gc22_1009 0 n44 ns1009 0 0.000284643795516
Gc22_1010 0 n44 ns1010 0 -0.00112925559814
Gc22_1011 0 n44 ns1011 0 0.0013918890726
Gc22_1012 0 n44 ns1012 0 0.00238729424973
Gc22_1013 0 n44 ns1013 0 0.00146400702018
Gc22_1014 0 n44 ns1014 0 0.00264100766226
Gc22_1015 0 n44 ns1015 0 -0.00213511760227
Gc22_1016 0 n44 ns1016 0 -0.000700560836168
Gc22_1017 0 n44 ns1017 0 0.000234454430255
Gc22_1018 0 n44 ns1018 0 -0.000980336811765
Gc22_1019 0 n44 ns1019 0 0.000482538315522
Gc22_1020 0 n44 ns1020 0 -0.000928414938046
Gc22_1021 0 n44 ns1021 0 -0.000834092746257
Gc22_1022 0 n44 ns1022 0 0.00240323524396
Gc22_1023 0 n44 ns1023 0 0.00113155051247
Gc22_1024 0 n44 ns1024 0 2.02697691188e-05
Gc22_1025 0 n44 ns1025 0 -0.000172558730042
Gc22_1026 0 n44 ns1026 0 4.85093233884e-05
Gc22_1027 0 n44 ns1027 0 0.000429088171081
Gc22_1028 0 n44 ns1028 0 -0.00170060001468
Gc22_1029 0 n44 ns1029 0 0.00118053003305
Gc22_1030 0 n44 ns1030 0 -0.00103855538406
Gc22_1031 0 n44 ns1031 0 -0.000788091566166
Gc22_1032 0 n44 ns1032 0 8.94478147164e-05
Gc22_1033 0 n44 ns1033 0 0.000197184357939
Gc22_1034 0 n44 ns1034 0 -0.000333262772166
Gc22_1035 0 n44 ns1035 0 0.000340462451147
Gc22_1036 0 n44 ns1036 0 0.000142108852044
Gc22_1037 0 n44 ns1037 0 0.000203764032222
Gc22_1038 0 n44 ns1038 0 -3.29503082142e-05
Gc22_1039 0 n44 ns1039 0 -2.40654428103e-05
Gc22_1040 0 n44 ns1040 0 0.000306268825695
Gc22_1041 0 n44 ns1041 0 0.000148918959602
Gc22_1042 0 n44 ns1042 0 -0.00091846482079
Gc22_1043 0 n44 ns1043 0 0.000728657054168
Gc22_1044 0 n44 ns1044 0 -0.000466098141328
Gc22_1045 0 n44 ns1045 0 0.000418504790092
Gc22_1046 0 n44 ns1046 0 -0.000805996731783
Gc22_1047 0 n44 ns1047 0 0.00160007750046
Gc22_1048 0 n44 ns1048 0 0.00120830258684
Gc22_1049 0 n44 ns1049 0 0.00194695701305
Gc22_1050 0 n44 ns1050 0 0.00375465531014
Gc22_1051 0 n44 ns1051 0 0.00154237330425
Gc22_1052 0 n44 ns1052 0 0.00398087461855
Gc22_1053 0 n44 ns1053 0 0.00161920501648
Gc22_1054 0 n44 ns1054 0 -0.0016666608626
Gc22_1055 0 n44 ns1055 0 0.000822913038457
Gc22_1056 0 n44 ns1056 0 -0.000971884690748
Gc22_1057 0 n44 ns1057 0 -0.000521735499079
Gc22_1058 0 n44 ns1058 0 -0.000597599411221
Gc22_1059 0 n44 ns1059 0 -0.00325894169905
Gc22_1060 0 n44 ns1060 0 0.00212239686838
Gc22_1061 0 n44 ns1061 0 0.00256554694658
Gc22_1062 0 n44 ns1062 0 4.00762704303e-05
Gc22_1063 0 n44 ns1063 0 -0.000154384585484
Gc22_1064 0 n44 ns1064 0 2.84707389909e-05
Gc22_1065 0 n44 ns1065 0 0.000747815009133
Gc22_1066 0 n44 ns1066 0 -0.00387457801218
Gc22_1067 0 n44 ns1067 0 -0.00105304000675
Gc22_1068 0 n44 ns1068 0 -0.00149347400085
Gc22_1069 0 n44 ns1069 0 -0.00124012962319
Gc22_1070 0 n44 ns1070 0 -9.97582765833e-05
Gc22_1071 0 n44 ns1071 0 0.000700721972413
Gc22_1072 0 n44 ns1072 0 -0.000130655677306
Gc22_1073 0 n44 ns1073 0 0.000119200785321
Gc22_1074 0 n44 ns1074 0 0.000512541592839
Gc22_1075 0 n44 ns1075 0 0.000277610171764
Gc22_1076 0 n44 ns1076 0 -1.35368618233e-05
Gc22_1077 0 n44 ns1077 0 -0.000421458499975
Gc22_1078 0 n44 ns1078 0 -0.000440458491971
Gc22_1079 0 n44 ns1079 0 4.47070680137e-05
Gc22_1080 0 n44 ns1080 0 -6.12313227266e-05
Gc22_1081 0 n44 ns1081 0 0.000333688340109
Gc22_1082 0 n44 ns1082 0 -0.000280227864656
Gc22_1083 0 n44 ns1083 0 -0.000382011095049
Gc22_1084 0 n44 ns1084 0 -0.00115651918244
Gc22_1085 0 n44 ns1085 0 -0.000278843525684
Gc22_1086 0 n44 ns1086 0 3.24880284049e-05
Gc22_1087 0 n44 ns1087 0 0.00648104377328
Gc22_1088 0 n44 ns1088 0 0.00585758576446
Gc22_1089 0 n44 ns1089 0 0.0048442382637
Gc22_1090 0 n44 ns1090 0 0.00575316341589
Gc22_1091 0 n44 ns1091 0 0.0005085419813
Gc22_1092 0 n44 ns1092 0 0.00532240641529
Gc22_1093 0 n44 ns1093 0 0.000836769309686
Gc22_1094 0 n44 ns1094 0 -0.000900064910252
Gc22_1095 0 n44 ns1095 0 -0.00629180256397
Gc22_1096 0 n44 ns1096 0 -0.00184890652466
Gc22_1097 0 n44 ns1097 0 0.00335354563447
Gc22_1098 0 n44 ns1098 0 -0.0050058645293
Gc22_1099 0 n44 ns1099 0 0.00459479181911
Gc22_1100 0 n44 ns1100 0 -1.72142477112e-05
Gc22_1101 0 n44 ns1101 0 4.88814958073e-05
Gc22_1102 0 n44 ns1102 0 -8.82391854584e-05
Gc22_1103 0 n44 ns1103 0 0.00123463322986
Gc22_1104 0 n44 ns1104 0 -0.00460014661395
Gc22_1105 0 n44 ns1105 0 0.00153326075715
Gc22_1106 0 n44 ns1106 0 -0.00317297194564
Gc22_1107 0 n44 ns1107 0 -0.00121263825339
Gc22_1108 0 n44 ns1108 0 -0.000661306955492
Gc22_1109 0 n44 ns1109 0 0.00062885867054
Gc22_1110 0 n44 ns1110 0 -3.98442268025e-05
Gc22_1111 0 n44 ns1111 0 0.000144125461845
Gc22_1112 0 n44 ns1112 0 0.000583320895874
Gc22_1113 0 n44 ns1113 0 0.000254975069189
Gc22_1114 0 n44 ns1114 0 -4.35889453227e-05
Gc22_1115 0 n44 ns1115 0 -0.000558064055389
Gc22_1116 0 n44 ns1116 0 0.000184149402438
Gc22_1117 0 n44 ns1117 0 0.000479513180767
Gc22_1118 0 n44 ns1118 0 -0.000841304197614
Gc22_1119 0 n44 ns1119 0 0.000598620293893
Gc22_1120 0 n44 ns1120 0 -0.000502093317344
Gc22_1121 0 n44 ns1121 0 3.67979427699e-05
Gc22_1122 0 n44 ns1122 0 -0.00122099422173
Gc22_1123 0 n44 ns1123 0 0.00105461133711
Gc22_1124 0 n44 ns1124 0 0.00160753823361
Gc22_1125 0 n44 ns1125 0 0.00596260064446
Gc22_1126 0 n44 ns1126 0 0.00556576896798
Gc22_1127 0 n44 ns1127 0 0.00455727972434
Gc22_1128 0 n44 ns1128 0 0.00555172189209
Gc22_1129 0 n44 ns1129 0 0.00267758351057
Gc22_1130 0 n44 ns1130 0 0.00184920856362
Gc22_1131 0 n44 ns1131 0 0.000928934827957
Gc22_1132 0 n44 ns1132 0 -0.000917770099671
Gc22_1133 0 n44 ns1133 0 -0.00411128918646
Gc22_1134 0 n44 ns1134 0 -0.00112508197504
Gc22_1135 0 n44 ns1135 0 -0.000620637636794
Gc22_1136 0 n44 ns1136 0 -0.00218986057142
Gc22_1137 0 n44 ns1137 0 0.0038070789885
Gc22_1138 0 n44 ns1138 0 1.74881788082e-05
Gc22_1139 0 n44 ns1139 0 -0.000106170112051
Gc22_1140 0 n44 ns1140 0 1.12076951994e-05
Gc22_1141 0 n44 ns1141 0 0.000646025650708
Gc22_1142 0 n44 ns1142 0 -0.00187428369256
Gc22_1143 0 n44 ns1143 0 0.00178120457548
Gc22_1144 0 n44 ns1144 0 -0.00123991298908
Gc22_1145 0 n44 ns1145 0 -0.000332382172151
Gc22_1146 0 n44 ns1146 0 7.233200552e-05
Gc22_1147 0 n44 ns1147 0 -0.000131750869388
Gc22_1148 0 n44 ns1148 0 -0.000132205108006
Gc22_1149 0 n44 ns1149 0 0.000247569880706
Gc22_1150 0 n44 ns1150 0 -3.95633580658e-05
Gc22_1151 0 n44 ns1151 0 0.000212595051619
Gc22_1152 0 n44 ns1152 0 -4.93794955007e-05
Gc22_1153 0 n44 ns1153 0 2.57112414004e-05
Gc22_1154 0 n44 ns1154 0 9.77646138464e-05
Gc22_1155 0 n44 ns1155 0 -0.000353713940006
Gc22_1156 0 n44 ns1156 0 -0.000812899764377
Gc22_1157 0 n44 ns1157 0 0.00058393848338
Gc22_1158 0 n44 ns1158 0 -0.000712614579142
Gc22_1159 0 n44 ns1159 0 0.000118527924343
Gc22_1160 0 n44 ns1160 0 -0.00126531222571
Gc22_1161 0 n44 ns1161 0 0.00178974143378
Gc22_1162 0 n44 ns1162 0 0.000197260301142
Gc22_1163 0 n44 ns1163 0 0.00296209076268
Gc22_1164 0 n44 ns1164 0 0.00424436200668
Gc22_1165 0 n44 ns1165 0 0.00253666692229
Gc22_1166 0 n44 ns1166 0 0.00447285248477
Gc22_1167 0 n44 ns1167 0 -8.63761127137e-05
Gc22_1168 0 n44 ns1168 0 -0.00189717358996
Gc22_1169 0 n44 ns1169 0 0.000676946840778
Gc22_1170 0 n44 ns1170 0 -0.00107154511404
Gc22_1171 0 n44 ns1171 0 1.75539916864e-05
Gc22_1172 0 n44 ns1172 0 -0.000644294306917
Gc22_1173 0 n44 ns1173 0 -0.00223754207713
Gc22_1174 0 n44 ns1174 0 0.00220048443904
Gc22_1175 0 n44 ns1175 0 0.00197853949172
Gc22_1176 0 n44 ns1176 0 2.10997269706e-05
Gc22_1177 0 n44 ns1177 0 -0.000210706937932
Gc22_1178 0 n44 ns1178 0 6.14610943508e-05
Gc22_1179 0 n44 ns1179 0 -0.000166894267779
Gc22_1180 0 n44 ns1180 0 -0.000635559214063
Gc22_1181 0 n44 ns1181 0 -0.000570627415789
Gc22_1182 0 n44 ns1182 0 -0.000327692180028
Gc22_1183 0 n44 ns1183 0 8.5320339048e-05
Gc22_1184 0 n44 ns1184 0 -0.000104079906659
Gc22_1185 0 n44 ns1185 0 3.58113150059e-05
Gc22_1186 0 n44 ns1186 0 0.000102318417965
Gc22_1187 0 n44 ns1187 0 -0.000371091207439
Gc22_1188 0 n44 ns1188 0 -0.000568221647635
Gc22_1189 0 n44 ns1189 0 0.000205229522078
Gc22_1190 0 n44 ns1190 0 -5.99783980433e-06
Gc22_1191 0 n44 ns1191 0 7.62929657392e-05
Gc22_1192 0 n44 ns1192 0 0.000169477411766
Gc22_1193 0 n44 ns1193 0 -9.72059765687e-05
Gc22_1194 0 n44 ns1194 0 0.00138927285994
Gc22_1195 0 n44 ns1195 0 0.000586936922339
Gc22_1196 0 n44 ns1196 0 5.29141054352e-05
Gc22_1197 0 n44 ns1197 0 -7.03379207477e-05
Gc22_1198 0 n44 ns1198 0 0.000178778563004
Gc22_1199 0 n44 ns1199 0 -0.000900527622846
Gc22_1200 0 n44 ns1200 0 -0.0011732912312
Gc22_1201 0 n44 ns1201 0 -0.000235680494055
Gc22_1202 0 n44 ns1202 0 0.00382382171012
Gc22_1203 0 n44 ns1203 0 0.000206568810929
Gc22_1204 0 n44 ns1204 0 0.00388814748876
Gc22_1205 0 n44 ns1205 0 -0.0024708821483
Gc22_1206 0 n44 ns1206 0 -0.000168520968483
Gc22_1207 0 n44 ns1207 0 0.000208433830059
Gc22_1208 0 n44 ns1208 0 -0.000925294395818
Gc22_1209 0 n44 ns1209 0 0.000761694605311
Gc22_1210 0 n44 ns1210 0 -0.00109111536585
Gc22_1211 0 n44 ns1211 0 -0.000497859179127
Gc22_1212 0 n44 ns1212 0 0.00202049464983
Gc22_1213 0 n44 ns1213 0 0.000920167026837
Gc22_1214 0 n44 ns1214 0 -7.44234576639e-06
Gc22_1215 0 n44 ns1215 0 -0.000137205140909
Gc22_1216 0 n44 ns1216 0 4.44235092059e-06
Gd22_1 0 n44 ni1 0 0.000540084401155
Gd22_2 0 n44 ni2 0 0.000228690281699
Gd22_3 0 n44 ni3 0 -9.39856810385e-05
Gd22_4 0 n44 ni4 0 8.37773901441e-05
Gd22_5 0 n44 ni5 0 -1.76278945353e-05
Gd22_6 0 n44 ni6 0 -0.000386502099905
Gd22_7 0 n44 ni7 0 0.000556882718608
Gd22_8 0 n44 ni8 0 0.000593669650159
Gd22_9 0 n44 ni9 0 3.44750288179e-05
Gd22_10 0 n44 ni10 0 2.04798275562e-05
Gd22_11 0 n44 ni11 0 -0.000593766036317
Gd22_12 0 n44 ni12 0 0.000688288269412
Gd22_13 0 n44 ni13 0 -0.00395662058081
Gd22_14 0 n44 ni14 0 -0.00180712329168
Gd22_15 0 n44 ni15 0 0.000710240100737
Gd22_16 0 n44 ni16 0 -0.000443358665183
Gd22_17 0 n44 ni17 0 0.000257302051619
Gd22_18 0 n44 ni18 0 0.000280316217225
Gd22_19 0 n44 ni19 0 0.000412466204452
Gd22_20 0 n44 ni20 0 -0.000270842364346
Gd22_21 0 n44 ni21 0 -0.00142357461715
Gd22_22 0 n44 ni22 0 0.00148629285662
Gd22_23 0 n44 ni23 0 -0.00185078203825
Gd22_24 0 n44 ni24 0 -0.000648471365051
Gd22_25 0 n44 ni25 0 -4.57928568338e-05
Gd22_26 0 n44 ni26 0 0.000234690520166
Gd22_27 0 n44 ni27 0 0.000532465859854
Gd22_28 0 n44 ni28 0 -0.00138365803855
Gd22_29 0 n44 ni29 0 -0.000598836931322
Gd22_30 0 n44 ni30 0 -0.00310757914749
Gd22_31 0 n44 ni31 0 -0.00163725540684
Gd22_32 0 n44 ni32 0 9.58364891594e-05
Gc23_1 0 n46 ns1 0 -0.000490477808568
Gc23_2 0 n46 ns2 0 0.000967576981667
Gc23_3 0 n46 ns3 0 -0.00133661851357
Gc23_4 0 n46 ns4 0 0.00135239944587
Gc23_5 0 n46 ns5 0 -0.000127723351486
Gc23_6 0 n46 ns6 0 0.000461644433961
Gc23_7 0 n46 ns7 0 4.71298954176e-05
Gc23_8 0 n46 ns8 0 -0.000305200973633
Gc23_9 0 n46 ns9 0 -0.000217127607217
Gc23_10 0 n46 ns10 0 1.19755874333e-05
Gc23_11 0 n46 ns11 0 0.000129032469188
Gc23_12 0 n46 ns12 0 7.08397625866e-05
Gc23_13 0 n46 ns13 0 0.000500851921087
Gc23_14 0 n46 ns14 0 -0.000454436247356
Gc23_15 0 n46 ns15 0 4.82769052251e-05
Gc23_16 0 n46 ns16 0 -0.000569531270172
Gc23_17 0 n46 ns17 0 -0.000280002018014
Gc23_18 0 n46 ns18 0 -0.000246469950302
Gc23_19 0 n46 ns19 0 -0.000288678704024
Gc23_20 0 n46 ns20 0 -0.000171038821636
Gc23_21 0 n46 ns21 0 -0.000566502855318
Gc23_22 0 n46 ns22 0 -7.63422395738e-05
Gc23_23 0 n46 ns23 0 -0.00322490257947
Gc23_24 0 n46 ns24 0 0.0010461669613
Gc23_25 0 n46 ns25 0 -0.0027793930679
Gc23_26 0 n46 ns26 0 0.000967052095216
Gc23_27 0 n46 ns27 0 0.000409857605005
Gc23_28 0 n46 ns28 0 0.0009426776102
Gc23_29 0 n46 ns29 0 -0.000206105616081
Gc23_30 0 n46 ns30 0 -0.000187955302796
Gc23_31 0 n46 ns31 0 -0.000718946076813
Gc23_32 0 n46 ns32 0 -0.000701886521183
Gc23_33 0 n46 ns33 0 -8.43717669074e-05
Gc23_34 0 n46 ns34 0 -0.000422748772968
Gc23_35 0 n46 ns35 0 -0.000141073608234
Gc23_36 0 n46 ns36 0 -1.51348952665e-05
Gc23_37 0 n46 ns37 0 4.74826674694e-05
Gc23_38 0 n46 ns38 0 1.99974397837e-06
Gc23_39 0 n46 ns39 0 -0.000240477521638
Gc23_40 0 n46 ns40 0 0.000666373554894
Gc23_41 0 n46 ns41 0 -0.000545072436464
Gc23_42 0 n46 ns42 0 0.00106539501138
Gc23_43 0 n46 ns43 0 -9.77457519679e-06
Gc23_44 0 n46 ns44 0 0.000368420682447
Gc23_45 0 n46 ns45 0 1.73484214763e-05
Gc23_46 0 n46 ns46 0 -0.000258201429845
Gc23_47 0 n46 ns47 0 -0.000151705739052
Gc23_48 0 n46 ns48 0 -0.000146550240055
Gc23_49 0 n46 ns49 0 0.000101891290723
Gc23_50 0 n46 ns50 0 9.55995087613e-05
Gc23_51 0 n46 ns51 0 0.000423673586333
Gc23_52 0 n46 ns52 0 -0.000288991256401
Gc23_53 0 n46 ns53 0 9.8676832482e-05
Gc23_54 0 n46 ns54 0 -0.00065540968581
Gc23_55 0 n46 ns55 0 -0.000318199803317
Gc23_56 0 n46 ns56 0 -0.0003732161188
Gc23_57 0 n46 ns57 0 -0.000345045132912
Gc23_58 0 n46 ns58 0 -0.000320714227735
Gc23_59 0 n46 ns59 0 -0.000506298538021
Gc23_60 0 n46 ns60 0 -0.000103950098428
Gc23_61 0 n46 ns61 0 -0.00386431801376
Gc23_62 0 n46 ns62 0 0.00103172790617
Gc23_63 0 n46 ns63 0 -0.00336572519938
Gc23_64 0 n46 ns64 0 0.00095851285892
Gc23_65 0 n46 ns65 0 0.00066440150725
Gc23_66 0 n46 ns66 0 0.00123060831335
Gc23_67 0 n46 ns67 0 -0.000285423767463
Gc23_68 0 n46 ns68 0 -0.000250500060949
Gc23_69 0 n46 ns69 0 -0.00105259399254
Gc23_70 0 n46 ns70 0 -0.000969424226278
Gc23_71 0 n46 ns71 0 -0.00016756359147
Gc23_72 0 n46 ns72 0 -0.000752609057536
Gc23_73 0 n46 ns73 0 -0.000218050282458
Gc23_74 0 n46 ns74 0 1.84209710577e-07
Gc23_75 0 n46 ns75 0 1.51577569022e-05
Gc23_76 0 n46 ns76 0 2.64494932412e-05
Gc23_77 0 n46 ns77 0 0.00033317497323
Gc23_78 0 n46 ns78 0 -0.00017613192059
Gc23_79 0 n46 ns79 0 0.00123585842902
Gc23_80 0 n46 ns80 0 -0.000402696298883
Gc23_81 0 n46 ns81 0 0.00022938063729
Gc23_82 0 n46 ns82 0 -3.0983245292e-05
Gc23_83 0 n46 ns83 0 -7.52378566899e-05
Gc23_84 0 n46 ns84 0 5.64918817463e-05
Gc23_85 0 n46 ns85 0 0.000300437418717
Gc23_86 0 n46 ns86 0 -0.000387155235332
Gc23_87 0 n46 ns87 0 -7.24277817067e-05
Gc23_88 0 n46 ns88 0 0.000110289486
Gc23_89 0 n46 ns89 0 -0.000177171943754
Gc23_90 0 n46 ns90 0 0.000397411881369
Gc23_91 0 n46 ns91 0 0.000417678678888
Gc23_92 0 n46 ns92 0 -0.000204160242677
Gc23_93 0 n46 ns93 0 -7.63840857662e-05
Gc23_94 0 n46 ns94 0 -0.00056063363311
Gc23_95 0 n46 ns95 0 -0.000211404834789
Gc23_96 0 n46 ns96 0 -0.000510967198558
Gc23_97 0 n46 ns97 0 -4.87224973589e-05
Gc23_98 0 n46 ns98 0 -0.000362594761931
Gc23_99 0 n46 ns99 0 -0.00475856005967
Gc23_100 0 n46 ns100 0 -0.00140212458623
Gc23_101 0 n46 ns101 0 -0.00431368356029
Gc23_102 0 n46 ns102 0 -0.00117819453203
Gc23_103 0 n46 ns103 0 0.000610067240356
Gc23_104 0 n46 ns104 0 0.00170754919977
Gc23_105 0 n46 ns105 0 -0.00038686336063
Gc23_106 0 n46 ns106 0 -0.000492577264551
Gc23_107 0 n46 ns107 0 -0.00142586998548
Gc23_108 0 n46 ns108 0 -0.0016285364037
Gc23_109 0 n46 ns109 0 -0.00023591727575
Gc23_110 0 n46 ns110 0 -0.00132891995341
Gc23_111 0 n46 ns111 0 -0.000380423091439
Gc23_112 0 n46 ns112 0 -3.30864297166e-06
Gc23_113 0 n46 ns113 0 2.93369504053e-05
Gc23_114 0 n46 ns114 0 2.59925016413e-05
Gc23_115 0 n46 ns115 0 -0.000129014591064
Gc23_116 0 n46 ns116 0 0.000124816143587
Gc23_117 0 n46 ns117 0 -8.46398594458e-05
Gc23_118 0 n46 ns118 0 0.000556672169638
Gc23_119 0 n46 ns119 0 -0.000177769781534
Gc23_120 0 n46 ns120 0 0.000191026073533
Gc23_121 0 n46 ns121 0 -1.38057696771e-05
Gc23_122 0 n46 ns122 0 -8.53165678262e-05
Gc23_123 0 n46 ns123 0 0.000342325319606
Gc23_124 0 n46 ns124 0 0.00036172210352
Gc23_125 0 n46 ns125 0 -6.82280501174e-05
Gc23_126 0 n46 ns126 0 6.02452052473e-05
Gc23_127 0 n46 ns127 0 -0.000174770187209
Gc23_128 0 n46 ns128 0 -0.000392515420406
Gc23_129 0 n46 ns129 0 0.00030482074476
Gc23_130 0 n46 ns130 0 0.000527045973136
Gc23_131 0 n46 ns131 0 0.000415446313584
Gc23_132 0 n46 ns132 0 -0.00031129394068
Gc23_133 0 n46 ns133 0 0.000185634374861
Gc23_134 0 n46 ns134 0 -0.000114191934231
Gc23_135 0 n46 ns135 0 -2.7753472891e-05
Gc23_136 0 n46 ns136 0 0.000262687965061
Gc23_137 0 n46 ns137 0 -0.00393546943642
Gc23_138 0 n46 ns138 0 -0.00367449465273
Gc23_139 0 n46 ns139 0 -0.00373198607792
Gc23_140 0 n46 ns140 0 -0.00342417279463
Gc23_141 0 n46 ns141 0 -0.000243276460725
Gc23_142 0 n46 ns142 0 0.00204164620412
Gc23_143 0 n46 ns143 0 -0.000262098624447
Gc23_144 0 n46 ns144 0 -0.000954672622489
Gc23_145 0 n46 ns145 0 -0.00103910860782
Gc23_146 0 n46 ns146 0 -0.00270169275691
Gc23_147 0 n46 ns147 0 3.20654837902e-05
Gc23_148 0 n46 ns148 0 -0.00223542516973
Gc23_149 0 n46 ns149 0 -0.000743761770166
Gc23_150 0 n46 ns150 0 -1.78679635863e-05
Gc23_151 0 n46 ns151 0 8.22855191805e-05
Gc23_152 0 n46 ns152 0 -1.1689455253e-05
Gc23_153 0 n46 ns153 0 7.77871719139e-05
Gc23_154 0 n46 ns154 0 -0.000557835001739
Gc23_155 0 n46 ns155 0 0.00036574403048
Gc23_156 0 n46 ns156 0 0.00102204629196
Gc23_157 0 n46 ns157 0 0.000196659648452
Gc23_158 0 n46 ns158 0 5.25997728402e-05
Gc23_159 0 n46 ns159 0 -7.22669523696e-05
Gc23_160 0 n46 ns160 0 -0.000153770105025
Gc23_161 0 n46 ns161 0 -0.00033838968914
Gc23_162 0 n46 ns162 0 0.0002715942451
Gc23_163 0 n46 ns163 0 -0.00011773713732
Gc23_164 0 n46 ns164 0 0.000113752968624
Gc23_165 0 n46 ns165 0 0.00072475610493
Gc23_166 0 n46 ns166 0 -0.000343252518431
Gc23_167 0 n46 ns167 0 -0.000484410684146
Gc23_168 0 n46 ns168 0 -0.00011416607126
Gc23_169 0 n46 ns169 0 0.000351853814322
Gc23_170 0 n46 ns170 0 -0.000310547049608
Gc23_171 0 n46 ns171 0 -0.000194178640969
Gc23_172 0 n46 ns172 0 -0.00043924401572
Gc23_173 0 n46 ns173 0 -0.00100861588544
Gc23_174 0 n46 ns174 0 0.000883583898679
Gc23_175 0 n46 ns175 0 -0.00268375828885
Gc23_176 0 n46 ns176 0 -0.00225052275342
Gc23_177 0 n46 ns177 0 -0.00245492297244
Gc23_178 0 n46 ns178 0 -0.00269137266442
Gc23_179 0 n46 ns179 0 -0.000155411414057
Gc23_180 0 n46 ns180 0 0.000748862049275
Gc23_181 0 n46 ns181 0 0.000290330427281
Gc23_182 0 n46 ns182 0 -0.00130111335117
Gc23_183 0 n46 ns183 0 -0.000254385184589
Gc23_184 0 n46 ns184 0 -0.00277356211082
Gc23_185 0 n46 ns185 0 0.00100242537973
Gc23_186 0 n46 ns186 0 -0.00322454835242
Gc23_187 0 n46 ns187 0 -0.00156334641614
Gc23_188 0 n46 ns188 0 -2.48569133302e-05
Gc23_189 0 n46 ns189 0 0.000100408835988
Gc23_190 0 n46 ns190 0 4.02951701995e-06
Gc23_191 0 n46 ns191 0 -0.0013626099822
Gc23_192 0 n46 ns192 0 -2.89344164301e-05
Gc23_193 0 n46 ns193 0 -0.00479917312472
Gc23_194 0 n46 ns194 0 -0.000447591808877
Gc23_195 0 n46 ns195 0 -0.00212494088573
Gc23_196 0 n46 ns196 0 0.001505704655
Gc23_197 0 n46 ns197 0 0.000964425480371
Gc23_198 0 n46 ns198 0 -0.000687368539462
Gc23_199 0 n46 ns199 0 -0.00034222906803
Gc23_200 0 n46 ns200 0 0.000180289604969
Gc23_201 0 n46 ns201 0 -0.000160579711355
Gc23_202 0 n46 ns202 0 5.62309671681e-05
Gc23_203 0 n46 ns203 0 0.000854103322904
Gc23_204 0 n46 ns204 0 -6.87929546168e-05
Gc23_205 0 n46 ns205 0 0.00112804788509
Gc23_206 0 n46 ns206 0 -0.00104722655916
Gc23_207 0 n46 ns207 0 0.00116214813076
Gc23_208 0 n46 ns208 0 -0.00044958497375
Gc23_209 0 n46 ns209 0 0.00103234013147
Gc23_210 0 n46 ns210 0 -0.000719567525289
Gc23_211 0 n46 ns211 0 -0.00220170126792
Gc23_212 0 n46 ns212 0 -0.000829058755792
Gc23_213 0 n46 ns213 0 -0.00651754458265
Gc23_214 0 n46 ns214 0 -0.00316453111959
Gc23_215 0 n46 ns215 0 -0.00518226734712
Gc23_216 0 n46 ns216 0 -0.00357528485286
Gc23_217 0 n46 ns217 0 0.00338201015675
Gc23_218 0 n46 ns218 0 0.00223660657981
Gc23_219 0 n46 ns219 0 0.000856519004016
Gc23_220 0 n46 ns220 0 -0.00124080276464
Gc23_221 0 n46 ns221 0 -0.00204849863861
Gc23_222 0 n46 ns222 0 -0.00313876150049
Gc23_223 0 n46 ns223 0 0.00248259334274
Gc23_224 0 n46 ns224 0 -0.000726251374154
Gc23_225 0 n46 ns225 0 -0.00322956970689
Gc23_226 0 n46 ns226 0 -4.82425162767e-05
Gc23_227 0 n46 ns227 0 0.000378603322896
Gc23_228 0 n46 ns228 0 -0.000175782488159
Gc23_229 0 n46 ns229 0 -0.000519165020424
Gc23_230 0 n46 ns230 0 -0.000136576123038
Gc23_231 0 n46 ns231 0 0.000429733023324
Gc23_232 0 n46 ns232 0 0.00310217051699
Gc23_233 0 n46 ns233 0 0.00130712790513
Gc23_234 0 n46 ns234 0 -0.000834454890577
Gc23_235 0 n46 ns235 0 -0.0002881359957
Gc23_236 0 n46 ns236 0 2.9477050965e-05
Gc23_237 0 n46 ns237 0 0.000400812362485
Gc23_238 0 n46 ns238 0 0.000225839203908
Gc23_239 0 n46 ns239 0 -0.000193036030893
Gc23_240 0 n46 ns240 0 -1.83716850337e-05
Gc23_241 0 n46 ns241 0 0.00182715347296
Gc23_242 0 n46 ns242 0 -0.000792221971468
Gc23_243 0 n46 ns243 0 -0.000163337401841
Gc23_244 0 n46 ns244 0 0.00134768747142
Gc23_245 0 n46 ns245 0 -9.48782984543e-05
Gc23_246 0 n46 ns246 0 -9.93284076661e-05
Gc23_247 0 n46 ns247 0 -0.00167376905775
Gc23_248 0 n46 ns248 0 -0.00144848764666
Gc23_249 0 n46 ns249 0 0.00321748101689
Gc23_250 0 n46 ns250 0 0.00371650426719
Gc23_251 0 n46 ns251 0 -0.00953364355139
Gc23_252 0 n46 ns252 0 -0.00095339108607
Gc23_253 0 n46 ns253 0 -0.00725472031048
Gc23_254 0 n46 ns254 0 -0.00208033152253
Gc23_255 0 n46 ns255 0 -0.0111853710294
Gc23_256 0 n46 ns256 0 -0.000335566721226
Gc23_257 0 n46 ns257 0 0.00151900892439
Gc23_258 0 n46 ns258 0 -2.19826806218e-05
Gc23_259 0 n46 ns259 0 -0.00327588244116
Gc23_260 0 n46 ns260 0 0.00837412242787
Gc23_261 0 n46 ns261 0 -0.0141833225454
Gc23_262 0 n46 ns262 0 -0.00409268293463
Gc23_263 0 n46 ns263 0 -0.00625668577928
Gc23_264 0 n46 ns264 0 -6.24008838116e-05
Gc23_265 0 n46 ns265 0 -0.00039220249564
Gc23_266 0 n46 ns266 0 0.000610691723649
Gc23_267 0 n46 ns267 0 -0.000741815704434
Gc23_268 0 n46 ns268 0 -0.000917455680967
Gc23_269 0 n46 ns269 0 -0.003265533921
Gc23_270 0 n46 ns270 0 -0.00150342623054
Gc23_271 0 n46 ns271 0 -0.0018275426843
Gc23_272 0 n46 ns272 0 0.00103113407039
Gc23_273 0 n46 ns273 0 0.000718925777526
Gc23_274 0 n46 ns274 0 -0.000353999004159
Gc23_275 0 n46 ns275 0 -0.00028469977145
Gc23_276 0 n46 ns276 0 0.000446973424147
Gc23_277 0 n46 ns277 0 -0.000214832407469
Gc23_278 0 n46 ns278 0 -0.000100000781975
Gc23_279 0 n46 ns279 0 0.000209172077025
Gc23_280 0 n46 ns280 0 1.71084356973e-06
Gc23_281 0 n46 ns281 0 0.000767339946131
Gc23_282 0 n46 ns282 0 -0.000354909429665
Gc23_283 0 n46 ns283 0 0.00138284884919
Gc23_284 0 n46 ns284 0 -3.52430329471e-06
Gc23_285 0 n46 ns285 0 0.00126068120864
Gc23_286 0 n46 ns286 0 -0.000341491559291
Gc23_287 0 n46 ns287 0 -0.00159859659279
Gc23_288 0 n46 ns288 0 -0.000633281266209
Gc23_289 0 n46 ns289 0 -0.00273093610318
Gc23_290 0 n46 ns290 0 -0.00418985027265
Gc23_291 0 n46 ns291 0 -0.00191993710297
Gc23_292 0 n46 ns292 0 -0.00455443224378
Gc23_293 0 n46 ns293 0 0.00283621957756
Gc23_294 0 n46 ns294 0 0.00124910953673
Gc23_295 0 n46 ns295 0 0.00106265521346
Gc23_296 0 n46 ns296 0 -0.00115619041673
Gc23_297 0 n46 ns297 0 -0.00135817435646
Gc23_298 0 n46 ns298 0 -0.00255240622619
Gc23_299 0 n46 ns299 0 0.00266213920551
Gc23_300 0 n46 ns300 0 -0.000264712773718
Gc23_301 0 n46 ns301 0 -0.0031525375755
Gc23_302 0 n46 ns302 0 -3.1456265682e-05
Gc23_303 0 n46 ns303 0 0.000273284571639
Gc23_304 0 n46 ns304 0 -0.000130759576879
Gc23_305 0 n46 ns305 0 -0.000396080848047
Gc23_306 0 n46 ns306 0 0.000111893436064
Gc23_307 0 n46 ns307 0 -0.0011417730654
Gc23_308 0 n46 ns308 0 0.00150497368831
Gc23_309 0 n46 ns309 0 -7.6071665547e-05
Gc23_310 0 n46 ns310 0 0.000130037766374
Gc23_311 0 n46 ns311 0 8.09156876487e-05
Gc23_312 0 n46 ns312 0 -0.000267473331474
Gc23_313 0 n46 ns313 0 -0.000692475105459
Gc23_314 0 n46 ns314 0 0.000660455538193
Gc23_315 0 n46 ns315 0 -4.01932559666e-05
Gc23_316 0 n46 ns316 0 -1.36135232414e-05
Gc23_317 0 n46 ns317 0 0.000972003164797
Gc23_318 0 n46 ns318 0 -0.000784199042329
Gc23_319 0 n46 ns319 0 -0.00101917597431
Gc23_320 0 n46 ns320 0 8.15631737636e-05
Gc23_321 0 n46 ns321 0 0.000445035119594
Gc23_322 0 n46 ns322 0 0.000289300026393
Gc23_323 0 n46 ns323 0 3.63126927758e-06
Gc23_324 0 n46 ns324 0 8.62568088159e-05
Gc23_325 0 n46 ns325 0 -0.000968418020793
Gc23_326 0 n46 ns326 0 0.00135836341488
Gc23_327 0 n46 ns327 0 0.00215463787048
Gc23_328 0 n46 ns328 0 -0.00149462799039
Gc23_329 0 n46 ns329 0 0.00188837004104
Gc23_330 0 n46 ns330 0 -0.0021695984836
Gc23_331 0 n46 ns331 0 -0.000900427164747
Gc23_332 0 n46 ns332 0 -0.000868386335518
Gc23_333 0 n46 ns333 0 0.000704656694458
Gc23_334 0 n46 ns334 0 -0.00107456214714
Gc23_335 0 n46 ns335 0 0.00106932582128
Gc23_336 0 n46 ns336 0 -0.00161789296969
Gc23_337 0 n46 ns337 0 0.00137646987357
Gc23_338 0 n46 ns338 0 -0.00214082871668
Gc23_339 0 n46 ns339 0 -0.00139563182088
Gc23_340 0 n46 ns340 0 -3.08638030288e-05
Gc23_341 0 n46 ns341 0 0.000130917188923
Gc23_342 0 n46 ns342 0 -1.10958790337e-05
Gc23_343 0 n46 ns343 0 0.000424983359697
Gc23_344 0 n46 ns344 0 -0.000177220551372
Gc23_345 0 n46 ns345 0 0.00131534555602
Gc23_346 0 n46 ns346 0 -0.000453374626477
Gc23_347 0 n46 ns347 0 0.000354455360737
Gc23_348 0 n46 ns348 0 -6.23166968399e-05
Gc23_349 0 n46 ns349 0 -0.000152674198598
Gc23_350 0 n46 ns350 0 1.22350412198e-05
Gc23_351 0 n46 ns351 0 4.94634263527e-05
Gc23_352 0 n46 ns352 0 -0.000507912133443
Gc23_353 0 n46 ns353 0 -2.60422902649e-05
Gc23_354 0 n46 ns354 0 0.000129045603805
Gc23_355 0 n46 ns355 0 4.09627031961e-05
Gc23_356 0 n46 ns356 0 0.000400307903677
Gc23_357 0 n46 ns357 0 0.000194480456433
Gc23_358 0 n46 ns358 0 -0.000395120429838
Gc23_359 0 n46 ns359 0 -0.000290406141423
Gc23_360 0 n46 ns360 0 -0.000476607408678
Gc23_361 0 n46 ns361 0 -0.000435525982149
Gc23_362 0 n46 ns362 0 -0.000442170118426
Gc23_363 0 n46 ns363 0 -0.000199513646202
Gc23_364 0 n46 ns364 0 -0.000419460659881
Gc23_365 0 n46 ns365 0 -0.00444876924376
Gc23_366 0 n46 ns366 0 -0.000482575008776
Gc23_367 0 n46 ns367 0 -0.00397629370229
Gc23_368 0 n46 ns368 0 -0.000345197533404
Gc23_369 0 n46 ns369 0 0.00070791269482
Gc23_370 0 n46 ns370 0 0.00135806918312
Gc23_371 0 n46 ns371 0 -0.000358903816773
Gc23_372 0 n46 ns372 0 -0.000356878730649
Gc23_373 0 n46 ns373 0 -0.00134992916315
Gc23_374 0 n46 ns374 0 -0.00116210886723
Gc23_375 0 n46 ns375 0 -0.00023067542842
Gc23_376 0 n46 ns376 0 -0.00082620905505
Gc23_377 0 n46 ns377 0 -0.000240624301947
Gc23_378 0 n46 ns378 0 -6.79836600821e-06
Gc23_379 0 n46 ns379 0 -1.63571246619e-05
Gc23_380 0 n46 ns380 0 5.30647485557e-05
Gc23_381 0 n46 ns381 0 -2.01666897354e-05
Gc23_382 0 n46 ns382 0 0.00021184771653
Gc23_383 0 n46 ns383 0 0.000245937332006
Gc23_384 0 n46 ns384 0 0.000335755594967
Gc23_385 0 n46 ns385 0 -2.3513685871e-05
Gc23_386 0 n46 ns386 0 0.000203173793671
Gc23_387 0 n46 ns387 0 -4.43598400958e-05
Gc23_388 0 n46 ns388 0 -2.65962411836e-05
Gc23_389 0 n46 ns389 0 0.000449507384111
Gc23_390 0 n46 ns390 0 9.50754673739e-05
Gc23_391 0 n46 ns391 0 -6.49806792455e-05
Gc23_392 0 n46 ns392 0 6.01716008494e-05
Gc23_393 0 n46 ns393 0 -0.00033153150403
Gc23_394 0 n46 ns394 0 -9.18564153463e-05
Gc23_395 0 n46 ns395 0 0.000487312536925
Gc23_396 0 n46 ns396 0 0.000283839542995
Gc23_397 0 n46 ns397 0 0.000277584383066
Gc23_398 0 n46 ns398 0 -0.000431308911669
Gc23_399 0 n46 ns399 0 0.000139418577265
Gc23_400 0 n46 ns400 0 -0.000280155753127
Gc23_401 0 n46 ns401 0 5.38286384056e-05
Gc23_402 0 n46 ns402 0 -3.15891607826e-05
Gc23_403 0 n46 ns403 0 -0.00444151020407
Gc23_404 0 n46 ns404 0 -0.00303146863642
Gc23_405 0 n46 ns405 0 -0.0041311881747
Gc23_406 0 n46 ns406 0 -0.00272951510333
Gc23_407 0 n46 ns407 0 0.000145805388033
Gc23_408 0 n46 ns408 0 0.00204073310165
Gc23_409 0 n46 ns409 0 -0.000356522571861
Gc23_410 0 n46 ns410 0 -0.000759853892057
Gc23_411 0 n46 ns411 0 -0.00130189329415
Gc23_412 0 n46 ns412 0 -0.00229953501793
Gc23_413 0 n46 ns413 0 -0.000117071181047
Gc23_414 0 n46 ns414 0 -0.00185522671288
Gc23_415 0 n46 ns415 0 -0.000575466740653
Gc23_416 0 n46 ns416 0 -1.22188119292e-05
Gc23_417 0 n46 ns417 0 4.00562127971e-05
Gc23_418 0 n46 ns418 0 1.05904075953e-05
Gc23_419 0 n46 ns419 0 0.000288074876093
Gc23_420 0 n46 ns420 0 -0.000725526114165
Gc23_421 0 n46 ns421 0 0.000895283196497
Gc23_422 0 n46 ns422 0 7.40970909465e-05
Gc23_423 0 n46 ns423 0 4.83644254322e-05
Gc23_424 0 n46 ns424 0 -0.000291166319842
Gc23_425 0 n46 ns425 0 -8.03431434087e-05
Gc23_426 0 n46 ns426 0 2.5233904285e-05
Gc23_427 0 n46 ns427 0 -0.000165443452592
Gc23_428 0 n46 ns428 0 0.000308172733306
Gc23_429 0 n46 ns429 0 -0.000100568612056
Gc23_430 0 n46 ns430 0 0.000120747077532
Gc23_431 0 n46 ns431 0 0.000417706917409
Gc23_432 0 n46 ns432 0 -0.000359126741744
Gc23_433 0 n46 ns433 0 -0.000388081028303
Gc23_434 0 n46 ns434 0 0.000399849116704
Gc23_435 0 n46 ns435 0 0.000281561623862
Gc23_436 0 n46 ns436 0 -0.00017050592162
Gc23_437 0 n46 ns437 0 -0.000229950107588
Gc23_438 0 n46 ns438 0 -8.46428082508e-05
Gc23_439 0 n46 ns439 0 -0.000443703830101
Gc23_440 0 n46 ns440 0 0.000717068469456
Gc23_441 0 n46 ns441 0 -0.00227747474317
Gc23_442 0 n46 ns442 0 -0.00322642924562
Gc23_443 0 n46 ns443 0 -0.00223673407895
Gc23_444 0 n46 ns444 0 -0.00333383471493
Gc23_445 0 n46 ns445 0 -0.000683029431989
Gc23_446 0 n46 ns446 0 0.00118110742326
Gc23_447 0 n46 ns447 0 7.91883602645e-05
Gc23_448 0 n46 ns448 0 -0.00120962989267
Gc23_449 0 n46 ns449 0 -0.000321436303269
Gc23_450 0 n46 ns450 0 -0.00285138984039
Gc23_451 0 n46 ns451 0 0.00054801082613
Gc23_452 0 n46 ns452 0 -0.00281837543013
Gc23_453 0 n46 ns453 0 -0.00114936443027
Gc23_454 0 n46 ns454 0 -3.36816939613e-05
Gc23_455 0 n46 ns455 0 9.40981655557e-05
Gc23_456 0 n46 ns456 0 -4.63221492982e-07
Gc23_457 0 n46 ns457 0 -0.00105230704635
Gc23_458 0 n46 ns458 0 4.95429683737e-05
Gc23_459 0 n46 ns459 0 -0.00312469559751
Gc23_460 0 n46 ns460 0 0.00152956841344
Gc23_461 0 n46 ns461 0 -0.00033722243408
Gc23_462 0 n46 ns462 0 0.00113701077525
Gc23_463 0 n46 ns463 0 0.000227722271712
Gc23_464 0 n46 ns464 0 -0.000493050601936
Gc23_465 0 n46 ns465 0 -0.000376008734529
Gc23_466 0 n46 ns466 0 0.000151382164464
Gc23_467 0 n46 ns467 0 -0.000155305699663
Gc23_468 0 n46 ns468 0 9.61472742278e-05
Gc23_469 0 n46 ns469 0 0.000952907324613
Gc23_470 0 n46 ns470 0 0.000113318264694
Gc23_471 0 n46 ns471 0 0.000331849601688
Gc23_472 0 n46 ns472 0 -0.0008250643324
Gc23_473 0 n46 ns473 0 0.000758242517593
Gc23_474 0 n46 ns474 0 -0.000479896150224
Gc23_475 0 n46 ns475 0 0.000464677984318
Gc23_476 0 n46 ns476 0 -0.000830573124273
Gc23_477 0 n46 ns477 0 -0.00231646343926
Gc23_478 0 n46 ns478 0 -5.76257970767e-05
Gc23_479 0 n46 ns479 0 -0.00610402805722
Gc23_480 0 n46 ns480 0 -0.00216289231219
Gc23_481 0 n46 ns481 0 -0.00497106023559
Gc23_482 0 n46 ns482 0 -0.002724524998
Gc23_483 0 n46 ns483 0 0.00173265852694
Gc23_484 0 n46 ns484 0 0.00017830907925
Gc23_485 0 n46 ns485 0 0.000784245215325
Gc23_486 0 n46 ns486 0 -0.00118444966848
Gc23_487 0 n46 ns487 0 -0.000508758361567
Gc23_488 0 n46 ns488 0 -0.00193601460346
Gc23_489 0 n46 ns489 0 0.00240689223411
Gc23_490 0 n46 ns490 0 -0.00261413891776
Gc23_491 0 n46 ns491 0 -0.00252675266277
Gc23_492 0 n46 ns492 0 -9.53262227002e-06
Gc23_493 0 n46 ns493 0 0.000196250339634
Gc23_494 0 n46 ns494 0 -5.11436481557e-05
Gc23_495 0 n46 ns495 0 0.00216920971808
Gc23_496 0 n46 ns496 0 -0.00324655651343
Gc23_497 0 n46 ns497 0 0.00476099392555
Gc23_498 0 n46 ns498 0 -0.00645600548118
Gc23_499 0 n46 ns499 0 -0.00336974407692
Gc23_500 0 n46 ns500 0 -0.00226708641265
Gc23_501 0 n46 ns501 0 0.00119284519347
Gc23_502 0 n46 ns502 0 0.000660763499534
Gc23_503 0 n46 ns503 0 -0.000279182694712
Gc23_504 0 n46 ns504 0 -0.00054301606238
Gc23_505 0 n46 ns505 0 -0.00027699997072
Gc23_506 0 n46 ns506 0 6.0725736097e-06
Gc23_507 0 n46 ns507 0 -0.000409269980241
Gc23_508 0 n46 ns508 0 -0.000347240764159
Gc23_509 0 n46 ns509 0 0.00147525562543
Gc23_510 0 n46 ns510 0 3.00501205017e-05
Gc23_511 0 n46 ns511 0 0.00102846619275
Gc23_512 0 n46 ns512 0 0.000207914445288
Gc23_513 0 n46 ns513 0 0.000426699486067
Gc23_514 0 n46 ns514 0 0.000392350507708
Gc23_515 0 n46 ns515 0 0.000882535095142
Gc23_516 0 n46 ns516 0 -0.00303849127061
Gc23_517 0 n46 ns517 0 -0.00227244243624
Gc23_518 0 n46 ns518 0 -0.00804981790684
Gc23_519 0 n46 ns519 0 -0.00159817241301
Gc23_520 0 n46 ns520 0 -0.00754340027532
Gc23_521 0 n46 ns521 0 0.00539243513642
Gc23_522 0 n46 ns522 0 0.00810537851889
Gc23_523 0 n46 ns523 0 0.000818682272645
Gc23_524 0 n46 ns524 0 -0.00123026946486
Gc23_525 0 n46 ns525 0 -0.00526149346922
Gc23_526 0 n46 ns526 0 -0.0059996034401
Gc23_527 0 n46 ns527 0 0.00146081685336
Gc23_528 0 n46 ns528 0 0.00525646564124
Gc23_529 0 n46 ns529 0 -0.00430917078367
Gc23_530 0 n46 ns530 0 2.32227782875e-06
Gc23_531 0 n46 ns531 0 0.000421490651738
Gc23_532 0 n46 ns532 0 -0.000231461254487
Gc23_533 0 n46 ns533 0 0.00125367479345
Gc23_534 0 n46 ns534 0 -0.00277671639802
Gc23_535 0 n46 ns535 0 0.0023355924529
Gc23_536 0 n46 ns536 0 -0.00461562165354
Gc23_537 0 n46 ns537 0 -0.00238386558473
Gc23_538 0 n46 ns538 0 -0.00136099406739
Gc23_539 0 n46 ns539 0 0.000846349212579
Gc23_540 0 n46 ns540 0 0.000566088339662
Gc23_541 0 n46 ns541 0 -0.000199684001808
Gc23_542 0 n46 ns542 0 -0.000196071384899
Gc23_543 0 n46 ns543 0 -0.000297641730396
Gc23_544 0 n46 ns544 0 -7.96748163731e-05
Gc23_545 0 n46 ns545 0 -0.000322680832156
Gc23_546 0 n46 ns546 0 0.000136402837049
Gc23_547 0 n46 ns547 0 0.00129373113536
Gc23_548 0 n46 ns548 0 -3.2840343709e-05
Gc23_549 0 n46 ns549 0 0.00127626710751
Gc23_550 0 n46 ns550 0 0.000142856169072
Gc23_551 0 n46 ns551 0 0.000840886574909
Gc23_552 0 n46 ns552 0 -4.07126907152e-05
Gc23_553 0 n46 ns553 0 -0.000346431440664
Gc23_554 0 n46 ns554 0 -0.0020369147475
Gc23_555 0 n46 ns555 0 -0.00309344633509
Gc23_556 0 n46 ns556 0 -0.00575041176069
Gc23_557 0 n46 ns557 0 -0.00220458973769
Gc23_558 0 n46 ns558 0 -0.00582981126976
Gc23_559 0 n46 ns559 0 0.00392706054411
Gc23_560 0 n46 ns560 0 0.00360753421195
Gc23_561 0 n46 ns561 0 0.00108679397076
Gc23_562 0 n46 ns562 0 -0.00112204773746
Gc23_563 0 n46 ns563 0 -0.00261168052661
Gc23_564 0 n46 ns564 0 -0.00316253096031
Gc23_565 0 n46 ns565 0 0.00234033557352
Gc23_566 0 n46 ns566 0 0.00171101884039
Gc23_567 0 n46 ns567 0 -0.00372474272111
Gc23_568 0 n46 ns568 0 1.25107552786e-05
Gc23_569 0 n46 ns569 0 0.00024743970513
Gc23_570 0 n46 ns570 0 -0.00011943332119
Gc23_571 0 n46 ns571 0 -0.000768149953178
Gc23_572 0 n46 ns572 0 -4.62129693602e-05
Gc23_573 0 n46 ns573 0 -0.00247473504894
Gc23_574 0 n46 ns574 0 0.001447899535
Gc23_575 0 n46 ns575 0 -0.00041820539309
Gc23_576 0 n46 ns576 0 0.00064606306847
Gc23_577 0 n46 ns577 0 0.000244036050165
Gc23_578 0 n46 ns578 0 -0.000389021040332
Gc23_579 0 n46 ns579 0 -0.000659656088385
Gc23_580 0 n46 ns580 0 0.000704009290745
Gc23_581 0 n46 ns581 0 -9.46331968022e-05
Gc23_582 0 n46 ns582 0 -3.9364119178e-05
Gc23_583 0 n46 ns583 0 0.000962093816203
Gc23_584 0 n46 ns584 0 -0.000641362721074
Gc23_585 0 n46 ns585 0 -0.000651698460004
Gc23_586 0 n46 ns586 0 -0.000144222457128
Gc23_587 0 n46 ns587 0 0.000757538071889
Gc23_588 0 n46 ns588 0 0.000197971995541
Gc23_589 0 n46 ns589 0 0.000369788163582
Gc23_590 0 n46 ns590 0 -9.42257799699e-05
Gc23_591 0 n46 ns591 0 -0.0014715860415
Gc23_592 0 n46 ns592 0 0.00108145163128
Gc23_593 0 n46 ns593 0 0.0005966749645
Gc23_594 0 n46 ns594 0 -0.00194211402427
Gc23_595 0 n46 ns595 0 0.000679135154996
Gc23_596 0 n46 ns596 0 -0.00269508192913
Gc23_597 0 n46 ns597 0 -0.000171118045317
Gc23_598 0 n46 ns598 0 -0.00071131501897
Gc23_599 0 n46 ns599 0 0.000896923920561
Gc23_600 0 n46 ns600 0 -0.00120444274264
Gc23_601 0 n46 ns601 0 0.000850950505924
Gc23_602 0 n46 ns602 0 -0.0018287800334
Gc23_603 0 n46 ns603 0 0.00198103861855
Gc23_604 0 n46 ns604 0 -0.00252824714923
Gc23_605 0 n46 ns605 0 -0.00201183210706
Gc23_606 0 n46 ns606 0 -2.58627524816e-05
Gc23_607 0 n46 ns607 0 0.000116125027201
Gc23_608 0 n46 ns608 0 -1.30413449265e-05
Gc23_609 0 n46 ns609 0 0.000447215280274
Gc23_610 0 n46 ns610 0 5.14303784398e-05
Gc23_611 0 n46 ns611 0 0.0014336169318
Gc23_612 0 n46 ns612 0 -8.0257778473e-05
Gc23_613 0 n46 ns613 0 0.000112065085624
Gc23_614 0 n46 ns614 0 -6.84708740352e-05
Gc23_615 0 n46 ns615 0 -3.57819273904e-05
Gc23_616 0 n46 ns616 0 0.000108523944406
Gc23_617 0 n46 ns617 0 0.000261528327951
Gc23_618 0 n46 ns618 0 0.000167117064849
Gc23_619 0 n46 ns619 0 -5.96211585374e-05
Gc23_620 0 n46 ns620 0 -6.74141999684e-05
Gc23_621 0 n46 ns621 0 -0.000310239785607
Gc23_622 0 n46 ns622 0 -0.000222584551943
Gc23_623 0 n46 ns623 0 -0.000288798306677
Gc23_624 0 n46 ns624 0 -0.000676502081361
Gc23_625 0 n46 ns625 0 -0.000384304597558
Gc23_626 0 n46 ns626 0 -0.000380545573332
Gc23_627 0 n46 ns627 0 -0.000382747848594
Gc23_628 0 n46 ns628 0 -0.000544998740554
Gc23_629 0 n46 ns629 0 0.000724218993761
Gc23_630 0 n46 ns630 0 0.000246137132212
Gc23_631 0 n46 ns631 0 0.0027793182222
Gc23_632 0 n46 ns632 0 -0.000596139841303
Gc23_633 0 n46 ns633 0 0.00239475005014
Gc23_634 0 n46 ns634 0 -0.000613963260623
Gc23_635 0 n46 ns635 0 0.000534685597552
Gc23_636 0 n46 ns636 0 0.000292923726159
Gc23_637 0 n46 ns637 0 -0.000190478916616
Gc23_638 0 n46 ns638 0 -0.000122169645876
Gc23_639 0 n46 ns639 0 -0.000831469709789
Gc23_640 0 n46 ns640 0 -0.000322577744172
Gc23_641 0 n46 ns641 0 -0.000341677993872
Gc23_642 0 n46 ns642 0 -0.000226259619253
Gc23_643 0 n46 ns643 0 3.4594435381e-05
Gc23_644 0 n46 ns644 0 1.22437699527e-05
Gc23_645 0 n46 ns645 0 -6.63352906521e-05
Gc23_646 0 n46 ns646 0 2.32353190161e-05
Gc23_647 0 n46 ns647 0 0.000158305681169
Gc23_648 0 n46 ns648 0 0.000363528532325
Gc23_649 0 n46 ns649 0 0.000723989493202
Gc23_650 0 n46 ns650 0 0.000394337594342
Gc23_651 0 n46 ns651 0 -2.37073477324e-05
Gc23_652 0 n46 ns652 0 0.000108577903961
Gc23_653 0 n46 ns653 0 3.11768668015e-07
Gc23_654 0 n46 ns654 0 1.67055529711e-06
Gc23_655 0 n46 ns655 0 0.00022298174992
Gc23_656 0 n46 ns656 0 0.000312199100499
Gc23_657 0 n46 ns657 0 -4.01408526917e-05
Gc23_658 0 n46 ns658 0 -9.19061021874e-05
Gc23_659 0 n46 ns659 0 -0.00018751819101
Gc23_660 0 n46 ns660 0 -0.000356828965945
Gc23_661 0 n46 ns661 0 -4.70820084947e-05
Gc23_662 0 n46 ns662 0 -0.000814035044257
Gc23_663 0 n46 ns663 0 -0.000311722116648
Gc23_664 0 n46 ns664 0 -0.00051119663196
Gc23_665 0 n46 ns665 0 -0.000251815827198
Gc23_666 0 n46 ns666 0 -0.0006392702375
Gc23_667 0 n46 ns667 0 0.000650897261791
Gc23_668 0 n46 ns668 0 0.000466809197446
Gc23_669 0 n46 ns669 0 0.00316058124539
Gc23_670 0 n46 ns670 0 -0.000122029759623
Gc23_671 0 n46 ns671 0 0.00276581130383
Gc23_672 0 n46 ns672 0 -0.000231501262043
Gc23_673 0 n46 ns673 0 0.000614491610788
Gc23_674 0 n46 ns674 0 0.000521793446164
Gc23_675 0 n46 ns675 0 -0.000243989404865
Gc23_676 0 n46 ns676 0 -0.000179198898936
Gc23_677 0 n46 ns677 0 -0.00101213333821
Gc23_678 0 n46 ns678 0 -0.000515792870513
Gc23_679 0 n46 ns679 0 -0.000412931410598
Gc23_680 0 n46 ns680 0 -0.000301114547564
Gc23_681 0 n46 ns681 0 3.51725821472e-05
Gc23_682 0 n46 ns682 0 7.42639757293e-06
Gc23_683 0 n46 ns683 0 -2.25376800404e-05
Gc23_684 0 n46 ns684 0 -1.35540854723e-06
Gc23_685 0 n46 ns685 0 -0.000342342433769
Gc23_686 0 n46 ns686 0 0.00060509631333
Gc23_687 0 n46 ns687 0 -0.000717091106245
Gc23_688 0 n46 ns688 0 0.00143535294164
Gc23_689 0 n46 ns689 0 -0.000227504124139
Gc23_690 0 n46 ns690 0 0.000338612765231
Gc23_691 0 n46 ns691 0 9.60649475358e-05
Gc23_692 0 n46 ns692 0 -0.000243099144308
Gc23_693 0 n46 ns693 0 -0.000138113565743
Gc23_694 0 n46 ns694 0 0.000448480738419
Gc23_695 0 n46 ns695 0 7.54702166625e-05
Gc23_696 0 n46 ns696 0 -0.000155811232511
Gc23_697 0 n46 ns697 0 5.45939751863e-05
Gc23_698 0 n46 ns698 0 -0.000473333805477
Gc23_699 0 n46 ns699 0 0.00082328631267
Gc23_700 0 n46 ns700 0 -0.000477428413444
Gc23_701 0 n46 ns701 0 0.000210898411873
Gc23_702 0 n46 ns702 0 -0.000679461216683
Gc23_703 0 n46 ns703 0 0.000315654407913
Gc23_704 0 n46 ns704 0 -0.000590712099589
Gc23_705 0 n46 ns705 0 -0.000111909036991
Gc23_706 0 n46 ns706 0 0.000943885635114
Gc23_707 0 n46 ns707 0 0.00327463003511
Gc23_708 0 n46 ns708 0 0.00254775156254
Gc23_709 0 n46 ns709 0 0.00307876486546
Gc23_710 0 n46 ns710 0 0.00209710913863
Gc23_711 0 n46 ns711 0 0.000397070176794
Gc23_712 0 n46 ns712 0 0.00138349649104
Gc23_713 0 n46 ns713 0 -0.000349165405955
Gc23_714 0 n46 ns714 0 -0.000470121353003
Gc23_715 0 n46 ns715 0 -0.00129408641459
Gc23_716 0 n46 ns716 0 -0.00139705074489
Gc23_717 0 n46 ns717 0 -0.000556539131387
Gc23_718 0 n46 ns718 0 -0.000554774661034
Gc23_719 0 n46 ns719 0 3.13103937289e-05
Gc23_720 0 n46 ns720 0 -1.04082447733e-06
Gc23_721 0 n46 ns721 0 -5.03738959611e-06
Gc23_722 0 n46 ns722 0 -3.5035424762e-05
Gc23_723 0 n46 ns723 0 -0.000142907934032
Gc23_724 0 n46 ns724 0 0.000116095854313
Gc23_725 0 n46 ns725 0 -2.59045991293e-05
Gc23_726 0 n46 ns726 0 0.000997675130489
Gc23_727 0 n46 ns727 0 1.61481521237e-05
Gc23_728 0 n46 ns728 0 0.000169520094463
Gc23_729 0 n46 ns729 0 0.000158130935332
Gc23_730 0 n46 ns730 0 -7.98945902333e-05
Gc23_731 0 n46 ns731 0 -0.000134386523658
Gc23_732 0 n46 ns732 0 -6.59838215752e-05
Gc23_733 0 n46 ns733 0 0.000142203132747
Gc23_734 0 n46 ns734 0 -0.000142377787549
Gc23_735 0 n46 ns735 0 -0.000279979952099
Gc23_736 0 n46 ns736 0 -0.000361591778437
Gc23_737 0 n46 ns737 0 0.000185389269848
Gc23_738 0 n46 ns738 0 0.000496603175287
Gc23_739 0 n46 ns739 0 0.000302572349357
Gc23_740 0 n46 ns740 0 -0.000426953742702
Gc23_741 0 n46 ns741 0 -7.54256040562e-05
Gc23_742 0 n46 ns742 0 -0.000376045905291
Gc23_743 0 n46 ns743 0 -0.000495768786721
Gc23_744 0 n46 ns744 0 -0.000250245708791
Gc23_745 0 n46 ns745 0 0.00206408569269
Gc23_746 0 n46 ns746 0 0.00337674280552
Gc23_747 0 n46 ns747 0 0.00217362927718
Gc23_748 0 n46 ns748 0 0.00317524160725
Gc23_749 0 n46 ns749 0 -0.00112806871628
Gc23_750 0 n46 ns750 0 0.000979129684967
Gc23_751 0 n46 ns751 0 -0.000155639724706
Gc23_752 0 n46 ns752 0 -0.00083758572435
Gc23_753 0 n46 ns753 0 -0.000508265986321
Gc23_754 0 n46 ns754 0 -0.0016667441249
Gc23_755 0 n46 ns755 0 -0.000636371941488
Gc23_756 0 n46 ns756 0 0.000550262628427
Gc23_757 0 n46 ns757 0 0.000449916757084
Gc23_758 0 n46 ns758 0 2.41951854782e-05
Gc23_759 0 n46 ns759 0 -0.000135623790416
Gc23_760 0 n46 ns760 0 1.63164321296e-05
Gc23_761 0 n46 ns761 0 1.69353047602e-05
Gc23_762 0 n46 ns762 0 -0.000578120269294
Gc23_763 0 n46 ns763 0 0.000194529487802
Gc23_764 0 n46 ns764 0 -0.000231265596792
Gc23_765 0 n46 ns765 0 -0.000366270268264
Gc23_766 0 n46 ns766 0 0.000368324516523
Gc23_767 0 n46 ns767 0 3.19305758136e-05
Gc23_768 0 n46 ns768 0 -0.000111182084357
Gc23_769 0 n46 ns769 0 0.000302223736805
Gc23_770 0 n46 ns770 0 -0.000139779761026
Gc23_771 0 n46 ns771 0 0.00017808874989
Gc23_772 0 n46 ns772 0 -6.5256882489e-05
Gc23_773 0 n46 ns773 0 7.40015586454e-05
Gc23_774 0 n46 ns774 0 -0.000251225765585
Gc23_775 0 n46 ns775 0 -0.00076248119588
Gc23_776 0 n46 ns776 0 -0.0002804950092
Gc23_777 0 n46 ns777 0 0.000258522881009
Gc23_778 0 n46 ns778 0 -0.000502483862809
Gc23_779 0 n46 ns779 0 -0.000261791376289
Gc23_780 0 n46 ns780 0 -0.000868881314496
Gc23_781 0 n46 ns781 0 0.00114898229122
Gc23_782 0 n46 ns782 0 -0.00080894131894
Gc23_783 0 n46 ns783 0 0.00194546261143
Gc23_784 0 n46 ns784 0 0.00270398775308
Gc23_785 0 n46 ns785 0 0.00180669599062
Gc23_786 0 n46 ns786 0 0.00304185080645
Gc23_787 0 n46 ns787 0 -0.00146364494845
Gc23_788 0 n46 ns788 0 -0.00162128212376
Gc23_789 0 n46 ns789 0 0.000440624021825
Gc23_790 0 n46 ns790 0 -0.00101813070536
Gc23_791 0 n46 ns791 0 0.00039367960473
Gc23_792 0 n46 ns792 0 -0.000541047916144
Gc23_793 0 n46 ns793 0 -0.00137834133472
Gc23_794 0 n46 ns794 0 0.00288773274922
Gc23_795 0 n46 ns795 0 0.00157529648056
Gc23_796 0 n46 ns796 0 1.99035478797e-05
Gc23_797 0 n46 ns797 0 -0.000178093908695
Gc23_798 0 n46 ns798 0 4.91706650785e-05
Gc23_799 0 n46 ns799 0 0.000491942899111
Gc23_800 0 n46 ns800 0 -0.00225856030837
Gc23_801 0 n46 ns801 0 0.00100665822854
Gc23_802 0 n46 ns802 0 -0.000642966225987
Gc23_803 0 n46 ns803 0 -0.000764747555936
Gc23_804 0 n46 ns804 0 0.000195929460764
Gc23_805 0 n46 ns805 0 0.000263627545441
Gc23_806 0 n46 ns806 0 -0.000402881296821
Gc23_807 0 n46 ns807 0 0.000259073910686
Gc23_808 0 n46 ns808 0 0.000427328278996
Gc23_809 0 n46 ns809 0 0.000253177394038
Gc23_810 0 n46 ns810 0 -5.03959140927e-05
Gc23_811 0 n46 ns811 0 -0.000394034451132
Gc23_812 0 n46 ns812 0 1.86658454803e-06
Gc23_813 0 n46 ns813 0 0.000741151024893
Gc23_814 0 n46 ns814 0 -0.000993225555607
Gc23_815 0 n46 ns815 0 0.000866992602926
Gc23_816 0 n46 ns816 0 -0.000530326473744
Gc23_817 0 n46 ns817 0 0.000464449181515
Gc23_818 0 n46 ns818 0 -0.00103589789866
Gc23_819 0 n46 ns819 0 0.000996662229824
Gc23_820 0 n46 ns820 0 0.00225190747848
Gc23_821 0 n46 ns821 0 0.00327135095407
Gc23_822 0 n46 ns822 0 0.00488590673917
Gc23_823 0 n46 ns823 0 0.00253798924669
Gc23_824 0 n46 ns824 0 0.00500595422
Gc23_825 0 n46 ns825 0 0.00362947548599
Gc23_826 0 n46 ns826 0 0.000393668642376
Gc23_827 0 n46 ns827 0 0.000894840695708
Gc23_828 0 n46 ns828 0 -0.000981134772038
Gc23_829 0 n46 ns829 0 -0.00191662078292
Gc23_830 0 n46 ns830 0 -0.0013164511844
Gc23_831 0 n46 ns831 0 -0.00391852094629
Gc23_832 0 n46 ns832 0 -0.000302115914997
Gc23_833 0 n46 ns833 0 0.00308747656246
Gc23_834 0 n46 ns834 0 5.65583570298e-05
Gc23_835 0 n46 ns835 0 -0.000167385778262
Gc23_836 0 n46 ns836 0 4.72204610466e-05
Gc23_837 0 n46 ns837 0 0.000156565772367
Gc23_838 0 n46 ns838 0 -0.00242360947769
Gc23_839 0 n46 ns839 0 -0.00236196820803
Gc23_840 0 n46 ns840 0 -4.01232371271e-05
Gc23_841 0 n46 ns841 0 -0.000736045218957
Gc23_842 0 n46 ns842 0 0.000155318581457
Gc23_843 0 n46 ns843 0 0.000397095253333
Gc23_844 0 n46 ns844 0 -0.000270481010545
Gc23_845 0 n46 ns845 0 -0.000205896081859
Gc23_846 0 n46 ns846 0 0.000304307690754
Gc23_847 0 n46 ns847 0 0.000311329717253
Gc23_848 0 n46 ns848 0 4.66030727881e-05
Gc23_849 0 n46 ns849 0 -0.000313363861003
Gc23_850 0 n46 ns850 0 -0.000278765681094
Gc23_851 0 n46 ns851 0 0.000720240946696
Gc23_852 0 n46 ns852 0 0.000496715509299
Gc23_853 0 n46 ns853 0 0.000687630431628
Gc23_854 0 n46 ns854 0 -7.95979877843e-05
Gc23_855 0 n46 ns855 0 -9.28561491501e-05
Gc23_856 0 n46 ns856 0 -0.000822544467538
Gc23_857 0 n46 ns857 0 -0.00111718347034
Gc23_858 0 n46 ns858 0 0.000331962039404
Gc23_859 0 n46 ns859 0 0.00615260783749
Gc23_860 0 n46 ns860 0 0.00619000822252
Gc23_861 0 n46 ns861 0 0.00458870569699
Gc23_862 0 n46 ns862 0 0.00614480523944
Gc23_863 0 n46 ns863 0 0.000627361937629
Gc23_864 0 n46 ns864 0 0.00547968399298
Gc23_865 0 n46 ns865 0 0.00098406192771
Gc23_866 0 n46 ns866 0 -0.000847487276405
Gc23_867 0 n46 ns867 0 -0.00569816473781
Gc23_868 0 n46 ns868 0 -0.00161534962504
Gc23_869 0 n46 ns869 0 0.00288162627284
Gc23_870 0 n46 ns870 0 -0.00436874441446
Gc23_871 0 n46 ns871 0 0.00473118874525
Gc23_872 0 n46 ns872 0 -4.99985352119e-06
Gc23_873 0 n46 ns873 0 0.000136705322993
Gc23_874 0 n46 ns874 0 -0.000163884610026
Gc23_875 0 n46 ns875 0 0.000302153475052
Gc23_876 0 n46 ns876 0 -0.00267850181045
Gc23_877 0 n46 ns877 0 0.000145223967969
Gc23_878 0 n46 ns878 0 -0.00155964129543
Gc23_879 0 n46 ns879 0 -0.000899768570568
Gc23_880 0 n46 ns880 0 1.46726034049e-05
Gc23_881 0 n46 ns881 0 0.000420544772109
Gc23_882 0 n46 ns882 0 -0.00038239699789
Gc23_883 0 n46 ns883 0 0.000118415499601
Gc23_884 0 n46 ns884 0 -1.93259307416e-05
Gc23_885 0 n46 ns885 0 0.000264636999859
Gc23_886 0 n46 ns886 0 8.71299704605e-05
Gc23_887 0 n46 ns887 0 -0.000241558720871
Gc23_888 0 n46 ns888 0 0.000506128394541
Gc23_889 0 n46 ns889 0 0.000590700736558
Gc23_890 0 n46 ns890 0 8.20684222507e-05
Gc23_891 0 n46 ns891 0 0.00108870929787
Gc23_892 0 n46 ns892 0 0.000189316514602
Gc23_893 0 n46 ns893 0 0.000539916873741
Gc23_894 0 n46 ns894 0 -0.000116928433882
Gc23_895 0 n46 ns895 0 0.000144761387575
Gc23_896 0 n46 ns896 0 0.00150685182679
Gc23_897 0 n46 ns897 0 -0.000178540144241
Gc23_898 0 n46 ns898 0 0.00460505545022
Gc23_899 0 n46 ns899 0 -0.000433569018489
Gc23_900 0 n46 ns900 0 0.00493256639472
Gc23_901 0 n46 ns901 0 0.00263186366171
Gc23_902 0 n46 ns902 0 8.45454194346e-05
Gc23_903 0 n46 ns903 0 0.00112362966749
Gc23_904 0 n46 ns904 0 -0.000981338410138
Gc23_905 0 n46 ns905 0 -0.000913405854432
Gc23_906 0 n46 ns906 0 -0.00113761391612
Gc23_907 0 n46 ns907 0 -0.00361445929265
Gc23_908 0 n46 ns908 0 0.000206654190607
Gc23_909 0 n46 ns909 0 0.00317120637019
Gc23_910 0 n46 ns910 0 2.50088581868e-05
Gc23_911 0 n46 ns911 0 -0.000130534589688
Gc23_912 0 n46 ns912 0 2.11471143697e-06
Gc23_913 0 n46 ns913 0 0.000337316974403
Gc23_914 0 n46 ns914 0 -0.000614988527695
Gc23_915 0 n46 ns915 0 0.000980310465724
Gc23_916 0 n46 ns916 0 0.000341992381462
Gc23_917 0 n46 ns917 0 -0.000189583754405
Gc23_918 0 n46 ns918 0 0.000359993952702
Gc23_919 0 n46 ns919 0 -4.39792396393e-05
Gc23_920 0 n46 ns920 0 4.16392467358e-05
Gc23_921 0 n46 ns921 0 0.000642010433047
Gc23_922 0 n46 ns922 0 -0.000262641363104
Gc23_923 0 n46 ns923 0 0.000170002481466
Gc23_924 0 n46 ns924 0 4.29002914728e-05
Gc23_925 0 n46 ns925 0 2.23472482477e-05
Gc23_926 0 n46 ns926 0 -0.000452500178515
Gc23_927 0 n46 ns927 0 -0.00154590793197
Gc23_928 0 n46 ns928 0 -0.000282288564126
Gc23_929 0 n46 ns929 0 0.000217391705827
Gc23_930 0 n46 ns930 0 -8.75750160961e-05
Gc23_931 0 n46 ns931 0 -0.000241192688261
Gc23_932 0 n46 ns932 0 -0.000722301030493
Gc23_933 0 n46 ns933 0 0.00140492581055
Gc23_934 0 n46 ns934 0 -0.00132279695006
Gc23_935 0 n46 ns935 0 -0.00134055578317
Gc23_936 0 n46 ns936 0 0.00200031889866
Gc23_937 0 n46 ns937 0 -0.00123765868513
Gc23_938 0 n46 ns938 0 0.0025769590048
Gc23_939 0 n46 ns939 0 -0.00160544395779
Gc23_940 0 n46 ns940 0 -0.0023005778978
Gc23_941 0 n46 ns941 0 0.000752575834491
Gc23_942 0 n46 ns942 0 -0.000915051488037
Gc23_943 0 n46 ns943 0 0.00119913087118
Gc23_944 0 n46 ns944 0 -0.00027021624669
Gc23_945 0 n46 ns945 0 -0.00121334823453
Gc23_946 0 n46 ns946 0 0.0024908751171
Gc23_947 0 n46 ns947 0 0.00148703938464
Gc23_948 0 n46 ns948 0 4.43005547456e-05
Gc23_949 0 n46 ns949 0 -0.000325461781792
Gc23_950 0 n46 ns950 0 0.000127647967042
Gc23_951 0 n46 ns951 0 5.6431288032e-05
Gc23_952 0 n46 ns952 0 0.000362849683293
Gc23_953 0 n46 ns953 0 0.000259699988918
Gc23_954 0 n46 ns954 0 0.000604065271379
Gc23_955 0 n46 ns955 0 -2.36141748453e-05
Gc23_956 0 n46 ns956 0 5.83988795582e-05
Gc23_957 0 n46 ns957 0 -4.11247908436e-05
Gc23_958 0 n46 ns958 0 -3.11587914477e-05
Gc23_959 0 n46 ns959 0 -1.89575501838e-05
Gc23_960 0 n46 ns960 0 0.000364665852318
Gc23_961 0 n46 ns961 0 -3.19024245518e-06
Gc23_962 0 n46 ns962 0 -0.0001254880773
Gc23_963 0 n46 ns963 0 -4.68091389882e-05
Gc23_964 0 n46 ns964 0 -0.000256453602359
Gc23_965 0 n46 ns965 0 0.000437695971497
Gc23_966 0 n46 ns966 0 -0.000633424886811
Gc23_967 0 n46 ns967 0 -7.69651489879e-05
Gc23_968 0 n46 ns968 0 -0.000592361322336
Gc23_969 0 n46 ns969 0 -4.65287714619e-06
Gc23_970 0 n46 ns970 0 -0.000575725734295
Gc23_971 0 n46 ns971 0 0.000269556063242
Gc23_972 0 n46 ns972 0 0.0007235006201
Gc23_973 0 n46 ns973 0 0.00357266998946
Gc23_974 0 n46 ns974 0 0.00112020869209
Gc23_975 0 n46 ns975 0 0.00323744976945
Gc23_976 0 n46 ns976 0 0.000843393518183
Gc23_977 0 n46 ns977 0 0.000488394659353
Gc23_978 0 n46 ns978 0 0.000966046351899
Gc23_979 0 n46 ns979 0 -0.000321348160074
Gc23_980 0 n46 ns980 0 -0.000344223199139
Gc23_981 0 n46 ns981 0 -0.00125162122748
Gc23_982 0 n46 ns982 0 -0.000941744587564
Gc23_983 0 n46 ns983 0 -0.000517195287549
Gc23_984 0 n46 ns984 0 -0.000206317834339
Gc23_985 0 n46 ns985 0 9.84212700459e-05
Gc23_986 0 n46 ns986 0 1.14234448066e-05
Gc23_987 0 n46 ns987 0 -4.12761428902e-05
Gc23_988 0 n46 ns988 0 -6.74880406006e-06
Gc23_989 0 n46 ns989 0 -0.000106209127229
Gc23_990 0 n46 ns990 0 0.000157607807372
Gc23_991 0 n46 ns991 0 3.16517909623e-05
Gc23_992 0 n46 ns992 0 0.00105427474754
Gc23_993 0 n46 ns993 0 7.04775529809e-07
Gc23_994 0 n46 ns994 0 0.000151931736474
Gc23_995 0 n46 ns995 0 0.0001159893304
Gc23_996 0 n46 ns996 0 -0.000153542558149
Gc23_997 0 n46 ns997 0 -0.000183664190934
Gc23_998 0 n46 ns998 0 0.00010963567325
Gc23_999 0 n46 ns999 0 0.000101557291888
Gc23_1000 0 n46 ns1000 0 -0.000159640069791
Gc23_1001 0 n46 ns1001 0 -0.00025899044069
Gc23_1002 0 n46 ns1002 0 -0.000293260031027
Gc23_1003 0 n46 ns1003 0 0.000547365889924
Gc23_1004 0 n46 ns1004 0 0.000228413580953
Gc23_1005 0 n46 ns1005 0 0.00028449017161
Gc23_1006 0 n46 ns1006 0 -0.000505847726187
Gc23_1007 0 n46 ns1007 0 8.93179388665e-05
Gc23_1008 0 n46 ns1008 0 -0.00039577038644
Gc23_1009 0 n46 ns1009 0 -0.000489519837025
Gc23_1010 0 n46 ns1010 0 0.000296769827178
Gc23_1011 0 n46 ns1011 0 0.0026113751427
Gc23_1012 0 n46 ns1012 0 0.00327821475004
Gc23_1013 0 n46 ns1013 0 0.00261321930647
Gc23_1014 0 n46 ns1014 0 0.00291974656483
Gc23_1015 0 n46 ns1015 0 -0.000485800800769
Gc23_1016 0 n46 ns1016 0 0.00134076991919
Gc23_1017 0 n46 ns1017 0 -0.000269178680702
Gc23_1018 0 n46 ns1018 0 -0.000700084248055
Gc23_1019 0 n46 ns1019 0 -0.000903604839577
Gc23_1020 0 n46 ns1020 0 -0.00169350196161
Gc23_1021 0 n46 ns1021 0 -0.000600791820843
Gc23_1022 0 n46 ns1022 0 -6.27593581452e-05
Gc23_1023 0 n46 ns1023 0 0.000224493034871
Gc23_1024 0 n46 ns1024 0 1.04344450056e-05
Gc23_1025 0 n46 ns1025 0 -7.55450926739e-05
Gc23_1026 0 n46 ns1026 0 -7.52831124818e-06
Gc23_1027 0 n46 ns1027 0 -0.00031552215134
Gc23_1028 0 n46 ns1028 0 0.000102962346132
Gc23_1029 0 n46 ns1029 0 -0.000617440639364
Gc23_1030 0 n46 ns1030 0 0.000498276912144
Gc23_1031 0 n46 ns1031 0 -0.000105181075673
Gc23_1032 0 n46 ns1032 0 0.000427560409062
Gc23_1033 0 n46 ns1033 0 4.59298143348e-05
Gc23_1034 0 n46 ns1034 0 -8.11898676024e-05
Gc23_1035 0 n46 ns1035 0 9.61119830262e-05
Gc23_1036 0 n46 ns1036 0 -0.000247139440874
Gc23_1037 0 n46 ns1037 0 0.000149859366555
Gc23_1038 0 n46 ns1038 0 -7.45145135669e-05
Gc23_1039 0 n46 ns1039 0 1.57461958141e-05
Gc23_1040 0 n46 ns1040 0 -0.000336328031425
Gc23_1041 0 n46 ns1041 0 -0.000585025913562
Gc23_1042 0 n46 ns1042 0 0.000308624087431
Gc23_1043 0 n46 ns1043 0 0.00019831063097
Gc23_1044 0 n46 ns1044 0 -0.000338915230552
Gc23_1045 0 n46 ns1045 0 -0.000332314301549
Gc23_1046 0 n46 ns1046 0 -0.000507602998339
Gc23_1047 0 n46 ns1047 0 0.000281734149636
Gc23_1048 0 n46 ns1048 0 -0.00113946476406
Gc23_1049 0 n46 ns1049 0 0.00138966302847
Gc23_1050 0 n46 ns1050 0 0.00237403409649
Gc23_1051 0 n46 ns1051 0 0.00146282374145
Gc23_1052 0 n46 ns1052 0 0.00263119950513
Gc23_1053 0 n46 ns1053 0 -0.00214756542284
Gc23_1054 0 n46 ns1054 0 -0.000707735941957
Gc23_1055 0 n46 ns1055 0 0.000235396424408
Gc23_1056 0 n46 ns1056 0 -0.000980825383924
Gc23_1057 0 n46 ns1057 0 0.000489046022967
Gc23_1058 0 n46 ns1058 0 -0.000922401945319
Gc23_1059 0 n46 ns1059 0 -0.000834834524291
Gc23_1060 0 n46 ns1060 0 0.00242517847154
Gc23_1061 0 n46 ns1061 0 0.00113846828736
Gc23_1062 0 n46 ns1062 0 1.99943729844e-05
Gc23_1063 0 n46 ns1063 0 -0.000173389490442
Gc23_1064 0 n46 ns1064 0 5.00430116318e-05
Gc23_1065 0 n46 ns1065 0 0.000447288460542
Gc23_1066 0 n46 ns1066 0 -0.00187149171682
Gc23_1067 0 n46 ns1067 0 0.0010908632426
Gc23_1068 0 n46 ns1068 0 -0.00154389762039
Gc23_1069 0 n46 ns1069 0 -0.000789348677971
Gc23_1070 0 n46 ns1070 0 -7.54555504237e-05
Gc23_1071 0 n46 ns1071 0 0.000171603886984
Gc23_1072 0 n46 ns1072 0 -0.000219258471468
Gc23_1073 0 n46 ns1073 0 0.000267189194361
Gc23_1074 0 n46 ns1074 0 0.000152636307014
Gc23_1075 0 n46 ns1075 0 0.000192419582171
Gc23_1076 0 n46 ns1076 0 -2.75466649829e-05
Gc23_1077 0 n46 ns1077 0 4.83967529618e-05
Gc23_1078 0 n46 ns1078 0 0.000416818786852
Gc23_1079 0 n46 ns1079 0 0.000161851930116
Gc23_1080 0 n46 ns1080 0 -0.00089995275295
Gc23_1081 0 n46 ns1081 0 0.000680948432117
Gc23_1082 0 n46 ns1082 0 -0.00047630996603
Gc23_1083 0 n46 ns1083 0 0.00032423223567
Gc23_1084 0 n46 ns1084 0 -0.000787447032649
Gc23_1085 0 n46 ns1085 0 0.00162087159072
Gc23_1086 0 n46 ns1086 0 0.00114269836217
Gc23_1087 0 n46 ns1087 0 0.00238927964915
Gc23_1088 0 n46 ns1088 0 0.00376523734646
Gc23_1089 0 n46 ns1089 0 0.0019252352911
Gc23_1090 0 n46 ns1090 0 0.00400366675389
Gc23_1091 0 n46 ns1091 0 0.00145966353413
Gc23_1092 0 n46 ns1092 0 -0.00202294964986
Gc23_1093 0 n46 ns1093 0 0.000860961704349
Gc23_1094 0 n46 ns1094 0 -0.000922961685694
Gc23_1095 0 n46 ns1095 0 -0.000362437465269
Gc23_1096 0 n46 ns1096 0 -0.000262499889129
Gc23_1097 0 n46 ns1097 0 -0.00322193726894
Gc23_1098 0 n46 ns1098 0 0.00261173535774
Gc23_1099 0 n46 ns1099 0 0.00269114842628
Gc23_1100 0 n46 ns1100 0 2.77566926319e-05
Gc23_1101 0 n46 ns1101 0 -0.000114351833133
Gc23_1102 0 n46 ns1102 0 1.4773430352e-05
Gc23_1103 0 n46 ns1103 0 0.00105589346001
Gc23_1104 0 n46 ns1104 0 -0.00419599306584
Gc23_1105 0 n46 ns1105 0 -0.000270405334598
Gc23_1106 0 n46 ns1106 0 -0.00159816091252
Gc23_1107 0 n46 ns1107 0 -0.000915731384443
Gc23_1108 0 n46 ns1108 0 -0.000186950661663
Gc23_1109 0 n46 ns1109 0 0.000449080031689
Gc23_1110 0 n46 ns1110 0 -0.000106884453252
Gc23_1111 0 n46 ns1111 0 -4.9076277784e-05
Gc23_1112 0 n46 ns1112 0 0.000408898548832
Gc23_1113 0 n46 ns1113 0 0.000288254001313
Gc23_1114 0 n46 ns1114 0 -1.03366499678e-05
Gc23_1115 0 n46 ns1115 0 -0.000377545108174
Gc23_1116 0 n46 ns1116 0 -0.000296095436978
Gc23_1117 0 n46 ns1117 0 0.000321751500017
Gc23_1118 0 n46 ns1118 0 -7.00488077594e-05
Gc23_1119 0 n46 ns1119 0 0.000536242218878
Gc23_1120 0 n46 ns1120 0 -0.000426393156606
Gc23_1121 0 n46 ns1121 0 -0.000137731617612
Gc23_1122 0 n46 ns1122 0 -0.00134572088181
Gc23_1123 0 n46 ns1123 0 -0.000244632882272
Gc23_1124 0 n46 ns1124 0 0.000350085520563
Gc23_1125 0 n46 ns1125 0 0.00695622995985
Gc23_1126 0 n46 ns1126 0 0.00733588435024
Gc23_1127 0 n46 ns1127 0 0.00526750830232
Gc23_1128 0 n46 ns1128 0 0.00702745242821
Gc23_1129 0 n46 ns1129 0 0.000688462202894
Gc23_1130 0 n46 ns1130 0 0.00527117842445
Gc23_1131 0 n46 ns1131 0 0.000856897181911
Gc23_1132 0 n46 ns1132 0 -0.000921095237582
Gc23_1133 0 n46 ns1133 0 -0.00634987069711
Gc23_1134 0 n46 ns1134 0 -0.00196556322148
Gc23_1135 0 n46 ns1135 0 0.00325287413176
Gc23_1136 0 n46 ns1136 0 -0.00526275636075
Gc23_1137 0 n46 ns1137 0 0.00455560070947
Gc23_1138 0 n46 ns1138 0 -5.0038824351e-07
Gc23_1139 0 n46 ns1139 0 -1.21915774842e-05
Gc23_1140 0 n46 ns1140 0 -5.26532715119e-05
Gc23_1141 0 n46 ns1141 0 0.00111459759667
Gc23_1142 0 n46 ns1142 0 -0.00495081721696
Gc23_1143 0 n46 ns1143 0 0.000927437371874
Gc23_1144 0 n46 ns1144 0 -0.003678202192
Gc23_1145 0 n46 ns1145 0 -0.00117255018133
Gc23_1146 0 n46 ns1146 0 -0.000729599245448
Gc23_1147 0 n46 ns1147 0 0.00060942046924
Gc23_1148 0 n46 ns1148 0 -0.000111207827297
Gc23_1149 0 n46 ns1149 0 -0.000115277196234
Gc23_1150 0 n46 ns1150 0 0.000205573775332
Gc23_1151 0 n46 ns1151 0 0.000281940141141
Gc23_1152 0 n46 ns1152 0 5.35326020879e-05
Gc23_1153 0 n46 ns1153 0 -0.000360202361615
Gc23_1154 0 n46 ns1154 0 0.000641304606514
Gc23_1155 0 n46 ns1155 0 0.000689013700014
Gc23_1156 0 n46 ns1156 0 2.91518624003e-06
Gc23_1157 0 n46 ns1157 0 0.000948530437207
Gc23_1158 0 n46 ns1158 0 -5.18128915577e-05
Gc23_1159 0 n46 ns1159 0 0.000331306664354
Gc23_1160 0 n46 ns1160 0 -0.000588344299862
Gc23_1161 0 n46 ns1161 0 0.000290232688194
Gc23_1162 0 n46 ns1162 0 0.0013248265232
Gc23_1163 0 n46 ns1163 0 0.00354804903911
Gc23_1164 0 n46 ns1164 0 0.00634577672494
Gc23_1165 0 n46 ns1165 0 0.00251178551808
Gc23_1166 0 n46 ns1166 0 0.00633014631083
Gc23_1167 0 n46 ns1167 0 0.00206709317384
Gc23_1168 0 n46 ns1168 0 0.00177110687564
Gc23_1169 0 n46 ns1169 0 0.00107683163124
Gc23_1170 0 n46 ns1170 0 -0.000941509515266
Gc23_1171 0 n46 ns1171 0 -0.00347327268996
Gc23_1172 0 n46 ns1172 0 -0.00115444229559
Gc23_1173 0 n46 ns1173 0 -0.000460974453299
Gc23_1174 0 n46 ns1174 0 -0.00198832003111
Gc23_1175 0 n46 ns1175 0 0.0038357016536
Gc23_1176 0 n46 ns1176 0 2.0797062869e-06
Gc23_1177 0 n46 ns1177 0 -9.62168408078e-05
Gc23_1178 0 n46 ns1178 0 -1.42619017787e-05
Gc23_1179 0 n46 ns1179 0 0.000744581182051
Gc23_1180 0 n46 ns1180 0 -0.00221373280723
Gc23_1181 0 n46 ns1181 0 0.001871829647
Gc23_1182 0 n46 ns1182 0 -0.00167112210641
Gc23_1183 0 n46 ns1183 0 -0.000409688743232
Gc23_1184 0 n46 ns1184 0 -9.05711595135e-05
Gc23_1185 0 n46 ns1185 0 5.79695976533e-05
Gc23_1186 0 n46 ns1186 0 3.66301568293e-05
Gc23_1187 0 n46 ns1187 0 0.000541456293247
Gc23_1188 0 n46 ns1188 0 -0.000354322613815
Gc23_1189 0 n46 ns1189 0 0.00017399312139
Gc23_1190 0 n46 ns1190 0 7.93675033068e-05
Gc23_1191 0 n46 ns1191 0 -0.000106886942715
Gc23_1192 0 n46 ns1192 0 0.000222434159068
Gc23_1193 0 n46 ns1193 0 -0.00129437757217
Gc23_1194 0 n46 ns1194 0 -0.000230492619138
Gc23_1195 0 n46 ns1195 0 0.000375981866987
Gc23_1196 0 n46 ns1196 0 9.11628844745e-06
Gc23_1197 0 n46 ns1197 0 -0.000246746179318
Gc23_1198 0 n46 ns1198 0 -0.000595323088514
Gc23_1199 0 n46 ns1199 0 0.00159086783062
Gc23_1200 0 n46 ns1200 0 -0.000939469710808
Gc23_1201 0 n46 ns1201 0 -0.00078849606776
Gc23_1202 0 n46 ns1202 0 0.00208616077055
Gc23_1203 0 n46 ns1203 0 -0.000840148054082
Gc23_1204 0 n46 ns1204 0 0.00280050425713
Gc23_1205 0 n46 ns1205 0 -0.000981948643539
Gc23_1206 0 n46 ns1206 0 -0.00261352589717
Gc23_1207 0 n46 ns1207 0 0.000985921071857
Gc23_1208 0 n46 ns1208 0 -0.000994482628403
Gc23_1209 0 n46 ns1209 0 0.00115771502861
Gc23_1210 0 n46 ns1210 0 -0.000179593213896
Gc23_1211 0 n46 ns1211 0 -0.00193769429219
Gc23_1212 0 n46 ns1212 0 0.00271601898438
Gc23_1213 0 n46 ns1213 0 0.00208037760111
Gc23_1214 0 n46 ns1214 0 1.97700706265e-05
Gc23_1215 0 n46 ns1215 0 -0.000259014601876
Gc23_1216 0 n46 ns1216 0 9.63754083228e-05
Gd23_1 0 n46 ni1 0 0.0010086654227
Gd23_2 0 n46 ni2 0 0.00062623948392
Gd23_3 0 n46 ni3 0 -0.000449608784668
Gd23_4 0 n46 ni4 0 0.00013537573036
Gd23_5 0 n46 ni5 0 -0.000303701195919
Gd23_6 0 n46 ni6 0 0.000576099233129
Gd23_7 0 n46 ni7 0 0.000509180809551
Gd23_8 0 n46 ni8 0 -0.000403225304522
Gd23_9 0 n46 ni9 0 0.000498068703284
Gd23_10 0 n46 ni10 0 -0.000475055654673
Gd23_11 0 n46 ni11 0 6.1852699812e-05
Gd23_12 0 n46 ni12 0 -0.000589590986858
Gd23_13 0 n46 ni13 0 0.000655321880826
Gd23_14 0 n46 ni14 0 -0.00306191902354
Gd23_15 0 n46 ni15 0 -0.00236826112514
Gd23_16 0 n46 ni16 0 0.000508101134563
Gd23_17 0 n46 ni17 0 -0.000373691161031
Gd23_18 0 n46 ni18 0 2.65168759283e-05
Gd23_19 0 n46 ni19 0 0.000720219319961
Gd23_20 0 n46 ni20 0 0.000478126914873
Gd23_21 0 n46 ni21 0 -0.000252524333401
Gd23_22 0 n46 ni22 0 -0.00185078201992
Gd23_23 0 n46 ni23 0 0.00107476364185
Gd23_24 0 n46 ni24 0 -0.00193374707207
Gd23_25 0 n46 ni25 0 -0.000294555647044
Gd23_26 0 n46 ni26 0 0.000209881179972
Gd23_27 0 n46 ni27 0 0.000419375069749
Gd23_28 0 n46 ni28 0 0.000515080722516
Gd23_29 0 n46 ni29 0 -0.00155322369074
Gd23_30 0 n46 ni30 0 -0.000968093458333
Gd23_31 0 n46 ni31 0 -0.00316016930909
Gd23_32 0 n46 ni32 0 -0.00182253168652
Gc24_1 0 n48 ns1 0 0.000342403036276
Gc24_2 0 n48 ns2 0 -0.000226179798052
Gc24_3 0 n48 ns3 0 0.000895312823509
Gc24_4 0 n48 ns4 0 -0.00046878209445
Gc24_5 0 n48 ns5 0 0.000165225134199
Gc24_6 0 n48 ns6 0 -0.000233593463015
Gc24_7 0 n48 ns7 0 -0.000129669129057
Gc24_8 0 n48 ns8 0 0.000150715531651
Gc24_9 0 n48 ns9 0 -0.000135647004961
Gc24_10 0 n48 ns10 0 0.000101362330738
Gc24_11 0 n48 ns11 0 6.1102540517e-05
Gc24_12 0 n48 ns12 0 -4.34109755576e-05
Gc24_13 0 n48 ns13 0 -0.000140294150786
Gc24_14 0 n48 ns14 0 -0.00018647908682
Gc24_15 0 n48 ns15 0 -0.000360930894174
Gc24_16 0 n48 ns16 0 -2.9788129055e-05
Gc24_17 0 n48 ns17 0 -0.000262122194146
Gc24_18 0 n48 ns18 0 0.00012700598271
Gc24_19 0 n48 ns19 0 -0.0003065597064
Gc24_20 0 n48 ns20 0 0.000174631214822
Gc24_21 0 n48 ns21 0 -0.000181439870834
Gc24_22 0 n48 ns22 0 0.000122712633178
Gc24_23 0 n48 ns23 0 -0.00065188563402
Gc24_24 0 n48 ns24 0 0.00150089402666
Gc24_25 0 n48 ns25 0 -0.000549706180601
Gc24_26 0 n48 ns26 0 0.00131444109668
Gc24_27 0 n48 ns27 0 0.000495673030732
Gc24_28 0 n48 ns28 0 0.00021894122511
Gc24_29 0 n48 ns29 0 -0.000127646353259
Gc24_30 0 n48 ns30 0 -4.89761846713e-05
Gc24_31 0 n48 ns31 0 -0.000549798535538
Gc24_32 0 n48 ns32 0 -0.000165851615624
Gc24_33 0 n48 ns33 0 -7.69279937339e-05
Gc24_34 0 n48 ns34 0 -0.00024284647937
Gc24_35 0 n48 ns35 0 -9.33810283663e-05
Gc24_36 0 n48 ns36 0 -1.01189316058e-05
Gc24_37 0 n48 ns37 0 4.21403906771e-06
Gc24_38 0 n48 ns38 0 7.71129412983e-06
Gc24_39 0 n48 ns39 0 0.00011448537442
Gc24_40 0 n48 ns40 0 0.000196597038927
Gc24_41 0 n48 ns41 0 0.000419645722875
Gc24_42 0 n48 ns42 0 0.000120710092084
Gc24_43 0 n48 ns43 0 4.8168399788e-05
Gc24_44 0 n48 ns44 0 6.37687468201e-06
Gc24_45 0 n48 ns45 0 -5.99495104233e-05
Gc24_46 0 n48 ns46 0 -1.53241016487e-06
Gc24_47 0 n48 ns47 0 -0.000127579353286
Gc24_48 0 n48 ns48 0 0.000164048894986
Gc24_49 0 n48 ns49 0 9.84430041877e-05
Gc24_50 0 n48 ns50 0 -4.47047015216e-05
Gc24_51 0 n48 ns51 0 -5.97170430024e-05
Gc24_52 0 n48 ns52 0 -0.000407287091838
Gc24_53 0 n48 ns53 0 -0.000327762190064
Gc24_54 0 n48 ns54 0 -0.000215092540726
Gc24_55 0 n48 ns55 0 -0.000291231381761
Gc24_56 0 n48 ns56 0 4.62351489224e-05
Gc24_57 0 n48 ns57 0 -0.000296858241673
Gc24_58 0 n48 ns58 0 9.33021219877e-05
Gc24_59 0 n48 ns59 0 -0.000290983203091
Gc24_60 0 n48 ns60 0 0.000237195076782
Gc24_61 0 n48 ns61 0 -0.00130641277872
Gc24_62 0 n48 ns62 0 0.00207144113072
Gc24_63 0 n48 ns63 0 -0.00111033510912
Gc24_64 0 n48 ns64 0 0.00180627885651
Gc24_65 0 n48 ns65 0 0.000732857677634
Gc24_66 0 n48 ns66 0 0.000524606483845
Gc24_67 0 n48 ns67 0 -0.000187085668167
Gc24_68 0 n48 ns68 0 -9.56960556992e-05
Gc24_69 0 n48 ns69 0 -0.000804002544103
Gc24_70 0 n48 ns70 0 -0.000426317156658
Gc24_71 0 n48 ns71 0 -0.000141222362889
Gc24_72 0 n48 ns72 0 -0.00056414652177
Gc24_73 0 n48 ns73 0 -0.000166832793104
Gc24_74 0 n48 ns74 0 -1.29078081294e-05
Gc24_75 0 n48 ns75 0 4.6741204865e-06
Gc24_76 0 n48 ns76 0 5.81924145714e-06
Gc24_77 0 n48 ns77 0 -0.000304530276293
Gc24_78 0 n48 ns78 0 0.00105224158007
Gc24_79 0 n48 ns79 0 -0.000502206471099
Gc24_80 0 n48 ns80 0 0.00130663476314
Gc24_81 0 n48 ns81 0 -9.84900753243e-05
Gc24_82 0 n48 ns82 0 0.000505010785655
Gc24_83 0 n48 ns83 0 9.33438816536e-05
Gc24_84 0 n48 ns84 0 -0.000317827378094
Gc24_85 0 n48 ns85 0 -3.7785574992e-06
Gc24_86 0 n48 ns86 0 -1.43994705971e-05
Gc24_87 0 n48 ns87 0 0.00010293869779
Gc24_88 0 n48 ns88 0 3.60586690238e-05
Gc24_89 0 n48 ns89 0 0.000216115846529
Gc24_90 0 n48 ns90 0 -0.000463748121828
Gc24_91 0 n48 ns91 0 5.51043403503e-05
Gc24_92 0 n48 ns92 0 -0.000689893969079
Gc24_93 0 n48 ns93 0 -0.000287524607648
Gc24_94 0 n48 ns94 0 -0.000369444168412
Gc24_95 0 n48 ns95 0 -0.000256703210687
Gc24_96 0 n48 ns96 0 -0.000346068559524
Gc24_97 0 n48 ns97 0 -0.000453740892336
Gc24_98 0 n48 ns98 0 0.000164769753078
Gc24_99 0 n48 ns99 0 -0.00363531261985
Gc24_100 0 n48 ns100 0 0.00193249966163
Gc24_101 0 n48 ns101 0 -0.00316380460516
Gc24_102 0 n48 ns102 0 0.00171008278864
Gc24_103 0 n48 ns103 0 0.00103806517722
Gc24_104 0 n48 ns104 0 0.00140086173064
Gc24_105 0 n48 ns105 0 -0.000337273558793
Gc24_106 0 n48 ns106 0 -0.000270615954778
Gc24_107 0 n48 ns107 0 -0.0013527801157
Gc24_108 0 n48 ns108 0 -0.00117206320223
Gc24_109 0 n48 ns109 0 -0.000273057269982
Gc24_110 0 n48 ns110 0 -0.00119766570265
Gc24_111 0 n48 ns111 0 -0.000313305324102
Gc24_112 0 n48 ns112 0 -7.77666241255e-06
Gc24_113 0 n48 ns113 0 1.37759368748e-05
Gc24_114 0 n48 ns114 0 1.74564454191e-05
Gc24_115 0 n48 ns115 0 0.000494169975665
Gc24_116 0 n48 ns116 0 -0.000679871426159
Gc24_117 0 n48 ns117 0 0.0015175330186
Gc24_118 0 n48 ns118 0 -0.000946072001881
Gc24_119 0 n48 ns119 0 0.000309590229468
Gc24_120 0 n48 ns120 0 -0.000216035661409
Gc24_121 0 n48 ns121 0 -0.000137644011551
Gc24_122 0 n48 ns122 0 0.000131725055947
Gc24_123 0 n48 ns123 0 0.000185289583254
Gc24_124 0 n48 ns124 0 -0.000531106669763
Gc24_125 0 n48 ns125 0 -8.45115406534e-05
Gc24_126 0 n48 ns126 0 0.000158081726381
Gc24_127 0 n48 ns127 0 -6.17346479158e-05
Gc24_128 0 n48 ns128 0 0.000608174430638
Gc24_129 0 n48 ns129 0 0.000396928266586
Gc24_130 0 n48 ns130 0 -0.000139858012995
Gc24_131 0 n48 ns131 0 -0.000131538386958
Gc24_132 0 n48 ns132 0 -0.000537767592843
Gc24_133 0 n48 ns133 0 -0.000331183782821
Gc24_134 0 n48 ns134 0 -0.000464686697884
Gc24_135 0 n48 ns135 0 -6.81189798272e-05
Gc24_136 0 n48 ns136 0 -0.000585597045639
Gc24_137 0 n48 ns137 0 -0.00486753626426
Gc24_138 0 n48 ns138 0 -0.00205488846377
Gc24_139 0 n48 ns139 0 -0.00441372860154
Gc24_140 0 n48 ns140 0 -0.001720902482
Gc24_141 0 n48 ns141 0 0.000370602368668
Gc24_142 0 n48 ns142 0 0.00153305666644
Gc24_143 0 n48 ns143 0 -0.000352205292799
Gc24_144 0 n48 ns144 0 -0.00046862521279
Gc24_145 0 n48 ns145 0 -0.0012310554305
Gc24_146 0 n48 ns146 0 -0.00143506321548
Gc24_147 0 n48 ns147 0 -0.000169407218011
Gc24_148 0 n48 ns148 0 -0.000976332490172
Gc24_149 0 n48 ns149 0 -0.000300532973913
Gc24_150 0 n48 ns150 0 -5.07399777923e-06
Gc24_151 0 n48 ns151 0 2.74408818849e-05
Gc24_152 0 n48 ns152 0 2.69014648988e-05
Gc24_153 0 n48 ns153 0 -0.00056523411454
Gc24_154 0 n48 ns154 0 0.000316870092133
Gc24_155 0 n48 ns155 0 -0.00148127883832
Gc24_156 0 n48 ns156 0 0.00130959793158
Gc24_157 0 n48 ns157 0 -0.000414910445458
Gc24_158 0 n48 ns158 0 0.000376025515525
Gc24_159 0 n48 ns159 0 0.000132925738686
Gc24_160 0 n48 ns160 0 -0.00019620151695
Gc24_161 0 n48 ns161 0 0.000303097377684
Gc24_162 0 n48 ns162 0 0.000349819469772
Gc24_163 0 n48 ns163 0 -6.49684035892e-05
Gc24_164 0 n48 ns164 0 0.000124066022692
Gc24_165 0 n48 ns165 0 0.000209123318933
Gc24_166 0 n48 ns166 0 -0.000389834748325
Gc24_167 0 n48 ns167 0 0.000650612958439
Gc24_168 0 n48 ns168 0 0.000433797109919
Gc24_169 0 n48 ns169 0 0.000564951972374
Gc24_170 0 n48 ns170 0 -0.000455413437896
Gc24_171 0 n48 ns171 0 0.00035389764931
Gc24_172 0 n48 ns172 0 -0.000247190298494
Gc24_173 0 n48 ns173 0 -0.000113113822945
Gc24_174 0 n48 ns174 0 2.7956321713e-05
Gc24_175 0 n48 ns175 0 -0.0043771782236
Gc24_176 0 n48 ns176 0 -0.00496722440895
Gc24_177 0 n48 ns177 0 -0.00411557327735
Gc24_178 0 n48 ns178 0 -0.00452175537381
Gc24_179 0 n48 ns179 0 -0.000810269854744
Gc24_180 0 n48 ns180 0 0.00200765917439
Gc24_181 0 n48 ns181 0 -0.000187904264236
Gc24_182 0 n48 ns182 0 -0.000967239101573
Gc24_183 0 n48 ns183 0 -0.000602750261352
Gc24_184 0 n48 ns184 0 -0.00262151205221
Gc24_185 0 n48 ns185 0 0.000182450757033
Gc24_186 0 n48 ns186 0 -0.00178615851207
Gc24_187 0 n48 ns187 0 -0.000651562773395
Gc24_188 0 n48 ns188 0 -1.97361737663e-05
Gc24_189 0 n48 ns189 0 9.78098566675e-05
Gc24_190 0 n48 ns190 0 -2.1661866268e-05
Gc24_191 0 n48 ns191 0 -0.000430690050836
Gc24_192 0 n48 ns192 0 7.71245033904e-05
Gc24_193 0 n48 ns193 0 -0.000933372074352
Gc24_194 0 n48 ns194 0 0.0024321697827
Gc24_195 0 n48 ns195 0 -0.000130518027538
Gc24_196 0 n48 ns196 0 0.000404495203577
Gc24_197 0 n48 ns197 0 0.000189602390022
Gc24_198 0 n48 ns198 0 -0.000267053118852
Gc24_199 0 n48 ns199 0 1.4216904655e-05
Gc24_200 0 n48 ns200 0 0.000513493914852
Gc24_201 0 n48 ns201 0 -0.000173084283165
Gc24_202 0 n48 ns202 0 5.73101533464e-05
Gc24_203 0 n48 ns203 0 0.000647959692363
Gc24_204 0 n48 ns204 0 -0.000488484403926
Gc24_205 0 n48 ns205 0 2.46518715905e-05
Gc24_206 0 n48 ns206 0 -0.000125740004449
Gc24_207 0 n48 ns207 0 0.000810558222569
Gc24_208 0 n48 ns208 0 -0.00051817387361
Gc24_209 0 n48 ns209 0 0.000409765536991
Gc24_210 0 n48 ns210 0 -0.000757567230298
Gc24_211 0 n48 ns211 0 -0.000713511069215
Gc24_212 0 n48 ns212 0 0.000994062337947
Gc24_213 0 n48 ns213 0 -0.00182710153943
Gc24_214 0 n48 ns214 0 -0.00355287573853
Gc24_215 0 n48 ns215 0 -0.00174041418237
Gc24_216 0 n48 ns216 0 -0.00386421330309
Gc24_217 0 n48 ns217 0 -0.00058418115706
Gc24_218 0 n48 ns218 0 0.000812999627081
Gc24_219 0 n48 ns219 0 0.000374229688752
Gc24_220 0 n48 ns220 0 -0.00135999404173
Gc24_221 0 n48 ns221 0 0.000102307177979
Gc24_222 0 n48 ns222 0 -0.00297018903511
Gc24_223 0 n48 ns223 0 0.00109146692854
Gc24_224 0 n48 ns224 0 -0.00331572063879
Gc24_225 0 n48 ns225 0 -0.00160281576386
Gc24_226 0 n48 ns226 0 -2.46194514326e-05
Gc24_227 0 n48 ns227 0 8.01436542485e-05
Gc24_228 0 n48 ns228 0 8.60037714302e-06
Gc24_229 0 n48 ns229 0 -0.000747675290967
Gc24_230 0 n48 ns230 0 -0.000910147283297
Gc24_231 0 n48 ns231 0 -0.00327341747653
Gc24_232 0 n48 ns232 0 -0.00148994571279
Gc24_233 0 n48 ns233 0 -0.00182886918561
Gc24_234 0 n48 ns234 0 0.00103659726932
Gc24_235 0 n48 ns235 0 0.000719625906478
Gc24_236 0 n48 ns236 0 -0.000357509783596
Gc24_237 0 n48 ns237 0 -0.000282964339486
Gc24_238 0 n48 ns238 0 0.000447839586886
Gc24_239 0 n48 ns239 0 -0.000214711816791
Gc24_240 0 n48 ns240 0 -0.000100185865351
Gc24_241 0 n48 ns241 0 0.000209169650201
Gc24_242 0 n48 ns242 0 -1.06976301153e-06
Gc24_243 0 n48 ns243 0 0.000768922977597
Gc24_244 0 n48 ns244 0 -0.00035609865904
Gc24_245 0 n48 ns245 0 0.00138380534783
Gc24_246 0 n48 ns246 0 -4.07955789359e-06
Gc24_247 0 n48 ns247 0 0.00126254680781
Gc24_248 0 n48 ns248 0 -0.000342049458512
Gc24_249 0 n48 ns249 0 -0.00160098265004
Gc24_250 0 n48 ns250 0 -0.000630422623102
Gc24_251 0 n48 ns251 0 -0.00274054694913
Gc24_252 0 n48 ns252 0 -0.00418203116596
Gc24_253 0 n48 ns253 0 -0.0019278364497
Gc24_254 0 n48 ns254 0 -0.00454800926861
Gc24_255 0 n48 ns255 0 0.00283661265522
Gc24_256 0 n48 ns256 0 0.00125639667018
Gc24_257 0 n48 ns257 0 0.00106285982167
Gc24_258 0 n48 ns258 0 -0.00115766368124
Gc24_259 0 n48 ns259 0 -0.00135775752554
Gc24_260 0 n48 ns260 0 -0.00256147009743
Gc24_261 0 n48 ns261 0 0.00266327402524
Gc24_262 0 n48 ns262 0 -0.000281024268173
Gc24_263 0 n48 ns263 0 -0.00315740618918
Gc24_264 0 n48 ns264 0 -3.04071906461e-05
Gc24_265 0 n48 ns265 0 0.000274662445895
Gc24_266 0 n48 ns266 0 -0.000131600708132
Gc24_267 0 n48 ns267 0 -0.000440545777081
Gc24_268 0 n48 ns268 0 -0.000130006741076
Gc24_269 0 n48 ns269 0 0.000291055548404
Gc24_270 0 n48 ns270 0 0.00236931803278
Gc24_271 0 n48 ns271 0 0.00121148194783
Gc24_272 0 n48 ns272 0 -0.0010630581659
Gc24_273 0 n48 ns273 0 -0.000288316575327
Gc24_274 0 n48 ns274 0 3.7474339206e-06
Gc24_275 0 n48 ns275 0 -0.000246036243693
Gc24_276 0 n48 ns276 0 0.000438315718106
Gc24_277 0 n48 ns277 0 -4.03268832854e-05
Gc24_278 0 n48 ns278 0 -0.000104578753949
Gc24_279 0 n48 ns279 0 0.00213411156808
Gc24_280 0 n48 ns280 0 -0.00122379908714
Gc24_281 0 n48 ns281 0 -0.0011106038365
Gc24_282 0 n48 ns282 0 0.00144807255334
Gc24_283 0 n48 ns283 0 -0.000411182281879
Gc24_284 0 n48 ns284 0 0.000659898438316
Gc24_285 0 n48 ns285 0 -0.00194646854957
Gc24_286 0 n48 ns286 0 -0.000672391815425
Gc24_287 0 n48 ns287 0 0.00290227850018
Gc24_288 0 n48 ns288 0 0.00430355645097
Gc24_289 0 n48 ns289 0 -0.00588217411008
Gc24_290 0 n48 ns290 0 0.0019794980326
Gc24_291 0 n48 ns291 0 -0.00388539855898
Gc24_292 0 n48 ns292 0 0.000358828756908
Gc24_293 0 n48 ns293 0 -0.01118220462
Gc24_294 0 n48 ns294 0 -0.0017108040391
Gc24_295 0 n48 ns295 0 0.00180736680693
Gc24_296 0 n48 ns296 0 0.000212219398506
Gc24_297 0 n48 ns297 0 -0.0025738109885
Gc24_298 0 n48 ns298 0 0.00937612915222
Gc24_299 0 n48 ns299 0 -0.0139775336498
Gc24_300 0 n48 ns300 0 -0.00350659961823
Gc24_301 0 n48 ns301 0 -0.00617595947432
Gc24_302 0 n48 ns302 0 -5.56980608283e-05
Gc24_303 0 n48 ns303 0 -0.000429828036969
Gc24_304 0 n48 ns304 0 0.000593881235732
Gc24_305 0 n48 ns305 0 -0.00104001665941
Gc24_306 0 n48 ns306 0 -0.000302675962812
Gc24_307 0 n48 ns307 0 -0.0042143146399
Gc24_308 0 n48 ns308 0 -0.00176758963879
Gc24_309 0 n48 ns309 0 -0.00180912998047
Gc24_310 0 n48 ns310 0 0.00119766677257
Gc24_311 0 n48 ns311 0 0.000894256406878
Gc24_312 0 n48 ns312 0 -0.000413023620455
Gc24_313 0 n48 ns313 0 -0.000669286768322
Gc24_314 0 n48 ns314 0 -0.00025365398045
Gc24_315 0 n48 ns315 0 -8.70998091363e-05
Gc24_316 0 n48 ns316 0 -5.26182189164e-05
Gc24_317 0 n48 ns317 0 0.00074289152313
Gc24_318 0 n48 ns318 0 0.000536694549036
Gc24_319 0 n48 ns319 0 0.000656649715938
Gc24_320 0 n48 ns320 0 -0.00145175284577
Gc24_321 0 n48 ns321 0 0.000687129063266
Gc24_322 0 n48 ns322 0 9.90617917379e-05
Gc24_323 0 n48 ns323 0 0.00079100754931
Gc24_324 0 n48 ns324 0 -0.000327279871599
Gc24_325 0 n48 ns325 0 -0.00249962823541
Gc24_326 0 n48 ns326 0 -0.00107302188278
Gc24_327 0 n48 ns327 0 -0.00285650000497
Gc24_328 0 n48 ns328 0 0.000759961019621
Gc24_329 0 n48 ns329 0 -0.0016254415418
Gc24_330 0 n48 ns330 0 -6.3028805972e-05
Gc24_331 0 n48 ns331 0 0.00414507415831
Gc24_332 0 n48 ns332 0 0.000126849524766
Gc24_333 0 n48 ns333 0 0.00123071141776
Gc24_334 0 n48 ns334 0 -0.000537019806694
Gc24_335 0 n48 ns335 0 -0.00134857726494
Gc24_336 0 n48 ns336 0 -0.000704056546879
Gc24_337 0 n48 ns337 0 0.00270010240823
Gc24_338 0 n48 ns338 0 0.00140745138254
Gc24_339 0 n48 ns339 0 -0.00284197904092
Gc24_340 0 n48 ns340 0 -4.07041774418e-05
Gc24_341 0 n48 ns341 0 0.000368920698966
Gc24_342 0 n48 ns342 0 -0.000187543500055
Gc24_343 0 n48 ns343 0 -0.000451038696994
Gc24_344 0 n48 ns344 0 0.00127708174581
Gc24_345 0 n48 ns345 0 -0.000934111493789
Gc24_346 0 n48 ns346 0 0.00159115540079
Gc24_347 0 n48 ns347 0 -0.000181139881403
Gc24_348 0 n48 ns348 0 0.000559975650781
Gc24_349 0 n48 ns349 0 0.000105769891649
Gc24_350 0 n48 ns350 0 -0.000327273619611
Gc24_351 0 n48 ns351 0 -4.11117266549e-05
Gc24_352 0 n48 ns352 0 0.000209599329611
Gc24_353 0 n48 ns353 0 0.000138287654428
Gc24_354 0 n48 ns354 0 -2.0175161535e-05
Gc24_355 0 n48 ns355 0 0.00017518346191
Gc24_356 0 n48 ns356 0 -0.00071297327519
Gc24_357 0 n48 ns357 0 -6.22438630235e-05
Gc24_358 0 n48 ns358 0 -0.000610337031698
Gc24_359 0 n48 ns359 0 -0.000256673375253
Gc24_360 0 n48 ns360 0 -0.00022589816781
Gc24_361 0 n48 ns361 0 -0.000187423715521
Gc24_362 0 n48 ns362 0 -0.0001977235649
Gc24_363 0 n48 ns363 0 -0.000465334811358
Gc24_364 0 n48 ns364 0 0.00032060434937
Gc24_365 0 n48 ns365 0 -0.00277885917441
Gc24_366 0 n48 ns366 0 0.00239753428717
Gc24_367 0 n48 ns367 0 -0.0023891780728
Gc24_368 0 n48 ns368 0 0.00209446201797
Gc24_369 0 n48 ns369 0 0.000968507943027
Gc24_370 0 n48 ns370 0 0.00114392652843
Gc24_371 0 n48 ns371 0 -0.000282961125703
Gc24_372 0 n48 ns372 0 -0.000205724843738
Gc24_373 0 n48 ns373 0 -0.00115656049317
Gc24_374 0 n48 ns374 0 -0.000945656893181
Gc24_375 0 n48 ns375 0 -0.00022239488183
Gc24_376 0 n48 ns376 0 -0.00105692683899
Gc24_377 0 n48 ns377 0 -0.000281602565105
Gc24_378 0 n48 ns378 0 -2.06171909405e-05
Gc24_379 0 n48 ns379 0 1.90165172928e-05
Gc24_380 0 n48 ns380 0 8.00428079613e-06
Gc24_381 0 n48 ns381 0 0.000427755964598
Gc24_382 0 n48 ns382 0 -0.000184602324234
Gc24_383 0 n48 ns383 0 0.00132377462093
Gc24_384 0 n48 ns384 0 -0.000462810209984
Gc24_385 0 n48 ns385 0 0.000357433542643
Gc24_386 0 n48 ns386 0 -6.62420647756e-05
Gc24_387 0 n48 ns387 0 -0.000154670191263
Gc24_388 0 n48 ns388 0 1.50391259862e-05
Gc24_389 0 n48 ns389 0 4.91010670393e-05
Gc24_390 0 n48 ns390 0 -0.000508435334278
Gc24_391 0 n48 ns391 0 -2.65472044663e-05
Gc24_392 0 n48 ns392 0 0.000128884284506
Gc24_393 0 n48 ns393 0 3.91896900745e-05
Gc24_394 0 n48 ns394 0 0.000403337240066
Gc24_395 0 n48 ns395 0 0.000193083942778
Gc24_396 0 n48 ns396 0 -0.000391611132265
Gc24_397 0 n48 ns397 0 -0.000290208889408
Gc24_398 0 n48 ns398 0 -0.000474283148428
Gc24_399 0 n48 ns399 0 -0.000435672059951
Gc24_400 0 n48 ns400 0 -0.000439444760393
Gc24_401 0 n48 ns401 0 -0.000198128181861
Gc24_402 0 n48 ns402 0 -0.000419449347276
Gc24_403 0 n48 ns403 0 -0.0044359367874
Gc24_404 0 n48 ns404 0 -0.000482775002776
Gc24_405 0 n48 ns405 0 -0.00396521711923
Gc24_406 0 n48 ns406 0 -0.000345479214591
Gc24_407 0 n48 ns407 0 0.000705898543961
Gc24_408 0 n48 ns408 0 0.00134990633493
Gc24_409 0 n48 ns409 0 -0.000357858899944
Gc24_410 0 n48 ns410 0 -0.00035516688196
Gc24_411 0 n48 ns411 0 -0.00134535346057
Gc24_412 0 n48 ns412 0 -0.00115417941271
Gc24_413 0 n48 ns413 0 -0.000228579549147
Gc24_414 0 n48 ns414 0 -0.00082165985333
Gc24_415 0 n48 ns415 0 -0.000239787958783
Gc24_416 0 n48 ns416 0 -7.33548349453e-06
Gc24_417 0 n48 ns417 0 -1.58069275418e-05
Gc24_418 0 n48 ns418 0 5.31744880979e-05
Gc24_419 0 n48 ns419 0 -0.000102940571917
Gc24_420 0 n48 ns420 0 -0.00013442183169
Gc24_421 0 n48 ns421 0 -0.000249645762222
Gc24_422 0 n48 ns422 0 0.000248030718944
Gc24_423 0 n48 ns423 0 -4.4874948098e-05
Gc24_424 0 n48 ns424 0 0.000123371869779
Gc24_425 0 n48 ns425 0 -5.15175173938e-05
Gc24_426 0 n48 ns426 0 -9.77712638623e-06
Gc24_427 0 n48 ns427 0 0.000293668016321
Gc24_428 0 n48 ns428 0 -4.66013213512e-05
Gc24_429 0 n48 ns429 0 -6.73287254002e-05
Gc24_430 0 n48 ns430 0 0.000141806904875
Gc24_431 0 n48 ns431 0 -8.46495752676e-07
Gc24_432 0 n48 ns432 0 9.70386852903e-05
Gc24_433 0 n48 ns433 0 0.000638547933629
Gc24_434 0 n48 ns434 0 0.000299408936268
Gc24_435 0 n48 ns435 0 0.000291755642031
Gc24_436 0 n48 ns436 0 -0.000471358820928
Gc24_437 0 n48 ns437 0 0.00010080116851
Gc24_438 0 n48 ns438 0 -0.000280710304231
Gc24_439 0 n48 ns439 0 -4.1501551516e-05
Gc24_440 0 n48 ns440 0 -0.000365189854561
Gc24_441 0 n48 ns441 0 -0.00485048245976
Gc24_442 0 n48 ns442 0 -0.00426220124153
Gc24_443 0 n48 ns443 0 -0.00448799325957
Gc24_444 0 n48 ns444 0 -0.00375998579218
Gc24_445 0 n48 ns445 0 -0.000376521477212
Gc24_446 0 n48 ns446 0 0.00186822807164
Gc24_447 0 n48 ns447 0 -0.000288440467026
Gc24_448 0 n48 ns448 0 -0.000744008917689
Gc24_449 0 n48 ns449 0 -0.000896448341068
Gc24_450 0 n48 ns450 0 -0.00207340312807
Gc24_451 0 n48 ns451 0 2.18673473515e-05
Gc24_452 0 n48 ns452 0 -0.00126452266632
Gc24_453 0 n48 ns453 0 -0.000444153496475
Gc24_454 0 n48 ns454 0 -1.15597468814e-05
Gc24_455 0 n48 ns455 0 4.20242511477e-05
Gc24_456 0 n48 ns456 0 1.30374059811e-05
Gc24_457 0 n48 ns457 0 -0.000311659594512
Gc24_458 0 n48 ns458 0 -0.000120330693632
Gc24_459 0 n48 ns459 0 -0.000719167029316
Gc24_460 0 n48 ns460 0 0.00141539164947
Gc24_461 0 n48 ns461 0 -0.000344557385238
Gc24_462 0 n48 ns462 0 0.000100389943548
Gc24_463 0 n48 ns463 0 0.000214243436284
Gc24_464 0 n48 ns464 0 -0.000165516318498
Gc24_465 0 n48 ns465 0 6.15354468383e-05
Gc24_466 0 n48 ns466 0 0.000429616340736
Gc24_467 0 n48 ns467 0 -0.000132884137343
Gc24_468 0 n48 ns468 0 0.000125341661033
Gc24_469 0 n48 ns469 0 0.00058959565333
Gc24_470 0 n48 ns470 0 -0.00046599165803
Gc24_471 0 n48 ns471 0 0.000126682970962
Gc24_472 0 n48 ns472 0 0.00027378817561
Gc24_473 0 n48 ns473 0 0.000630562178194
Gc24_474 0 n48 ns474 0 -0.000411550841522
Gc24_475 0 n48 ns475 0 0.00023027246061
Gc24_476 0 n48 ns476 0 -0.000394199402279
Gc24_477 0 n48 ns477 0 -0.000337721147473
Gc24_478 0 n48 ns478 0 0.000699510198773
Gc24_479 0 n48 ns479 0 -0.0022037976897
Gc24_480 0 n48 ns480 0 -0.00447934107278
Gc24_481 0 n48 ns481 0 -0.0021858111814
Gc24_482 0 n48 ns482 0 -0.00443543988993
Gc24_483 0 n48 ns483 0 -0.00112642925187
Gc24_484 0 n48 ns484 0 0.00134510817705
Gc24_485 0 n48 ns485 0 0.000147520981722
Gc24_486 0 n48 ns486 0 -0.00127004952557
Gc24_487 0 n48 ns487 0 1.72352481089e-05
Gc24_488 0 n48 ns488 0 -0.00306394513787
Gc24_489 0 n48 ns489 0 0.000641178500705
Gc24_490 0 n48 ns490 0 -0.00283366488333
Gc24_491 0 n48 ns491 0 -0.00116759087226
Gc24_492 0 n48 ns492 0 -3.86427773346e-05
Gc24_493 0 n48 ns493 0 0.000102264847338
Gc24_494 0 n48 ns494 0 -1.01514859823e-05
Gc24_495 0 n48 ns495 0 -0.00072978782148
Gc24_496 0 n48 ns496 0 -0.000505676760022
Gc24_497 0 n48 ns497 0 -0.00229293050416
Gc24_498 0 n48 ns498 0 0.00105275730316
Gc24_499 0 n48 ns499 0 -0.000233936661542
Gc24_500 0 n48 ns500 0 0.000864107712767
Gc24_501 0 n48 ns501 0 0.000169756554732
Gc24_502 0 n48 ns502 0 -0.000243895018994
Gc24_503 0 n48 ns503 0 -0.00012094582135
Gc24_504 0 n48 ns504 0 0.000349547519104
Gc24_505 0 n48 ns505 0 -0.000249501208071
Gc24_506 0 n48 ns506 0 -2.18512252542e-05
Gc24_507 0 n48 ns507 0 0.000410427615945
Gc24_508 0 n48 ns508 0 0.000275683766294
Gc24_509 0 n48 ns509 0 0.000352874950075
Gc24_510 0 n48 ns510 0 -0.000327403544613
Gc24_511 0 n48 ns511 0 0.00110431604479
Gc24_512 0 n48 ns512 0 -0.000306172706433
Gc24_513 0 n48 ns513 0 0.000852270696986
Gc24_514 0 n48 ns514 0 -0.000750452405756
Gc24_515 0 n48 ns515 0 -0.00174303945993
Gc24_516 0 n48 ns516 0 3.67310710562e-05
Gc24_517 0 n48 ns517 0 -0.00340881004142
Gc24_518 0 n48 ns518 0 -0.00364214149052
Gc24_519 0 n48 ns519 0 -0.00267867835729
Gc24_520 0 n48 ns520 0 -0.00407652939605
Gc24_521 0 n48 ns521 0 0.00120218394911
Gc24_522 0 n48 ns522 0 -0.000411597235837
Gc24_523 0 n48 ns523 0 0.000938298749079
Gc24_524 0 n48 ns524 0 -0.00116292458739
Gc24_525 0 n48 ns525 0 4.58341328292e-05
Gc24_526 0 n48 ns526 0 -0.00165882096252
Gc24_527 0 n48 ns527 0 0.00254157348342
Gc24_528 0 n48 ns528 0 -0.00236003070146
Gc24_529 0 n48 ns529 0 -0.00249108500847
Gc24_530 0 n48 ns530 0 3.06402210975e-06
Gc24_531 0 n48 ns531 0 0.000132730791482
Gc24_532 0 n48 ns532 0 -2.97465792615e-05
Gc24_533 0 n48 ns533 0 0.00226606963921
Gc24_534 0 n48 ns534 0 -0.00344224061483
Gc24_535 0 n48 ns535 0 0.00475129746911
Gc24_536 0 n48 ns536 0 -0.00707969372694
Gc24_537 0 n48 ns537 0 -0.00338405360477
Gc24_538 0 n48 ns538 0 -0.00251244816602
Gc24_539 0 n48 ns539 0 0.00108182728609
Gc24_540 0 n48 ns540 0 0.0007405078187
Gc24_541 0 n48 ns541 0 -0.000652047600126
Gc24_542 0 n48 ns542 0 -0.000125390392835
Gc24_543 0 n48 ns543 0 -0.000189835133854
Gc24_544 0 n48 ns544 0 -0.000134914967441
Gc24_545 0 n48 ns545 0 -0.000518774039041
Gc24_546 0 n48 ns546 0 -0.000766529167797
Gc24_547 0 n48 ns547 0 0.000683187744244
Gc24_548 0 n48 ns548 0 0.000552084522504
Gc24_549 0 n48 ns549 0 0.000952658105826
Gc24_550 0 n48 ns550 0 0.000965328623985
Gc24_551 0 n48 ns551 0 0.000362712138149
Gc24_552 0 n48 ns552 0 0.00119477171305
Gc24_553 0 n48 ns553 0 0.000966270334714
Gc24_554 0 n48 ns554 0 -0.00257438070349
Gc24_555 0 n48 ns555 0 0.00199742010027
Gc24_556 0 n48 ns556 0 -0.00704701025202
Gc24_557 0 n48 ns557 0 0.00220202329232
Gc24_558 0 n48 ns558 0 -0.00677902002269
Gc24_559 0 n48 ns559 0 0.00479710366403
Gc24_560 0 n48 ns560 0 0.00666425668281
Gc24_561 0 n48 ns561 0 0.00113341550845
Gc24_562 0 n48 ns562 0 -0.00105004113403
Gc24_563 0 n48 ns563 0 -0.00425049389061
Gc24_564 0 n48 ns564 0 -0.0050285526191
Gc24_565 0 n48 ns565 0 0.00175444327404
Gc24_566 0 n48 ns566 0 0.00605170462709
Gc24_567 0 n48 ns567 0 -0.00418065978814
Gc24_568 0 n48 ns568 0 -8.57390999657e-06
Gc24_569 0 n48 ns569 0 0.000373877875567
Gc24_570 0 n48 ns570 0 -0.000220815010972
Gc24_571 0 n48 ns571 0 0.000937724670793
Gc24_572 0 n48 ns572 0 -0.00216473348596
Gc24_573 0 n48 ns573 0 0.00134964658674
Gc24_574 0 n48 ns574 0 -0.00440949129636
Gc24_575 0 n48 ns575 0 -0.00242846401674
Gc24_576 0 n48 ns576 0 -0.00130515696671
Gc24_577 0 n48 ns577 0 0.00101293886907
Gc24_578 0 n48 ns578 0 0.000439470613962
Gc24_579 0 n48 ns579 0 -0.000791429305942
Gc24_580 0 n48 ns580 0 -0.000482353740238
Gc24_581 0 n48 ns581 0 -0.000134246877929
Gc24_582 0 n48 ns582 0 -8.63226344075e-05
Gc24_583 0 n48 ns583 0 0.000353292214511
Gc24_584 0 n48 ns584 0 0.000128548202919
Gc24_585 0 n48 ns585 0 0.000722860358822
Gc24_586 0 n48 ns586 0 -0.00084787864635
Gc24_587 0 n48 ns587 0 0.0006531207533
Gc24_588 0 n48 ns588 0 0.000484020570092
Gc24_589 0 n48 ns589 0 0.000350823850847
Gc24_590 0 n48 ns590 0 0.000207029031114
Gc24_591 0 n48 ns591 0 -0.00120162078605
Gc24_592 0 n48 ns592 0 -0.0019123118104
Gc24_593 0 n48 ns593 0 -0.0014587513381
Gc24_594 0 n48 ns594 0 -0.000878633476297
Gc24_595 0 n48 ns595 0 -0.000418478842144
Gc24_596 0 n48 ns596 0 -0.00156116814945
Gc24_597 0 n48 ns597 0 0.00460928958256
Gc24_598 0 n48 ns598 0 0.00200379441869
Gc24_599 0 n48 ns599 0 0.00139323521862
Gc24_600 0 n48 ns600 0 -0.000646488728653
Gc24_601 0 n48 ns601 0 -0.00206859855997
Gc24_602 0 n48 ns602 0 -0.001472494975
Gc24_603 0 n48 ns603 0 0.00261012337972
Gc24_604 0 n48 ns604 0 0.00295102556355
Gc24_605 0 n48 ns605 0 -0.0035404621458
Gc24_606 0 n48 ns606 0 -9.38230326429e-06
Gc24_607 0 n48 ns607 0 0.00029269299793
Gc24_608 0 n48 ns608 0 -0.000152353869959
Gc24_609 0 n48 ns609 0 3.4609329281e-05
Gc24_610 0 n48 ns610 0 0.000157449233507
Gc24_611 0 n48 ns611 0 9.97533018972e-05
Gc24_612 0 n48 ns612 0 -0.000728399244887
Gc24_613 0 n48 ns613 0 -7.36367325509e-05
Gc24_614 0 n48 ns614 0 -5.98009532176e-05
Gc24_615 0 n48 ns615 0 7.89779748371e-05
Gc24_616 0 n48 ns616 0 8.70748388223e-06
Gc24_617 0 n48 ns617 0 9.83333032475e-05
Gc24_618 0 n48 ns618 0 -0.000121867108156
Gc24_619 0 n48 ns619 0 -4.44865605078e-05
Gc24_620 0 n48 ns620 0 2.85102641888e-05
Gc24_621 0 n48 ns621 0 -0.000101034809638
Gc24_622 0 n48 ns622 0 0.000161273890759
Gc24_623 0 n48 ns623 0 -0.000329741738672
Gc24_624 0 n48 ns624 0 0.000101326928988
Gc24_625 0 n48 ns625 0 -0.000243021017034
Gc24_626 0 n48 ns626 0 0.000180774506596
Gc24_627 0 n48 ns627 0 -0.000323918423565
Gc24_628 0 n48 ns628 0 0.000227486006124
Gc24_629 0 n48 ns629 0 6.71792789951e-05
Gc24_630 0 n48 ns630 0 -0.000310863762918
Gc24_631 0 n48 ns631 0 0.000110269718194
Gc24_632 0 n48 ns632 0 -0.00157835517196
Gc24_633 0 n48 ns633 0 8.7731220514e-05
Gc24_634 0 n48 ns634 0 -0.0013711668304
Gc24_635 0 n48 ns635 0 -6.07778681503e-05
Gc24_636 0 n48 ns636 0 0.000119555662178
Gc24_637 0 n48 ns637 0 -7.17459042127e-05
Gc24_638 0 n48 ns638 0 -4.28115146688e-05
Gc24_639 0 n48 ns639 0 -0.000192609759656
Gc24_640 0 n48 ns640 0 1.90259176743e-06
Gc24_641 0 n48 ns641 0 -7.24203124642e-05
Gc24_642 0 n48 ns642 0 0.000293428014441
Gc24_643 0 n48 ns643 0 0.000113996997718
Gc24_644 0 n48 ns644 0 -6.95341849842e-06
Gc24_645 0 n48 ns645 0 3.29520047241e-05
Gc24_646 0 n48 ns646 0 -3.8761327283e-05
Gc24_647 0 n48 ns647 0 0.000107178680512
Gc24_648 0 n48 ns648 0 0.000272698564504
Gc24_649 0 n48 ns649 0 0.000503036187764
Gc24_650 0 n48 ns650 0 -0.000401059278837
Gc24_651 0 n48 ns651 0 -4.59642236531e-05
Gc24_652 0 n48 ns652 0 1.76225032176e-05
Gc24_653 0 n48 ns653 0 7.99214362407e-05
Gc24_654 0 n48 ns654 0 -1.18590658584e-05
Gc24_655 0 n48 ns655 0 0.000211483141917
Gc24_656 0 n48 ns656 0 -3.74924314521e-05
Gc24_657 0 n48 ns657 0 -4.99038959577e-05
Gc24_658 0 n48 ns658 0 -3.59025846721e-06
Gc24_659 0 n48 ns659 0 -0.000225654854076
Gc24_660 0 n48 ns660 0 -6.49496043528e-06
Gc24_661 0 n48 ns661 0 -0.000384718508995
Gc24_662 0 n48 ns662 0 -0.000139452158872
Gc24_663 0 n48 ns663 0 -0.000305489685151
Gc24_664 0 n48 ns664 0 3.67654059759e-05
Gc24_665 0 n48 ns665 0 -0.000353721442761
Gc24_666 0 n48 ns666 0 6.28117935117e-06
Gc24_667 0 n48 ns667 0 0.000275404064839
Gc24_668 0 n48 ns668 0 -0.000150389282811
Gc24_669 0 n48 ns669 0 0.000715212907376
Gc24_670 0 n48 ns670 0 -0.00140820725002
Gc24_671 0 n48 ns671 0 0.000604533803313
Gc24_672 0 n48 ns672 0 -0.00125723642202
Gc24_673 0 n48 ns673 0 0.000206048232161
Gc24_674 0 n48 ns674 0 0.000291859876121
Gc24_675 0 n48 ns675 0 -0.000129439145089
Gc24_676 0 n48 ns676 0 -8.0511727891e-05
Gc24_677 0 n48 ns677 0 -0.00047377611287
Gc24_678 0 n48 ns678 0 -0.000198675443618
Gc24_679 0 n48 ns679 0 -0.00018824723747
Gc24_680 0 n48 ns680 0 -9.60316285266e-06
Gc24_681 0 n48 ns681 0 5.76839536177e-05
Gc24_682 0 n48 ns682 0 6.93114905285e-06
Gc24_683 0 n48 ns683 0 9.90684940122e-06
Gc24_684 0 n48 ns684 0 -2.43793705419e-05
Gc24_685 0 n48 ns685 0 0.000211440830743
Gc24_686 0 n48 ns686 0 0.000492743423854
Gc24_687 0 n48 ns687 0 0.000961891923904
Gc24_688 0 n48 ns688 0 0.000829137854513
Gc24_689 0 n48 ns689 0 3.83525018813e-05
Gc24_690 0 n48 ns690 0 0.000212853613228
Gc24_691 0 n48 ns691 0 -1.8346665726e-05
Gc24_692 0 n48 ns692 0 -6.57298288924e-05
Gc24_693 0 n48 ns693 0 0.000268561745819
Gc24_694 0 n48 ns694 0 0.000311200096329
Gc24_695 0 n48 ns695 0 -2.91209226898e-05
Gc24_696 0 n48 ns696 0 -0.000102086305913
Gc24_697 0 n48 ns697 0 -0.000258085818044
Gc24_698 0 n48 ns698 0 -0.000454355164374
Gc24_699 0 n48 ns699 0 -3.54465724888e-05
Gc24_700 0 n48 ns700 0 -0.00086389883266
Gc24_701 0 n48 ns701 0 -0.000259473437888
Gc24_702 0 n48 ns702 0 -0.000540670899733
Gc24_703 0 n48 ns703 0 -0.000152489557305
Gc24_704 0 n48 ns704 0 -0.000711039278909
Gc24_705 0 n48 ns705 0 0.000685228921643
Gc24_706 0 n48 ns706 0 0.000572188425321
Gc24_707 0 n48 ns707 0 0.00299994575254
Gc24_708 0 n48 ns708 0 4.13650094266e-05
Gc24_709 0 n48 ns709 0 0.00262325111026
Gc24_710 0 n48 ns710 0 -0.00010538546617
Gc24_711 0 n48 ns711 0 0.000784422584967
Gc24_712 0 n48 ns712 0 0.000784491363926
Gc24_713 0 n48 ns713 0 -0.000277967861888
Gc24_714 0 n48 ns714 0 -0.000219385494451
Gc24_715 0 n48 ns715 0 -0.00117425328323
Gc24_716 0 n48 ns716 0 -0.000785169264831
Gc24_717 0 n48 ns717 0 -0.000468481681772
Gc24_718 0 n48 ns718 0 -0.000695474844168
Gc24_719 0 n48 ns719 0 -5.9727324318e-05
Gc24_720 0 n48 ns720 0 2.74813889149e-05
Gc24_721 0 n48 ns721 0 -5.96781988708e-05
Gc24_722 0 n48 ns722 0 1.35030144102e-05
Gc24_723 0 n48 ns723 0 -0.000444514052036
Gc24_724 0 n48 ns724 0 0.000576476655134
Gc24_725 0 n48 ns725 0 -0.00108349782973
Gc24_726 0 n48 ns726 0 0.00124517878247
Gc24_727 0 n48 ns727 0 -0.000300813541422
Gc24_728 0 n48 ns728 0 0.000271194106287
Gc24_729 0 n48 ns729 0 0.00013021471586
Gc24_730 0 n48 ns730 0 -0.000187152021822
Gc24_731 0 n48 ns731 0 -0.000171954709285
Gc24_732 0 n48 ns732 0 0.000482903527555
Gc24_733 0 n48 ns733 0 7.38936253916e-05
Gc24_734 0 n48 ns734 0 -0.000151817993818
Gc24_735 0 n48 ns735 0 0.0001241624281
Gc24_736 0 n48 ns736 0 -0.00043937054959
Gc24_737 0 n48 ns737 0 0.000823026379039
Gc24_738 0 n48 ns738 0 -0.000437695174651
Gc24_739 0 n48 ns739 0 0.00017668992227
Gc24_740 0 n48 ns740 0 -0.000648855575165
Gc24_741 0 n48 ns741 0 0.00024980380732
Gc24_742 0 n48 ns742 0 -0.000520247132355
Gc24_743 0 n48 ns743 0 -0.000161946943873
Gc24_744 0 n48 ns744 0 0.000851196448208
Gc24_745 0 n48 ns745 0 0.00333590005336
Gc24_746 0 n48 ns746 0 0.00236838722501
Gc24_747 0 n48 ns747 0 0.00313610031053
Gc24_748 0 n48 ns748 0 0.00195596916058
Gc24_749 0 n48 ns749 0 0.000231510746794
Gc24_750 0 n48 ns750 0 0.00116605620997
Gc24_751 0 n48 ns751 0 -0.000322112752421
Gc24_752 0 n48 ns752 0 -0.000433971443446
Gc24_753 0 n48 ns753 0 -0.00114603091874
Gc24_754 0 n48 ns754 0 -0.00115159156421
Gc24_755 0 n48 ns755 0 -0.000500308013255
Gc24_756 0 n48 ns756 0 -0.000163057320775
Gc24_757 0 n48 ns757 0 0.000124586844983
Gc24_758 0 n48 ns758 0 -1.51051003697e-05
Gc24_759 0 n48 ns759 0 1.87191095158e-05
Gc24_760 0 n48 ns760 0 -5.09940008962e-05
Gc24_761 0 n48 ns761 0 8.49589743356e-05
Gc24_762 0 n48 ns762 0 -0.000244192332023
Gc24_763 0 n48 ns763 0 0.000503106236878
Gc24_764 0 n48 ns764 0 0.00049754775518
Gc24_765 0 n48 ns765 0 0.000183353771152
Gc24_766 0 n48 ns766 0 -2.3049901932e-05
Gc24_767 0 n48 ns767 0 1.88042094124e-05
Gc24_768 0 n48 ns768 0 4.0729775803e-05
Gc24_769 0 n48 ns769 0 -0.000236174004507
Gc24_770 0 n48 ns770 0 -9.89994046721e-05
Gc24_771 0 n48 ns771 0 0.000132865543925
Gc24_772 0 n48 ns772 0 -0.000143226609661
Gc24_773 0 n48 ns773 0 -0.000255122057393
Gc24_774 0 n48 ns774 0 -0.000231724172099
Gc24_775 0 n48 ns775 0 0.000249117263645
Gc24_776 0 n48 ns776 0 0.000448197968373
Gc24_777 0 n48 ns777 0 0.000302090364747
Gc24_778 0 n48 ns778 0 -0.000531916718136
Gc24_779 0 n48 ns779 0 -0.000106371194736
Gc24_780 0 n48 ns780 0 -0.00050465002692
Gc24_781 0 n48 ns781 0 -0.000380821974899
Gc24_782 0 n48 ns782 0 -0.000186770853517
Gc24_783 0 n48 ns783 0 0.00278417549791
Gc24_784 0 n48 ns784 0 0.00387820697429
Gc24_785 0 n48 ns785 0 0.00279494688346
Gc24_786 0 n48 ns786 0 0.0036122132474
Gc24_787 0 n48 ns787 0 -0.00113479527872
Gc24_788 0 n48 ns788 0 0.000683480667381
Gc24_789 0 n48 ns789 0 -0.000128051720262
Gc24_790 0 n48 ns790 0 -0.000807088270892
Gc24_791 0 n48 ns791 0 -0.000459928456468
Gc24_792 0 n48 ns792 0 -0.00146237949784
Gc24_793 0 n48 ns793 0 -0.000658873694716
Gc24_794 0 n48 ns794 0 0.000782985743418
Gc24_795 0 n48 ns795 0 0.000522553720113
Gc24_796 0 n48 ns796 0 2.07446721896e-05
Gc24_797 0 n48 ns797 0 -0.000138013921684
Gc24_798 0 n48 ns798 0 2.28070146672e-05
Gc24_799 0 n48 ns799 0 0.000237106187248
Gc24_800 0 n48 ns800 0 -0.00108236347971
Gc24_801 0 n48 ns801 0 0.000616477672403
Gc24_802 0 n48 ns802 0 -0.000509016151833
Gc24_803 0 n48 ns803 0 -0.000126635203779
Gc24_804 0 n48 ns804 0 0.000243620238825
Gc24_805 0 n48 ns805 0 -0.000167201385685
Gc24_806 0 n48 ns806 0 -0.000110621939289
Gc24_807 0 n48 ns807 0 2.6858415936e-05
Gc24_808 0 n48 ns808 0 -0.000337081079552
Gc24_809 0 n48 ns809 0 0.00020955518913
Gc24_810 0 n48 ns810 0 -2.71503503207e-05
Gc24_811 0 n48 ns811 0 0.00024715568183
Gc24_812 0 n48 ns812 0 9.73763640251e-06
Gc24_813 0 n48 ns813 0 -0.000379825822097
Gc24_814 0 n48 ns814 0 -2.50749131963e-05
Gc24_815 0 n48 ns815 0 0.000595704319813
Gc24_816 0 n48 ns816 0 -0.000504812102929
Gc24_817 0 n48 ns817 0 0.00011595846055
Gc24_818 0 n48 ns818 0 -0.000841912995744
Gc24_819 0 n48 ns819 0 0.000908458376873
Gc24_820 0 n48 ns820 0 -0.000576626195242
Gc24_821 0 n48 ns821 0 0.00157250403191
Gc24_822 0 n48 ns822 0 0.00430548963663
Gc24_823 0 n48 ns823 0 0.00151803447538
Gc24_824 0 n48 ns824 0 0.00444943330831
Gc24_825 0 n48 ns825 0 -0.0014958142874
Gc24_826 0 n48 ns826 0 -0.00155254076121
Gc24_827 0 n48 ns827 0 0.000490964559003
Gc24_828 0 n48 ns828 0 -0.00106694276705
Gc24_829 0 n48 ns829 0 0.00049659864099
Gc24_830 0 n48 ns830 0 -0.00077878335207
Gc24_831 0 n48 ns831 0 -0.00140811078741
Gc24_832 0 n48 ns832 0 0.00258631909185
Gc24_833 0 n48 ns833 0 0.00151829188347
Gc24_834 0 n48 ns834 0 2.34524590906e-05
Gc24_835 0 n48 ns835 0 -0.000216762079145
Gc24_836 0 n48 ns836 0 6.90083288582e-05
Gc24_837 0 n48 ns837 0 0.000302153398224
Gc24_838 0 n48 ns838 0 -0.00267850181593
Gc24_839 0 n48 ns839 0 0.000145223692143
Gc24_840 0 n48 ns840 0 -0.00155964144764
Gc24_841 0 n48 ns841 0 -0.000899768619142
Gc24_842 0 n48 ns842 0 1.46725512916e-05
Gc24_843 0 n48 ns843 0 0.000420544794156
Gc24_844 0 n48 ns844 0 -0.000382396965723
Gc24_845 0 n48 ns845 0 0.000118415457816
Gc24_846 0 n48 ns846 0 -1.93259309966e-05
Gc24_847 0 n48 ns847 0 0.000264637000611
Gc24_848 0 n48 ns848 0 8.71299815658e-05
Gc24_849 0 n48 ns849 0 -0.000241558649863
Gc24_850 0 n48 ns850 0 0.000506128442478
Gc24_851 0 n48 ns851 0 0.0005907007542
Gc24_852 0 n48 ns852 0 8.20684861604e-05
Gc24_853 0 n48 ns853 0 0.0010887093009
Gc24_854 0 n48 ns854 0 0.000189316561107
Gc24_855 0 n48 ns855 0 0.00053991686479
Gc24_856 0 n48 ns856 0 -0.00011692835445
Gc24_857 0 n48 ns857 0 0.000144761334646
Gc24_858 0 n48 ns858 0 0.00150685175471
Gc24_859 0 n48 ns859 0 -0.000178540203713
Gc24_860 0 n48 ns860 0 0.004605055249
Gc24_861 0 n48 ns861 0 -0.000433569066977
Gc24_862 0 n48 ns862 0 0.00493256623031
Gc24_863 0 n48 ns863 0 0.00263186354074
Gc24_864 0 n48 ns864 0 8.45453182867e-05
Gc24_865 0 n48 ns865 0 0.00112362967983
Gc24_866 0 n48 ns866 0 -0.000981338395169
Gc24_867 0 n48 ns867 0 -0.000913405771136
Gc24_868 0 n48 ns868 0 -0.00113761378688
Gc24_869 0 n48 ns869 0 -0.00361445927344
Gc24_870 0 n48 ns870 0 0.000206654474821
Gc24_871 0 n48 ns871 0 0.00317120644754
Gc24_872 0 n48 ns872 0 2.50088492405e-05
Gc24_873 0 n48 ns873 0 -0.000130534572892
Gc24_874 0 n48 ns874 0 2.11471576425e-06
Gc24_875 0 n48 ns875 0 0.000354437005786
Gc24_876 0 n48 ns876 0 -0.00209582312886
Gc24_877 0 n48 ns877 0 -0.00166854422824
Gc24_878 0 n48 ns878 0 0.000357552012962
Gc24_879 0 n48 ns879 0 -0.000647155379541
Gc24_880 0 n48 ns880 0 0.000306644074673
Gc24_881 0 n48 ns881 0 0.000416155588225
Gc24_882 0 n48 ns882 0 -0.000189864339061
Gc24_883 0 n48 ns883 0 0.000428538667101
Gc24_884 0 n48 ns884 0 0.000214531962738
Gc24_885 0 n48 ns885 0 0.000220493349936
Gc24_886 0 n48 ns886 0 0.000129696490634
Gc24_887 0 n48 ns887 0 -0.000647136824396
Gc24_888 0 n48 ns888 0 -0.000486746837189
Gc24_889 0 n48 ns889 0 -0.000520375039168
Gc24_890 0 n48 ns890 0 0.000337529829995
Gc24_891 0 n48 ns891 0 0.000225208689713
Gc24_892 0 n48 ns892 0 0.000408197415178
Gc24_893 0 n48 ns893 0 -0.000571172523241
Gc24_894 0 n48 ns894 0 -0.000611928327875
Gc24_895 0 n48 ns895 0 -0.000564917997887
Gc24_896 0 n48 ns896 0 -0.000532395383913
Gc24_897 0 n48 ns897 0 0.00329502870783
Gc24_898 0 n48 ns898 0 0.00353300266944
Gc24_899 0 n48 ns899 0 0.00185400565307
Gc24_900 0 n48 ns900 0 0.00396521582956
Gc24_901 0 n48 ns901 0 0.000432697392917
Gc24_902 0 n48 ns902 0 0.00444229214706
Gc24_903 0 n48 ns903 0 0.0012761994526
Gc24_904 0 n48 ns904 0 -0.000681829074573
Gc24_905 0 n48 ns905 0 -0.00495372447734
Gc24_906 0 n48 ns906 0 -0.000920537660773
Gc24_907 0 n48 ns907 0 0.00295229609018
Gc24_908 0 n48 ns908 0 -0.00387107162777
Gc24_909 0 n48 ns909 0 0.00489947412083
Gc24_910 0 n48 ns910 0 -2.65427508237e-05
Gc24_911 0 n48 ns911 0 1.77609593116e-05
Gc24_912 0 n48 ns912 0 -5.50311304426e-05
Gc24_913 0 n48 ns913 0 0.000707786034814
Gc24_914 0 n48 ns914 0 -0.00256674889913
Gc24_915 0 n48 ns915 0 0.00107762379944
Gc24_916 0 n48 ns916 0 -0.00187779482658
Gc24_917 0 n48 ns917 0 -0.00110031194007
Gc24_918 0 n48 ns918 0 -0.000223959543349
Gc24_919 0 n48 ns919 0 0.000360587503069
Gc24_920 0 n48 ns920 0 -0.000310479882473
Gc24_921 0 n48 ns921 0 0.000345525774127
Gc24_922 0 n48 ns922 0 0.000664043976542
Gc24_923 0 n48 ns923 0 0.000110725234212
Gc24_924 0 n48 ns924 0 9.8382142321e-05
Gc24_925 0 n48 ns925 0 -9.4230368725e-05
Gc24_926 0 n48 ns926 0 0.000407093421523
Gc24_927 0 n48 ns927 0 0.000678896195508
Gc24_928 0 n48 ns928 0 -0.00155407667825
Gc24_929 0 n48 ns929 0 0.000637645423835
Gc24_930 0 n48 ns930 0 -1.35261836249e-05
Gc24_931 0 n48 ns931 0 0.000643194170556
Gc24_932 0 n48 ns932 0 -0.000550051566396
Gc24_933 0 n48 ns933 0 0.00149308925409
Gc24_934 0 n48 ns934 0 0.0026422563331
Gc24_935 0 n48 ns935 0 0.000571753305814
Gc24_936 0 n48 ns936 0 0.00171552308036
Gc24_937 0 n48 ns937 0 -0.000207998287291
Gc24_938 0 n48 ns938 0 0.00213351380815
Gc24_939 0 n48 ns939 0 0.00497676583948
Gc24_940 0 n48 ns940 0 -0.000425384663689
Gc24_941 0 n48 ns941 0 0.00117223680746
Gc24_942 0 n48 ns942 0 -0.00044627886548
Gc24_943 0 n48 ns943 0 -0.00160567970961
Gc24_944 0 n48 ns944 0 -0.000107767690742
Gc24_945 0 n48 ns945 0 -0.00371291948256
Gc24_946 0 n48 ns946 0 -0.00102545729829
Gc24_947 0 n48 ns947 0 0.00296497828626
Gc24_948 0 n48 ns948 0 3.46083210022e-05
Gc24_949 0 n48 ns949 0 -0.000158671789904
Gc24_950 0 n48 ns950 0 2.3029318927e-05
Gc24_951 0 n48 ns951 0 0.000348380523381
Gc24_952 0 n48 ns952 0 0.000306466994452
Gc24_953 0 n48 ns953 0 0.00130867879614
Gc24_954 0 n48 ns954 0 0.00023152285856
Gc24_955 0 n48 ns955 0 8.32089767297e-05
Gc24_956 0 n48 ns956 0 6.5372736456e-05
Gc24_957 0 n48 ns957 0 2.92259014139e-06
Gc24_958 0 n48 ns958 0 1.1986700852e-05
Gc24_959 0 n48 ns959 0 0.000308046493552
Gc24_960 0 n48 ns960 0 0.000146832917999
Gc24_961 0 n48 ns961 0 -5.00726650514e-05
Gc24_962 0 n48 ns962 0 -6.56533301414e-05
Gc24_963 0 n48 ns963 0 -0.000346800317719
Gc24_964 0 n48 ns964 0 -0.000282240241243
Gc24_965 0 n48 ns965 0 -0.000294543731994
Gc24_966 0 n48 ns966 0 -0.000634518573267
Gc24_967 0 n48 ns967 0 -0.000334331627802
Gc24_968 0 n48 ns968 0 -0.000329723367114
Gc24_969 0 n48 ns969 0 -0.000297434701119
Gc24_970 0 n48 ns970 0 -0.000499310437516
Gc24_971 0 n48 ns971 0 0.000668502270571
Gc24_972 0 n48 ns972 0 0.00026948564534
Gc24_973 0 n48 ns973 0 0.00229794780851
Gc24_974 0 n48 ns974 0 -0.000673015608169
Gc24_975 0 n48 ns975 0 0.00197809639288
Gc24_976 0 n48 ns976 0 -0.000687215341275
Gc24_977 0 n48 ns977 0 0.000627289127365
Gc24_978 0 n48 ns978 0 0.00057645689932
Gc24_979 0 n48 ns979 0 -0.000221636046846
Gc24_980 0 n48 ns980 0 -0.000162528173619
Gc24_981 0 n48 ns981 0 -0.000940074903776
Gc24_982 0 n48 ns982 0 -0.000582207216901
Gc24_983 0 n48 ns983 0 -0.000376722902176
Gc24_984 0 n48 ns984 0 -0.000562563132124
Gc24_985 0 n48 ns985 0 -5.08409881064e-05
Gc24_986 0 n48 ns986 0 2.4685276409e-05
Gc24_987 0 n48 ns987 0 -4.70169730825e-05
Gc24_988 0 n48 ns988 0 1.58598859487e-05
Gc24_989 0 n48 ns989 0 -1.59112584023e-05
Gc24_990 0 n48 ns990 0 0.000367067703951
Gc24_991 0 n48 ns991 0 4.55002856801e-05
Gc24_992 0 n48 ns992 0 0.000507139724732
Gc24_993 0 n48 ns993 0 -7.6937747845e-05
Gc24_994 0 n48 ns994 0 3.87983100567e-05
Gc24_995 0 n48 ns995 0 -1.29536966076e-05
Gc24_996 0 n48 ns996 0 -2.17008045681e-05
Gc24_997 0 n48 ns997 0 -4.15191509722e-05
Gc24_998 0 n48 ns998 0 0.000368598950102
Gc24_999 0 n48 ns999 0 -1.80368410838e-06
Gc24_1000 0 n48 ns1000 0 -0.000118446707483
Gc24_1001 0 n48 ns1001 0 1.73481041592e-06
Gc24_1002 0 n48 ns1002 0 -0.000234396906828
Gc24_1003 0 n48 ns1003 0 0.000452821917803
Gc24_1004 0 n48 ns1004 0 -0.000595692875701
Gc24_1005 0 n48 ns1005 0 -7.21331660873e-05
Gc24_1006 0 n48 ns1006 0 -0.000564346838135
Gc24_1007 0 n48 ns1007 0 -5.6655995265e-06
Gc24_1008 0 n48 ns1008 0 -0.000526758941778
Gc24_1009 0 n48 ns1009 0 0.000227661482809
Gc24_1010 0 n48 ns1010 0 0.000679730010565
Gc24_1011 0 n48 ns1011 0 0.00348770452255
Gc24_1012 0 n48 ns1012 0 0.000997351657242
Gc24_1013 0 n48 ns1013 0 0.0031663659328
Gc24_1014 0 n48 ns1014 0 0.00074337046074
Gc24_1015 0 n48 ns1015 0 0.000389815275715
Gc24_1016 0 n48 ns1016 0 0.000924884102072
Gc24_1017 0 n48 ns1017 0 -0.000302130785519
Gc24_1018 0 n48 ns1018 0 -0.000331688869258
Gc24_1019 0 n48 ns1019 0 -0.00113424356639
Gc24_1020 0 n48 ns1020 0 -0.000897005696202
Gc24_1021 0 n48 ns1021 0 -0.00047641175432
Gc24_1022 0 n48 ns1022 0 -0.000198891817357
Gc24_1023 0 n48 ns1023 0 9.550798837e-05
Gc24_1024 0 n48 ns1024 0 1.4917540745e-05
Gc24_1025 0 n48 ns1025 0 -1.7748025655e-05
Gc24_1026 0 n48 ns1026 0 -1.2439141049e-05
Gc24_1027 0 n48 ns1027 0 -6.91085990731e-05
Gc24_1028 0 n48 ns1028 0 -2.06804077853e-05
Gc24_1029 0 n48 ns1029 0 4.36893828341e-05
Gc24_1030 0 n48 ns1030 0 0.000585383046713
Gc24_1031 0 n48 ns1031 0 2.9432485798e-05
Gc24_1032 0 n48 ns1032 0 1.09780045747e-05
Gc24_1033 0 n48 ns1033 0 7.06765613269e-05
Gc24_1034 0 n48 ns1034 0 -5.62216896176e-05
Gc24_1035 0 n48 ns1035 0 -0.000246498649397
Gc24_1036 0 n48 ns1036 0 0.000108122118226
Gc24_1037 0 n48 ns1037 0 8.91680626226e-05
Gc24_1038 0 n48 ns1038 0 -0.000156219185748
Gc24_1039 0 n48 ns1039 0 -0.000209188402482
Gc24_1040 0 n48 ns1040 0 -0.000185813825004
Gc24_1041 0 n48 ns1041 0 0.00055342321847
Gc24_1042 0 n48 ns1042 0 0.000229314464457
Gc24_1043 0 n48 ns1043 0 0.000234837480629
Gc24_1044 0 n48 ns1044 0 -0.000534452829617
Gc24_1045 0 n48 ns1045 0 -8.2508875215e-06
Gc24_1046 0 n48 ns1046 0 -0.000407056174701
Gc24_1047 0 n48 ns1047 0 -0.000448747688826
Gc24_1048 0 n48 ns1048 0 0.000243928497719
Gc24_1049 0 n48 ns1049 0 0.00309132363607
Gc24_1050 0 n48 ns1050 0 0.00334286680854
Gc24_1051 0 n48 ns1051 0 0.00302877384246
Gc24_1052 0 n48 ns1052 0 0.00298738955909
Gc24_1053 0 n48 ns1053 0 -0.000609058907553
Gc24_1054 0 n48 ns1054 0 0.000997469769474
Gc24_1055 0 n48 ns1055 0 -0.000236038459203
Gc24_1056 0 n48 ns1056 0 -0.000652428245166
Gc24_1057 0 n48 ns1057 0 -0.000772338898912
Gc24_1058 0 n48 ns1058 0 -0.00137525354745
Gc24_1059 0 n48 ns1059 0 -0.000569961511161
Gc24_1060 0 n48 ns1060 0 0.000374740794416
Gc24_1061 0 n48 ns1061 0 0.000337225943413
Gc24_1062 0 n48 ns1062 0 -3.24642316743e-06
Gc24_1063 0 n48 ns1063 0 -5.30795704143e-05
Gc24_1064 0 n48 ns1064 0 -2.02703339577e-05
Gc24_1065 0 n48 ns1065 0 -3.41938433386e-05
Gc24_1066 0 n48 ns1066 0 -0.000288439367116
Gc24_1067 0 n48 ns1067 0 6.73478671063e-05
Gc24_1068 0 n48 ns1068 0 0.000410890153158
Gc24_1069 0 n48 ns1069 0 0.000178675280378
Gc24_1070 0 n48 ns1070 0 0.000314376100576
Gc24_1071 0 n48 ns1071 0 -0.00017980291562
Gc24_1072 0 n48 ns1072 0 -3.76095443607e-05
Gc24_1073 0 n48 ns1073 0 -8.72422556559e-05
Gc24_1074 0 n48 ns1074 0 -0.000328459741996
Gc24_1075 0 n48 ns1075 0 0.000166231833061
Gc24_1076 0 n48 ns1076 0 -7.00019109702e-05
Gc24_1077 0 n48 ns1077 0 9.78826425431e-05
Gc24_1078 0 n48 ns1078 0 -0.000210832474639
Gc24_1079 0 n48 ns1079 0 -0.000292019652784
Gc24_1080 0 n48 ns1080 0 0.000304872284338
Gc24_1081 0 n48 ns1081 0 0.000411121908851
Gc24_1082 0 n48 ns1082 0 -0.000479206401015
Gc24_1083 0 n48 ns1083 0 -7.07971233901e-05
Gc24_1084 0 n48 ns1084 0 -0.000681893738859
Gc24_1085 0 n48 ns1085 0 0.000285113585515
Gc24_1086 0 n48 ns1086 0 -0.000834700734755
Gc24_1087 0 n48 ns1087 0 0.00177010511733
Gc24_1088 0 n48 ns1088 0 0.00383107882384
Gc24_1089 0 n48 ns1089 0 0.00180718755451
Gc24_1090 0 n48 ns1090 0 0.00388694171742
Gc24_1091 0 n48 ns1091 0 -0.00202053416136
Gc24_1092 0 n48 ns1092 0 -0.000723313171192
Gc24_1093 0 n48 ns1093 0 0.000258933723769
Gc24_1094 0 n48 ns1094 0 -0.00100823444952
Gc24_1095 0 n48 ns1095 0 0.000451477911718
Gc24_1096 0 n48 ns1096 0 -0.00107361778535
Gc24_1097 0 n48 ns1097 0 -0.00091370240752
Gc24_1098 0 n48 ns1098 0 0.00216428154979
Gc24_1099 0 n48 ns1099 0 0.00109925251883
Gc24_1100 0 n48 ns1100 0 2.92361906667e-05
Gc24_1101 0 n48 ns1101 0 -0.000229867848468
Gc24_1102 0 n48 ns1102 0 8.29855207513e-05
Gc24_1103 0 n48 ns1103 0 0.000363264096047
Gc24_1104 0 n48 ns1104 0 -0.0024080250702
Gc24_1105 0 n48 ns1105 0 0.000506768072215
Gc24_1106 0 n48 ns1106 0 -0.00223772504342
Gc24_1107 0 n48 ns1107 0 -0.000796512587298
Gc24_1108 0 n48 ns1108 0 -0.000239209643961
Gc24_1109 0 n48 ns1109 0 0.000179070817621
Gc24_1110 0 n48 ns1110 0 -0.00023629571821
Gc24_1111 0 n48 ns1111 0 -2.11404837121e-05
Gc24_1112 0 n48 ns1112 0 -0.00020861807286
Gc24_1113 0 n48 ns1113 0 0.000227447756862
Gc24_1114 0 n48 ns1114 0 7.29252348761e-05
Gc24_1115 0 n48 ns1115 0 0.000283746514231
Gc24_1116 0 n48 ns1116 0 0.000886508323694
Gc24_1117 0 n48 ns1117 0 0.000363554947283
Gc24_1118 0 n48 ns1118 0 -5.46946478615e-05
Gc24_1119 0 n48 ns1119 0 0.00102871204059
Gc24_1120 0 n48 ns1120 0 -2.79533603473e-05
Gc24_1121 0 n48 ns1121 0 0.000600576489799
Gc24_1122 0 n48 ns1122 0 -0.000155884651693
Gc24_1123 0 n48 ns1123 0 0.000870490316564
Gc24_1124 0 n48 ns1124 0 0.000814795534988
Gc24_1125 0 n48 ns1125 0 2.76633195959e-05
Gc24_1126 0 n48 ns1126 0 0.00443244337295
Gc24_1127 0 n48 ns1127 0 -7.26260615218e-05
Gc24_1128 0 n48 ns1128 0 0.00469588976235
Gc24_1129 0 n48 ns1129 0 0.000782610629318
Gc24_1130 0 n48 ns1130 0 -0.00212233741742
Gc24_1131 0 n48 ns1131 0 0.00101384357915
Gc24_1132 0 n48 ns1132 0 -0.000952150682161
Gc24_1133 0 n48 ns1133 0 0.000306162572035
Gc24_1134 0 n48 ns1134 0 -0.000267599374749
Gc24_1135 0 n48 ns1135 0 -0.0030213808799
Gc24_1136 0 n48 ns1136 0 0.00284391375811
Gc24_1137 0 n48 ns1137 0 0.00272457544106
Gc24_1138 0 n48 ns1138 0 1.40413882606e-06
Gc24_1139 0 n48 ns1139 0 -0.000106613300229
Gc24_1140 0 n48 ns1140 0 -1.13265649489e-05
Gc24_1141 0 n48 ns1141 0 0.00109912838793
Gc24_1142 0 n48 ns1142 0 -0.00433885194114
Gc24_1143 0 n48 ns1143 0 -0.000207998251838
Gc24_1144 0 n48 ns1144 0 -0.00208458000646
Gc24_1145 0 n48 ns1145 0 -0.000941780515936
Gc24_1146 0 n48 ns1146 0 -0.000258423843295
Gc24_1147 0 n48 ns1147 0 0.00060471849544
Gc24_1148 0 n48 ns1148 0 -3.14923304917e-06
Gc24_1149 0 n48 ns1149 0 0.000273474215987
Gc24_1150 0 n48 ns1150 0 3.0708852366e-05
Gc24_1151 0 n48 ns1151 0 0.000233054687048
Gc24_1152 0 n48 ns1152 0 0.000120928378089
Gc24_1153 0 n48 ns1153 0 -0.000562822013523
Gc24_1154 0 n48 ns1154 0 -0.000108128523697
Gc24_1155 0 n48 ns1155 0 -0.000639567563833
Gc24_1156 0 n48 ns1156 0 0.000560072872651
Gc24_1157 0 n48 ns1157 0 0.000308754097587
Gc24_1158 0 n48 ns1158 0 0.000317586066968
Gc24_1159 0 n48 ns1159 0 -0.0005356605559
Gc24_1160 0 n48 ns1160 0 -0.000642649475406
Gc24_1161 0 n48 ns1161 0 -0.000463459620615
Gc24_1162 0 n48 ns1162 0 -0.000806459515963
Gc24_1163 0 n48 ns1163 0 0.00313744673983
Gc24_1164 0 n48 ns1164 0 0.00516766965202
Gc24_1165 0 n48 ns1165 0 0.00183152817492
Gc24_1166 0 n48 ns1166 0 0.00533952535441
Gc24_1167 0 n48 ns1167 0 -0.000183351783032
Gc24_1168 0 n48 ns1168 0 0.00452660043126
Gc24_1169 0 n48 ns1169 0 0.00116043004843
Gc24_1170 0 n48 ns1170 0 -0.000838202894487
Gc24_1171 0 n48 ns1171 0 -0.00522688869675
Gc24_1172 0 n48 ns1172 0 -0.00148866795974
Gc24_1173 0 n48 ns1173 0 0.00350566036196
Gc24_1174 0 n48 ns1174 0 -0.00468171116429
Gc24_1175 0 n48 ns1175 0 0.00467977693829
Gc24_1176 0 n48 ns1176 0 -7.61659568048e-06
Gc24_1177 0 n48 ns1177 0 -5.71714240873e-05
Gc24_1178 0 n48 ns1178 0 -2.91175913814e-05
Gc24_1179 0 n48 ns1179 0 0.0014415553492
Gc24_1180 0 n48 ns1180 0 -0.00476403780389
Gc24_1181 0 n48 ns1181 0 0.00176123708196
Gc24_1182 0 n48 ns1182 0 -0.00379156878751
Gc24_1183 0 n48 ns1183 0 -0.0013502684319
Gc24_1184 0 n48 ns1184 0 -0.000815093761426
Gc24_1185 0 n48 ns1185 0 0.000577341740138
Gc24_1186 0 n48 ns1186 0 1.12392970337e-05
Gc24_1187 0 n48 ns1187 0 0.00036288197082
Gc24_1188 0 n48 ns1188 0 0.000582601879085
Gc24_1189 0 n48 ns1189 0 0.000142530928055
Gc24_1190 0 n48 ns1190 0 0.000120211515454
Gc24_1191 0 n48 ns1191 0 -0.000237085635441
Gc24_1192 0 n48 ns1192 0 0.000474444659614
Gc24_1193 0 n48 ns1193 0 9.47770052686e-05
Gc24_1194 0 n48 ns1194 0 -0.00124139113048
Gc24_1195 0 n48 ns1195 0 0.000449491116748
Gc24_1196 0 n48 ns1196 0 7.65229454231e-06
Gc24_1197 0 n48 ns1197 0 0.000215243133925
Gc24_1198 0 n48 ns1198 0 -0.000827663402148
Gc24_1199 0 n48 ns1199 0 0.00159301368907
Gc24_1200 0 n48 ns1200 0 0.00160086803703
Gc24_1201 0 n48 ns1201 0 0.00260440503756
Gc24_1202 0 n48 ns1202 0 0.00311336616262
Gc24_1203 0 n48 ns1203 0 0.00128520564561
Gc24_1204 0 n48 ns1204 0 0.00341200669977
Gc24_1205 0 n48 ns1205 0 0.00340131855658
Gc24_1206 0 n48 ns1206 0 0.000680379557684
Gc24_1207 0 n48 ns1207 0 0.00129356724128
Gc24_1208 0 n48 ns1208 0 -0.000539692941681
Gc24_1209 0 n48 ns1209 0 -0.00344647466444
Gc24_1210 0 n48 ns1210 0 -9.50813227038e-05
Gc24_1211 0 n48 ns1211 0 -0.000573385010979
Gc24_1212 0 n48 ns1212 0 -0.00226254538452
Gc24_1213 0 n48 ns1213 0 0.00385450846424
Gc24_1214 0 n48 ns1214 0 1.57689338675e-05
Gc24_1215 0 n48 ns1215 0 -0.000142746654834
Gc24_1216 0 n48 ns1216 0 3.26739731562e-05
Gd24_1 0 n48 ni1 0 -0.000440998314141
Gd24_2 0 n48 ni2 0 -2.03197130633e-05
Gd24_3 0 n48 ni3 0 0.000831679344213
Gd24_4 0 n48 ni4 0 -0.000849247617449
Gd24_5 0 n48 ni5 0 0.000703122315152
Gd24_6 0 n48 ni6 0 0.000573067832868
Gd24_7 0 n48 ni7 0 -0.000394081370392
Gd24_8 0 n48 ni8 0 0.000365745409555
Gd24_9 0 n48 ni9 0 0.000105205620677
Gd24_10 0 n48 ni10 0 0.00108762897897
Gd24_11 0 n48 ni11 0 -0.000481745193509
Gd24_12 0 n48 ni12 0 1.21430390066e-05
Gd24_13 0 n48 ni13 0 0.000332128393436
Gd24_14 0 n48 ni14 0 0.000109874544808
Gd24_15 0 n48 ni15 0 -0.00327350790553
Gd24_16 0 n48 ni16 0 -0.00176334582079
Gd24_17 0 n48 ni17 0 -5.10491140211e-05
Gd24_18 0 n48 ni18 0 -3.43237057382e-05
Gd24_19 0 n48 ni19 0 0.000119131213061
Gd24_20 0 n48 ni20 0 0.000753888969731
Gd24_21 0 n48 ni21 0 6.86594289424e-05
Gd24_22 0 n48 ni22 0 -0.000648471397085
Gd24_23 0 n48 ni23 0 -0.00193374702879
Gd24_24 0 n48 ni24 0 0.00118523680512
Gd24_25 0 n48 ni25 0 -0.00236687771286
Gd24_26 0 n48 ni26 0 -0.000138888950888
Gd24_27 0 n48 ni27 0 0.000248906056952
Gd24_28 0 n48 ni28 0 0.00023514348079
Gd24_29 0 n48 ni29 0 0.000133641742993
Gd24_30 0 n48 ni30 0 -0.00175241238889
Gd24_31 0 n48 ni31 0 -0.00103457450306
Gd24_32 0 n48 ni32 0 -0.00339409868139
Gc25_1 0 n50 ns1 0 -0.00022782845519
Gc25_2 0 n50 ns2 0 0.000878498487599
Gc25_3 0 n50 ns3 0 -0.000311282702665
Gc25_4 0 n50 ns4 0 0.000699625584186
Gc25_5 0 n50 ns5 0 -0.00019268237649
Gc25_6 0 n50 ns6 0 0.000302698542623
Gc25_7 0 n50 ns7 0 0.000140473747273
Gc25_8 0 n50 ns8 0 -0.00012974671272
Gc25_9 0 n50 ns9 0 0.000213843307979
Gc25_10 0 n50 ns10 0 0.000284302259098
Gc25_11 0 n50 ns11 0 2.71543029309e-05
Gc25_12 0 n50 ns12 0 -0.00010005371232
Gc25_13 0 n50 ns13 0 -0.000267910077279
Gc25_14 0 n50 ns14 0 -0.00041340019291
Gc25_15 0 n50 ns15 0 -5.72627884588e-05
Gc25_16 0 n50 ns16 0 -0.000130883726911
Gc25_17 0 n50 ns17 0 2.92350326823e-05
Gc25_18 0 n50 ns18 0 -2.11500989183e-05
Gc25_19 0 n50 ns19 0 0.00012925095824
Gc25_20 0 n50 ns20 0 -5.74985637006e-05
Gc25_21 0 n50 ns21 0 -6.75366273327e-06
Gc25_22 0 n50 ns22 0 0.000452821225636
Gc25_23 0 n50 ns23 0 4.16612384404e-05
Gc25_24 0 n50 ns24 0 0.00170455570955
Gc25_25 0 n50 ns25 0 5.12844661389e-05
Gc25_26 0 n50 ns26 0 0.00143842438403
Gc25_27 0 n50 ns27 0 0.000620004305892
Gc25_28 0 n50 ns28 0 0.000417824529519
Gc25_29 0 n50 ns29 0 -0.000112048851557
Gc25_30 0 n50 ns30 0 -7.47738345051e-05
Gc25_31 0 n50 ns31 0 -0.00057147222878
Gc25_32 0 n50 ns32 0 -0.000455800651174
Gc25_33 0 n50 ns33 0 -0.000125996293019
Gc25_34 0 n50 ns34 0 -0.000788385581744
Gc25_35 0 n50 ns35 0 -0.000223937204068
Gc25_36 0 n50 ns36 0 -7.98681427231e-06
Gc25_37 0 n50 ns37 0 4.93047903392e-05
Gc25_38 0 n50 ns38 0 -3.43406499842e-05
Gc25_39 0 n50 ns39 0 0.000111346303592
Gc25_40 0 n50 ns40 0 0.000546246137251
Gc25_41 0 n50 ns41 0 0.000641229147571
Gc25_42 0 n50 ns42 0 0.000749746523878
Gc25_43 0 n50 ns43 0 5.40696378824e-05
Gc25_44 0 n50 ns44 0 0.00024547193179
Gc25_45 0 n50 ns45 0 -1.4585334124e-05
Gc25_46 0 n50 ns46 0 -9.54107069217e-05
Gc25_47 0 n50 ns47 0 0.000195681640444
Gc25_48 0 n50 ns48 0 0.000249029331498
Gc25_49 0 n50 ns49 0 3.87678897139e-05
Gc25_50 0 n50 ns50 0 -0.000114208466919
Gc25_51 0 n50 ns51 0 -0.000402001110556
Gc25_52 0 n50 ns52 0 -0.000460239096387
Gc25_53 0 n50 ns53 0 -0.000193835511394
Gc25_54 0 n50 ns54 0 -0.000200331023769
Gc25_55 0 n50 ns55 0 -5.0858065211e-05
Gc25_56 0 n50 ns56 0 -4.13184237647e-05
Gc25_57 0 n50 ns57 0 4.23728746761e-05
Gc25_58 0 n50 ns58 0 -0.000114163625624
Gc25_59 0 n50 ns59 0 5.43918982881e-05
Gc25_60 0 n50 ns60 0 0.000540064450221
Gc25_61 0 n50 ns61 0 7.83626837824e-05
Gc25_62 0 n50 ns62 0 0.00219955742038
Gc25_63 0 n50 ns63 0 7.72187937055e-05
Gc25_64 0 n50 ns64 0 0.00185941838408
Gc25_65 0 n50 ns65 0 0.000874011550742
Gc25_66 0 n50 ns66 0 0.000472244078934
Gc25_67 0 n50 ns67 0 -0.000151355045896
Gc25_68 0 n50 ns68 0 -8.30727941534e-05
Gc25_69 0 n50 ns69 0 -0.000805000122526
Gc25_70 0 n50 ns70 0 -0.000523658614284
Gc25_71 0 n50 ns71 0 -0.000206011137521
Gc25_72 0 n50 ns72 0 -0.000887210993632
Gc25_73 0 n50 ns73 0 -0.000237079878285
Gc25_74 0 n50 ns74 0 1.1807574731e-05
Gc25_75 0 n50 ns75 0 -3.40223627327e-05
Gc25_76 0 n50 ns76 0 1.91982869513e-05
Gc25_77 0 n50 ns77 0 0.000303289830253
Gc25_78 0 n50 ns78 0 -0.000315787747132
Gc25_79 0 n50 ns79 0 0.00071269402843
Gc25_80 0 n50 ns80 0 -0.000513111183122
Gc25_81 0 n50 ns81 0 0.000168443533683
Gc25_82 0 n50 ns82 0 -0.000218069717964
Gc25_83 0 n50 ns83 0 -0.000149851460591
Gc25_84 0 n50 ns84 0 9.86520166837e-05
Gc25_85 0 n50 ns85 0 -0.000268007533602
Gc25_86 0 n50 ns86 0 -3.72266972252e-06
Gc25_87 0 n50 ns87 0 8.45909770945e-05
Gc25_88 0 n50 ns88 0 9.61675183721e-06
Gc25_89 0 n50 ns89 0 6.95178439844e-05
Gc25_90 0 n50 ns90 0 -0.000153708365795
Gc25_91 0 n50 ns91 0 -0.00036859469217
Gc25_92 0 n50 ns92 0 -0.00011894982811
Gc25_93 0 n50 ns93 0 -0.000367706863906
Gc25_94 0 n50 ns94 0 9.47886853018e-05
Gc25_95 0 n50 ns95 0 -0.00045492857323
Gc25_96 0 n50 ns96 0 0.000180985627875
Gc25_97 0 n50 ns97 0 -0.000339558099366
Gc25_98 0 n50 ns98 0 -3.80796106409e-05
Gc25_99 0 n50 ns99 0 -0.0014887516355
Gc25_100 0 n50 ns100 0 0.0013116556091
Gc25_101 0 n50 ns101 0 -0.00127243659947
Gc25_102 0 n50 ns102 0 0.0011783096937
Gc25_103 0 n50 ns103 0 0.000433973567325
Gc25_104 0 n50 ns104 0 0.000334640110097
Gc25_105 0 n50 ns105 0 -0.000145372514057
Gc25_106 0 n50 ns106 0 -7.25797642043e-05
Gc25_107 0 n50 ns107 0 -0.000568700203176
Gc25_108 0 n50 ns108 0 -0.000215685457018
Gc25_109 0 n50 ns109 0 -6.94309735785e-05
Gc25_110 0 n50 ns110 0 -0.00014117950678
Gc25_111 0 n50 ns111 0 -6.88012887168e-05
Gc25_112 0 n50 ns112 0 -1.12346556861e-05
Gc25_113 0 n50 ns113 0 1.9696848651e-05
Gc25_114 0 n50 ns114 0 7.67691098814e-06
Gc25_115 0 n50 ns115 0 -0.000705623970507
Gc25_116 0 n50 ns116 0 0.00129924571278
Gc25_117 0 n50 ns117 0 -0.00181295373085
Gc25_118 0 n50 ns118 0 0.00186167934125
Gc25_119 0 n50 ns119 0 -0.000246229081992
Gc25_120 0 n50 ns120 0 0.000685254664287
Gc25_121 0 n50 ns121 0 0.000174929889394
Gc25_122 0 n50 ns122 0 -0.000435871409233
Gc25_123 0 n50 ns123 0 -6.0204321905e-05
Gc25_124 0 n50 ns124 0 -0.000107669482087
Gc25_125 0 n50 ns125 0 9.39182891031e-05
Gc25_126 0 n50 ns126 0 0.000114133863495
Gc25_127 0 n50 ns127 0 0.000592060137142
Gc25_128 0 n50 ns128 0 -0.000356864306213
Gc25_129 0 n50 ns129 0 0.000352833310181
Gc25_130 0 n50 ns130 0 -0.000742012177594
Gc25_131 0 n50 ns131 0 -0.000187844100659
Gc25_132 0 n50 ns132 0 -0.000485517219298
Gc25_133 0 n50 ns133 0 -0.000173976025201
Gc25_134 0 n50 ns134 0 -0.000434709520239
Gc25_135 0 n50 ns135 0 -0.000558215798877
Gc25_136 0 n50 ns136 0 -0.000160509045747
Gc25_137 0 n50 ns137 0 -0.00417438697153
Gc25_138 0 n50 ns138 0 0.000457744214433
Gc25_139 0 n50 ns139 0 -0.00363344446151
Gc25_140 0 n50 ns140 0 0.000465166128869
Gc25_141 0 n50 ns141 0 0.000424187087869
Gc25_142 0 n50 ns142 0 0.00132366828893
Gc25_143 0 n50 ns143 0 -0.000252452898146
Gc25_144 0 n50 ns144 0 -0.000276302139391
Gc25_145 0 n50 ns145 0 -0.000870143499007
Gc25_146 0 n50 ns146 0 -0.0010516483067
Gc25_147 0 n50 ns147 0 -0.000116689014861
Gc25_148 0 n50 ns148 0 -0.000681888134952
Gc25_149 0 n50 ns149 0 -0.000208529322133
Gc25_150 0 n50 ns150 0 1.9100735668e-06
Gc25_151 0 n50 ns151 0 6.55015185699e-05
Gc25_152 0 n50 ns152 0 -5.98447288064e-06
Gc25_153 0 n50 ns153 0 -7.09767660487e-05
Gc25_154 0 n50 ns154 0 -1.35733028983e-05
Gc25_155 0 n50 ns155 0 3.97425649056e-05
Gc25_156 0 n50 ns156 0 0.000333544985689
Gc25_157 0 n50 ns157 0 -2.98079598168e-05
Gc25_158 0 n50 ns158 0 0.000123582506596
Gc25_159 0 n50 ns159 0 0.000126345295356
Gc25_160 0 n50 ns160 0 2.17688525841e-05
Gc25_161 0 n50 ns161 0 0.000528767299395
Gc25_162 0 n50 ns162 0 -0.000332348183295
Gc25_163 0 n50 ns163 0 -0.000149604980611
Gc25_164 0 n50 ns164 0 0.00011769103518
Gc25_165 0 n50 ns165 0 -9.92741695875e-05
Gc25_166 0 n50 ns166 0 0.000549803339402
Gc25_167 0 n50 ns167 0 0.000923418090432
Gc25_168 0 n50 ns168 0 -9.95014517893e-05
Gc25_169 0 n50 ns169 0 0.000310562922964
Gc25_170 0 n50 ns170 0 -0.000719314275665
Gc25_171 0 n50 ns171 0 0.000232242410392
Gc25_172 0 n50 ns172 0 -0.000722991191166
Gc25_173 0 n50 ns173 0 0.00015740654285
Gc25_174 0 n50 ns174 0 -0.000567261358595
Gc25_175 0 n50 ns175 0 -0.00425906598291
Gc25_176 0 n50 ns176 0 -0.00354698846449
Gc25_177 0 n50 ns177 0 -0.00391281027214
Gc25_178 0 n50 ns178 0 -0.00304418443005
Gc25_179 0 n50 ns179 0 -0.000150485415055
Gc25_180 0 n50 ns180 0 0.00155078858762
Gc25_181 0 n50 ns181 0 -0.00024880528329
Gc25_182 0 n50 ns182 0 -0.00051760263834
Gc25_183 0 n50 ns183 0 -0.000780560364226
Gc25_184 0 n50 ns184 0 -0.00157184331462
Gc25_185 0 n50 ns185 0 -5.7085782247e-05
Gc25_186 0 n50 ns186 0 -0.000937847698159
Gc25_187 0 n50 ns187 0 -0.000313877364789
Gc25_188 0 n50 ns188 0 -1.82253049387e-06
Gc25_189 0 n50 ns189 0 6.59800380596e-05
Gc25_190 0 n50 ns190 0 1.0747468316e-05
Gc25_191 0 n50 ns191 0 -0.000156677520647
Gc25_192 0 n50 ns192 0 -0.000403841332389
Gc25_193 0 n50 ns193 0 -0.000503439742896
Gc25_194 0 n50 ns194 0 0.000586159773415
Gc25_195 0 n50 ns195 0 -0.000196731280137
Gc25_196 0 n50 ns196 0 -3.10580016221e-05
Gc25_197 0 n50 ns197 0 -7.18859187742e-05
Gc25_198 0 n50 ns198 0 0.000117149176525
Gc25_199 0 n50 ns199 0 0.000368110458229
Gc25_200 0 n50 ns200 0 0.000684157882909
Gc25_201 0 n50 ns201 0 -0.000117332276522
Gc25_202 0 n50 ns202 0 -2.74194519962e-05
Gc25_203 0 n50 ns203 0 -0.000358012420258
Gc25_204 0 n50 ns204 0 -0.000373054794343
Gc25_205 0 n50 ns205 0 0.000383592397786
Gc25_206 0 n50 ns206 0 0.00115832542498
Gc25_207 0 n50 ns207 0 0.000849892469282
Gc25_208 0 n50 ns208 0 -1.64026045424e-05
Gc25_209 0 n50 ns209 0 0.000651727497344
Gc25_210 0 n50 ns210 0 0.000153975007837
Gc25_211 0 n50 ns211 0 0.000399382210291
Gc25_212 0 n50 ns212 0 0.000196829315653
Gc25_213 0 n50 ns213 0 -0.000937603634682
Gc25_214 0 n50 ns214 0 -0.00617966412117
Gc25_215 0 n50 ns215 0 -0.0011571203194
Gc25_216 0 n50 ns216 0 -0.00565965903411
Gc25_217 0 n50 ns217 0 -0.00143389454762
Gc25_218 0 n50 ns218 0 0.00104468155628
Gc25_219 0 n50 ns219 0 2.74675058671e-05
Gc25_220 0 n50 ns220 0 -0.000880653894056
Gc25_221 0 n50 ns221 0 0.000148467395887
Gc25_222 0 n50 ns222 0 -0.00200756469734
Gc25_223 0 n50 ns223 0 0.000365566938215
Gc25_224 0 n50 ns224 0 -0.00111727456274
Gc25_225 0 n50 ns225 0 -0.000526143242108
Gc25_226 0 n50 ns226 0 -9.06487590498e-06
Gc25_227 0 n50 ns227 0 7.49640473326e-05
Gc25_228 0 n50 ns228 0 9.07895782907e-07
Gc25_229 0 n50 ns229 0 -0.000380522382201
Gc25_230 0 n50 ns230 0 8.89007231027e-05
Gc25_231 0 n50 ns231 0 -0.00109726928277
Gc25_232 0 n50 ns232 0 0.00149737760375
Gc25_233 0 n50 ns233 0 -6.47582734298e-05
Gc25_234 0 n50 ns234 0 0.000123535760452
Gc25_235 0 n50 ns235 0 7.48179951538e-05
Gc25_236 0 n50 ns236 0 -0.000263522218291
Gc25_237 0 n50 ns237 0 -0.0006925231585
Gc25_238 0 n50 ns238 0 0.000655439221142
Gc25_239 0 n50 ns239 0 -4.11464058986e-05
Gc25_240 0 n50 ns240 0 -1.36437334582e-05
Gc25_241 0 n50 ns241 0 0.00096705875762
Gc25_242 0 n50 ns242 0 -0.00077861426972
Gc25_243 0 n50 ns243 0 -0.00102329173496
Gc25_244 0 n50 ns244 0 8.06318333954e-05
Gc25_245 0 n50 ns245 0 0.000442430617802
Gc25_246 0 n50 ns246 0 0.000288507971514
Gc25_247 0 n50 ns247 0 -7.12168377145e-07
Gc25_248 0 n50 ns248 0 8.3733219894e-05
Gc25_249 0 n50 ns249 0 -0.000965268888126
Gc25_250 0 n50 ns250 0 0.00135704223398
Gc25_251 0 n50 ns251 0 0.00216240607433
Gc25_252 0 n50 ns252 0 -0.00149943907771
Gc25_253 0 n50 ns253 0 0.00189497850717
Gc25_254 0 n50 ns254 0 -0.00217399600111
Gc25_255 0 n50 ns255 0 -0.000904626445774
Gc25_256 0 n50 ns256 0 -0.000866112125838
Gc25_257 0 n50 ns257 0 0.000706093516366
Gc25_258 0 n50 ns258 0 -0.00107548111696
Gc25_259 0 n50 ns259 0 0.00107571200083
Gc25_260 0 n50 ns260 0 -0.00162429933182
Gc25_261 0 n50 ns261 0 0.00138372084072
Gc25_262 0 n50 ns262 0 -0.00216593180316
Gc25_263 0 n50 ns263 0 -0.00140572945578
Gc25_264 0 n50 ns264 0 -3.24103024896e-05
Gc25_265 0 n50 ns265 0 0.000129475216861
Gc25_266 0 n50 ns266 0 -1.01308359077e-05
Gc25_267 0 n50 ns267 0 -0.00103540382839
Gc25_268 0 n50 ns268 0 -0.00030383375036
Gc25_269 0 n50 ns269 0 -0.00419603710179
Gc25_270 0 n50 ns270 0 -0.00173479841217
Gc25_271 0 n50 ns271 0 -0.00180608390231
Gc25_272 0 n50 ns272 0 0.00120316232696
Gc25_273 0 n50 ns273 0 0.000893483702138
Gc25_274 0 n50 ns274 0 -0.000415282245352
Gc25_275 0 n50 ns275 0 -0.000665322869108
Gc25_276 0 n50 ns276 0 -0.000250600547317
Gc25_277 0 n50 ns277 0 -8.64214382757e-05
Gc25_278 0 n50 ns278 0 -5.41318508723e-05
Gc25_279 0 n50 ns279 0 0.000738352312093
Gc25_280 0 n50 ns280 0 0.000527762242762
Gc25_281 0 n50 ns281 0 0.000658510052535
Gc25_282 0 n50 ns282 0 -0.00145934138772
Gc25_283 0 n50 ns283 0 0.000689307865347
Gc25_284 0 n50 ns284 0 9.43710955276e-05
Gc25_285 0 n50 ns285 0 0.00079611718959
Gc25_286 0 n50 ns286 0 -0.000335048301646
Gc25_287 0 n50 ns287 0 -0.00249795962631
Gc25_288 0 n50 ns288 0 -0.00106307523274
Gc25_289 0 n50 ns289 0 -0.00285875133006
Gc25_290 0 n50 ns290 0 0.000783158613209
Gc25_291 0 n50 ns291 0 -0.00162683863288
Gc25_292 0 n50 ns292 0 -4.42166974363e-05
Gc25_293 0 n50 ns293 0 0.00415186971406
Gc25_294 0 n50 ns294 0 0.000143476730444
Gc25_295 0 n50 ns295 0 0.00123096985552
Gc25_296 0 n50 ns296 0 -0.000539655018642
Gc25_297 0 n50 ns297 0 -0.00134951693688
Gc25_298 0 n50 ns298 0 -0.000724918868666
Gc25_299 0 n50 ns299 0 0.00270725194467
Gc25_300 0 n50 ns300 0 0.00135617228785
Gc25_301 0 n50 ns301 0 -0.00286031768495
Gc25_302 0 n50 ns302 0 -3.87301285555e-05
Gc25_303 0 n50 ns303 0 0.000369392616181
Gc25_304 0 n50 ns304 0 -0.000192001968545
Gc25_305 0 n50 ns305 0 0.000121966308708
Gc25_306 0 n50 ns306 0 0.000229600507768
Gc25_307 0 n50 ns307 0 0.00240523505369
Gc25_308 0 n50 ns308 0 0.0022267927904
Gc25_309 0 n50 ns309 0 0.000984848557929
Gc25_310 0 n50 ns310 0 -0.00205265556464
Gc25_311 0 n50 ns311 0 -0.000263578996152
Gc25_312 0 n50 ns312 0 0.000518733942234
Gc25_313 0 n50 ns313 0 0.000582191251177
Gc25_314 0 n50 ns314 0 -9.63807604064e-05
Gc25_315 0 n50 ns315 0 4.18493926475e-05
Gc25_316 0 n50 ns316 0 -0.000117667744452
Gc25_317 0 n50 ns317 0 0.00108138389876
Gc25_318 0 n50 ns318 0 -0.00104277696534
Gc25_319 0 n50 ns319 0 0.000240986972044
Gc25_320 0 n50 ns320 0 0.00161226394037
Gc25_321 0 n50 ns321 0 -0.000719048192989
Gc25_322 0 n50 ns322 0 0.000570654736811
Gc25_323 0 n50 ns323 0 -0.00191393016975
Gc25_324 0 n50 ns324 0 -0.000391902909761
Gc25_325 0 n50 ns325 0 0.00408806121714
Gc25_326 0 n50 ns326 0 0.00260921096811
Gc25_327 0 n50 ns327 0 -0.00833105474822
Gc25_328 0 n50 ns328 0 0.00311839914264
Gc25_329 0 n50 ns329 0 -0.00597758249636
Gc25_330 0 n50 ns330 0 0.00203286159132
Gc25_331 0 n50 ns331 0 -0.010319700899
Gc25_332 0 n50 ns332 0 4.64689515344e-05
Gc25_333 0 n50 ns333 0 0.00129064306473
Gc25_334 0 n50 ns334 0 0.000991310828512
Gc25_335 0 n50 ns335 0 -0.0036029506372
Gc25_336 0 n50 ns336 0 0.0108451761794
Gc25_337 0 n50 ns337 0 -0.0155892398602
Gc25_338 0 n50 ns338 0 -0.000688582908797
Gc25_339 0 n50 ns339 0 -0.00491304676373
Gc25_340 0 n50 ns340 0 -4.74693783079e-05
Gc25_341 0 n50 ns341 0 -0.000370471703545
Gc25_342 0 n50 ns342 0 0.000563149014492
Gc25_343 0 n50 ns343 0 0.000347183861896
Gc25_344 0 n50 ns344 0 -0.000218877280895
Gc25_345 0 n50 ns345 0 0.000908841993202
Gc25_346 0 n50 ns346 0 -0.000473853266348
Gc25_347 0 n50 ns347 0 0.000171808766307
Gc25_348 0 n50 ns348 0 -0.000231436184438
Gc25_349 0 n50 ns349 0 -0.000134278626398
Gc25_350 0 n50 ns350 0 0.000148938570695
Gc25_351 0 n50 ns351 0 -0.000134893455346
Gc25_352 0 n50 ns352 0 9.7481689191e-05
Gc25_353 0 n50 ns353 0 6.03278924439e-05
Gc25_354 0 n50 ns354 0 -4.31998372812e-05
Gc25_355 0 n50 ns355 0 -0.000143424814477
Gc25_356 0 n50 ns356 0 -0.000182824398089
Gc25_357 0 n50 ns357 0 -0.000362931226706
Gc25_358 0 n50 ns358 0 -3.01307042397e-05
Gc25_359 0 n50 ns359 0 -0.000263386570383
Gc25_360 0 n50 ns360 0 0.000125947346847
Gc25_361 0 n50 ns361 0 -0.000308809100093
Gc25_362 0 n50 ns362 0 0.000172439374664
Gc25_363 0 n50 ns363 0 -0.000177761183102
Gc25_364 0 n50 ns364 0 0.000122090582623
Gc25_365 0 n50 ns365 0 -0.000643109801959
Gc25_366 0 n50 ns366 0 0.0014994261859
Gc25_367 0 n50 ns367 0 -0.000542482557673
Gc25_368 0 n50 ns368 0 0.00131305430919
Gc25_369 0 n50 ns369 0 0.000498175282686
Gc25_370 0 n50 ns370 0 0.000216860192327
Gc25_371 0 n50 ns371 0 -0.000127481000144
Gc25_372 0 n50 ns372 0 -4.88162588468e-05
Gc25_373 0 n50 ns373 0 -0.000551172778083
Gc25_374 0 n50 ns374 0 -0.000165416972944
Gc25_375 0 n50 ns375 0 -7.64631887651e-05
Gc25_376 0 n50 ns376 0 -0.000247072958702
Gc25_377 0 n50 ns377 0 -9.50775465482e-05
Gc25_378 0 n50 ns378 0 -8.46474174281e-06
Gc25_379 0 n50 ns379 0 4.1618845953e-06
Gc25_380 0 n50 ns380 0 7.18878287349e-06
Gc25_381 0 n50 ns381 0 -0.000491220265748
Gc25_382 0 n50 ns382 0 0.00095902062586
Gc25_383 0 n50 ns383 0 -0.00134912239802
Gc25_384 0 n50 ns384 0 0.00134536609568
Gc25_385 0 n50 ns385 0 -0.000130737240311
Gc25_386 0 n50 ns386 0 0.000454653846025
Gc25_387 0 n50 ns387 0 4.90114371892e-05
Gc25_388 0 n50 ns388 0 -0.000300356037211
Gc25_389 0 n50 ns389 0 -0.000220133851864
Gc25_390 0 n50 ns390 0 1.32496328347e-05
Gc25_391 0 n50 ns391 0 0.000129115792031
Gc25_392 0 n50 ns392 0 7.14095227684e-05
Gc25_393 0 n50 ns393 0 0.000505989314516
Gc25_394 0 n50 ns394 0 -0.000451744058864
Gc25_395 0 n50 ns395 0 5.15978318051e-05
Gc25_396 0 n50 ns396 0 -0.000565377629691
Gc25_397 0 n50 ns397 0 -0.000277949411513
Gc25_398 0 n50 ns398 0 -0.000244310999322
Gc25_399 0 n50 ns399 0 -0.000286923149653
Gc25_400 0 n50 ns400 0 -0.000167061088722
Gc25_401 0 n50 ns401 0 -0.000569874891469
Gc25_402 0 n50 ns402 0 -8.08316538187e-05
Gc25_403 0 n50 ns403 0 -0.00322900658738
Gc25_404 0 n50 ns404 0 0.0010245258696
Gc25_405 0 n50 ns405 0 -0.00278262577878
Gc25_406 0 n50 ns406 0 0.000948741868995
Gc25_407 0 n50 ns407 0 0.000397631399616
Gc25_408 0 n50 ns408 0 0.000940889115923
Gc25_409 0 n50 ns409 0 -0.000204180950274
Gc25_410 0 n50 ns410 0 -0.000187822400296
Gc25_411 0 n50 ns411 0 -0.000707810670702
Gc25_412 0 n50 ns412 0 -0.000699529247723
Gc25_413 0 n50 ns413 0 -7.81515868817e-05
Gc25_414 0 n50 ns414 0 -0.000421019732659
Gc25_415 0 n50 ns415 0 -0.00014253144962
Gc25_416 0 n50 ns416 0 -1.68515358727e-05
Gc25_417 0 n50 ns417 0 4.70669788442e-05
Gc25_418 0 n50 ns418 0 3.67148664263e-06
Gc25_419 0 n50 ns419 0 -0.000262761935398
Gc25_420 0 n50 ns420 0 0.000513181840997
Gc25_421 0 n50 ns421 0 -0.000523450855231
Gc25_422 0 n50 ns422 0 0.000815637402988
Gc25_423 0 n50 ns423 0 -7.20777494791e-05
Gc25_424 0 n50 ns424 0 0.000349739474643
Gc25_425 0 n50 ns425 0 0.000158920863301
Gc25_426 0 n50 ns426 0 -0.000193278439199
Gc25_427 0 n50 ns427 0 0.000274468593438
Gc25_428 0 n50 ns428 0 -0.000411644434872
Gc25_429 0 n50 ns429 0 -6.40502230723e-05
Gc25_430 0 n50 ns430 0 0.000146618480863
Gc25_431 0 n50 ns431 0 0.000256517291603
Gc25_432 0 n50 ns432 0 0.000339485321538
Gc25_433 0 n50 ns433 0 0.000740939574829
Gc25_434 0 n50 ns434 0 -0.000502805867908
Gc25_435 0 n50 ns435 0 6.16536958388e-05
Gc25_436 0 n50 ns436 0 -0.000714028938333
Gc25_437 0 n50 ns437 0 2.18983672321e-05
Gc25_438 0 n50 ns438 0 -0.000730725297775
Gc25_439 0 n50 ns439 0 -0.000115200147239
Gc25_440 0 n50 ns440 0 -0.000470080375569
Gc25_441 0 n50 ns441 0 -0.0044385930735
Gc25_442 0 n50 ns442 0 -0.00178738450973
Gc25_443 0 n50 ns443 0 -0.00398267132405
Gc25_444 0 n50 ns444 0 -0.00148511253935
Gc25_445 0 n50 ns445 0 0.000225170885334
Gc25_446 0 n50 ns446 0 0.00145228885971
Gc25_447 0 n50 ns447 0 -0.000284165744331
Gc25_448 0 n50 ns448 0 -0.000407524888994
Gc25_449 0 n50 ns449 0 -0.000977735036474
Gc25_450 0 n50 ns450 0 -0.00129129771134
Gc25_451 0 n50 ns451 0 -0.000109110527573
Gc25_452 0 n50 ns452 0 -0.000710324527779
Gc25_453 0 n50 ns453 0 -0.000239626648996
Gc25_454 0 n50 ns454 0 -9.26559003692e-07
Gc25_455 0 n50 ns455 0 4.21557817427e-05
Gc25_456 0 n50 ns456 0 2.02892491099e-05
Gc25_457 0 n50 ns457 0 9.14450070225e-05
Gc25_458 0 n50 ns458 0 -0.000594900760431
Gc25_459 0 n50 ns459 0 0.000236699961485
Gc25_460 0 n50 ns460 0 -3.15960774378e-05
Gc25_461 0 n50 ns461 0 -4.08902437821e-07
Gc25_462 0 n50 ns462 0 -0.000109559622314
Gc25_463 0 n50 ns463 0 -7.73053589699e-05
Gc25_464 0 n50 ns464 0 0.000225565549677
Gc25_465 0 n50 ns465 0 0.000563573263566
Gc25_466 0 n50 ns466 0 0.000184392329812
Gc25_467 0 n50 ns467 0 -0.000161567856842
Gc25_468 0 n50 ns468 0 2.85031238144e-05
Gc25_469 0 n50 ns469 0 -0.000499935789804
Gc25_470 0 n50 ns470 0 0.0002399168874
Gc25_471 0 n50 ns471 0 0.000728109532434
Gc25_472 0 n50 ns472 0 0.000822530563897
Gc25_473 0 n50 ns473 0 0.000673325242808
Gc25_474 0 n50 ns474 0 -0.000301214047753
Gc25_475 0 n50 ns475 0 0.000528714303948
Gc25_476 0 n50 ns476 0 -0.000180542252185
Gc25_477 0 n50 ns477 0 0.000470570557532
Gc25_478 0 n50 ns478 0 -0.000301424493015
Gc25_479 0 n50 ns479 0 -0.00240336003052
Gc25_480 0 n50 ns480 0 -0.00585973662309
Gc25_481 0 n50 ns481 0 -0.002410040496
Gc25_482 0 n50 ns482 0 -0.00520667969896
Gc25_483 0 n50 ns483 0 -0.000960942469482
Gc25_484 0 n50 ns484 0 0.00127142037897
Gc25_485 0 n50 ns485 0 -0.000119473613657
Gc25_486 0 n50 ns486 0 -0.000714709705796
Gc25_487 0 n50 ns487 0 -0.00028134192973
Gc25_488 0 n50 ns488 0 -0.00176002619095
Gc25_489 0 n50 ns489 0 0.000164731880653
Gc25_490 0 n50 ns490 0 -0.000858910951957
Gc25_491 0 n50 ns491 0 -0.000375043085463
Gc25_492 0 n50 ns492 0 -1.51614371455e-06
Gc25_493 0 n50 ns493 0 4.27490605406e-05
Gc25_494 0 n50 ns494 0 1.97965309993e-05
Gc25_495 0 n50 ns495 0 -0.000316475611361
Gc25_496 0 n50 ns496 0 -0.000201815122723
Gc25_497 0 n50 ns497 0 -0.00100251698634
Gc25_498 0 n50 ns498 0 0.000811157721866
Gc25_499 0 n50 ns499 0 -0.000334741961417
Gc25_500 0 n50 ns500 0 -0.000145508919205
Gc25_501 0 n50 ns501 0 6.89854357644e-05
Gc25_502 0 n50 ns502 0 -7.93763192569e-05
Gc25_503 0 n50 ns503 0 -0.000353499986448
Gc25_504 0 n50 ns504 0 0.000855248505327
Gc25_505 0 n50 ns505 0 -5.36839660475e-05
Gc25_506 0 n50 ns506 0 -2.2065153659e-06
Gc25_507 0 n50 ns507 0 0.000549584788261
Gc25_508 0 n50 ns508 0 -0.00085661082059
Gc25_509 0 n50 ns509 0 -0.000645406510041
Gc25_510 0 n50 ns510 0 0.000861225714754
Gc25_511 0 n50 ns511 0 0.000590519927885
Gc25_512 0 n50 ns512 0 0.000359014808716
Gc25_513 0 n50 ns513 0 0.000174143081423
Gc25_514 0 n50 ns514 0 0.00044107366564
Gc25_515 0 n50 ns515 0 -0.000295155992587
Gc25_516 0 n50 ns516 0 0.0010751578896
Gc25_517 0 n50 ns517 0 0.00184660563279
Gc25_518 0 n50 ns518 0 -0.0039226890641
Gc25_519 0 n50 ns519 0 0.0014114936762
Gc25_520 0 n50 ns520 0 -0.0040585160747
Gc25_521 0 n50 ns521 0 -0.00178229807249
Gc25_522 0 n50 ns522 0 -0.000114059922092
Gc25_523 0 n50 ns523 0 0.000460444958003
Gc25_524 0 n50 ns524 0 -0.00108087942423
Gc25_525 0 n50 ns525 0 0.00105949616718
Gc25_526 0 n50 ns526 0 -0.00199810114044
Gc25_527 0 n50 ns527 0 0.000942319205361
Gc25_528 0 n50 ns528 0 -0.00179061988411
Gc25_529 0 n50 ns529 0 -0.000983300495063
Gc25_530 0 n50 ns530 0 -3.71261787471e-05
Gc25_531 0 n50 ns531 0 0.000151306688752
Gc25_532 0 n50 ns532 0 -2.91701419708e-05
Gc25_533 0 n50 ns533 0 -0.000973089966117
Gc25_534 0 n50 ns534 0 0.000219256106254
Gc25_535 0 n50 ns535 0 -0.00297854473263
Gc25_536 0 n50 ns536 0 0.00112422084828
Gc25_537 0 n50 ns537 0 -0.000118231968917
Gc25_538 0 n50 ns538 0 0.000961407842504
Gc25_539 0 n50 ns539 0 0.000237409903418
Gc25_540 0 n50 ns540 0 -0.000407110240665
Gc25_541 0 n50 ns541 0 -0.00072989720407
Gc25_542 0 n50 ns542 0 -1.67062345174e-05
Gc25_543 0 n50 ns543 0 -0.000104117974323
Gc25_544 0 n50 ns544 0 -2.50863726848e-05
Gc25_545 0 n50 ns545 0 0.00103856277628
Gc25_546 0 n50 ns546 0 0.000346170410869
Gc25_547 0 n50 ns547 0 -0.000317235782566
Gc25_548 0 n50 ns548 0 -0.00114935356743
Gc25_549 0 n50 ns549 0 0.000451372390549
Gc25_550 0 n50 ns550 0 2.58297308006e-05
Gc25_551 0 n50 ns551 0 0.000289330304291
Gc25_552 0 n50 ns552 0 -0.000537288991928
Gc25_553 0 n50 ns553 0 -0.0025216746147
Gc25_554 0 n50 ns554 0 0.000152359516221
Gc25_555 0 n50 ns555 0 -0.00161298320051
Gc25_556 0 n50 ns556 0 0.00111404140231
Gc25_557 0 n50 ns557 0 -0.000780206750608
Gc25_558 0 n50 ns558 0 7.59831178642e-05
Gc25_559 0 n50 ns559 0 0.00195768154127
Gc25_560 0 n50 ns560 0 -0.00198055542216
Gc25_561 0 n50 ns561 0 0.00121011168733
Gc25_562 0 n50 ns562 0 -0.000682663952498
Gc25_563 0 n50 ns563 0 0.000490627104498
Gc25_564 0 n50 ns564 0 3.19865677481e-05
Gc25_565 0 n50 ns565 0 0.00272046794173
Gc25_566 0 n50 ns566 0 -0.00108627286693
Gc25_567 0 n50 ns567 0 -0.0022767640548
Gc25_568 0 n50 ns568 0 -1.0486424506e-05
Gc25_569 0 n50 ns569 0 0.000220859166207
Gc25_570 0 n50 ns570 0 -7.40383564257e-05
Gc25_571 0 n50 ns571 0 0.00243403747922
Gc25_572 0 n50 ns572 0 -0.00367964746646
Gc25_573 0 n50 ns573 0 0.00478248461216
Gc25_574 0 n50 ns574 0 -0.00873442590266
Gc25_575 0 n50 ns575 0 -0.00381361219966
Gc25_576 0 n50 ns576 0 -0.00260494030993
Gc25_577 0 n50 ns577 0 0.00129697415845
Gc25_578 0 n50 ns578 0 0.000982341164562
Gc25_579 0 n50 ns579 0 -0.000374935299929
Gc25_580 0 n50 ns580 0 -0.000863939552133
Gc25_581 0 n50 ns581 0 -0.000110193192746
Gc25_582 0 n50 ns582 0 -0.000103672572503
Gc25_583 0 n50 ns583 0 -0.000957853030899
Gc25_584 0 n50 ns584 0 6.0273770351e-05
Gc25_585 0 n50 ns585 0 0.00168467846135
Gc25_586 0 n50 ns586 0 -2.73576789642e-05
Gc25_587 0 n50 ns587 0 0.000576503525249
Gc25_588 0 n50 ns588 0 0.000826339059764
Gc25_589 0 n50 ns589 0 0.000432994930522
Gc25_590 0 n50 ns590 0 0.00118187555679
Gc25_591 0 n50 ns591 0 0.000944903899839
Gc25_592 0 n50 ns592 0 -0.0041406579362
Gc25_593 0 n50 ns593 0 -0.000480980462817
Gc25_594 0 n50 ns594 0 -0.00486021093996
Gc25_595 0 n50 ns595 0 0.00031631186285
Gc25_596 0 n50 ns596 0 -0.00430484246489
Gc25_597 0 n50 ns597 0 0.00670121830458
Gc25_598 0 n50 ns598 0 0.0073887339398
Gc25_599 0 n50 ns599 0 0.000894428219916
Gc25_600 0 n50 ns600 0 -0.000278884357997
Gc25_601 0 n50 ns601 0 -0.00546279714181
Gc25_602 0 n50 ns602 0 -0.0035787441984
Gc25_603 0 n50 ns603 0 0.0010578293172
Gc25_604 0 n50 ns604 0 0.00890662484645
Gc25_605 0 n50 ns605 0 -0.00350033623032
Gc25_606 0 n50 ns606 0 8.42673456687e-06
Gc25_607 0 n50 ns607 0 0.000477222152652
Gc25_608 0 n50 ns608 0 -0.000317420867326
Gc25_609 0 n50 ns609 0 0.000347463883711
Gc25_610 0 n50 ns610 0 -0.000112956887278
Gc25_611 0 n50 ns611 0 0.00100271253597
Gc25_612 0 n50 ns612 0 -0.000218026037525
Gc25_613 0 n50 ns613 0 0.000195127908062
Gc25_614 0 n50 ns614 0 -6.07548940746e-05
Gc25_615 0 n50 ns615 0 -8.84474983862e-05
Gc25_616 0 n50 ns616 0 -1.09114816313e-05
Gc25_617 0 n50 ns617 0 2.99838570956e-05
Gc25_618 0 n50 ns618 0 -0.000167025441192
Gc25_619 0 n50 ns619 0 -2.04997615143e-05
Gc25_620 0 n50 ns620 0 1.70947310209e-05
Gc25_621 0 n50 ns621 0 -0.000133484565332
Gc25_622 0 n50 ns622 0 0.000120216164484
Gc25_623 0 n50 ns623 0 -0.000105535420137
Gc25_624 0 n50 ns624 0 4.15298035992e-05
Gc25_625 0 n50 ns625 0 -1.17457530121e-05
Gc25_626 0 n50 ns626 0 4.58709712045e-05
Gc25_627 0 n50 ns627 0 3.26034006689e-06
Gc25_628 0 n50 ns628 0 7.56410238066e-06
Gc25_629 0 n50 ns629 0 9.09758215828e-05
Gc25_630 0 n50 ns630 0 1.74348340585e-05
Gc25_631 0 n50 ns631 0 -0.000133114730254
Gc25_632 0 n50 ns632 0 -0.000334289435658
Gc25_633 0 n50 ns633 0 -0.000124996749598
Gc25_634 0 n50 ns634 0 -0.00031160197288
Gc25_635 0 n50 ns635 0 0.000252785299059
Gc25_636 0 n50 ns636 0 0.000425729970507
Gc25_637 0 n50 ns637 0 -7.10205942595e-05
Gc25_638 0 n50 ns638 0 -8.99085744968e-05
Gc25_639 0 n50 ns639 0 -0.000350279192396
Gc25_640 0 n50 ns640 0 -0.000437496008332
Gc25_641 0 n50 ns641 0 -0.000183393000852
Gc25_642 0 n50 ns642 0 -0.000466810662143
Gc25_643 0 n50 ns643 0 -4.76018549101e-05
Gc25_644 0 n50 ns644 0 2.67016665647e-05
Gc25_645 0 n50 ns645 0 -7.30357404846e-05
Gc25_646 0 n50 ns646 0 4.5101821363e-05
Gc25_647 0 n50 ns647 0 0.000179415644998
Gc25_648 0 n50 ns648 0 0.000103664463366
Gc25_649 0 n50 ns649 0 0.000607892881583
Gc25_650 0 n50 ns650 0 -0.00011955661832
Gc25_651 0 n50 ns651 0 7.18553631712e-05
Gc25_652 0 n50 ns652 0 3.06043140257e-05
Gc25_653 0 n50 ns653 0 -5.67378662602e-06
Gc25_654 0 n50 ns654 0 -5.99781459524e-05
Gc25_655 0 n50 ns655 0 7.91640501973e-05
Gc25_656 0 n50 ns656 0 -0.000125402916773
Gc25_657 0 n50 ns657 0 -1.82399822541e-05
Gc25_658 0 n50 ns658 0 1.49806732276e-05
Gc25_659 0 n50 ns659 0 -0.000129851119464
Gc25_660 0 n50 ns660 0 5.15795436328e-05
Gc25_661 0 n50 ns661 0 -0.000148200685242
Gc25_662 0 n50 ns662 0 2.4700947605e-05
Gc25_663 0 n50 ns663 0 -5.02677764176e-05
Gc25_664 0 n50 ns664 0 6.70655600217e-05
Gc25_665 0 n50 ns665 0 -3.8379043785e-05
Gc25_666 0 n50 ns666 0 4.10949699467e-05
Gc25_667 0 n50 ns667 0 7.41934613266e-05
Gc25_668 0 n50 ns668 0 -2.1218407639e-05
Gc25_669 0 n50 ns669 0 -0.000186156767663
Gc25_670 0 n50 ns670 0 -0.000577799413257
Gc25_671 0 n50 ns671 0 -0.00016892112667
Gc25_672 0 n50 ns672 0 -0.000524164656318
Gc25_673 0 n50 ns673 0 0.000231537089172
Gc25_674 0 n50 ns674 0 0.000459856196521
Gc25_675 0 n50 ns675 0 -8.16827921451e-05
Gc25_676 0 n50 ns676 0 -9.49928275807e-05
Gc25_677 0 n50 ns677 0 -0.000366333902679
Gc25_678 0 n50 ns678 0 -0.000440428918919
Gc25_679 0 n50 ns679 0 -0.000185496721207
Gc25_680 0 n50 ns680 0 -0.000405382994873
Gc25_681 0 n50 ns681 0 -3.55252151361e-05
Gc25_682 0 n50 ns682 0 1.53201870736e-05
Gc25_683 0 n50 ns683 0 -4.5144946433e-05
Gc25_684 0 n50 ns684 0 1.88806236547e-05
Gc25_685 0 n50 ns685 0 5.84819047706e-05
Gc25_686 0 n50 ns686 0 0.000241867473632
Gc25_687 0 n50 ns687 0 0.000234379829744
Gc25_688 0 n50 ns688 0 -0.000525772292858
Gc25_689 0 n50 ns689 0 -9.12322634759e-05
Gc25_690 0 n50 ns690 0 -2.85922051365e-05
Gc25_691 0 n50 ns691 0 9.94798064062e-05
Gc25_692 0 n50 ns692 0 3.03811678189e-05
Gc25_693 0 n50 ns693 0 0.000195746259886
Gc25_694 0 n50 ns694 0 -1.41337812444e-05
Gc25_695 0 n50 ns695 0 -5.51868835261e-05
Gc25_696 0 n50 ns696 0 -1.59924780786e-06
Gc25_697 0 n50 ns697 0 -0.000184830360296
Gc25_698 0 n50 ns698 0 2.64156432026e-05
Gc25_699 0 n50 ns699 0 -0.000405584902033
Gc25_700 0 n50 ns700 0 -0.000111631506677
Gc25_701 0 n50 ns701 0 -0.00035360958522
Gc25_702 0 n50 ns702 0 6.23631077636e-05
Gc25_703 0 n50 ns703 0 -0.000436318281701
Gc25_704 0 n50 ns704 0 6.47526621858e-05
Gc25_705 0 n50 ns705 0 0.000244693194548
Gc25_706 0 n50 ns706 0 -0.000253085266348
Gc25_707 0 n50 ns707 0 0.000811148211435
Gc25_708 0 n50 ns708 0 -0.00166175623491
Gc25_709 0 n50 ns709 0 0.000690046334851
Gc25_710 0 n50 ns710 0 -0.00146332061783
Gc25_711 0 n50 ns711 0 3.6186236518e-05
Gc25_712 0 n50 ns712 0 8.84993755437e-05
Gc25_713 0 n50 ns713 0 -0.000102746359319
Gc25_714 0 n50 ns714 0 -4.67934259979e-05
Gc25_715 0 n50 ns715 0 -0.000327666342624
Gc25_716 0 n50 ns716 0 3.37916467254e-05
Gc25_717 0 n50 ns717 0 -0.00011856061707
Gc25_718 0 n50 ns718 0 0.0003498817305
Gc25_719 0 n50 ns719 0 0.000137243191158
Gc25_720 0 n50 ns720 0 -1.13517740881e-05
Gc25_721 0 n50 ns721 0 5.87842267754e-06
Gc25_722 0 n50 ns722 0 -2.19055648856e-05
Gc25_723 0 n50 ns723 0 0.000579030687309
Gc25_724 0 n50 ns724 0 -9.06614143134e-06
Gc25_725 0 n50 ns725 0 0.00182066765091
Gc25_726 0 n50 ns726 0 0.000442990377394
Gc25_727 0 n50 ns727 0 0.000277346891453
Gc25_728 0 n50 ns728 0 2.21270009032e-05
Gc25_729 0 n50 ns729 0 -0.000198034124787
Gc25_730 0 n50 ns730 0 4.95543485667e-05
Gc25_731 0 n50 ns731 0 0.000184810274492
Gc25_732 0 n50 ns732 0 0.000260567356345
Gc25_733 0 n50 ns733 0 -4.41198489732e-05
Gc25_734 0 n50 ns734 0 -0.000107034062947
Gc25_735 0 n50 ns735 0 -0.000279534130926
Gc25_736 0 n50 ns736 0 -0.000326193577709
Gc25_737 0 n50 ns737 0 9.30226744987e-06
Gc25_738 0 n50 ns738 0 -0.000950866383672
Gc25_739 0 n50 ns739 0 -0.000276095881368
Gc25_740 0 n50 ns740 0 -0.000671584732851
Gc25_741 0 n50 ns741 0 -0.000197575368632
Gc25_742 0 n50 ns742 0 -0.000881366408776
Gc25_743 0 n50 ns743 0 0.000833987934538
Gc25_744 0 n50 ns744 0 0.00065789270525
Gc25_745 0 n50 ns745 0 0.00377913918774
Gc25_746 0 n50 ns746 0 0.000567501578865
Gc25_747 0 n50 ns747 0 0.00329396379295
Gc25_748 0 n50 ns748 0 0.000348409613774
Gc25_749 0 n50 ns749 0 0.000824751398328
Gc25_750 0 n50 ns750 0 0.000520720932122
Gc25_751 0 n50 ns751 0 -0.000252773151502
Gc25_752 0 n50 ns752 0 -0.000190487634431
Gc25_753 0 n50 ns753 0 -0.0011563773288
Gc25_754 0 n50 ns754 0 -0.000613123839211
Gc25_755 0 n50 ns755 0 -0.000490326236527
Gc25_756 0 n50 ns756 0 -0.000549480015379
Gc25_757 0 n50 ns757 0 -9.20095867151e-06
Gc25_758 0 n50 ns758 0 2.70089321524e-05
Gc25_759 0 n50 ns759 0 -0.000130176362921
Gc25_760 0 n50 ns760 0 5.52309330276e-05
Gc25_761 0 n50 ns761 0 -4.6818692137e-07
Gc25_762 0 n50 ns762 0 -1.53292466919e-05
Gc25_763 0 n50 ns763 0 -4.31065613234e-05
Gc25_764 0 n50 ns764 0 0.00105943354755
Gc25_765 0 n50 ns765 0 0.000119074666227
Gc25_766 0 n50 ns766 0 0.000140502854734
Gc25_767 0 n50 ns767 0 -0.000175092036114
Gc25_768 0 n50 ns768 0 -0.000187749004226
Gc25_769 0 n50 ns769 0 -0.000433954678816
Gc25_770 0 n50 ns770 0 0.000241039490082
Gc25_771 0 n50 ns771 0 9.75070948354e-05
Gc25_772 0 n50 ns772 0 -0.000124816642882
Gc25_773 0 n50 ns773 0 0.000196852879395
Gc25_774 0 n50 ns774 0 -0.000163564651786
Gc25_775 0 n50 ns775 0 0.00118078039039
Gc25_776 0 n50 ns776 0 -0.00025159115435
Gc25_777 0 n50 ns777 0 0.000491494521398
Gc25_778 0 n50 ns778 0 -0.0007209346074
Gc25_779 0 n50 ns779 0 0.000602466696629
Gc25_780 0 n50 ns780 0 -0.000603335115351
Gc25_781 0 n50 ns781 0 -0.000298162552827
Gc25_782 0 n50 ns782 0 0.00113985722769
Gc25_783 0 n50 ns783 0 0.00322328967821
Gc25_784 0 n50 ns784 0 0.00408776391403
Gc25_785 0 n50 ns785 0 0.00306683797137
Gc25_786 0 n50 ns786 0 0.00345412499064
Gc25_787 0 n50 ns787 0 0.000348085866337
Gc25_788 0 n50 ns788 0 0.00124999420263
Gc25_789 0 n50 ns789 0 -0.000284592653361
Gc25_790 0 n50 ns790 0 -0.000474313991472
Gc25_791 0 n50 ns791 0 -0.00113891974948
Gc25_792 0 n50 ns792 0 -0.00140609094456
Gc25_793 0 n50 ns793 0 -0.000546015770477
Gc25_794 0 n50 ns794 0 -0.000632738038842
Gc25_795 0 n50 ns795 0 2.69259581526e-05
Gc25_796 0 n50 ns796 0 -7.37557760457e-07
Gc25_797 0 n50 ns797 0 -9.87816438854e-05
Gc25_798 0 n50 ns798 0 6.06778601455e-06
Gc25_799 0 n50 ns799 0 5.88433055098e-06
Gc25_800 0 n50 ns800 0 -0.000671835752329
Gc25_801 0 n50 ns801 0 -2.38596590632e-05
Gc25_802 0 n50 ns802 0 -0.000226122309193
Gc25_803 0 n50 ns803 0 0.000116155815522
Gc25_804 0 n50 ns804 0 -0.000218916185503
Gc25_805 0 n50 ns805 0 0.000151011224142
Gc25_806 0 n50 ns806 0 8.08520272948e-05
Gc25_807 0 n50 ns807 0 -0.000383988076847
Gc25_808 0 n50 ns808 0 -0.000536859615055
Gc25_809 0 n50 ns809 0 0.000164272860694
Gc25_810 0 n50 ns810 0 -1.79120192104e-05
Gc25_811 0 n50 ns811 0 -0.000140053960291
Gc25_812 0 n50 ns812 0 0.000189206328694
Gc25_813 0 n50 ns813 0 0.000118169884412
Gc25_814 0 n50 ns814 0 0.00146450376371
Gc25_815 0 n50 ns815 0 0.000554202511518
Gc25_816 0 n50 ns816 0 0.000110957026233
Gc25_817 0 n50 ns817 0 6.26155414757e-06
Gc25_818 0 n50 ns818 0 0.000307107186561
Gc25_819 0 n50 ns819 0 -0.00119126224484
Gc25_820 0 n50 ns820 0 -0.000824871259546
Gc25_821 0 n50 ns821 0 -0.00050626265253
Gc25_822 0 n50 ns822 0 0.00389905380279
Gc25_823 0 n50 ns823 0 -2.80235751539e-05
Gc25_824 0 n50 ns824 0 0.00379028758265
Gc25_825 0 n50 ns825 0 -0.00191177282835
Gc25_826 0 n50 ns826 0 0.000508802813093
Gc25_827 0 n50 ns827 0 6.77595780612e-05
Gc25_828 0 n50 ns828 0 -0.000805491967636
Gc25_829 0 n50 ns829 0 0.000377525809743
Gc25_830 0 n50 ns830 0 -0.00136288155515
Gc25_831 0 n50 ns831 0 -0.000376819027666
Gc25_832 0 n50 ns832 0 0.00101359175881
Gc25_833 0 n50 ns833 0 0.000548389853493
Gc25_834 0 n50 ns834 0 -7.19058046336e-06
Gc25_835 0 n50 ns835 0 -0.000147183139481
Gc25_836 0 n50 ns836 0 7.89792547443e-06
Gc25_837 0 n50 ns837 0 0.000337317286905
Gc25_838 0 n50 ns838 0 -0.000614988524665
Gc25_839 0 n50 ns839 0 0.000980311459397
Gc25_840 0 n50 ns840 0 0.000341992823366
Gc25_841 0 n50 ns841 0 -0.000189583515712
Gc25_842 0 n50 ns842 0 0.000359994083601
Gc25_843 0 n50 ns843 0 -4.39793661672e-05
Gc25_844 0 n50 ns844 0 4.1639169455e-05
Gc25_845 0 n50 ns845 0 0.000642010545004
Gc25_846 0 n50 ns846 0 -0.000262641392377
Gc25_847 0 n50 ns847 0 0.000170002476509
Gc25_848 0 n50 ns848 0 4.29002601987e-05
Gc25_849 0 n50 ns849 0 2.23470153051e-05
Gc25_850 0 n50 ns850 0 -0.000452500291503
Gc25_851 0 n50 ns851 0 -0.00154590801051
Gc25_852 0 n50 ns852 0 -0.000282288758435
Gc25_853 0 n50 ns853 0 0.000217391678371
Gc25_854 0 n50 ns854 0 -8.75751654802e-05
Gc25_855 0 n50 ns855 0 -0.000241192694867
Gc25_856 0 n50 ns856 0 -0.000722301291105
Gc25_857 0 n50 ns857 0 0.0014049260217
Gc25_858 0 n50 ns858 0 -0.0013227967691
Gc25_859 0 n50 ns859 0 -0.00134055541119
Gc25_860 0 n50 ns860 0 0.00200031938988
Gc25_861 0 n50 ns861 0 -0.00123765837741
Gc25_862 0 n50 ns862 0 0.00257695940332
Gc25_863 0 n50 ns863 0 -0.00160544362317
Gc25_864 0 n50 ns864 0 -0.00230057770601
Gc25_865 0 n50 ns865 0 0.000752575799817
Gc25_866 0 n50 ns866 0 -0.00091505151664
Gc25_867 0 n50 ns867 0 0.00119913063398
Gc25_868 0 n50 ns868 0 -0.000270216518056
Gc25_869 0 n50 ns869 0 -0.00121334831177
Gc25_870 0 n50 ns870 0 0.00249087447615
Gc25_871 0 n50 ns871 0 0.00148703922767
Gc25_872 0 n50 ns872 0 4.43005454264e-05
Gc25_873 0 n50 ns873 0 -0.00032546187664
Gc25_874 0 n50 ns874 0 0.00012764798554
Gc25_875 0 n50 ns875 0 0.000707786014895
Gc25_876 0 n50 ns876 0 -0.00256674889728
Gc25_877 0 n50 ns877 0 0.00107762373072
Gc25_878 0 n50 ns878 0 -0.00187779488905
Gc25_879 0 n50 ns879 0 -0.00110031194505
Gc25_880 0 n50 ns880 0 -0.000223959556586
Gc25_881 0 n50 ns881 0 0.00036058750316
Gc25_882 0 n50 ns882 0 -0.000310479876308
Gc25_883 0 n50 ns883 0 0.000345525763486
Gc25_884 0 n50 ns884 0 0.000664043967141
Gc25_885 0 n50 ns885 0 0.000110725232529
Gc25_886 0 n50 ns886 0 9.8382146244e-05
Gc25_887 0 n50 ns887 0 -9.42303554571e-05
Gc25_888 0 n50 ns888 0 0.000407093447995
Gc25_889 0 n50 ns889 0 0.00067889619123
Gc25_890 0 n50 ns890 0 -0.0015540766513
Gc25_891 0 n50 ns891 0 0.000637645418193
Gc25_892 0 n50 ns892 0 -1.35261648503e-05
Gc25_893 0 n50 ns893 0 0.000643194155882
Gc25_894 0 n50 ns894 0 -0.000550051537003
Gc25_895 0 n50 ns895 0 0.0014930892408
Gc25_896 0 n50 ns896 0 0.00264225629505
Gc25_897 0 n50 ns897 0 0.000571753286359
Gc25_898 0 n50 ns898 0 0.00171552297398
Gc25_899 0 n50 ns899 0 -0.000207998304184
Gc25_900 0 n50 ns900 0 0.0021335137205
Gc25_901 0 n50 ns901 0 0.00497676579785
Gc25_902 0 n50 ns902 0 -0.000425384714119
Gc25_903 0 n50 ns903 0 0.00117223681153
Gc25_904 0 n50 ns904 0 -0.000446278857172
Gc25_905 0 n50 ns905 0 -0.00160567968182
Gc25_906 0 n50 ns906 0 -0.000107767626622
Gc25_907 0 n50 ns907 0 -0.00371291947707
Gc25_908 0 n50 ns908 0 -0.00102545716956
Gc25_909 0 n50 ns909 0 0.00296497832183
Gc25_910 0 n50 ns910 0 3.46083471539e-05
Gc25_911 0 n50 ns911 0 -0.000158671760656
Gc25_912 0 n50 ns912 0 2.30292890022e-05
Gc25_913 0 n50 ns913 0 0.00139325910258
Gc25_914 0 n50 ns914 0 -0.00485263839048
Gc25_915 0 n50 ns915 0 0.000284285595044
Gc25_916 0 n50 ns916 0 -0.00371352617107
Gc25_917 0 n50 ns917 0 -0.000412577245963
Gc25_918 0 n50 ns918 0 -0.000401519709261
Gc25_919 0 n50 ns919 0 0.00048885821848
Gc25_920 0 n50 ns920 0 -8.11983815498e-05
Gc25_921 0 n50 ns921 0 -0.000169097618154
Gc25_922 0 n50 ns922 0 0.00025491288258
Gc25_923 0 n50 ns923 0 7.16930186991e-06
Gc25_924 0 n50 ns924 0 4.44758815289e-05
Gc25_925 0 n50 ns925 0 -0.00123399672447
Gc25_926 0 n50 ns926 0 8.7182125057e-05
Gc25_927 0 n50 ns927 0 0.000479389405061
Gc25_928 0 n50 ns928 0 0.00046420180023
Gc25_929 0 n50 ns929 0 -0.000249390681496
Gc25_930 0 n50 ns930 0 0.000219875857865
Gc25_931 0 n50 ns931 0 -0.000764140280378
Gc25_932 0 n50 ns932 0 -0.000571458342948
Gc25_933 0 n50 ns933 0 -0.000973594883888
Gc25_934 0 n50 ns934 0 0.00076691843159
Gc25_935 0 n50 ns935 0 0.00749854066474
Gc25_936 0 n50 ns936 0 0.00314596984672
Gc25_937 0 n50 ns937 0 0.00535768053229
Gc25_938 0 n50 ns938 0 0.00290198005373
Gc25_939 0 n50 ns939 0 0.00306009548539
Gc25_940 0 n50 ns940 0 0.00665912150046
Gc25_941 0 n50 ns941 0 0.000506141239308
Gc25_942 0 n50 ns942 0 1.70084245051e-05
Gc25_943 0 n50 ns943 0 -0.00789804832441
Gc25_944 0 n50 ns944 0 -0.000416102773414
Gc25_945 0 n50 ns945 0 0.00469912778737
Gc25_946 0 n50 ns946 0 -0.00727700598675
Gc25_947 0 n50 ns947 0 0.0036884646023
Gc25_948 0 n50 ns948 0 -1.61803003344e-05
Gc25_949 0 n50 ns949 0 -6.34965115678e-05
Gc25_950 0 n50 ns950 0 -1.08087290303e-05
Gc25_951 0 n50 ns951 0 3.65166162735e-05
Gc25_952 0 n50 ns952 0 0.000156060317911
Gc25_953 0 n50 ns953 0 9.65684530834e-05
Gc25_954 0 n50 ns954 0 -0.000731447689098
Gc25_955 0 n50 ns955 0 -7.04210040644e-05
Gc25_956 0 n50 ns956 0 -6.25927445345e-05
Gc25_957 0 n50 ns957 0 7.64531410627e-05
Gc25_958 0 n50 ns958 0 1.07513007357e-05
Gc25_959 0 n50 ns959 0 9.59121982021e-05
Gc25_960 0 n50 ns960 0 -0.000123177405202
Gc25_961 0 n50 ns961 0 -4.4545291738e-05
Gc25_962 0 n50 ns962 0 2.90531305014e-05
Gc25_963 0 n50 ns963 0 -9.88476441814e-05
Gc25_964 0 n50 ns964 0 0.000164315496255
Gc25_965 0 n50 ns965 0 -0.000329715216568
Gc25_966 0 n50 ns966 0 0.000103490053134
Gc25_967 0 n50 ns967 0 -0.000243558326718
Gc25_968 0 n50 ns968 0 0.000181898678565
Gc25_969 0 n50 ns969 0 -0.000325588575093
Gc25_970 0 n50 ns970 0 0.000229421514535
Gc25_971 0 n50 ns971 0 6.64585373073e-05
Gc25_972 0 n50 ns972 0 -0.000315736482536
Gc25_973 0 n50 ns973 0 0.000111678452591
Gc25_974 0 n50 ns974 0 -0.00159354368134
Gc25_975 0 n50 ns975 0 8.89513793456e-05
Gc25_976 0 n50 ns976 0 -0.00138373883536
Gc25_977 0 n50 ns977 0 -6.6880267644e-05
Gc25_978 0 n50 ns978 0 0.000114011992964
Gc25_979 0 n50 ns979 0 -7.14527021777e-05
Gc25_980 0 n50 ns980 0 -4.21788811883e-05
Gc25_981 0 n50 ns981 0 -0.000190001162775
Gc25_982 0 n50 ns982 0 9.04776459028e-06
Gc25_983 0 n50 ns983 0 -7.3667323089e-05
Gc25_984 0 n50 ns984 0 0.000313962521369
Gc25_985 0 n50 ns985 0 0.000120727432738
Gc25_986 0 n50 ns986 0 -5.34017270429e-06
Gc25_987 0 n50 ns987 0 3.12512080136e-05
Gc25_988 0 n50 ns988 0 -3.54150242865e-05
Gc25_989 0 n50 ns989 0 0.000449617288023
Gc25_990 0 n50 ns990 0 5.18422265142e-05
Gc25_991 0 n50 ns991 0 0.00143965627125
Gc25_992 0 n50 ns992 0 -7.65233014778e-05
Gc25_993 0 n50 ns993 0 0.000119312291906
Gc25_994 0 n50 ns994 0 -6.74090200605e-05
Gc25_995 0 n50 ns995 0 -4.10290856309e-05
Gc25_996 0 n50 ns996 0 0.000108075850752
Gc25_997 0 n50 ns997 0 0.000260121939065
Gc25_998 0 n50 ns998 0 0.00016434874313
Gc25_999 0 n50 ns999 0 -5.9746478699e-05
Gc25_1000 0 n50 ns1000 0 -6.7140487405e-05
Gc25_1001 0 n50 ns1001 0 -0.000310785080107
Gc25_1002 0 n50 ns1002 0 -0.000219651392912
Gc25_1003 0 n50 ns1003 0 -0.000288295033466
Gc25_1004 0 n50 ns1004 0 -0.000674133178881
Gc25_1005 0 n50 ns1005 0 -0.000383401732298
Gc25_1006 0 n50 ns1006 0 -0.000379567506087
Gc25_1007 0 n50 ns1007 0 -0.000382076073146
Gc25_1008 0 n50 ns1008 0 -0.000543647695138
Gc25_1009 0 n50 ns1009 0 0.000723217509199
Gc25_1010 0 n50 ns1010 0 0.000246053075728
Gc25_1011 0 n50 ns1011 0 0.00277864878901
Gc25_1012 0 n50 ns1012 0 -0.000591148163673
Gc25_1013 0 n50 ns1013 0 0.00239424721841
Gc25_1014 0 n50 ns1014 0 -0.000609402553827
Gc25_1015 0 n50 ns1015 0 0.000533817703333
Gc25_1016 0 n50 ns1016 0 0.000289855259612
Gc25_1017 0 n50 ns1017 0 -0.00019021442584
Gc25_1018 0 n50 ns1018 0 -0.000121842334052
Gc25_1019 0 n50 ns1019 0 -0.000830827360182
Gc25_1020 0 n50 ns1020 0 -0.000319520817367
Gc25_1021 0 n50 ns1021 0 -0.000341406452073
Gc25_1022 0 n50 ns1022 0 -0.000220041229967
Gc25_1023 0 n50 ns1023 0 3.61254166756e-05
Gc25_1024 0 n50 ns1024 0 1.25604351659e-05
Gc25_1025 0 n50 ns1025 0 -6.65932196711e-05
Gc25_1026 0 n50 ns1026 0 2.35655812614e-05
Gc25_1027 0 n50 ns1027 0 6.18921864676e-06
Gc25_1028 0 n50 ns1028 0 0.000265124733135
Gc25_1029 0 n50 ns1029 0 9.83490877392e-06
Gc25_1030 0 n50 ns1030 0 0.000874855410162
Gc25_1031 0 n50 ns1031 0 4.95508798206e-05
Gc25_1032 0 n50 ns1032 0 -2.54704946995e-05
Gc25_1033 0 n50 ns1033 0 -0.000156601432889
Gc25_1034 0 n50 ns1034 0 2.69349396362e-05
Gc25_1035 0 n50 ns1035 0 -0.000293952661841
Gc25_1036 0 n50 ns1036 0 0.000445802983082
Gc25_1037 0 n50 ns1037 0 5.92879159134e-05
Gc25_1038 0 n50 ns1038 0 -0.000116459143077
Gc25_1039 0 n50 ns1039 0 0.000272245618084
Gc25_1040 0 n50 ns1040 0 -0.000323825682086
Gc25_1041 0 n50 ns1041 0 0.000921584017116
Gc25_1042 0 n50 ns1042 0 -0.000698220640127
Gc25_1043 0 n50 ns1043 0 0.000243816486342
Gc25_1044 0 n50 ns1044 0 -0.000764759080987
Gc25_1045 0 n50 ns1045 0 0.00043675328534
Gc25_1046 0 n50 ns1046 0 -0.000747574079382
Gc25_1047 0 n50 ns1047 0 0.000143327821747
Gc25_1048 0 n50 ns1048 0 0.00116976020623
Gc25_1049 0 n50 ns1049 0 0.00365619256831
Gc25_1050 0 n50 ns1050 0 0.00292839716428
Gc25_1051 0 n50 ns1051 0 0.00334225934913
Gc25_1052 0 n50 ns1052 0 0.00239122709579
Gc25_1053 0 n50 ns1053 0 0.00076347694434
Gc25_1054 0 n50 ns1054 0 0.00102792139007
Gc25_1055 0 n50 ns1055 0 -0.000341725234263
Gc25_1056 0 n50 ns1056 0 -0.000360646349795
Gc25_1057 0 n50 ns1057 0 -0.00145010742369
Gc25_1058 0 n50 ns1058 0 -0.00102482011723
Gc25_1059 0 n50 ns1059 0 -0.000550491108615
Gc25_1060 0 n50 ns1060 0 -0.000360586481428
Gc25_1061 0 n50 ns1061 0 6.47892810792e-05
Gc25_1062 0 n50 ns1062 0 6.31934656244e-06
Gc25_1063 0 n50 ns1063 0 -7.79351830549e-05
Gc25_1064 0 n50 ns1064 0 -2.71006731836e-06
Gc25_1065 0 n50 ns1065 0 -1.68104898808e-05
Gc25_1066 0 n50 ns1066 0 -0.00051146681653
Gc25_1067 0 n50 ns1067 0 -0.000128941498866
Gc25_1068 0 n50 ns1068 0 7.88006529429e-05
Gc25_1069 0 n50 ns1069 0 0.000169054296687
Gc25_1070 0 n50 ns1070 0 -0.000132191439541
Gc25_1071 0 n50 ns1071 0 -5.54834692761e-06
Gc25_1072 0 n50 ns1072 0 -8.37589042138e-05
Gc25_1073 0 n50 ns1073 0 -0.000539437295173
Gc25_1074 0 n50 ns1074 0 -0.000285919049543
Gc25_1075 0 n50 ns1075 0 0.000129394490961
Gc25_1076 0 n50 ns1076 0 -6.34156446471e-05
Gc25_1077 0 n50 ns1077 0 -3.3762588259e-05
Gc25_1078 0 n50 ns1078 0 0.00025902638869
Gc25_1079 0 n50 ns1079 0 0.000763468261108
Gc25_1080 0 n50 ns1080 0 0.00102416692337
Gc25_1081 0 n50 ns1081 0 0.000590675918948
Gc25_1082 0 n50 ns1082 0 -0.000148834539799
Gc25_1083 0 n50 ns1083 0 0.000281880671177
Gc25_1084 0 n50 ns1084 0 0.000135097625868
Gc25_1085 0 n50 ns1085 0 -0.00115214144459
Gc25_1086 0 n50 ns1086 0 1.8693459301e-06
Gc25_1087 0 n50 ns1087 0 0.000846258750016
Gc25_1088 0 n50 ns1088 0 0.00422625622583
Gc25_1089 0 n50 ns1089 0 0.00113455216186
Gc25_1090 0 n50 ns1090 0 0.0038539804611
Gc25_1091 0 n50 ns1091 0 -0.00108301677313
Gc25_1092 0 n50 ns1092 0 0.000985875755581
Gc25_1093 0 n50 ns1093 0 -0.000106234475395
Gc25_1094 0 n50 ns1094 0 -0.000674144242358
Gc25_1095 0 n50 ns1095 0 -0.000243851584616
Gc25_1096 0 n50 ns1096 0 -0.00143476887479
Gc25_1097 0 n50 ns1097 0 -0.00040274817039
Gc25_1098 0 n50 ns1098 0 0.000396686832752
Gc25_1099 0 n50 ns1099 0 0.000329320569976
Gc25_1100 0 n50 ns1100 0 -2.07940507344e-05
Gc25_1101 0 n50 ns1101 0 -0.0001006664262
Gc25_1102 0 n50 ns1102 0 -1.03796592382e-05
Gc25_1103 0 n50 ns1103 0 9.28845921308e-05
Gc25_1104 0 n50 ns1104 0 -0.000431202387234
Gc25_1105 0 n50 ns1105 0 0.000334412019483
Gc25_1106 0 n50 ns1106 0 0.00038918851689
Gc25_1107 0 n50 ns1107 0 0.00013227916574
Gc25_1108 0 n50 ns1108 0 0.000217130718625
Gc25_1109 0 n50 ns1109 0 1.02166825536e-05
Gc25_1110 0 n50 ns1110 0 0.000123172367804
Gc25_1111 0 n50 ns1111 0 0.000238173154415
Gc25_1112 0 n50 ns1112 0 -0.000589644734885
Gc25_1113 0 n50 ns1113 0 0.000158441082736
Gc25_1114 0 n50 ns1114 0 3.69837529501e-05
Gc25_1115 0 n50 ns1115 0 -8.970172039e-05
Gc25_1116 0 n50 ns1116 0 -0.000269779077577
Gc25_1117 0 n50 ns1117 0 -0.0012157721766
Gc25_1118 0 n50 ns1118 0 0.000793607391585
Gc25_1119 0 n50 ns1119 0 0.000250813899727
Gc25_1120 0 n50 ns1120 0 0.000140498713991
Gc25_1121 0 n50 ns1121 0 -0.000369585818161
Gc25_1122 0 n50 ns1122 0 -0.00016239098949
Gc25_1123 0 n50 ns1123 0 0.000130043083546
Gc25_1124 0 n50 ns1124 0 -0.00180951838358
Gc25_1125 0 n50 ns1125 0 -0.00178568281558
Gc25_1126 0 n50 ns1126 0 0.00220951385657
Gc25_1127 0 n50 ns1127 0 -0.00138463867371
Gc25_1128 0 n50 ns1128 0 0.00266407439032
Gc25_1129 0 n50 ns1129 0 -0.00263752008549
Gc25_1130 0 n50 ns1130 0 -0.00124359203535
Gc25_1131 0 n50 ns1131 0 0.000516068606305
Gc25_1132 0 n50 ns1132 0 -0.00093936179318
Gc25_1133 0 n50 ns1133 0 0.00135961181683
Gc25_1134 0 n50 ns1134 0 -0.000752167120399
Gc25_1135 0 n50 ns1135 0 -0.00064316684201
Gc25_1136 0 n50 ns1136 0 0.00229781351451
Gc25_1137 0 n50 ns1137 0 0.00110754526163
Gc25_1138 0 n50 ns1138 0 3.25974031764e-05
Gc25_1139 0 n50 ns1139 0 -0.000326966721642
Gc25_1140 0 n50 ns1140 0 0.000129604125187
Gc25_1141 0 n50 ns1141 0 0.000659735270795
Gc25_1142 0 n50 ns1142 0 -0.00189661441151
Gc25_1143 0 n50 ns1143 0 0.00132827711623
Gc25_1144 0 n50 ns1144 0 -0.00162559016152
Gc25_1145 0 n50 ns1145 0 -0.00100238527494
Gc25_1146 0 n50 ns1146 0 -0.00019452493587
Gc25_1147 0 n50 ns1147 0 0.000160413748317
Gc25_1148 0 n50 ns1148 0 -0.000147405465174
Gc25_1149 0 n50 ns1149 0 0.000523550116483
Gc25_1150 0 n50 ns1150 0 0.000331258771647
Gc25_1151 0 n50 ns1151 0 0.000132275632077
Gc25_1152 0 n50 ns1152 0 0.000104751164166
Gc25_1153 0 n50 ns1153 0 0.000368201395522
Gc25_1154 0 n50 ns1154 0 0.000407699741846
Gc25_1155 0 n50 ns1155 0 -0.000231232359262
Gc25_1156 0 n50 ns1156 0 -0.00151989214813
Gc25_1157 0 n50 ns1157 0 0.000577892893842
Gc25_1158 0 n50 ns1158 0 -0.000115736099046
Gc25_1159 0 n50 ns1159 0 0.000573810309455
Gc25_1160 0 n50 ns1160 0 -0.000632102822595
Gc25_1161 0 n50 ns1161 0 0.00228402045825
Gc25_1162 0 n50 ns1162 0 0.00126277532533
Gc25_1163 0 n50 ns1163 0 -0.000627276313338
Gc25_1164 0 n50 ns1164 0 0.00179644234427
Gc25_1165 0 n50 ns1165 0 -0.00103673429147
Gc25_1166 0 n50 ns1166 0 0.00228862833727
Gc25_1167 0 n50 ns1167 0 0.00233010342768
Gc25_1168 0 n50 ns1168 0 -0.00297769286409
Gc25_1169 0 n50 ns1169 0 0.00117215158254
Gc25_1170 0 n50 ns1170 0 -0.000572863258843
Gc25_1171 0 n50 ns1171 0 0.000115994547186
Gc25_1172 0 n50 ns1172 0 0.000596581979608
Gc25_1173 0 n50 ns1173 0 -0.00310901877589
Gc25_1174 0 n50 ns1174 0 0.00208969577174
Gc25_1175 0 n50 ns1175 0 0.00260742923406
Gc25_1176 0 n50 ns1176 0 2.54162229169e-05
Gc25_1177 0 n50 ns1177 0 -0.000182596494047
Gc25_1178 0 n50 ns1178 0 3.50313522028e-05
Gc25_1179 0 n50 ns1179 0 0.00207735024757
Gc25_1180 0 n50 ns1180 0 -0.00582770253254
Gc25_1181 0 n50 ns1181 0 0.00185308942564
Gc25_1182 0 n50 ns1182 0 -0.00446361410254
Gc25_1183 0 n50 ns1183 0 -0.000809796401538
Gc25_1184 0 n50 ns1184 0 -0.00105071369861
Gc25_1185 0 n50 ns1185 0 0.000597523049469
Gc25_1186 0 n50 ns1186 0 0.000184078225885
Gc25_1187 0 n50 ns1187 0 -0.000143004120642
Gc25_1188 0 n50 ns1188 0 0.000398657269093
Gc25_1189 0 n50 ns1189 0 3.75170537971e-05
Gc25_1190 0 n50 ns1190 0 8.62890310943e-05
Gc25_1191 0 n50 ns1191 0 -0.000884161762778
Gc25_1192 0 n50 ns1192 0 0.000339848999686
Gc25_1193 0 n50 ns1193 0 0.00043388359852
Gc25_1194 0 n50 ns1194 0 6.71040931026e-06
Gc25_1195 0 n50 ns1195 0 -6.97766522556e-05
Gc25_1196 0 n50 ns1196 0 0.00018985252896
Gc25_1197 0 n50 ns1197 0 -0.000496302076891
Gc25_1198 0 n50 ns1198 0 -0.000619315347992
Gc25_1199 0 n50 ns1199 0 -0.00051763739732
Gc25_1200 0 n50 ns1200 0 0.00107313692064
Gc25_1201 0 n50 ns1201 0 0.00604095913982
Gc25_1202 0 n50 ns1202 0 0.00356431781327
Gc25_1203 0 n50 ns1203 0 0.00408282066971
Gc25_1204 0 n50 ns1204 0 0.00335446218165
Gc25_1205 0 n50 ns1205 0 0.00334497483842
Gc25_1206 0 n50 ns1206 0 0.00622558374566
Gc25_1207 0 n50 ns1207 0 0.00073672292242
Gc25_1208 0 n50 ns1208 0 -0.000154205464449
Gc25_1209 0 n50 ns1209 0 -0.00745694822848
Gc25_1210 0 n50 ns1210 0 -0.000942434242443
Gc25_1211 0 n50 ns1211 0 0.00386838509438
Gc25_1212 0 n50 ns1212 0 -0.00785298020067
Gc25_1213 0 n50 ns1213 0 0.00391539566736
Gc25_1214 0 n50 ns1214 0 1.11321915608e-05
Gc25_1215 0 n50 ns1215 0 -0.000111946070392
Gc25_1216 0 n50 ns1216 0 4.97853380202e-06
Gd25_1 0 n50 ni1 0 0.000584750849132
Gd25_2 0 n50 ni2 0 0.000201957446117
Gd25_3 0 n50 ni3 0 -0.000446363533593
Gd25_4 0 n50 ni4 0 0.00138029924935
Gd25_5 0 n50 ni5 0 7.49801229604e-05
Gd25_6 0 n50 ni6 0 2.15214094967e-05
Gd25_7 0 n50 ni7 0 0.000475778703514
Gd25_8 0 n50 ni8 0 0.000105159595698
Gd25_9 0 n50 ni9 0 0.000749992400746
Gd25_10 0 n50 ni10 0 -0.000441521450093
Gd25_11 0 n50 ni11 0 0.00100535919382
Gd25_12 0 n50 ni12 0 0.00053248419277
Gd25_13 0 n50 ni13 0 -0.000353156869814
Gd25_14 0 n50 ni14 0 0.000276851008746
Gd25_15 0 n50 ni15 0 0.000697257672476
Gd25_16 0 n50 ni16 0 -0.0035926930628
Gd25_17 0 n50 ni17 0 -0.000293799831984
Gd25_18 0 n50 ni18 0 -7.95384985281e-05
Gd25_19 0 n50 ni19 0 -2.12652021458e-05
Gd25_20 0 n50 ni20 0 -0.000424657888103
Gd25_21 0 n50 ni21 0 0.000192643641441
Gd25_22 0 n50 ni22 0 -4.57929263495e-05
Gd25_23 0 n50 ni23 0 -0.000294555825925
Gd25_24 0 n50 ni24 0 -0.00236687770038
Gd25_25 0 n50 ni25 0 -0.00240954608158
Gd25_26 0 n50 ni26 0 -5.20520180755e-05
Gd25_27 0 n50 ni27 0 -0.000373383590255
Gd25_28 0 n50 ni28 0 0.000251917002403
Gd25_29 0 n50 ni29 0 1.64307011739e-05
Gd25_30 0 n50 ni30 0 9.20857754491e-05
Gd25_31 0 n50 ni31 0 -0.00168938837383
Gd25_32 0 n50 ni32 0 -0.00320137742442
Gc26_1 0 n52 ns1 0 -0.00104679045756
Gc26_2 0 n52 ns2 0 -0.000306121888855
Gc26_3 0 n52 ns3 0 -0.00423506887136
Gc26_4 0 n52 ns4 0 -0.00174973884999
Gc26_5 0 n52 ns5 0 -0.00182026776584
Gc26_6 0 n52 ns6 0 0.00120205682463
Gc26_7 0 n52 ns7 0 0.000901668441917
Gc26_8 0 n52 ns8 0 -0.000413948260643
Gc26_9 0 n52 ns9 0 -0.0006695342122
Gc26_10 0 n52 ns10 0 -0.000245599904573
Gc26_11 0 n52 ns11 0 -8.62704561527e-05
Gc26_12 0 n52 ns12 0 -5.35135221383e-05
Gc26_13 0 n52 ns13 0 0.000747367851982
Gc26_14 0 n52 ns14 0 0.00052635499703
Gc26_15 0 n52 ns15 0 0.000661539456304
Gc26_16 0 n52 ns16 0 -0.00145740275981
Gc26_17 0 n52 ns17 0 0.000694279373604
Gc26_18 0 n52 ns18 0 9.47574744807e-05
Gc26_19 0 n52 ns19 0 0.00079996721764
Gc26_20 0 n52 ns20 0 -0.000333764019424
Gc26_21 0 n52 ns21 0 -0.00250145782153
Gc26_22 0 n52 ns22 0 -0.00106455275356
Gc26_23 0 n52 ns23 0 -0.00286882708153
Gc26_24 0 n52 ns24 0 0.000761033797495
Gc26_25 0 n52 ns25 0 -0.00163705264285
Gc26_26 0 n52 ns26 0 -6.52296963312e-05
Gc26_27 0 n52 ns27 0 0.00414927461876
Gc26_28 0 n52 ns28 0 0.000136936696233
Gc26_29 0 n52 ns29 0 0.00122887867468
Gc26_30 0 n52 ns30 0 -0.000540527716739
Gc26_31 0 n52 ns31 0 -0.00135322423426
Gc26_32 0 n52 ns32 0 -0.000714354870665
Gc26_33 0 n52 ns33 0 0.00270246347464
Gc26_34 0 n52 ns34 0 0.00138439885379
Gc26_35 0 n52 ns35 0 -0.00284919492186
Gc26_36 0 n52 ns36 0 -3.95856482012e-05
Gc26_37 0 n52 ns37 0 0.000368401892581
Gc26_38 0 n52 ns38 0 -0.000189174753423
Gc26_39 0 n52 ns39 0 0.000936342028283
Gc26_40 0 n52 ns40 0 -0.00215689763776
Gc26_41 0 n52 ns41 0 0.00135234579511
Gc26_42 0 n52 ns42 0 -0.00440699931221
Gc26_43 0 n52 ns43 0 -0.00242967420662
Gc26_44 0 n52 ns44 0 -0.00130465104647
Gc26_45 0 n52 ns45 0 0.00101329117653
Gc26_46 0 n52 ns46 0 0.000437824364082
Gc26_47 0 n52 ns47 0 -0.000785857037095
Gc26_48 0 n52 ns48 0 -0.000481408472018
Gc26_49 0 n52 ns49 0 -0.000135129742364
Gc26_50 0 n52 ns50 0 -8.64444276673e-05
Gc26_51 0 n52 ns51 0 0.000348150376943
Gc26_52 0 n52 ns52 0 0.000127846156109
Gc26_53 0 n52 ns53 0 0.000724737882297
Gc26_54 0 n52 ns54 0 -0.000842760138215
Gc26_55 0 n52 ns55 0 0.000654214904158
Gc26_56 0 n52 ns56 0 0.000483667827651
Gc26_57 0 n52 ns57 0 0.000351719225247
Gc26_58 0 n52 ns58 0 0.000207627869206
Gc26_59 0 n52 ns59 0 -0.0011936781335
Gc26_60 0 n52 ns60 0 -0.0019144536661
Gc26_61 0 n52 ns61 0 -0.00144981042406
Gc26_62 0 n52 ns62 0 -0.00089926673083
Gc26_63 0 n52 ns63 0 -0.000412000309935
Gc26_64 0 n52 ns64 0 -0.00157783957429
Gc26_65 0 n52 ns65 0 0.00460601407201
Gc26_66 0 n52 ns66 0 0.00201030607566
Gc26_67 0 n52 ns67 0 0.00139207368314
Gc26_68 0 n52 ns68 0 -0.000646095963273
Gc26_69 0 n52 ns69 0 -0.00207041426145
Gc26_70 0 n52 ns70 0 -0.00147566449825
Gc26_71 0 n52 ns71 0 0.0026087191404
Gc26_72 0 n52 ns72 0 0.00295502283501
Gc26_73 0 n52 ns73 0 -0.00354020598803
Gc26_74 0 n52 ns74 0 -9.14420773525e-06
Gc26_75 0 n52 ns75 0 0.000293044134744
Gc26_76 0 n52 ns76 0 -0.000152898052026
Gc26_77 0 n52 ns77 0 0.00220895911217
Gc26_78 0 n52 ns78 0 -0.00345295401766
Gc26_79 0 n52 ns79 0 0.00454825648582
Gc26_80 0 n52 ns80 0 -0.00711657777938
Gc26_81 0 n52 ns81 0 -0.00343848417176
Gc26_82 0 n52 ns82 0 -0.00251948992234
Gc26_83 0 n52 ns83 0 0.00111225931405
Gc26_84 0 n52 ns84 0 0.000750518018053
Gc26_85 0 n52 ns85 0 -0.000673371493918
Gc26_86 0 n52 ns86 0 -0.000106439500777
Gc26_87 0 n52 ns87 0 -0.000187332497284
Gc26_88 0 n52 ns88 0 -0.000130889427673
Gc26_89 0 n52 ns89 0 -0.000470213573503
Gc26_90 0 n52 ns90 0 -0.000764236356446
Gc26_91 0 n52 ns91 0 0.000705950707848
Gc26_92 0 n52 ns92 0 0.000566219625655
Gc26_93 0 n52 ns93 0 0.000970021449879
Gc26_94 0 n52 ns94 0 0.000977158974752
Gc26_95 0 n52 ns95 0 0.000382708179979
Gc26_96 0 n52 ns96 0 0.00121764790826
Gc26_97 0 n52 ns97 0 0.000922955745562
Gc26_98 0 n52 ns98 0 -0.00258653670983
Gc26_99 0 n52 ns99 0 0.00192343994274
Gc26_100 0 n52 ns100 0 -0.00711795985616
Gc26_101 0 n52 ns101 0 0.00214107073071
Gc26_102 0 n52 ns102 0 -0.00684116282935
Gc26_103 0 n52 ns103 0 0.00475288380322
Gc26_104 0 n52 ns104 0 0.0066262425264
Gc26_105 0 n52 ns105 0 0.0011402148596
Gc26_106 0 n52 ns106 0 -0.00105003151852
Gc26_107 0 n52 ns107 0 -0.00421156132913
Gc26_108 0 n52 ns108 0 -0.00499449127303
Gc26_109 0 n52 ns109 0 0.00178370196123
Gc26_110 0 n52 ns110 0 0.00610287383818
Gc26_111 0 n52 ns111 0 -0.00416886931209
Gc26_112 0 n52 ns112 0 -1.06370837375e-05
Gc26_113 0 n52 ns113 0 0.000376612347612
Gc26_114 0 n52 ns114 0 -0.000225783220185
Gc26_115 0 n52 ns115 0 -0.000717027734529
Gc26_116 0 n52 ns116 0 -0.00051239433387
Gc26_117 0 n52 ns117 0 -0.00227258007759
Gc26_118 0 n52 ns118 0 0.0010173699356
Gc26_119 0 n52 ns119 0 -0.000225071763703
Gc26_120 0 n52 ns120 0 0.000852290742982
Gc26_121 0 n52 ns121 0 0.000163382648111
Gc26_122 0 n52 ns122 0 -0.000237688088114
Gc26_123 0 n52 ns123 0 -0.00012505826342
Gc26_124 0 n52 ns124 0 0.000343354352039
Gc26_125 0 n52 ns125 0 -0.000250274318052
Gc26_126 0 n52 ns126 0 -2.16223216006e-05
Gc26_127 0 n52 ns127 0 0.000407621918618
Gc26_128 0 n52 ns128 0 0.000288600042154
Gc26_129 0 n52 ns129 0 0.000348974324622
Gc26_130 0 n52 ns130 0 -0.000319313826342
Gc26_131 0 n52 ns131 0 0.00110090950075
Gc26_132 0 n52 ns132 0 -0.000299151682003
Gc26_133 0 n52 ns133 0 0.000848090666058
Gc26_134 0 n52 ns134 0 -0.000743016284039
Gc26_135 0 n52 ns135 0 -0.00173907804713
Gc26_136 0 n52 ns136 0 2.31034868605e-05
Gc26_137 0 n52 ns137 0 -0.00337684431261
Gc26_138 0 n52 ns138 0 -0.00366810358311
Gc26_139 0 n52 ns139 0 -0.00264900491952
Gc26_140 0 n52 ns140 0 -0.00409637664002
Gc26_141 0 n52 ns141 0 0.00119345431074
Gc26_142 0 n52 ns142 0 -0.000430996423415
Gc26_143 0 n52 ns143 0 0.000943102998251
Gc26_144 0 n52 ns144 0 -0.00115750658814
Gc26_145 0 n52 ns145 0 6.06024810316e-05
Gc26_146 0 n52 ns146 0 -0.00163821165693
Gc26_147 0 n52 ns147 0 0.0025490883313
Gc26_148 0 n52 ns148 0 -0.00233709823424
Gc26_149 0 n52 ns149 0 -0.00248842237106
Gc26_150 0 n52 ns150 0 3.51871279699e-06
Gc26_151 0 n52 ns151 0 0.00013171080405
Gc26_152 0 n52 ns152 0 -3.02360405771e-05
Gc26_153 0 n52 ns153 0 -0.000312331478097
Gc26_154 0 n52 ns154 0 -0.000112594897075
Gc26_155 0 n52 ns155 0 -0.000727409023848
Gc26_156 0 n52 ns156 0 0.00142177564213
Gc26_157 0 n52 ns157 0 -0.000347654563289
Gc26_158 0 n52 ns158 0 0.000100393453861
Gc26_159 0 n52 ns159 0 0.000216474476826
Gc26_160 0 n52 ns160 0 -0.000164964839639
Gc26_161 0 n52 ns161 0 6.07564590554e-05
Gc26_162 0 n52 ns162 0 0.000433804441455
Gc26_163 0 n52 ns163 0 -0.000132154116328
Gc26_164 0 n52 ns164 0 0.000124113459468
Gc26_165 0 n52 ns165 0 0.000590177833335
Gc26_166 0 n52 ns166 0 -0.000470820769673
Gc26_167 0 n52 ns167 0 0.000125924069343
Gc26_168 0 n52 ns168 0 0.000272587161873
Gc26_169 0 n52 ns169 0 0.000632435295634
Gc26_170 0 n52 ns170 0 -0.000410356790338
Gc26_171 0 n52 ns171 0 0.00023379014726
Gc26_172 0 n52 ns172 0 -0.000394441458076
Gc26_173 0 n52 ns173 0 -0.000335655567102
Gc26_174 0 n52 ns174 0 0.000704271115796
Gc26_175 0 n52 ns175 0 -0.00217864620662
Gc26_176 0 n52 ns176 0 -0.00447375670852
Gc26_177 0 n52 ns177 0 -0.00216348955376
Gc26_178 0 n52 ns178 0 -0.00443162129517
Gc26_179 0 n52 ns179 0 -0.00112780295245
Gc26_180 0 n52 ns180 0 0.00134175171861
Gc26_181 0 n52 ns181 0 0.000148367926314
Gc26_182 0 n52 ns182 0 -0.00127010812663
Gc26_183 0 n52 ns183 0 1.94660226872e-05
Gc26_184 0 n52 ns184 0 -0.00306327451219
Gc26_185 0 n52 ns185 0 0.000641156144859
Gc26_186 0 n52 ns186 0 -0.002833468727
Gc26_187 0 n52 ns187 0 -0.00116730422608
Gc26_188 0 n52 ns188 0 -3.84532615849e-05
Gc26_189 0 n52 ns189 0 0.000102773251564
Gc26_190 0 n52 ns190 0 -1.11832259459e-05
Gc26_191 0 n52 ns191 0 -0.000101366815432
Gc26_192 0 n52 ns192 0 -0.000129845179332
Gc26_193 0 n52 ns193 0 -0.000251292806103
Gc26_194 0 n52 ns194 0 0.000259481224317
Gc26_195 0 n52 ns195 0 -4.31792551407e-05
Gc26_196 0 n52 ns196 0 0.000124188359813
Gc26_197 0 n52 ns197 0 -5.26232419081e-05
Gc26_198 0 n52 ns198 0 -9.24822493189e-06
Gc26_199 0 n52 ns199 0 0.000293214818566
Gc26_200 0 n52 ns200 0 -4.43395030657e-05
Gc26_201 0 n52 ns201 0 -6.6562495588e-05
Gc26_202 0 n52 ns202 0 0.000141212562502
Gc26_203 0 n52 ns203 0 -1.23518062731e-06
Gc26_204 0 n52 ns204 0 9.31006971263e-05
Gc26_205 0 n52 ns205 0 0.000638611966907
Gc26_206 0 n52 ns206 0 0.000298012062739
Gc26_207 0 n52 ns207 0 0.000292337166948
Gc26_208 0 n52 ns208 0 -0.000471684319836
Gc26_209 0 n52 ns209 0 0.000102415170822
Gc26_210 0 n52 ns210 0 -0.000281483432572
Gc26_211 0 n52 ns211 0 -4.01481231565e-05
Gc26_212 0 n52 ns212 0 -0.000362174041182
Gc26_213 0 n52 ns213 0 -0.00484267277824
Gc26_214 0 n52 ns214 0 -0.00425279729864
Gc26_215 0 n52 ns215 0 -0.00448132278141
Gc26_216 0 n52 ns216 0 -0.00375210843467
Gc26_217 0 n52 ns217 0 -0.000373401232686
Gc26_218 0 n52 ns218 0 0.00186404907396
Gc26_219 0 n52 ns219 0 -0.000289282184091
Gc26_220 0 n52 ns220 0 -0.000743366638944
Gc26_221 0 n52 ns221 0 -0.000900625224589
Gc26_222 0 n52 ns222 0 -0.00206800351142
Gc26_223 0 n52 ns223 0 1.90384136799e-05
Gc26_224 0 n52 ns224 0 -0.00125058287045
Gc26_225 0 n52 ns225 0 -0.000439342500782
Gc26_226 0 n52 ns226 0 -1.18913419677e-05
Gc26_227 0 n52 ns227 0 4.30628625867e-05
Gc26_228 0 n52 ns228 0 1.31904845187e-05
Gc26_229 0 n52 ns229 0 0.000426614801115
Gc26_230 0 n52 ns230 0 -0.000183088903726
Gc26_231 0 n52 ns231 0 0.00131705542256
Gc26_232 0 n52 ns232 0 -0.000458625296798
Gc26_233 0 n52 ns233 0 0.000354918966074
Gc26_234 0 n52 ns234 0 -6.54821083038e-05
Gc26_235 0 n52 ns235 0 -0.000152911723031
Gc26_236 0 n52 ns236 0 1.41583288995e-05
Gc26_237 0 n52 ns237 0 4.80855903482e-05
Gc26_238 0 n52 ns238 0 -0.000508420083763
Gc26_239 0 n52 ns239 0 -2.60445361663e-05
Gc26_240 0 n52 ns240 0 0.000129333801646
Gc26_241 0 n52 ns241 0 4.22748464153e-05
Gc26_242 0 n52 ns242 0 0.000401959119646
Gc26_243 0 n52 ns243 0 0.000194487323436
Gc26_244 0 n52 ns244 0 -0.000394039569145
Gc26_245 0 n52 ns245 0 -0.000290651168631
Gc26_246 0 n52 ns246 0 -0.000475803132474
Gc26_247 0 n52 ns247 0 -0.000436100300101
Gc26_248 0 n52 ns248 0 -0.000440847178473
Gc26_249 0 n52 ns249 0 -0.000200245362078
Gc26_250 0 n52 ns250 0 -0.000421002608253
Gc26_251 0 n52 ns251 0 -0.00444991462
Gc26_252 0 n52 ns252 0 -0.000486291386787
Gc26_253 0 n52 ns253 0 -0.00397725896769
Gc26_254 0 n52 ns254 0 -0.000348201651938
Gc26_255 0 n52 ns255 0 0.000705667918972
Gc26_256 0 n52 ns256 0 0.00135613896291
Gc26_257 0 n52 ns257 0 -0.000358655282752
Gc26_258 0 n52 ns258 0 -0.000356484028358
Gc26_259 0 n52 ns259 0 -0.00134810441622
Gc26_260 0 n52 ns260 0 -0.00115953840292
Gc26_261 0 n52 ns261 0 -0.000229876619161
Gc26_262 0 n52 ns262 0 -0.000822037286229
Gc26_263 0 n52 ns263 0 -0.000239615005852
Gc26_264 0 n52 ns264 0 -7.5584206989e-06
Gc26_265 0 n52 ns265 0 -1.69439807566e-05
Gc26_266 0 n52 ns266 0 5.40847585217e-05
Gc26_267 0 n52 ns267 0 -0.00045070193446
Gc26_268 0 n52 ns268 0 0.00127564550235
Gc26_269 0 n52 ns269 0 -0.00093537318042
Gc26_270 0 n52 ns270 0 0.00159222050767
Gc26_271 0 n52 ns271 0 -0.000181875694866
Gc26_272 0 n52 ns272 0 0.000559699145785
Gc26_273 0 n52 ns273 0 0.000106342405981
Gc26_274 0 n52 ns274 0 -0.000327136050978
Gc26_275 0 n52 ns275 0 -4.1069833263e-05
Gc26_276 0 n52 ns276 0 0.000209729076505
Gc26_277 0 n52 ns277 0 0.000138227827871
Gc26_278 0 n52 ns278 0 -2.01175494264e-05
Gc26_279 0 n52 ns279 0 0.000175708500068
Gc26_280 0 n52 ns280 0 -0.000712771346677
Gc26_281 0 n52 ns281 0 -6.15313824199e-05
Gc26_282 0 n52 ns282 0 -0.000609866431218
Gc26_283 0 n52 ns283 0 -0.000256116846882
Gc26_284 0 n52 ns284 0 -0.000225551851423
Gc26_285 0 n52 ns285 0 -0.000186618089272
Gc26_286 0 n52 ns286 0 -0.000197081048609
Gc26_287 0 n52 ns287 0 -0.000466051959543
Gc26_288 0 n52 ns288 0 0.000320819368372
Gc26_289 0 n52 ns289 0 -0.00278010558962
Gc26_290 0 n52 ns290 0 0.00239695204515
Gc26_291 0 n52 ns291 0 -0.00239017523527
Gc26_292 0 n52 ns292 0 0.00209395913849
Gc26_293 0 n52 ns293 0 0.000967007447431
Gc26_294 0 n52 ns294 0 0.00114461535962
Gc26_295 0 n52 ns295 0 -0.000282678996821
Gc26_296 0 n52 ns296 0 -0.000205761258851
Gc26_297 0 n52 ns297 0 -0.00115463594315
Gc26_298 0 n52 ns298 0 -0.00094632172767
Gc26_299 0 n52 ns299 0 -0.000220408616172
Gc26_300 0 n52 ns300 0 -0.00106057532874
Gc26_301 0 n52 ns301 0 -0.000283495465833
Gc26_302 0 n52 ns302 0 -2.0461325179e-05
Gc26_303 0 n52 ns303 0 2.10886277198e-05
Gc26_304 0 n52 ns304 0 6.13874488222e-06
Gc26_305 0 n52 ns305 0 0.000346422383305
Gc26_306 0 n52 ns306 0 -0.00022156435147
Gc26_307 0 n52 ns307 0 0.000912116660677
Gc26_308 0 n52 ns308 0 -0.000456156488178
Gc26_309 0 n52 ns309 0 0.000171963352869
Gc26_310 0 n52 ns310 0 -0.000227492404064
Gc26_311 0 n52 ns311 0 -0.000133844365256
Gc26_312 0 n52 ns312 0 0.000147025445659
Gc26_313 0 n52 ns313 0 -0.00013249010192
Gc26_314 0 n52 ns314 0 9.94524325483e-05
Gc26_315 0 n52 ns315 0 6.06267268513e-05
Gc26_316 0 n52 ns316 0 -4.39712739771e-05
Gc26_317 0 n52 ns317 0 -0.000145937574372
Gc26_318 0 n52 ns318 0 -0.000187606488235
Gc26_319 0 n52 ns319 0 -0.000363057007955
Gc26_320 0 n52 ns320 0 -3.37024584911e-05
Gc26_321 0 n52 ns321 0 -0.000263299074731
Gc26_322 0 n52 ns322 0 0.000123565765523
Gc26_323 0 n52 ns323 0 -0.00030804564073
Gc26_324 0 n52 ns324 0 0.000168698545886
Gc26_325 0 n52 ns325 0 -0.000175948616116
Gc26_326 0 n52 ns326 0 0.000124241286494
Gc26_327 0 n52 ns327 0 -0.000640802966653
Gc26_328 0 n52 ns328 0 0.00150416616965
Gc26_329 0 n52 ns329 0 -0.000540618841074
Gc26_330 0 n52 ns330 0 0.00131689697664
Gc26_331 0 n52 ns331 0 0.000501426683234
Gc26_332 0 n52 ns332 0 0.000217484987736
Gc26_333 0 n52 ns333 0 -0.000128138771902
Gc26_334 0 n52 ns334 0 -4.88760082828e-05
Gc26_335 0 n52 ns335 0 -0.000554842282399
Gc26_336 0 n52 ns336 0 -0.000165484472812
Gc26_337 0 n52 ns337 0 -7.87830909054e-05
Gc26_338 0 n52 ns338 0 -0.000242632280009
Gc26_339 0 n52 ns339 0 -9.30919447713e-05
Gc26_340 0 n52 ns340 0 -9.82184066217e-06
Gc26_341 0 n52 ns341 0 2.91579772165e-06
Gc26_342 0 n52 ns342 0 8.22016274203e-06
Gc26_343 0 n52 ns343 0 -0.000370721880239
Gc26_344 0 n52 ns344 0 -0.000153730883619
Gc26_345 0 n52 ns345 0 0.00051165575741
Gc26_346 0 n52 ns346 0 0.00243896747922
Gc26_347 0 n52 ns347 0 0.00126591032043
Gc26_348 0 n52 ns348 0 -0.00105449233997
Gc26_349 0 n52 ns349 0 -0.000318268067893
Gc26_350 0 n52 ns350 0 -3.60783989836e-06
Gc26_351 0 n52 ns351 0 -0.00022377118421
Gc26_352 0 n52 ns352 0 0.000427333899076
Gc26_353 0 n52 ns353 0 -4.42431766745e-05
Gc26_354 0 n52 ns354 0 -0.000110912035099
Gc26_355 0 n52 ns355 0 0.00208341313276
Gc26_356 0 n52 ns356 0 -0.00123648776133
Gc26_357 0 n52 ns357 0 -0.00113486496011
Gc26_358 0 n52 ns358 0 0.00142186418193
Gc26_359 0 n52 ns359 0 -0.000423533559791
Gc26_360 0 n52 ns360 0 0.000637079345472
Gc26_361 0 n52 ns361 0 -0.00196685048331
Gc26_362 0 n52 ns362 0 -0.000714516408896
Gc26_363 0 n52 ns363 0 0.00295175703427
Gc26_364 0 n52 ns364 0 0.00431817415602
Gc26_365 0 n52 ns365 0 -0.00578613119366
Gc26_366 0 n52 ns366 0 0.00202211222969
Gc26_367 0 n52 ns367 0 -0.00380713789219
Gc26_368 0 n52 ns368 0 0.00038957322034
Gc26_369 0 n52 ns369 0 -0.0111491089391
Gc26_370 0 n52 ns370 0 -0.00170280911815
Gc26_371 0 n52 ns371 0 0.00180232325526
Gc26_372 0 n52 ns372 0 0.000208166522713
Gc26_373 0 n52 ns373 0 -0.00260370990654
Gc26_374 0 n52 ns374 0 0.00936586955892
Gc26_375 0 n52 ns375 0 -0.0139989085832
Gc26_376 0 n52 ns376 0 -0.00354108434421
Gc26_377 0 n52 ns377 0 -0.00618380696104
Gc26_378 0 n52 ns378 0 -5.80470017294e-05
Gc26_379 0 n52 ns379 0 -0.000441189638916
Gc26_380 0 n52 ns380 0 0.000605873509457
Gc26_381 0 n52 ns381 0 -0.00075791174661
Gc26_382 0 n52 ns382 0 -0.000896199898889
Gc26_383 0 n52 ns383 0 -0.00330573724906
Gc26_384 0 n52 ns384 0 -0.00145405537203
Gc26_385 0 n52 ns385 0 -0.00183818285712
Gc26_386 0 n52 ns386 0 0.001046320912
Gc26_387 0 n52 ns387 0 0.00072655649626
Gc26_388 0 n52 ns388 0 -0.000361763135347
Gc26_389 0 n52 ns389 0 -0.000280464993319
Gc26_390 0 n52 ns390 0 0.000456951372075
Gc26_391 0 n52 ns391 0 -0.000213694717414
Gc26_392 0 n52 ns392 0 -0.000102019402302
Gc26_393 0 n52 ns393 0 0.000210527875695
Gc26_394 0 n52 ns394 0 -1.27456438723e-05
Gc26_395 0 n52 ns395 0 0.000773376267679
Gc26_396 0 n52 ns396 0 -0.000362256626555
Gc26_397 0 n52 ns397 0 0.00138903848842
Gc26_398 0 n52 ns398 0 -6.77088806734e-06
Gc26_399 0 n52 ns399 0 0.00127147375067
Gc26_400 0 n52 ns400 0 -0.000346848169906
Gc26_401 0 n52 ns401 0 -0.00160191758956
Gc26_402 0 n52 ns402 0 -0.000624185739393
Gc26_403 0 n52 ns403 0 -0.00272688454039
Gc26_404 0 n52 ns404 0 -0.0041700619543
Gc26_405 0 n52 ns405 0 -0.00191475006855
Gc26_406 0 n52 ns406 0 -0.00453853578012
Gc26_407 0 n52 ns407 0 0.00283976090679
Gc26_408 0 n52 ns408 0 0.00126283602315
Gc26_409 0 n52 ns409 0 0.00106480613971
Gc26_410 0 n52 ns410 0 -0.0011586786133
Gc26_411 0 n52 ns411 0 -0.00135812737009
Gc26_412 0 n52 ns412 0 -0.00257021956807
Gc26_413 0 n52 ns413 0 0.00266472679252
Gc26_414 0 n52 ns414 0 -0.000281302790737
Gc26_415 0 n52 ns415 0 -0.003161358246
Gc26_416 0 n52 ns416 0 -3.02315942637e-05
Gc26_417 0 n52 ns417 0 0.000274413172882
Gc26_418 0 n52 ns418 0 -0.000132257986729
Gc26_419 0 n52 ns419 0 -0.000427359976219
Gc26_420 0 n52 ns420 0 8.40996496089e-05
Gc26_421 0 n52 ns421 0 -0.000929937565527
Gc26_422 0 n52 ns422 0 0.00244227627297
Gc26_423 0 n52 ns423 0 -0.000133030103559
Gc26_424 0 n52 ns424 0 0.000404287615908
Gc26_425 0 n52 ns425 0 0.000191807692128
Gc26_426 0 n52 ns426 0 -0.000266093336207
Gc26_427 0 n52 ns427 0 1.49969389e-05
Gc26_428 0 n52 ns428 0 0.000518594469846
Gc26_429 0 n52 ns429 0 -0.000172078583543
Gc26_430 0 n52 ns430 0 5.5417784392e-05
Gc26_431 0 n52 ns431 0 0.000645718612589
Gc26_432 0 n52 ns432 0 -0.000495630281371
Gc26_433 0 n52 ns433 0 2.4615287805e-05
Gc26_434 0 n52 ns434 0 -0.00013002686691
Gc26_435 0 n52 ns435 0 0.000812634771662
Gc26_436 0 n52 ns436 0 -0.000518795009093
Gc26_437 0 n52 ns437 0 0.000414927489902
Gc26_438 0 n52 ns438 0 -0.000761179199005
Gc26_439 0 n52 ns439 0 -0.000709057466438
Gc26_440 0 n52 ns440 0 0.00100211764333
Gc26_441 0 n52 ns441 0 -0.00179620011048
Gc26_442 0 n52 ns442 0 -0.0035341535717
Gc26_443 0 n52 ns443 0 -0.00171267109557
Gc26_444 0 n52 ns444 0 -0.0038491487181
Gc26_445 0 n52 ns445 0 -0.000580116980398
Gc26_446 0 n52 ns446 0 0.000814196855988
Gc26_447 0 n52 ns447 0 0.00037488021565
Gc26_448 0 n52 ns448 0 -0.0013603361783
Gc26_449 0 n52 ns449 0 0.000101366041945
Gc26_450 0 n52 ns450 0 -0.00297524894987
Gc26_451 0 n52 ns451 0 0.00109029436361
Gc26_452 0 n52 ns452 0 -0.00332820840724
Gc26_453 0 n52 ns453 0 -0.00160564740295
Gc26_454 0 n52 ns454 0 -2.44059879752e-05
Gc26_455 0 n52 ns455 0 8.00668874182e-05
Gc26_456 0 n52 ns456 0 7.4186960309e-06
Gc26_457 0 n52 ns457 0 -0.000569288546306
Gc26_458 0 n52 ns458 0 0.000324258860983
Gc26_459 0 n52 ns459 0 -0.00150134989566
Gc26_460 0 n52 ns460 0 0.00131335386575
Gc26_461 0 n52 ns461 0 -0.000416551240103
Gc26_462 0 n52 ns462 0 0.000374387601513
Gc26_463 0 n52 ns463 0 0.000133085208111
Gc26_464 0 n52 ns464 0 -0.000194005005753
Gc26_465 0 n52 ns465 0 0.000300509156832
Gc26_466 0 n52 ns466 0 0.000353367316499
Gc26_467 0 n52 ns467 0 -6.43092353975e-05
Gc26_468 0 n52 ns468 0 0.000123973702254
Gc26_469 0 n52 ns469 0 0.000212861324721
Gc26_470 0 n52 ns470 0 -0.000392171039304
Gc26_471 0 n52 ns471 0 0.000651837863867
Gc26_472 0 n52 ns472 0 0.000436443003285
Gc26_473 0 n52 ns473 0 0.00056667260492
Gc26_474 0 n52 ns474 0 -0.000453521986461
Gc26_475 0 n52 ns475 0 0.000355663659476
Gc26_476 0 n52 ns476 0 -0.000244228517767
Gc26_477 0 n52 ns477 0 -0.000114266699093
Gc26_478 0 n52 ns478 0 2.68917051413e-05
Gc26_479 0 n52 ns479 0 -0.00437194421623
Gc26_480 0 n52 ns480 0 -0.00497748429299
Gc26_481 0 n52 ns481 0 -0.00411110255067
Gc26_482 0 n52 ns482 0 -0.00453067056874
Gc26_483 0 n52 ns483 0 -0.000817405803521
Gc26_484 0 n52 ns484 0 0.002001256771
Gc26_485 0 n52 ns485 0 -0.000187304149887
Gc26_486 0 n52 ns486 0 -0.000966703088693
Gc26_487 0 n52 ns487 0 -0.000598243589949
Gc26_488 0 n52 ns488 0 -0.00261433569458
Gc26_489 0 n52 ns489 0 0.000183271109016
Gc26_490 0 n52 ns490 0 -0.00176935475739
Gc26_491 0 n52 ns491 0 -0.000646838269392
Gc26_492 0 n52 ns492 0 -2.00654364331e-05
Gc26_493 0 n52 ns493 0 9.8516457548e-05
Gc26_494 0 n52 ns494 0 -2.14666460033e-05
Gc26_495 0 n52 ns495 0 0.000489098278209
Gc26_496 0 n52 ns496 0 -0.00068190711136
Gc26_497 0 n52 ns497 0 0.00149887327383
Gc26_498 0 n52 ns498 0 -0.000958441239818
Gc26_499 0 n52 ns499 0 0.000306185260901
Gc26_500 0 n52 ns500 0 -0.00022021443854
Gc26_501 0 n52 ns501 0 -0.000135908383923
Gc26_502 0 n52 ns502 0 0.000134006151306
Gc26_503 0 n52 ns503 0 0.000180845074162
Gc26_504 0 n52 ns504 0 -0.000533063166278
Gc26_505 0 n52 ns505 0 -8.40272106369e-05
Gc26_506 0 n52 ns506 0 0.000159795825891
Gc26_507 0 n52 ns507 0 -5.3625445257e-05
Gc26_508 0 n52 ns508 0 0.000612058137721
Gc26_509 0 n52 ns509 0 0.000399224004439
Gc26_510 0 n52 ns510 0 -0.000137649001682
Gc26_511 0 n52 ns511 0 -0.000132662679768
Gc26_512 0 n52 ns512 0 -0.000535593842615
Gc26_513 0 n52 ns513 0 -0.000333029409488
Gc26_514 0 n52 ns514 0 -0.000459393836518
Gc26_515 0 n52 ns515 0 -7.49622191562e-05
Gc26_516 0 n52 ns516 0 -0.000590340826022
Gc26_517 0 n52 ns517 0 -0.00489021071932
Gc26_518 0 n52 ns518 0 -0.00205905658005
Gc26_519 0 n52 ns519 0 -0.00443310996064
Gc26_520 0 n52 ns520 0 -0.00172346501855
Gc26_521 0 n52 ns521 0 0.000365700453196
Gc26_522 0 n52 ns522 0 0.0015318585204
Gc26_523 0 n52 ns523 0 -0.000352705846524
Gc26_524 0 n52 ns524 0 -0.00046813285762
Gc26_525 0 n52 ns525 0 -0.00122893562798
Gc26_526 0 n52 ns526 0 -0.00142999576143
Gc26_527 0 n52 ns527 0 -0.000167893770102
Gc26_528 0 n52 ns528 0 -0.000965242349716
Gc26_529 0 n52 ns529 0 -0.000297594494049
Gc26_530 0 n52 ns530 0 -5.26244365799e-06
Gc26_531 0 n52 ns531 0 2.73827401981e-05
Gc26_532 0 n52 ns532 0 2.81461281116e-05
Gc26_533 0 n52 ns533 0 -0.000306960936658
Gc26_534 0 n52 ns534 0 0.00104739692671
Gc26_535 0 n52 ns535 0 -0.000516480027335
Gc26_536 0 n52 ns536 0 0.00130846427122
Gc26_537 0 n52 ns537 0 -0.000100073123158
Gc26_538 0 n52 ns538 0 0.000500417093811
Gc26_539 0 n52 ns539 0 9.4078097228e-05
Gc26_540 0 n52 ns540 0 -0.000314002778724
Gc26_541 0 n52 ns541 0 -6.93767188547e-06
Gc26_542 0 n52 ns542 0 -1.19671564928e-05
Gc26_543 0 n52 ns543 0 0.00010346185802
Gc26_544 0 n52 ns544 0 3.62850662669e-05
Gc26_545 0 n52 ns545 0 0.000220984996444
Gc26_546 0 n52 ns546 0 -0.000463900950478
Gc26_547 0 n52 ns547 0 5.82597248985e-05
Gc26_548 0 n52 ns548 0 -0.000686695793387
Gc26_549 0 n52 ns549 0 -0.000284908928973
Gc26_550 0 n52 ns550 0 -0.000367186298154
Gc26_551 0 n52 ns551 0 -0.000253403192936
Gc26_552 0 n52 ns552 0 -0.000342316690226
Gc26_553 0 n52 ns553 0 -0.000456756076913
Gc26_554 0 n52 ns554 0 0.000163208523112
Gc26_555 0 n52 ns555 0 -0.00363670954021
Gc26_556 0 n52 ns556 0 0.00192090103579
Gc26_557 0 n52 ns557 0 -0.00316466027239
Gc26_558 0 n52 ns558 0 0.00170021777979
Gc26_559 0 n52 ns559 0 0.00102931909683
Gc26_560 0 n52 ns560 0 0.00139820975032
Gc26_561 0 n52 ns561 0 -0.000336017147082
Gc26_562 0 n52 ns562 0 -0.000270119439662
Gc26_563 0 n52 ns563 0 -0.00134469457711
Gc26_564 0 n52 ns564 0 -0.00116818657959
Gc26_565 0 n52 ns565 0 -0.00026888088245
Gc26_566 0 n52 ns566 0 -0.0011920054998
Gc26_567 0 n52 ns567 0 -0.000312941277123
Gc26_568 0 n52 ns568 0 -7.20516425106e-06
Gc26_569 0 n52 ns569 0 1.41751741129e-05
Gc26_570 0 n52 ns570 0 1.76381104766e-05
Gc26_571 0 n52 ns571 0 0.000115354654487
Gc26_572 0 n52 ns572 0 0.000193676454112
Gc26_573 0 n52 ns573 0 0.000425124280948
Gc26_574 0 n52 ns574 0 0.000123165500949
Gc26_575 0 n52 ns575 0 4.68024250658e-05
Gc26_576 0 n52 ns576 0 6.76031533747e-06
Gc26_577 0 n52 ns577 0 -5.87330637629e-05
Gc26_578 0 n52 ns578 0 -1.84481872356e-06
Gc26_579 0 n52 ns579 0 -0.000126704809486
Gc26_580 0 n52 ns580 0 0.000165426794078
Gc26_581 0 n52 ns581 0 9.87374949691e-05
Gc26_582 0 n52 ns582 0 -4.51735118196e-05
Gc26_583 0 n52 ns583 0 -6.11541243454e-05
Gc26_584 0 n52 ns584 0 -0.000409968705061
Gc26_585 0 n52 ns585 0 -0.000328089727655
Gc26_586 0 n52 ns586 0 -0.000216167162823
Gc26_587 0 n52 ns587 0 -0.000290855052767
Gc26_588 0 n52 ns588 0 4.61087565578e-05
Gc26_589 0 n52 ns589 0 -0.000295472983912
Gc26_590 0 n52 ns590 0 9.29293413192e-05
Gc26_591 0 n52 ns591 0 -0.000291119355244
Gc26_592 0 n52 ns592 0 0.000241844213675
Gc26_593 0 n52 ns593 0 -0.00130716672151
Gc26_594 0 n52 ns594 0 0.00208794575968
Gc26_595 0 n52 ns595 0 -0.00111087418185
Gc26_596 0 n52 ns596 0 0.00182009331633
Gc26_597 0 n52 ns597 0 0.000740334351598
Gc26_598 0 n52 ns598 0 0.000527678229261
Gc26_599 0 n52 ns599 0 -0.000188260647569
Gc26_600 0 n52 ns600 0 -9.5944958514e-05
Gc26_601 0 n52 ns601 0 -0.000810468731811
Gc26_602 0 n52 ns602 0 -0.000429022409574
Gc26_603 0 n52 ns603 0 -0.000144166781562
Gc26_604 0 n52 ns604 0 -0.000567728530967
Gc26_605 0 n52 ns605 0 -0.000166832751625
Gc26_606 0 n52 ns606 0 -1.15240469459e-05
Gc26_607 0 n52 ns607 0 7.61451964199e-06
Gc26_608 0 n52 ns608 0 3.36901275594e-06
Gc26_609 0 n52 ns609 0 0.000717844100615
Gc26_610 0 n52 ns610 0 -0.0026026432864
Gc26_611 0 n52 ns611 0 0.00109095799261
Gc26_612 0 n52 ns612 0 -0.00192859521551
Gc26_613 0 n52 ns613 0 -0.00110451413321
Gc26_614 0 n52 ns614 0 -0.000255114114174
Gc26_615 0 n52 ns615 0 0.000363414234043
Gc26_616 0 n52 ns616 0 -0.000291871059433
Gc26_617 0 n52 ns617 0 0.000335409868281
Gc26_618 0 n52 ns618 0 0.000665912504367
Gc26_619 0 n52 ns619 0 0.000112396167716
Gc26_620 0 n52 ns620 0 9.97659906531e-05
Gc26_621 0 n52 ns621 0 -8.56895183495e-05
Gc26_622 0 n52 ns622 0 0.000415740752885
Gc26_623 0 n52 ns623 0 0.000677975332335
Gc26_624 0 n52 ns624 0 -0.00154675518711
Gc26_625 0 n52 ns625 0 0.000638517776438
Gc26_626 0 n52 ns626 0 -9.98124779211e-06
Gc26_627 0 n52 ns627 0 0.000638832111995
Gc26_628 0 n52 ns628 0 -0.000544702845708
Gc26_629 0 n52 ns629 0 0.00149138146336
Gc26_630 0 n52 ns630 0 0.00263050680986
Gc26_631 0 n52 ns631 0 0.000585345807385
Gc26_632 0 n52 ns632 0 0.00169428881712
Gc26_633 0 n52 ns633 0 -0.000194900466096
Gc26_634 0 n52 ns634 0 0.00211865501406
Gc26_635 0 n52 ns635 0 0.00495532529288
Gc26_636 0 n52 ns636 0 -0.000433602509887
Gc26_637 0 n52 ns637 0 0.0011736684826
Gc26_638 0 n52 ns638 0 -0.000447455705822
Gc26_639 0 n52 ns639 0 -0.00159181375492
Gc26_640 0 n52 ns640 0 -9.89886300957e-05
Gc26_641 0 n52 ns641 0 -0.00370401588578
Gc26_642 0 n52 ns642 0 -0.0010126227269
Gc26_643 0 n52 ns643 0 0.00296645702638
Gc26_644 0 n52 ns644 0 3.31572280179e-05
Gc26_645 0 n52 ns645 0 -0.000156845212909
Gc26_646 0 n52 ns646 0 2.16419115016e-05
Gc26_647 0 n52 ns647 0 0.00143316843534
Gc26_648 0 n52 ns648 0 -0.00474262289493
Gc26_649 0 n52 ns649 0 0.00173321940628
Gc26_650 0 n52 ns650 0 -0.00377371916381
Gc26_651 0 n52 ns651 0 -0.00134351639757
Gc26_652 0 n52 ns652 0 -0.000808565759841
Gc26_653 0 n52 ns653 0 0.000572830243591
Gc26_654 0 n52 ns654 0 9.09324392152e-06
Gc26_655 0 n52 ns655 0 0.000359550284217
Gc26_656 0 n52 ns656 0 0.000580800467649
Gc26_657 0 n52 ns657 0 0.000143012126887
Gc26_658 0 n52 ns658 0 0.000120181762327
Gc26_659 0 n52 ns659 0 -0.000235636149925
Gc26_660 0 n52 ns660 0 0.0004741524551
Gc26_661 0 n52 ns661 0 9.82597391284e-05
Gc26_662 0 n52 ns662 0 -0.00123392232411
Gc26_663 0 n52 ns663 0 0.000451220771369
Gc26_664 0 n52 ns664 0 9.59399513465e-06
Gc26_665 0 n52 ns665 0 0.000216298116319
Gc26_666 0 n52 ns666 0 -0.000823619529524
Gc26_667 0 n52 ns667 0 0.00158384950682
Gc26_668 0 n52 ns668 0 0.00159671530734
Gc26_669 0 n52 ns669 0 0.00260434098889
Gc26_670 0 n52 ns670 0 0.00311943721169
Gc26_671 0 n52 ns671 0 0.00128613992482
Gc26_672 0 n52 ns672 0 0.00341709788133
Gc26_673 0 n52 ns673 0 0.00338885744626
Gc26_674 0 n52 ns674 0 0.000681765674262
Gc26_675 0 n52 ns675 0 0.00129356526498
Gc26_676 0 n52 ns676 0 -0.000538554751712
Gc26_677 0 n52 ns677 0 -0.00344286666634
Gc26_678 0 n52 ns678 0 -9.15068559254e-05
Gc26_679 0 n52 ns679 0 -0.000566958002318
Gc26_680 0 n52 ns680 0 -0.00225036430264
Gc26_681 0 n52 ns681 0 0.00385797867856
Gc26_682 0 n52 ns682 0 1.58172297441e-05
Gc26_683 0 n52 ns683 0 -0.000142236766248
Gc26_684 0 n52 ns684 0 3.18819684597e-05
Gc26_685 0 n52 ns685 0 0.00112523170727
Gc26_686 0 n52 ns686 0 -0.00446807210452
Gc26_687 0 n52 ns687 0 -0.000170307301756
Gc26_688 0 n52 ns688 0 -0.00230068801082
Gc26_689 0 n52 ns689 0 -0.000954118986441
Gc26_690 0 n52 ns690 0 -0.000340071365061
Gc26_691 0 n52 ns691 0 0.000609331578082
Gc26_692 0 n52 ns692 0 4.46350190243e-05
Gc26_693 0 n52 ns693 0 0.000245900764251
Gc26_694 0 n52 ns694 0 2.66104469546e-05
Gc26_695 0 n52 ns695 0 0.000234451062086
Gc26_696 0 n52 ns696 0 0.000125772075063
Gc26_697 0 n52 ns697 0 -0.000536683435044
Gc26_698 0 n52 ns698 0 -7.21433109513e-05
Gc26_699 0 n52 ns699 0 -0.000649311553361
Gc26_700 0 n52 ns700 0 0.000577094994272
Gc26_701 0 n52 ns701 0 0.000305067484117
Gc26_702 0 n52 ns702 0 0.000325039565156
Gc26_703 0 n52 ns703 0 -0.00055013738425
Gc26_704 0 n52 ns704 0 -0.000633662876205
Gc26_705 0 n52 ns705 0 -0.000442732139066
Gc26_706 0 n52 ns706 0 -0.000845669513439
Gc26_707 0 n52 ns707 0 0.003216249975
Gc26_708 0 n52 ns708 0 0.00510957675166
Gc26_709 0 n52 ns709 0 0.00189727340382
Gc26_710 0 n52 ns710 0 0.00529522496113
Gc26_711 0 n52 ns711 0 -0.000245523940967
Gc26_712 0 n52 ns712 0 0.00447311116572
Gc26_713 0 n52 ns713 0 0.00116479533517
Gc26_714 0 n52 ns714 0 -0.000838396717628
Gc26_715 0 n52 ns715 0 -0.00520964808286
Gc26_716 0 n52 ns716 0 -0.00144398621337
Gc26_717 0 n52 ns717 0 0.00354538464223
Gc26_718 0 n52 ns718 0 -0.00460712379236
Gc26_719 0 n52 ns719 0 0.00469407139197
Gc26_720 0 n52 ns720 0 -1.34709308365e-05
Gc26_721 0 n52 ns721 0 -5.15659321249e-05
Gc26_722 0 n52 ns722 0 -3.36697496146e-05
Gc26_723 0 n52 ns723 0 0.000373598815244
Gc26_724 0 n52 ns724 0 -0.00238293950551
Gc26_725 0 n52 ns725 0 0.000536239724122
Gc26_726 0 n52 ns726 0 -0.00223417459083
Gc26_727 0 n52 ns727 0 -0.000779178687554
Gc26_728 0 n52 ns728 0 -0.00023081355749
Gc26_729 0 n52 ns729 0 0.000168022350588
Gc26_730 0 n52 ns730 0 -0.000241667273031
Gc26_731 0 n52 ns731 0 -1.69099125024e-05
Gc26_732 0 n52 ns732 0 -0.00021680495526
Gc26_733 0 n52 ns733 0 0.000225107869363
Gc26_734 0 n52 ns734 0 7.34102000945e-05
Gc26_735 0 n52 ns735 0 0.000273154149299
Gc26_736 0 n52 ns736 0 0.000893142325034
Gc26_737 0 n52 ns737 0 0.000357849398137
Gc26_738 0 n52 ns738 0 -5.41374915199e-05
Gc26_739 0 n52 ns739 0 0.0010246440685
Gc26_740 0 n52 ns740 0 -2.52798203547e-05
Gc26_741 0 n52 ns741 0 0.000596749075148
Gc26_742 0 n52 ns742 0 -0.000155187881303
Gc26_743 0 n52 ns743 0 0.000875240868332
Gc26_744 0 n52 ns744 0 0.00081836077836
Gc26_745 0 n52 ns745 0 2.59901570363e-05
Gc26_746 0 n52 ns746 0 0.00443620062624
Gc26_747 0 n52 ns747 0 -7.703359246e-05
Gc26_748 0 n52 ns748 0 0.00469770939856
Gc26_749 0 n52 ns749 0 0.000798621960765
Gc26_750 0 n52 ns750 0 -0.00213280803997
Gc26_751 0 n52 ns751 0 0.00101539708347
Gc26_752 0 n52 ns752 0 -0.0009478578266
Gc26_753 0 n52 ns753 0 0.000301817992555
Gc26_754 0 n52 ns754 0 -0.000257484203712
Gc26_755 0 n52 ns755 0 -0.00302743931226
Gc26_756 0 n52 ns756 0 0.00284866558414
Gc26_757 0 n52 ns757 0 0.00272804611309
Gc26_758 0 n52 ns758 0 3.00130644508e-06
Gc26_759 0 n52 ns759 0 -0.000110591192854
Gc26_760 0 n52 ns760 0 -9.73713212587e-06
Gc26_761 0 n52 ns761 0 -2.98768710289e-05
Gc26_762 0 n52 ns762 0 -0.000283799384831
Gc26_763 0 n52 ns763 0 7.78762109666e-05
Gc26_764 0 n52 ns764 0 0.000399701057161
Gc26_765 0 n52 ns765 0 0.000181251544468
Gc26_766 0 n52 ns766 0 0.000314878313081
Gc26_767 0 n52 ns767 0 -0.000181236465712
Gc26_768 0 n52 ns768 0 -3.82647179144e-05
Gc26_769 0 n52 ns769 0 -8.52301757069e-05
Gc26_770 0 n52 ns770 0 -0.000331600503631
Gc26_771 0 n52 ns771 0 0.000165672999053
Gc26_772 0 n52 ns772 0 -6.95716432661e-05
Gc26_773 0 n52 ns773 0 9.43641831985e-05
Gc26_774 0 n52 ns774 0 -0.000208222596727
Gc26_775 0 n52 ns775 0 -0.000297215173773
Gc26_776 0 n52 ns776 0 0.000305903351218
Gc26_777 0 n52 ns777 0 0.000409868021364
Gc26_778 0 n52 ns778 0 -0.000477739141655
Gc26_779 0 n52 ns779 0 -7.3062349283e-05
Gc26_780 0 n52 ns780 0 -0.000682533480922
Gc26_781 0 n52 ns781 0 0.00028960122621
Gc26_782 0 n52 ns782 0 -0.000838239615477
Gc26_783 0 n52 ns783 0 0.00177131380974
Gc26_784 0 n52 ns784 0 0.00383115554495
Gc26_785 0 n52 ns785 0 0.00180714318123
Gc26_786 0 n52 ns786 0 0.00388791776104
Gc26_787 0 n52 ns787 0 -0.00202289320629
Gc26_788 0 n52 ns788 0 -0.000729345144482
Gc26_789 0 n52 ns789 0 0.000260093723227
Gc26_790 0 n52 ns790 0 -0.00100813632111
Gc26_791 0 n52 ns791 0 0.000454710736393
Gc26_792 0 n52 ns792 0 -0.00107180755987
Gc26_793 0 n52 ns793 0 -0.000912572576591
Gc26_794 0 n52 ns794 0 0.0021627266225
Gc26_795 0 n52 ns795 0 0.00109800665556
Gc26_796 0 n52 ns796 0 2.91373439687e-05
Gc26_797 0 n52 ns797 0 -0.000230310373445
Gc26_798 0 n52 ns798 0 8.26362069264e-05
Gc26_799 0 n52 ns799 0 -6.95242037825e-05
Gc26_800 0 n52 ns800 0 -1.64962709562e-05
Gc26_801 0 n52 ns801 0 3.98740041651e-05
Gc26_802 0 n52 ns802 0 0.000566634065197
Gc26_803 0 n52 ns803 0 2.87918888344e-05
Gc26_804 0 n52 ns804 0 8.1733587872e-06
Gc26_805 0 n52 ns805 0 7.06732874263e-05
Gc26_806 0 n52 ns806 0 -5.49271668292e-05
Gc26_807 0 n52 ns807 0 -0.000247431723123
Gc26_808 0 n52 ns808 0 0.000106529220616
Gc26_809 0 n52 ns809 0 8.86186925988e-05
Gc26_810 0 n52 ns810 0 -0.000155713741763
Gc26_811 0 n52 ns811 0 -0.000208559096731
Gc26_812 0 n52 ns812 0 -0.000181590679542
Gc26_813 0 n52 ns813 0 0.000550981179264
Gc26_814 0 n52 ns814 0 0.000231428881663
Gc26_815 0 n52 ns815 0 0.000232652865274
Gc26_816 0 n52 ns816 0 -0.000532949933552
Gc26_817 0 n52 ns817 0 -1.21786090007e-05
Gc26_818 0 n52 ns818 0 -0.000405147859014
Gc26_819 0 n52 ns819 0 -0.00044750930994
Gc26_820 0 n52 ns820 0 0.000238368303449
Gc26_821 0 n52 ns821 0 0.00309589758348
Gc26_822 0 n52 ns822 0 0.00332694859242
Gc26_823 0 n52 ns823 0 0.00303248449905
Gc26_824 0 n52 ns824 0 0.00297413087933
Gc26_825 0 n52 ns825 0 -0.000613712587123
Gc26_826 0 n52 ns826 0 0.000991738592702
Gc26_827 0 n52 ns827 0 -0.000235426004895
Gc26_828 0 n52 ns828 0 -0.000651536920749
Gc26_829 0 n52 ns829 0 -0.000768372543703
Gc26_830 0 n52 ns830 0 -0.00136956961279
Gc26_831 0 n52 ns831 0 -0.000568818721051
Gc26_832 0 n52 ns832 0 0.000381499319731
Gc26_833 0 n52 ns833 0 0.000338956181633
Gc26_834 0 n52 ns834 0 -4.71867497302e-06
Gc26_835 0 n52 ns835 0 -5.19661801685e-05
Gc26_836 0 n52 ns836 0 -2.04804442719e-05
Gc26_837 0 n52 ns837 0 5.64311736456e-05
Gc26_838 0 n52 ns838 0 0.00036284972814
Gc26_839 0 n52 ns839 0 0.000259699806095
Gc26_840 0 n52 ns840 0 0.000604065199694
Gc26_841 0 n52 ns841 0 -2.36142845086e-05
Gc26_842 0 n52 ns842 0 5.83989165264e-05
Gc26_843 0 n52 ns843 0 -4.11247189353e-05
Gc26_844 0 n52 ns844 0 -3.1158828237e-05
Gc26_845 0 n52 ns845 0 -1.89575247173e-05
Gc26_846 0 n52 ns846 0 0.000364665865471
Gc26_847 0 n52 ns847 0 -3.19024509936e-06
Gc26_848 0 n52 ns848 0 -0.000125488079111
Gc26_849 0 n52 ns849 0 -4.68091373012e-05
Gc26_850 0 n52 ns850 0 -0.000256453607894
Gc26_851 0 n52 ns851 0 0.000437695976416
Gc26_852 0 n52 ns852 0 -0.000633424874922
Gc26_853 0 n52 ns853 0 -7.69651466473e-05
Gc26_854 0 n52 ns854 0 -0.000592361311142
Gc26_855 0 n52 ns855 0 -4.65287445789e-06
Gc26_856 0 n52 ns856 0 -0.000575725714393
Gc26_857 0 n52 ns857 0 0.00026955603501
Gc26_858 0 n52 ns858 0 0.000723500616772
Gc26_859 0 n52 ns859 0 0.00357266987076
Gc26_860 0 n52 ns860 0 0.00112020868338
Gc26_861 0 n52 ns861 0 0.00323744966878
Gc26_862 0 n52 ns862 0 0.000843393510325
Gc26_863 0 n52 ns863 0 0.00048839468777
Gc26_864 0 n52 ns864 0 0.000966046404721
Gc26_865 0 n52 ns865 0 -0.000321348167948
Gc26_866 0 n52 ns866 0 -0.000344223207998
Gc26_867 0 n52 ns867 0 -0.00125162126901
Gc26_868 0 n52 ns868 0 -0.000941744634747
Gc26_869 0 n52 ns869 0 -0.000517195318424
Gc26_870 0 n52 ns870 0 -0.000206317845886
Gc26_871 0 n52 ns871 0 9.84212788328e-05
Gc26_872 0 n52 ns872 0 1.142341914e-05
Gc26_873 0 n52 ns873 0 -4.1276100805e-05
Gc26_874 0 n52 ns874 0 -6.74883470424e-06
Gc26_875 0 n52 ns875 0 0.000348380596005
Gc26_876 0 n52 ns876 0 0.000306466962285
Gc26_877 0 n52 ns877 0 0.00130867910069
Gc26_878 0 n52 ns878 0 0.000231523027215
Gc26_879 0 n52 ns879 0 8.32090416708e-05
Gc26_880 0 n52 ns880 0 6.53727804936e-05
Gc26_881 0 n52 ns881 0 2.92255560127e-06
Gc26_882 0 n52 ns882 0 1.19866784166e-05
Gc26_883 0 n52 ns883 0 0.00030804653109
Gc26_884 0 n52 ns884 0 0.000146832924761
Gc26_885 0 n52 ns885 0 -5.00726639113e-05
Gc26_886 0 n52 ns886 0 -6.56533437047e-05
Gc26_887 0 n52 ns887 0 -0.000346800393976
Gc26_888 0 n52 ns888 0 -0.000282240297141
Gc26_889 0 n52 ns889 0 -0.000294543752443
Gc26_890 0 n52 ns890 0 -0.000634518643359
Gc26_891 0 n52 ns891 0 -0.00033433163021
Gc26_892 0 n52 ns892 0 -0.000329723419015
Gc26_893 0 n52 ns893 0 -0.000297434689625
Gc26_894 0 n52 ns894 0 -0.000499310528477
Gc26_895 0 n52 ns895 0 0.000668502355376
Gc26_896 0 n52 ns896 0 0.0002694857269
Gc26_897 0 n52 ns897 0 0.00229794801257
Gc26_898 0 n52 ns898 0 -0.000673015371431
Gc26_899 0 n52 ns899 0 0.0019780965635
Gc26_900 0 n52 ns900 0 -0.000687215147213
Gc26_901 0 n52 ns901 0 0.000627289279766
Gc26_902 0 n52 ns902 0 0.000576456900324
Gc26_903 0 n52 ns903 0 -0.000221636067647
Gc26_904 0 n52 ns904 0 -0.000162528171189
Gc26_905 0 n52 ns905 0 -0.000940075033907
Gc26_906 0 n52 ns906 0 -0.000582207225756
Gc26_907 0 n52 ns907 0 -0.000376722984756
Gc26_908 0 n52 ns908 0 -0.00056256313553
Gc26_909 0 n52 ns909 0 -5.084095297e-05
Gc26_910 0 n52 ns910 0 2.46852999309e-05
Gc26_911 0 n52 ns911 0 -4.70169772014e-05
Gc26_912 0 n52 ns912 0 1.58598870514e-05
Gc26_913 0 n52 ns913 0 3.65165284469e-05
Gc26_914 0 n52 ns914 0 0.000156060333524
Gc26_915 0 n52 ns915 0 9.65682355929e-05
Gc26_916 0 n52 ns916 0 -0.000731447807068
Gc26_917 0 n52 ns917 0 -7.04210624471e-05
Gc26_918 0 n52 ns918 0 -6.25927625558e-05
Gc26_919 0 n52 ns919 0 7.64531693143e-05
Gc26_920 0 n52 ns920 0 1.07513064149e-05
Gc26_921 0 n52 ns921 0 9.59121745518e-05
Gc26_922 0 n52 ns922 0 -0.000123177404585
Gc26_923 0 n52 ns923 0 -4.45452919545e-05
Gc26_924 0 n52 ns924 0 2.90531386791e-05
Gc26_925 0 n52 ns925 0 -9.88475911345e-05
Gc26_926 0 n52 ns926 0 0.000164315528138
Gc26_927 0 n52 ns927 0 -0.000329715194784
Gc26_928 0 n52 ns928 0 0.000103490103046
Gc26_929 0 n52 ns929 0 -0.000243558316364
Gc26_930 0 n52 ns930 0 0.000181898718538
Gc26_931 0 n52 ns931 0 -0.000325588565976
Gc26_932 0 n52 ns932 0 0.000229421584303
Gc26_933 0 n52 ns933 0 6.64584686231e-05
Gc26_934 0 n52 ns934 0 -0.000315736509836
Gc26_935 0 n52 ns935 0 0.000111678288794
Gc26_936 0 n52 ns936 0 -0.00159354375737
Gc26_937 0 n52 ns937 0 8.8951243702e-05
Gc26_938 0 n52 ns938 0 -0.0013837388967
Gc26_939 0 n52 ns939 0 -6.68803426293e-05
Gc26_940 0 n52 ns940 0 0.000114012033539
Gc26_941 0 n52 ns941 0 -7.14526915143e-05
Gc26_942 0 n52 ns942 0 -4.21788883196e-05
Gc26_943 0 n52 ns943 0 -0.000190001093219
Gc26_944 0 n52 ns944 0 9.04772674462e-06
Gc26_945 0 n52 ns945 0 -7.36672660423e-05
Gc26_946 0 n52 ns946 0 0.000313962428789
Gc26_947 0 n52 ns947 0 0.000120727383018
Gc26_948 0 n52 ns948 0 -5.34013144014e-06
Gc26_949 0 n52 ns949 0 3.12512639397e-05
Gc26_950 0 n52 ns950 0 -3.5415053238e-05
Gc26_951 0 n52 ns951 0 0.00037526035445
Gc26_952 0 n52 ns952 0 -0.00204144724571
Gc26_953 0 n52 ns953 0 -0.00161059111561
Gc26_954 0 n52 ns954 0 0.000474692840311
Gc26_955 0 n52 ns955 0 -0.000628846134004
Gc26_956 0 n52 ns956 0 0.000349295553141
Gc26_957 0 n52 ns957 0 0.000406537117569
Gc26_958 0 n52 ns958 0 -0.000216726136386
Gc26_959 0 n52 ns959 0 0.000446752155206
Gc26_960 0 n52 ns960 0 0.00021306621924
Gc26_961 0 n52 ns961 0 0.000221349233983
Gc26_962 0 n52 ns962 0 0.000126272411698
Gc26_963 0 n52 ns963 0 -0.000673642616481
Gc26_964 0 n52 ns964 0 -0.000508942724141
Gc26_965 0 n52 ns965 0 -0.000520535107174
Gc26_966 0 n52 ns966 0 0.000316380987408
Gc26_967 0 n52 ns967 0 0.000229263367811
Gc26_968 0 n52 ns968 0 0.000393582838431
Gc26_969 0 n52 ns969 0 -0.000564780715648
Gc26_970 0 n52 ns970 0 -0.00063740496081
Gc26_971 0 n52 ns971 0 -0.000554914537591
Gc26_972 0 n52 ns972 0 -0.000503065675934
Gc26_973 0 n52 ns973 0 0.00329501679805
Gc26_974 0 n52 ns974 0 0.00359341558805
Gc26_975 0 n52 ns975 0 0.00185441123495
Gc26_976 0 n52 ns976 0 0.00401805947007
Gc26_977 0 n52 ns977 0 0.000483531683186
Gc26_978 0 n52 ns978 0 0.00446065478434
Gc26_979 0 n52 ns979 0 0.00127352420682
Gc26_980 0 n52 ns980 0 -0.00068582916516
Gc26_981 0 n52 ns981 0 -0.00496573886238
Gc26_982 0 n52 ns982 0 -0.000945596734077
Gc26_983 0 n52 ns983 0 0.00291537821352
Gc26_984 0 n52 ns984 0 -0.00392593604295
Gc26_985 0 n52 ns985 0 0.00488757608314
Gc26_986 0 n52 ns986 0 -1.96735857934e-05
Gc26_987 0 n52 ns987 0 3.65809977967e-06
Gc26_988 0 n52 ns988 0 -4.81225860297e-05
Gc26_989 0 n52 ns989 0 0.000310363879036
Gc26_990 0 n52 ns990 0 -0.00266941250062
Gc26_991 0 n52 ns991 0 0.000169403686177
Gc26_992 0 n52 ns992 0 -0.00155195601144
Gc26_993 0 n52 ns993 0 -0.000902045939769
Gc26_994 0 n52 ns994 0 1.98297656243e-05
Gc26_995 0 n52 ns995 0 0.000422516239333
Gc26_996 0 n52 ns996 0 -0.000386103944124
Gc26_997 0 n52 ns997 0 0.000123860290308
Gc26_998 0 n52 ns998 0 -1.79008159821e-05
Gc26_999 0 n52 ns999 0 0.000265365580916
Gc26_1000 0 n52 ns1000 0 8.6259085746e-05
Gc26_1001 0 n52 ns1001 0 -0.000247996098462
Gc26_1002 0 n52 ns1002 0 0.000498837674227
Gc26_1003 0 n52 ns1003 0 0.000589379887076
Gc26_1004 0 n52 ns1004 0 7.42027642896e-05
Gc26_1005 0 n52 ns1005 0 0.00109083481064
Gc26_1006 0 n52 ns1006 0 0.000184794467191
Gc26_1007 0 n52 ns1007 0 0.00054422892089
Gc26_1008 0 n52 ns1008 0 -0.000126808474505
Gc26_1009 0 n52 ns1009 0 0.000153104513398
Gc26_1010 0 n52 ns1010 0 0.00151964211939
Gc26_1011 0 n52 ns1011 0 -0.000171735788922
Gc26_1012 0 n52 ns1012 0 0.00463920924896
Gc26_1013 0 n52 ns1013 0 -0.00042959785248
Gc26_1014 0 n52 ns1014 0 0.00496146951864
Gc26_1015 0 n52 ns1015 0 0.00265598056332
Gc26_1016 0 n52 ns1016 0 9.32663480285e-05
Gc26_1017 0 n52 ns1017 0 0.00112307307239
Gc26_1018 0 n52 ns1018 0 -0.00098266719462
Gc26_1019 0 n52 ns1019 0 -0.000929558659682
Gc26_1020 0 n52 ns1020 0 -0.00114910624363
Gc26_1021 0 n52 ns1021 0 -0.00362179210921
Gc26_1022 0 n52 ns1022 0 0.000178913346606
Gc26_1023 0 n52 ns1023 0 0.003167472733
Gc26_1024 0 n52 ns1024 0 2.55392612008e-05
Gc26_1025 0 n52 ns1025 0 -0.000134021950504
Gc26_1026 0 n52 ns1026 0 4.10455720916e-06
Gc26_1027 0 n52 ns1027 0 0.000247098770368
Gc26_1028 0 n52 ns1028 0 -0.00107554166548
Gc26_1029 0 n52 ns1029 0 0.000645943425437
Gc26_1030 0 n52 ns1030 0 -0.000517400087966
Gc26_1031 0 n52 ns1031 0 -0.000121942267066
Gc26_1032 0 n52 ns1032 0 0.000245983815747
Gc26_1033 0 n52 ns1033 0 -0.000169051248389
Gc26_1034 0 n52 ns1034 0 -0.00011293769284
Gc26_1035 0 n52 ns1035 0 3.16206331317e-05
Gc26_1036 0 n52 ns1036 0 -0.000340832793766
Gc26_1037 0 n52 ns1037 0 0.000208541128291
Gc26_1038 0 n52 ns1038 0 -2.71701176289e-05
Gc26_1039 0 n52 ns1039 0 0.000238926408049
Gc26_1040 0 n52 ns1040 0 1.0742922868e-05
Gc26_1041 0 n52 ns1041 0 -0.000386275657949
Gc26_1042 0 n52 ns1042 0 -2.74862690605e-05
Gc26_1043 0 n52 ns1043 0 0.000593807552899
Gc26_1044 0 n52 ns1044 0 -0.000505400439363
Gc26_1045 0 n52 ns1045 0 0.000114185244066
Gc26_1046 0 n52 ns1046 0 -0.000846665132192
Gc26_1047 0 n52 ns1047 0 0.000916598860004
Gc26_1048 0 n52 ns1048 0 -0.000574886918727
Gc26_1049 0 n52 ns1049 0 0.00157764838197
Gc26_1050 0 n52 ns1050 0 0.00431900981555
Gc26_1051 0 n52 ns1051 0 0.0015207010446
Gc26_1052 0 n52 ns1052 0 0.00446098840716
Gc26_1053 0 n52 ns1053 0 -0.0014885462243
Gc26_1054 0 n52 ns1054 0 -0.00155381464278
Gc26_1055 0 n52 ns1055 0 0.000491424349129
Gc26_1056 0 n52 ns1056 0 -0.00106718389394
Gc26_1057 0 n52 ns1057 0 0.000493412236206
Gc26_1058 0 n52 ns1058 0 -0.000783661494731
Gc26_1059 0 n52 ns1059 0 -0.00140907221373
Gc26_1060 0 n52 ns1060 0 0.00256904795137
Gc26_1061 0 n52 ns1061 0 0.00151275469858
Gc26_1062 0 n52 ns1062 0 2.40786561788e-05
Gc26_1063 0 n52 ns1063 0 -0.000217474778364
Gc26_1064 0 n52 ns1064 0 6.80164143139e-05
Gc26_1065 0 n52 ns1065 0 8.55695478031e-05
Gc26_1066 0 n52 ns1066 0 -0.000245637187823
Gc26_1067 0 n52 ns1067 0 0.00049673737644
Gc26_1068 0 n52 ns1068 0 0.00047672389617
Gc26_1069 0 n52 ns1069 0 0.000185476947101
Gc26_1070 0 n52 ns1070 0 -2.98877683746e-05
Gc26_1071 0 n52 ns1071 0 1.71793133491e-05
Gc26_1072 0 n52 ns1072 0 4.51476554122e-05
Gc26_1073 0 n52 ns1073 0 -0.000239675115695
Gc26_1074 0 n52 ns1074 0 -0.00010219873473
Gc26_1075 0 n52 ns1075 0 0.000132574933534
Gc26_1076 0 n52 ns1076 0 -0.000142025278706
Gc26_1077 0 n52 ns1077 0 -0.000252215109071
Gc26_1078 0 n52 ns1078 0 -0.000224773398014
Gc26_1079 0 n52 ns1079 0 0.000246894970429
Gc26_1080 0 n52 ns1080 0 0.000455494782395
Gc26_1081 0 n52 ns1081 0 0.000301076754316
Gc26_1082 0 n52 ns1082 0 -0.000527219806795
Gc26_1083 0 n52 ns1083 0 -0.000109912852634
Gc26_1084 0 n52 ns1084 0 -0.000498143306131
Gc26_1085 0 n52 ns1085 0 -0.00038365441757
Gc26_1086 0 n52 ns1086 0 -0.000196027546473
Gc26_1087 0 n52 ns1087 0 0.00278081246293
Gc26_1088 0 n52 ns1088 0 0.00386012167327
Gc26_1089 0 n52 ns1089 0 0.00279214211256
Gc26_1090 0 n52 ns1090 0 0.00359800154792
Gc26_1091 0 n52 ns1091 0 -0.00114742715709
Gc26_1092 0 n52 ns1092 0 0.000673939644115
Gc26_1093 0 n52 ns1093 0 -0.000126390663777
Gc26_1094 0 n52 ns1094 0 -0.00080618236212
Gc26_1095 0 n52 ns1095 0 -0.000450221512108
Gc26_1096 0 n52 ns1096 0 -0.00145292475579
Gc26_1097 0 n52 ns1097 0 -0.00065620194859
Gc26_1098 0 n52 ns1098 0 0.000800895216791
Gc26_1099 0 n52 ns1099 0 0.000527194183288
Gc26_1100 0 n52 ns1100 0 2.0211223039e-05
Gc26_1101 0 n52 ns1101 0 -0.000138450419725
Gc26_1102 0 n52 ns1102 0 2.41324758443e-05
Gc26_1103 0 n52 ns1103 0 -0.000451101071354
Gc26_1104 0 n52 ns1104 0 0.000587779560732
Gc26_1105 0 n52 ns1105 0 -0.00109853299017
Gc26_1106 0 n52 ns1106 0 0.00123757484503
Gc26_1107 0 n52 ns1107 0 -0.000302284791682
Gc26_1108 0 n52 ns1108 0 0.000274394611298
Gc26_1109 0 n52 ns1109 0 0.000129967312145
Gc26_1110 0 n52 ns1110 0 -0.000189437983159
Gc26_1111 0 n52 ns1111 0 -0.000171943690455
Gc26_1112 0 n52 ns1112 0 0.00048190867982
Gc26_1113 0 n52 ns1113 0 7.32264378059e-05
Gc26_1114 0 n52 ns1114 0 -0.0001514414211
Gc26_1115 0 n52 ns1115 0 0.000125707165263
Gc26_1116 0 n52 ns1116 0 -0.000436375246559
Gc26_1117 0 n52 ns1117 0 0.000823134296399
Gc26_1118 0 n52 ns1118 0 -0.000436858624672
Gc26_1119 0 n52 ns1119 0 0.000175082247018
Gc26_1120 0 n52 ns1120 0 -0.000648028685823
Gc26_1121 0 n52 ns1121 0 0.000247427467412
Gc26_1122 0 n52 ns1122 0 -0.000517955932006
Gc26_1123 0 n52 ns1123 0 -0.000163490282128
Gc26_1124 0 n52 ns1124 0 0.000849008785875
Gc26_1125 0 n52 ns1125 0 0.00333548936411
Gc26_1126 0 n52 ns1126 0 0.00235805227102
Gc26_1127 0 n52 ns1127 0 0.00313603931876
Gc26_1128 0 n52 ns1128 0 0.00194690938395
Gc26_1129 0 n52 ns1129 0 0.000231635959695
Gc26_1130 0 n52 ns1130 0 0.00116605781782
Gc26_1131 0 n52 ns1131 0 -0.000322854131945
Gc26_1132 0 n52 ns1132 0 -0.000433372413144
Gc26_1133 0 n52 ns1133 0 -0.00114682004796
Gc26_1134 0 n52 ns1134 0 -0.00114905466332
Gc26_1135 0 n52 ns1135 0 -0.000501121206749
Gc26_1136 0 n52 ns1136 0 -0.000159565646929
Gc26_1137 0 n52 ns1137 0 0.000126185494058
Gc26_1138 0 n52 ns1138 0 -1.6581180276e-05
Gc26_1139 0 n52 ns1139 0 1.74117878779e-05
Gc26_1140 0 n52 ns1140 0 -4.73261681526e-05
Gc26_1141 0 n52 ns1141 0 0.000209602973617
Gc26_1142 0 n52 ns1142 0 0.000496845037854
Gc26_1143 0 n52 ns1143 0 0.000955222329284
Gc26_1144 0 n52 ns1144 0 0.000822589770479
Gc26_1145 0 n52 ns1145 0 3.70341202152e-05
Gc26_1146 0 n52 ns1146 0 0.000213266916095
Gc26_1147 0 n52 ns1147 0 -1.77527970148e-05
Gc26_1148 0 n52 ns1148 0 -6.61952304432e-05
Gc26_1149 0 n52 ns1149 0 0.000268272424398
Gc26_1150 0 n52 ns1150 0 0.000310437632832
Gc26_1151 0 n52 ns1151 0 -2.9217953327e-05
Gc26_1152 0 n52 ns1152 0 -0.000101853918933
Gc26_1153 0 n52 ns1153 0 -0.000257492087697
Gc26_1154 0 n52 ns1154 0 -0.000452752033801
Gc26_1155 0 n52 ns1155 0 -3.53940445851e-05
Gc26_1156 0 n52 ns1156 0 -0.000862013194707
Gc26_1157 0 n52 ns1157 0 -0.000259225302503
Gc26_1158 0 n52 ns1158 0 -0.000539786380726
Gc26_1159 0 n52 ns1159 0 -0.00015285726988
Gc26_1160 0 n52 ns1160 0 -0.000709760393557
Gc26_1161 0 n52 ns1161 0 0.000684130795751
Gc26_1162 0 n52 ns1162 0 0.00057071501103
Gc26_1163 0 n52 ns1163 0 0.002997861643
Gc26_1164 0 n52 ns1164 0 4.25130627107e-05
Gc26_1165 0 n52 ns1165 0 0.00262149477018
Gc26_1166 0 n52 ns1166 0 -0.000104010186462
Gc26_1167 0 n52 ns1167 0 0.000782445950507
Gc26_1168 0 n52 ns1168 0 0.00078257942372
Gc26_1169 0 n52 ns1169 0 -0.0002775023255
Gc26_1170 0 n52 ns1170 0 -0.000219262820175
Gc26_1171 0 n52 ns1171 0 -0.00117234952474
Gc26_1172 0 n52 ns1172 0 -0.000783902050773
Gc26_1173 0 n52 ns1173 0 -0.000467808662521
Gc26_1174 0 n52 ns1174 0 -0.000693978020234
Gc26_1175 0 n52 ns1175 0 -5.955508037e-05
Gc26_1176 0 n52 ns1176 0 2.63509530866e-05
Gc26_1177 0 n52 ns1177 0 -6.03631126214e-05
Gc26_1178 0 n52 ns1178 0 1.52822797428e-05
Gc26_1179 0 n52 ns1179 0 0.000104983586143
Gc26_1180 0 n52 ns1180 0 0.000270742987486
Gc26_1181 0 n52 ns1181 0 0.000492352799997
Gc26_1182 0 n52 ns1182 0 -0.000403795360388
Gc26_1183 0 n52 ns1183 0 -4.8739286994e-05
Gc26_1184 0 n52 ns1184 0 1.47664358273e-05
Gc26_1185 0 n52 ns1185 0 8.17287050919e-05
Gc26_1186 0 n52 ns1186 0 -9.82388463773e-06
Gc26_1187 0 n52 ns1187 0 0.000209892470217
Gc26_1188 0 n52 ns1188 0 -3.64571194353e-05
Gc26_1189 0 n52 ns1189 0 -4.9628042892e-05
Gc26_1190 0 n52 ns1190 0 -3.23266748462e-06
Gc26_1191 0 n52 ns1191 0 -0.000222474968061
Gc26_1192 0 n52 ns1192 0 -6.26434159511e-06
Gc26_1193 0 n52 ns1193 0 -0.000383655089674
Gc26_1194 0 n52 ns1194 0 -0.000137888987317
Gc26_1195 0 n52 ns1195 0 -0.00030498398093
Gc26_1196 0 n52 ns1196 0 3.80179186044e-05
Gc26_1197 0 n52 ns1197 0 -0.000353305734068
Gc26_1198 0 n52 ns1198 0 8.43969014517e-06
Gc26_1199 0 n52 ns1199 0 0.000273747422692
Gc26_1200 0 n52 ns1200 0 -0.000152981126256
Gc26_1201 0 n52 ns1201 0 0.000712732271288
Gc26_1202 0 n52 ns1202 0 -0.0014181704798
Gc26_1203 0 n52 ns1203 0 0.000602482156205
Gc26_1204 0 n52 ns1204 0 -0.00126553981034
Gc26_1205 0 n52 ns1205 0 0.000200939254512
Gc26_1206 0 n52 ns1206 0 0.000289846888983
Gc26_1207 0 n52 ns1207 0 -0.00012900025238
Gc26_1208 0 n52 ns1208 0 -8.03931496732e-05
Gc26_1209 0 n52 ns1209 0 -0.00047079040553
Gc26_1210 0 n52 ns1210 0 -0.000195873916617
Gc26_1211 0 n52 ns1211 0 -0.000188699499798
Gc26_1212 0 n52 ns1212 0 1.20385513398e-06
Gc26_1213 0 n52 ns1213 0 6.12733842641e-05
Gc26_1214 0 n52 ns1214 0 6.06898503979e-06
Gc26_1215 0 n52 ns1215 0 1.05740432887e-05
Gc26_1216 0 n52 ns1216 0 -2.53492733798e-05
Gd26_1 0 n52 ni1 0 0.000108560323061
Gd26_2 0 n52 ni2 0 -0.00175719482234
Gd26_3 0 n52 ni3 0 -0.00324549580483
Gd26_4 0 n52 ni4 0 9.62235038006e-05
Gd26_5 0 n52 ni5 0 0.000337670361629
Gd26_6 0 n52 ni6 0 1.56822993118e-05
Gd26_7 0 n52 ni7 0 -0.000479459214692
Gd26_8 0 n52 ni8 0 0.00108702500274
Gd26_9 0 n52 ni9 0 -0.000439911294097
Gd26_10 0 n52 ni10 0 0.000318099804071
Gd26_11 0 n52 ni11 0 -0.000376073659953
Gd26_12 0 n52 ni12 0 0.000575663257446
Gd26_13 0 n52 ni13 0 0.000711487795816
Gd26_14 0 n52 ni14 0 -0.000847874365092
Gd26_15 0 n52 ni15 0 0.00083258845551
Gd26_16 0 n52 ni16 0 -2.28590838481e-05
Gd26_17 0 n52 ni17 0 -0.00239267818025
Gd26_18 0 n52 ni18 0 -0.00337258124844
Gd26_19 0 n52 ni19 0 -0.00115442320594
Gd26_20 0 n52 ni20 0 -0.00174481042036
Gd26_21 0 n52 ni21 0 0.000130780363641
Gd26_22 0 n52 ni22 0 0.000234690446799
Gd26_23 0 n52 ni23 0 0.000209881254915
Gd26_24 0 n52 ni24 0 -0.000138889000954
Gd26_25 0 n52 ni25 0 -5.2051965348e-05
Gd26_26 0 n52 ni26 0 0.00121691249428
Gd26_27 0 n52 ni27 0 -0.00193471261373
Gd26_28 0 n52 ni28 0 -0.000654895695074
Gd26_29 0 n52 ni29 0 6.620814324e-05
Gd26_30 0 n52 ni30 0 0.000762211285702
Gd26_31 0 n52 ni31 0 0.000121125867101
Gd26_32 0 n52 ni32 0 -3.35256192569e-05
Gc27_1 0 n54 ns1 0 -0.000403133966986
Gc27_2 0 n54 ns2 0 0.000114879877758
Gc27_3 0 n54 ns3 0 -0.00116070151943
Gc27_4 0 n54 ns4 0 0.00152411332108
Gc27_5 0 n54 ns5 0 -8.07028539464e-05
Gc27_6 0 n54 ns6 0 0.000132947509767
Gc27_7 0 n54 ns7 0 8.36287635663e-05
Gc27_8 0 n54 ns8 0 -0.000269217217097
Gc27_9 0 n54 ns9 0 -0.000692988611063
Gc27_10 0 n54 ns10 0 0.000666738080446
Gc27_11 0 n54 ns11 0 -3.99233970979e-05
Gc27_12 0 n54 ns12 0 -1.44136481023e-05
Gc27_13 0 n54 ns13 0 0.000975119591423
Gc27_14 0 n54 ns14 0 -0.000791197985294
Gc27_15 0 n54 ns15 0 -0.00101943942056
Gc27_16 0 n54 ns16 0 8.2134329094e-05
Gc27_17 0 n54 ns17 0 0.000448100377451
Gc27_18 0 n54 ns18 0 0.000289561295728
Gc27_19 0 n54 ns19 0 6.35294038675e-06
Gc27_20 0 n54 ns20 0 8.62473593313e-05
Gc27_21 0 n54 ns21 0 -0.000970886438428
Gc27_22 0 n54 ns22 0 0.00136296160937
Gc27_23 0 n54 ns23 0 0.00215934032916
Gc27_24 0 n54 ns24 0 -0.00149436926267
Gc27_25 0 n54 ns25 0 0.0018922008992
Gc27_26 0 n54 ns26 0 -0.00217081077749
Gc27_27 0 n54 ns27 0 -0.00090764540574
Gc27_28 0 n54 ns28 0 -0.000874090708265
Gc27_29 0 n54 ns29 0 0.000706251889891
Gc27_30 0 n54 ns30 0 -0.00107547985253
Gc27_31 0 n54 ns31 0 0.00107607540961
Gc27_32 0 n54 ns32 0 -0.00161641064986
Gc27_33 0 n54 ns33 0 0.00137836049667
Gc27_34 0 n54 ns34 0 -0.00213664004067
Gc27_35 0 n54 ns35 0 -0.00139435965138
Gc27_36 0 n54 ns36 0 -3.09036101134e-05
Gc27_37 0 n54 ns37 0 0.000131718871154
Gc27_38 0 n54 ns38 0 -1.28005035694e-05
Gc27_39 0 n54 ns39 0 -0.000760545475773
Gc27_40 0 n54 ns40 0 -5.99068419164e-05
Gc27_41 0 n54 ns41 0 -0.00245504360833
Gc27_42 0 n54 ns42 0 0.00143570051711
Gc27_43 0 n54 ns43 0 -0.00041637451949
Gc27_44 0 n54 ns44 0 0.000640929212405
Gc27_45 0 n54 ns45 0 0.000243363841998
Gc27_46 0 n54 ns46 0 -0.000385582477492
Gc27_47 0 n54 ns47 0 -0.000659515217887
Gc27_48 0 n54 ns48 0 0.000702392093606
Gc27_49 0 n54 ns49 0 -9.46800098754e-05
Gc27_50 0 n54 ns50 0 -3.98176409264e-05
Gc27_51 0 n54 ns51 0 0.000958785422601
Gc27_52 0 n54 ns52 0 -0.000637922533302
Gc27_53 0 n54 ns53 0 -0.000652801110536
Gc27_54 0 n54 ns54 0 -0.000145823515054
Gc27_55 0 n54 ns55 0 0.000755892563477
Gc27_56 0 n54 ns56 0 0.000198526333776
Gc27_57 0 n54 ns57 0 0.00036927084472
Gc27_58 0 n54 ns58 0 -9.52350713337e-05
Gc27_59 0 n54 ns59 0 -0.00146985647523
Gc27_60 0 n54 ns60 0 0.00107990982939
Gc27_61 0 n54 ns61 0 0.000617084221152
Gc27_62 0 n54 ns62 0 -0.00193063980615
Gc27_63 0 n54 ns63 0 0.000698524978979
Gc27_64 0 n54 ns64 0 -0.00268458674062
Gc27_65 0 n54 ns65 0 -0.000167507676575
Gc27_66 0 n54 ns66 0 -0.000721231614362
Gc27_67 0 n54 ns67 0 0.000899734197061
Gc27_68 0 n54 ns68 0 -0.00120214772172
Gc27_69 0 n54 ns69 0 0.000854517621457
Gc27_70 0 n54 ns70 0 -0.0018213480085
Gc27_71 0 n54 ns71 0 0.00198303330822
Gc27_72 0 n54 ns72 0 -0.00252307529314
Gc27_73 0 n54 ns73 0 -0.00201179457531
Gc27_74 0 n54 ns74 0 -2.61285252339e-05
Gc27_75 0 n54 ns75 0 0.000113646605556
Gc27_76 0 n54 ns76 0 -1.2502335138e-05
Gc27_77 0 n54 ns77 0 0.0012866582068
Gc27_78 0 n54 ns78 0 -0.00282368338624
Gc27_79 0 n54 ns79 0 0.00240949083286
Gc27_80 0 n54 ns80 0 -0.00468579033352
Gc27_81 0 n54 ns81 0 -0.00236322276685
Gc27_82 0 n54 ns82 0 -0.0013902969592
Gc27_83 0 n54 ns83 0 0.000832099088269
Gc27_84 0 n54 ns84 0 0.000583610434582
Gc27_85 0 n54 ns85 0 -0.000209521934385
Gc27_86 0 n54 ns86 0 -0.000210361665399
Gc27_87 0 n54 ns87 0 -0.000300753645519
Gc27_88 0 n54 ns88 0 -7.79986288014e-05
Gc27_89 0 n54 ns89 0 -0.000324315587472
Gc27_90 0 n54 ns90 0 0.000160681209076
Gc27_91 0 n54 ns91 0 0.00128849350953
Gc27_92 0 n54 ns92 0 -2.47707550164e-05
Gc27_93 0 n54 ns93 0 0.0012730718382
Gc27_94 0 n54 ns94 0 0.00014801459234
Gc27_95 0 n54 ns95 0 0.000830663858987
Gc27_96 0 n54 ns96 0 -3.65824407765e-05
Gc27_97 0 n54 ns97 0 -0.000339916834242
Gc27_98 0 n54 ns98 0 -0.00205790899346
Gc27_99 0 n54 ns99 0 -0.00307614530073
Gc27_100 0 n54 ns100 0 -0.00579965389698
Gc27_101 0 n54 ns101 0 -0.00218919780755
Gc27_102 0 n54 ns102 0 -0.00587321791924
Gc27_103 0 n54 ns103 0 0.00391198209557
Gc27_104 0 n54 ns104 0 0.0035910384454
Gc27_105 0 n54 ns105 0 0.001092405617
Gc27_106 0 n54 ns106 0 -0.00112103533318
Gc27_107 0 n54 ns107 0 -0.00259108733312
Gc27_108 0 n54 ns108 0 -0.0031428600013
Gc27_109 0 n54 ns109 0 0.00234913570665
Gc27_110 0 n54 ns110 0 0.00171436507281
Gc27_111 0 n54 ns111 0 -0.00372744778193
Gc27_112 0 n54 ns112 0 1.16060623903e-05
Gc27_113 0 n54 ns113 0 0.00024358764253
Gc27_114 0 n54 ns114 0 -0.000118063142609
Gc27_115 0 n54 ns115 0 0.00213713625396
Gc27_116 0 n54 ns116 0 -0.00318333114315
Gc27_117 0 n54 ns117 0 0.00468279424004
Gc27_118 0 n54 ns118 0 -0.00647666454449
Gc27_119 0 n54 ns119 0 -0.00338318831431
Gc27_120 0 n54 ns120 0 -0.00226945700446
Gc27_121 0 n54 ns121 0 0.00120224167481
Gc27_122 0 n54 ns122 0 0.000659663577076
Gc27_123 0 n54 ns123 0 -0.000278289524082
Gc27_124 0 n54 ns124 0 -0.000540021616404
Gc27_125 0 n54 ns125 0 -0.000276113916145
Gc27_126 0 n54 ns126 0 5.63043082827e-06
Gc27_127 0 n54 ns127 0 -0.000403686754809
Gc27_128 0 n54 ns128 0 -0.000341626926869
Gc27_129 0 n54 ns129 0 0.0014738868099
Gc27_130 0 n54 ns130 0 4.82396508768e-05
Gc27_131 0 n54 ns131 0 0.00102612476709
Gc27_132 0 n54 ns132 0 0.000222831793326
Gc27_133 0 n54 ns133 0 0.000427001170517
Gc27_134 0 n54 ns134 0 0.000414099124604
Gc27_135 0 n54 ns135 0 0.000881542656631
Gc27_136 0 n54 ns136 0 -0.00304242601906
Gc27_137 0 n54 ns137 0 -0.00222918055063
Gc27_138 0 n54 ns138 0 -0.00806547064206
Gc27_139 0 n54 ns139 0 -0.00155982087953
Gc27_140 0 n54 ns140 0 -0.00755062555053
Gc27_141 0 n54 ns141 0 0.00537055478183
Gc27_142 0 n54 ns142 0 0.00809302775892
Gc27_143 0 n54 ns143 0 0.0008208420125
Gc27_144 0 n54 ns144 0 -0.00122188016281
Gc27_145 0 n54 ns145 0 -0.00524651253901
Gc27_146 0 n54 ns146 0 -0.00598954187652
Gc27_147 0 n54 ns147 0 0.0014634818267
Gc27_148 0 n54 ns148 0 0.00530257591722
Gc27_149 0 n54 ns149 0 -0.00429856730458
Gc27_150 0 n54 ns150 0 1.51850674643e-06
Gc27_151 0 n54 ns151 0 0.000431191882628
Gc27_152 0 n54 ns152 0 -0.000237882489919
Gc27_153 0 n54 ns153 0 -0.00104155912851
Gc27_154 0 n54 ns154 0 6.11757317866e-05
Gc27_155 0 n54 ns155 0 -0.00309309380193
Gc27_156 0 n54 ns156 0 0.00149454026321
Gc27_157 0 n54 ns157 0 -0.000327643721665
Gc27_158 0 n54 ns158 0 0.00113517442787
Gc27_159 0 n54 ns159 0 0.000220926890808
Gc27_160 0 n54 ns160 0 -0.000492375839897
Gc27_161 0 n54 ns161 0 -0.00037509072479
Gc27_162 0 n54 ns162 0 0.00014179210476
Gc27_163 0 n54 ns163 0 -0.00015612160024
Gc27_164 0 n54 ns164 0 9.55582107934e-05
Gc27_165 0 n54 ns165 0 0.000943357553379
Gc27_166 0 n54 ns166 0 0.000124687067743
Gc27_167 0 n54 ns167 0 0.000326278083455
Gc27_168 0 n54 ns168 0 -0.000825226505856
Gc27_169 0 n54 ns169 0 0.00075218121911
Gc27_170 0 n54 ns170 0 -0.000477355182696
Gc27_171 0 n54 ns171 0 0.000458445991029
Gc27_172 0 n54 ns172 0 -0.000830253505055
Gc27_173 0 n54 ns173 0 -0.00230862734415
Gc27_174 0 n54 ns174 0 -6.25193425467e-05
Gc27_175 0 n54 ns175 0 -0.00606874310056
Gc27_176 0 n54 ns176 0 -0.00214673405813
Gc27_177 0 n54 ns177 0 -0.00493939264704
Gc27_178 0 n54 ns178 0 -0.00270893801106
Gc27_179 0 n54 ns179 0 0.00173752415701
Gc27_180 0 n54 ns180 0 0.000166027784619
Gc27_181 0 n54 ns181 0 0.00078566614623
Gc27_182 0 n54 ns182 0 -0.00118069261273
Gc27_183 0 n54 ns183 0 -0.000506963798032
Gc27_184 0 n54 ns184 0 -0.00192607468098
Gc27_185 0 n54 ns185 0 0.00240223749523
Gc27_186 0 n54 ns186 0 -0.0026125164667
Gc27_187 0 n54 ns187 0 -0.00252330899236
Gc27_188 0 n54 ns188 0 -1.00914306938e-05
Gc27_189 0 n54 ns189 0 0.000195610431667
Gc27_190 0 n54 ns190 0 -4.94124463893e-05
Gc27_191 0 n54 ns191 0 0.0002885940001
Gc27_192 0 n54 ns192 0 -0.000724807015118
Gc27_193 0 n54 ns193 0 0.000891746786594
Gc27_194 0 n54 ns194 0 6.83002549884e-05
Gc27_195 0 n54 ns195 0 4.706428882e-05
Gc27_196 0 n54 ns196 0 -0.000293730910102
Gc27_197 0 n54 ns197 0 -7.89290975127e-05
Gc27_198 0 n54 ns198 0 2.61711952287e-05
Gc27_199 0 n54 ns199 0 -0.000168628474419
Gc27_200 0 n54 ns200 0 0.000306517251515
Gc27_201 0 n54 ns201 0 -9.99876743772e-05
Gc27_202 0 n54 ns202 0 0.000121349230508
Gc27_203 0 n54 ns203 0 0.000421958181596
Gc27_204 0 n54 ns204 0 -0.000357820015729
Gc27_205 0 n54 ns205 0 -0.000387804270349
Gc27_206 0 n54 ns206 0 0.000397579514863
Gc27_207 0 n54 ns207 0 0.000280290309898
Gc27_208 0 n54 ns208 0 -0.00016993809091
Gc27_209 0 n54 ns209 0 -0.000230430551988
Gc27_210 0 n54 ns210 0 -8.39963370387e-05
Gc27_211 0 n54 ns211 0 -0.000445269671533
Gc27_212 0 n54 ns212 0 0.000715617464293
Gc27_213 0 n54 ns213 0 -0.00227722245008
Gc27_214 0 n54 ns214 0 -0.00321914414644
Gc27_215 0 n54 ns215 0 -0.00223564017841
Gc27_216 0 n54 ns216 0 -0.0033268401413
Gc27_217 0 n54 ns217 0 -0.000681040754801
Gc27_218 0 n54 ns218 0 0.00118045142248
Gc27_219 0 n54 ns219 0 7.9255655808e-05
Gc27_220 0 n54 ns220 0 -0.00120836363458
Gc27_221 0 n54 ns221 0 -0.000322054825672
Gc27_222 0 n54 ns222 0 -0.00284856634925
Gc27_223 0 n54 ns223 0 0.000546254567893
Gc27_224 0 n54 ns224 0 -0.00281225070039
Gc27_225 0 n54 ns225 0 -0.00114702845829
Gc27_226 0 n54 ns226 0 -3.3284601099e-05
Gc27_227 0 n54 ns227 0 9.46442342838e-05
Gc27_228 0 n54 ns228 0 -1.32146695331e-06
Gc27_229 0 n54 ns229 0 -2.16628140033e-05
Gc27_230 0 n54 ns230 0 0.000209560205935
Gc27_231 0 n54 ns231 0 0.000244918265501
Gc27_232 0 n54 ns232 0 0.000336274919236
Gc27_233 0 n54 ns233 0 -2.43881504983e-05
Gc27_234 0 n54 ns234 0 0.000203114606417
Gc27_235 0 n54 ns235 0 -4.37459372504e-05
Gc27_236 0 n54 ns236 0 -2.65079822906e-05
Gc27_237 0 n54 ns237 0 0.000449683035539
Gc27_238 0 n54 ns238 0 9.51522889465e-05
Gc27_239 0 n54 ns239 0 -6.49001711782e-05
Gc27_240 0 n54 ns240 0 6.02669060201e-05
Gc27_241 0 n54 ns241 0 -0.000331143792682
Gc27_242 0 n54 ns242 0 -9.19961681919e-05
Gc27_243 0 n54 ns243 0 0.000488030173016
Gc27_244 0 n54 ns244 0 0.000283566954157
Gc27_245 0 n54 ns245 0 0.000277729023255
Gc27_246 0 n54 ns246 0 -0.000431621103651
Gc27_247 0 n54 ns247 0 0.000139686210868
Gc27_248 0 n54 ns248 0 -0.000280341651499
Gc27_249 0 n54 ns249 0 5.31500012625e-05
Gc27_250 0 n54 ns250 0 -3.16793205297e-05
Gc27_251 0 n54 ns251 0 -0.00444626046361
Gc27_252 0 n54 ns252 0 -0.00303058527851
Gc27_253 0 n54 ns253 0 -0.00413529908069
Gc27_254 0 n54 ns254 0 -0.00272867983298
Gc27_255 0 n54 ns255 0 0.000146499659769
Gc27_256 0 n54 ns256 0 0.00204165740143
Gc27_257 0 n54 ns257 0 -0.000356763554215
Gc27_258 0 n54 ns258 0 -0.000759906485315
Gc27_259 0 n54 ns259 0 -0.00130278142304
Gc27_260 0 n54 ns260 0 -0.00229999493877
Gc27_261 0 n54 ns261 0 -0.000118280236971
Gc27_262 0 n54 ns262 0 -0.00185403514984
Gc27_263 0 n54 ns263 0 -0.000574421534831
Gc27_264 0 n54 ns264 0 -1.13790984403e-05
Gc27_265 0 n54 ns265 0 3.87449213586e-05
Gc27_266 0 n54 ns266 0 1.09999159854e-05
Gc27_267 0 n54 ns267 0 0.000425702143385
Gc27_268 0 n54 ns268 0 -0.000184556375457
Gc27_269 0 n54 ns269 0 0.00132063887247
Gc27_270 0 n54 ns270 0 -0.000460241857789
Gc27_271 0 n54 ns271 0 0.000356055722492
Gc27_272 0 n54 ns272 0 -6.5096904805e-05
Gc27_273 0 n54 ns273 0 -0.000153699361797
Gc27_274 0 n54 ns274 0 1.4216884666e-05
Gc27_275 0 n54 ns275 0 4.9687513404e-05
Gc27_276 0 n54 ns276 0 -0.000508122470244
Gc27_277 0 n54 ns277 0 -2.65938437623e-05
Gc27_278 0 n54 ns278 0 0.00012880875036
Gc27_279 0 n54 ns279 0 3.92033396347e-05
Gc27_280 0 n54 ns280 0 0.000402928024806
Gc27_281 0 n54 ns281 0 0.000193660446046
Gc27_282 0 n54 ns282 0 -0.000391609688496
Gc27_283 0 n54 ns283 0 -0.000289771008527
Gc27_284 0 n54 ns284 0 -0.000474374351559
Gc27_285 0 n54 ns285 0 -0.000435089883695
Gc27_286 0 n54 ns286 0 -0.000439486803899
Gc27_287 0 n54 ns287 0 -0.000198686454047
Gc27_288 0 n54 ns288 0 -0.000419370982431
Gc27_289 0 n54 ns289 0 -0.00443894355717
Gc27_290 0 n54 ns290 0 -0.000482926708295
Gc27_291 0 n54 ns291 0 -0.00396781285317
Gc27_292 0 n54 ns292 0 -0.000345616549218
Gc27_293 0 n54 ns293 0 0.000706124701451
Gc27_294 0 n54 ns294 0 0.00135022914302
Gc27_295 0 n54 ns295 0 -0.000357956779392
Gc27_296 0 n54 ns296 0 -0.00035507177967
Gc27_297 0 n54 ns297 0 -0.00134535623545
Gc27_298 0 n54 ns298 0 -0.00115403758536
Gc27_299 0 n54 ns299 0 -0.000228941468875
Gc27_300 0 n54 ns300 0 -0.00082113711861
Gc27_301 0 n54 ns301 0 -0.000239346331002
Gc27_302 0 n54 ns302 0 -7.03720265876e-06
Gc27_303 0 n54 ns303 0 -1.66090866317e-05
Gc27_304 0 n54 ns304 0 5.3845494864e-05
Gc27_305 0 n54 ns305 0 -0.000499230311864
Gc27_306 0 n54 ns306 0 0.000961377833637
Gc27_307 0 n54 ns307 0 -0.00136535428583
Gc27_308 0 n54 ns308 0 0.00134964216133
Gc27_309 0 n54 ns309 0 -0.000133791425651
Gc27_310 0 n54 ns310 0 0.000457203706333
Gc27_311 0 n54 ns311 0 5.05155815922e-05
Gc27_312 0 n54 ns312 0 -0.000302027842505
Gc27_313 0 n54 ns313 0 -0.00022038865273
Gc27_314 0 n54 ns314 0 1.35467268296e-05
Gc27_315 0 n54 ns315 0 0.000129172507856
Gc27_316 0 n54 ns316 0 7.17708356476e-05
Gc27_317 0 n54 ns317 0 0.000508727623981
Gc27_318 0 n54 ns318 0 -0.00045170014539
Gc27_319 0 n54 ns319 0 5.35042893971e-05
Gc27_320 0 n54 ns320 0 -0.000564353743787
Gc27_321 0 n54 ns321 0 -0.000277007992456
Gc27_322 0 n54 ns322 0 -0.000243651540759
Gc27_323 0 n54 ns323 0 -0.000285973397779
Gc27_324 0 n54 ns324 0 -0.000165509059927
Gc27_325 0 n54 ns325 0 -0.000572872877351
Gc27_326 0 n54 ns326 0 -8.28250643357e-05
Gc27_327 0 n54 ns327 0 -0.00323833357704
Gc27_328 0 n54 ns328 0 0.00101799398742
Gc27_329 0 n54 ns329 0 -0.00279049943233
Gc27_330 0 n54 ns330 0 0.000943378975651
Gc27_331 0 n54 ns331 0 0.000393598443298
Gc27_332 0 n54 ns332 0 0.000941006861197
Gc27_333 0 n54 ns333 0 -0.000203776166686
Gc27_334 0 n54 ns334 0 -0.00018777596886
Gc27_335 0 n54 ns335 0 -0.0007045686574
Gc27_336 0 n54 ns336 0 -0.000698772246615
Gc27_337 0 n54 ns337 0 -7.75043104207e-05
Gc27_338 0 n54 ns338 0 -0.000416645107604
Gc27_339 0 n54 ns339 0 -0.000141284766698
Gc27_340 0 n54 ns340 0 -1.49164957272e-05
Gc27_341 0 n54 ns341 0 4.74660524049e-05
Gc27_342 0 n54 ns342 0 2.40891818287e-06
Gc27_343 0 n54 ns343 0 -0.00075174808631
Gc27_344 0 n54 ns344 0 -0.000900895755944
Gc27_345 0 n54 ns345 0 -0.00328972587846
Gc27_346 0 n54 ns346 0 -0.00146073746418
Gc27_347 0 n54 ns347 0 -0.0018358294554
Gc27_348 0 n54 ns348 0 0.00104428867334
Gc27_349 0 n54 ns349 0 0.00072548439288
Gc27_350 0 n54 ns350 0 -0.00036103918745
Gc27_351 0 n54 ns351 0 -0.000280423771056
Gc27_352 0 n54 ns352 0 0.000455248668351
Gc27_353 0 n54 ns353 0 -0.000213990572665
Gc27_354 0 n54 ns354 0 -0.000102107213895
Gc27_355 0 n54 ns355 0 0.000208294064283
Gc27_356 0 n54 ns356 0 -1.16253147623e-05
Gc27_357 0 n54 ns357 0 0.000770674169701
Gc27_358 0 n54 ns358 0 -0.000363017310835
Gc27_359 0 n54 ns359 0 0.00138766006301
Gc27_360 0 n54 ns360 0 -7.47341933877e-06
Gc27_361 0 n54 ns361 0 0.00126912240113
Gc27_362 0 n54 ns362 0 -0.000348474431908
Gc27_363 0 n54 ns363 0 -0.00159843291979
Gc27_364 0 n54 ns364 0 -0.000623915619497
Gc27_365 0 n54 ns365 0 -0.00271793055443
Gc27_366 0 n54 ns366 0 -0.00416974995263
Gc27_367 0 n54 ns367 0 -0.00190762099966
Gc27_368 0 n54 ns368 0 -0.00453853872371
Gc27_369 0 n54 ns369 0 0.0028417668339
Gc27_370 0 n54 ns370 0 0.00126103770613
Gc27_371 0 n54 ns371 0 0.00106409904538
Gc27_372 0 n54 ns372 0 -0.00115859457903
Gc27_373 0 n54 ns373 0 -0.00136113233852
Gc27_374 0 n54 ns374 0 -0.00256888986025
Gc27_375 0 n54 ns375 0 0.00266178022825
Gc27_376 0 n54 ns376 0 -0.000277311766926
Gc27_377 0 n54 ns377 0 -0.00315919937937
Gc27_378 0 n54 ns378 0 -3.04900660132e-05
Gc27_379 0 n54 ns379 0 0.000272275711214
Gc27_380 0 n54 ns380 0 -0.000131172642427
Gc27_381 0 n54 ns381 0 -0.000511429785702
Gc27_382 0 n54 ns382 0 -0.000124219690656
Gc27_383 0 n54 ns383 0 0.000455017035614
Gc27_384 0 n54 ns384 0 0.00306289854749
Gc27_385 0 n54 ns385 0 0.00131251611865
Gc27_386 0 n54 ns386 0 -0.000835513195732
Gc27_387 0 n54 ns387 0 -0.000291438316251
Gc27_388 0 n54 ns388 0 2.8573498942e-05
Gc27_389 0 n54 ns389 0 0.000402572805386
Gc27_390 0 n54 ns390 0 0.000221033307612
Gc27_391 0 n54 ns391 0 -0.000194334800976
Gc27_392 0 n54 ns392 0 -1.90918750981e-05
Gc27_393 0 n54 ns393 0 0.00181813095737
Gc27_394 0 n54 ns394 0 -0.000783177082881
Gc27_395 0 n54 ns395 0 -0.000170938973605
Gc27_396 0 n54 ns396 0 0.00135202433307
Gc27_397 0 n54 ns397 0 -9.79380754052e-05
Gc27_398 0 n54 ns398 0 -9.6637845909e-05
Gc27_399 0 n54 ns399 0 -0.00167581653618
Gc27_400 0 n54 ns400 0 -0.0014477741162
Gc27_401 0 n54 ns401 0 0.00323024277703
Gc27_402 0 n54 ns402 0 0.00371755268841
Gc27_403 0 n54 ns403 0 -0.00947980500411
Gc27_404 0 n54 ns404 0 -0.000953691181295
Gc27_405 0 n54 ns405 0 -0.00720893161937
Gc27_406 0 n54 ns406 0 -0.00207825751729
Gc27_407 0 n54 ns407 0 -0.0111791332565
Gc27_408 0 n54 ns408 0 -0.000343482177646
Gc27_409 0 n54 ns409 0 0.00151930886092
Gc27_410 0 n54 ns410 0 -1.69610471109e-05
Gc27_411 0 n54 ns411 0 -0.00327598972994
Gc27_412 0 n54 ns412 0 0.00837678495294
Gc27_413 0 n54 ns413 0 -0.0141830309884
Gc27_414 0 n54 ns414 0 -0.0040978405082
Gc27_415 0 n54 ns415 0 -0.00626009851866
Gc27_416 0 n54 ns416 0 -6.18522920254e-05
Gc27_417 0 n54 ns417 0 -0.000388425235617
Gc27_418 0 n54 ns418 0 0.000610160331541
Gc27_419 0 n54 ns419 0 -0.00133117511457
Gc27_420 0 n54 ns420 0 -4.4370198998e-05
Gc27_421 0 n54 ns421 0 -0.00471353924398
Gc27_422 0 n54 ns422 0 -0.00055114092418
Gc27_423 0 n54 ns423 0 -0.00210418241703
Gc27_424 0 n54 ns424 0 0.00147859521321
Gc27_425 0 n54 ns425 0 0.000951203969118
Gc27_426 0 n54 ns426 0 -0.000674744324162
Gc27_427 0 n54 ns427 0 -0.000345301585136
Gc27_428 0 n54 ns428 0 0.000161330803873
Gc27_429 0 n54 ns429 0 -0.000163597888911
Gc27_430 0 n54 ns430 0 5.71950574753e-05
Gc27_431 0 n54 ns431 0 0.000841549155305
Gc27_432 0 n54 ns432 0 -3.81821010461e-05
Gc27_433 0 n54 ns433 0 0.00111413855377
Gc27_434 0 n54 ns434 0 -0.00103383368166
Gc27_435 0 n54 ns435 0 0.00115027024203
Gc27_436 0 n54 ns436 0 -0.000440657190182
Gc27_437 0 n54 ns437 0 0.00101550587536
Gc27_438 0 n54 ns438 0 -0.000711415749503
Gc27_439 0 n54 ns439 0 -0.00218713678114
Gc27_440 0 n54 ns440 0 -0.000845348722096
Gc27_441 0 n54 ns441 0 -0.00646445011918
Gc27_442 0 n54 ns442 0 -0.00318311013765
Gc27_443 0 n54 ns443 0 -0.00513592054549
Gc27_444 0 n54 ns444 0 -0.00358761186541
Gc27_445 0 n54 ns445 0 0.00337701912303
Gc27_446 0 n54 ns446 0 0.00220599333205
Gc27_447 0 n54 ns447 0 0.000859712112601
Gc27_448 0 n54 ns448 0 -0.00123383184084
Gc27_449 0 n54 ns449 0 -0.00203673271606
Gc27_450 0 n54 ns450 0 -0.00311308997476
Gc27_451 0 n54 ns451 0 0.00248231280088
Gc27_452 0 n54 ns452 0 -0.000717298992601
Gc27_453 0 n54 ns453 0 -0.00322303450156
Gc27_454 0 n54 ns454 0 -4.94161511723e-05
Gc27_455 0 n54 ns455 0 0.000378890890435
Gc27_456 0 n54 ns456 0 -0.000174270301107
Gc27_457 0 n54 ns457 0 8.31799364393e-05
Gc27_458 0 n54 ns458 0 -0.000554927848397
Gc27_459 0 n54 ns459 0 0.000376232439311
Gc27_460 0 n54 ns460 0 0.00099876648045
Gc27_461 0 n54 ns461 0 0.000201948528121
Gc27_462 0 n54 ns462 0 4.69885494922e-05
Gc27_463 0 n54 ns463 0 -7.5130524391e-05
Gc27_464 0 n54 ns464 0 -0.000151028280073
Gc27_465 0 n54 ns465 0 -0.000342784889295
Gc27_466 0 n54 ns466 0 0.000265692012635
Gc27_467 0 n54 ns467 0 -0.000117972770638
Gc27_468 0 n54 ns468 0 0.000114383795399
Gc27_469 0 n54 ns469 0 0.000726777010444
Gc27_470 0 n54 ns470 0 -0.000335600818815
Gc27_471 0 n54 ns471 0 -0.000488536397984
Gc27_472 0 n54 ns472 0 -0.000114844496999
Gc27_473 0 n54 ns473 0 0.000347973243372
Gc27_474 0 n54 ns474 0 -0.000308187463954
Gc27_475 0 n54 ns475 0 -0.000199126113625
Gc27_476 0 n54 ns476 0 -0.000437459211368
Gc27_477 0 n54 ns477 0 -0.00100780244709
Gc27_478 0 n54 ns478 0 0.000879450360897
Gc27_479 0 n54 ns479 0 -0.00266791594525
Gc27_480 0 n54 ns480 0 -0.00224751681202
Gc27_481 0 n54 ns481 0 -0.00244038308436
Gc27_482 0 n54 ns482 0 -0.00268809819719
Gc27_483 0 n54 ns483 0 -0.000155451371598
Gc27_484 0 n54 ns484 0 0.000741557427187
Gc27_485 0 n54 ns485 0 0.000291331154575
Gc27_486 0 n54 ns486 0 -0.0012990631341
Gc27_487 0 n54 ns487 0 -0.000251940738102
Gc27_488 0 n54 ns488 0 -0.00276635100462
Gc27_489 0 n54 ns489 0 0.00100105210389
Gc27_490 0 n54 ns490 0 -0.00321608670965
Gc27_491 0 n54 ns491 0 -0.00156047913551
Gc27_492 0 n54 ns492 0 -2.5604599854e-05
Gc27_493 0 n54 ns493 0 9.83824064124e-05
Gc27_494 0 n54 ns494 0 5.78948081284e-06
Gc27_495 0 n54 ns495 0 -0.000135843351794
Gc27_496 0 n54 ns496 0 0.00013103375027
Gc27_497 0 n54 ns497 0 -9.81842788415e-05
Gc27_498 0 n54 ns498 0 0.000567027972924
Gc27_499 0 n54 ns499 0 -0.000181809217986
Gc27_500 0 n54 ns500 0 0.000193755456635
Gc27_501 0 n54 ns501 0 -1.11694829148e-05
Gc27_502 0 n54 ns502 0 -8.64031676794e-05
Gc27_503 0 n54 ns503 0 0.00034322048899
Gc27_504 0 n54 ns504 0 0.000363849464885
Gc27_505 0 n54 ns505 0 -6.76731595153e-05
Gc27_506 0 n54 ns506 0 6.04544883126e-05
Gc27_507 0 n54 ns507 0 -0.000172366686977
Gc27_508 0 n54 ns508 0 -0.000396129451304
Gc27_509 0 n54 ns509 0 0.000308504435512
Gc27_510 0 n54 ns510 0 0.000524147168256
Gc27_511 0 n54 ns511 0 0.000416269330696
Gc27_512 0 n54 ns512 0 -0.000313599416712
Gc27_513 0 n54 ns513 0 0.000187562365685
Gc27_514 0 n54 ns514 0 -0.000115858600421
Gc27_515 0 n54 ns515 0 -3.1055729728e-05
Gc27_516 0 n54 ns516 0 0.000264947949077
Gc27_517 0 n54 ns517 0 -0.00395510276991
Gc27_518 0 n54 ns518 0 -0.00366171021101
Gc27_519 0 n54 ns519 0 -0.00374886872657
Gc27_520 0 n54 ns520 0 -0.00341291339012
Gc27_521 0 n54 ns521 0 -0.000238800141321
Gc27_522 0 n54 ns522 0 0.00204928216217
Gc27_523 0 n54 ns523 0 -0.000263369175223
Gc27_524 0 n54 ns524 0 -0.000955681550945
Gc27_525 0 n54 ns525 0 -0.00104418277709
Gc27_526 0 n54 ns526 0 -0.00270799024353
Gc27_527 0 n54 ns527 0 2.98955298591e-05
Gc27_528 0 n54 ns528 0 -0.00224137821016
Gc27_529 0 n54 ns529 0 -0.00074457282396
Gc27_530 0 n54 ns530 0 -1.80240452966e-05
Gc27_531 0 n54 ns531 0 8.18086540871e-05
Gc27_532 0 n54 ns532 0 -1.14523141563e-05
Gc27_533 0 n54 ns533 0 0.000344944033355
Gc27_534 0 n54 ns534 0 -0.000178820118396
Gc27_535 0 n54 ns535 0 0.00127276549462
Gc27_536 0 n54 ns536 0 -0.000403791507402
Gc27_537 0 n54 ns537 0 0.000236368744463
Gc27_538 0 n54 ns538 0 -2.84956003224e-05
Gc27_539 0 n54 ns539 0 -7.9240373936e-05
Gc27_540 0 n54 ns540 0 5.39998609792e-05
Gc27_541 0 n54 ns541 0 0.000303669750991
Gc27_542 0 n54 ns542 0 -0.00038866523481
Gc27_543 0 n54 ns543 0 -7.29742698305e-05
Gc27_544 0 n54 ns544 0 0.000108827213423
Gc27_545 0 n54 ns545 0 -0.000187184408845
Gc27_546 0 n54 ns546 0 0.000396053936992
Gc27_547 0 n54 ns547 0 0.000410315147828
Gc27_548 0 n54 ns548 0 -0.000207016162397
Gc27_549 0 n54 ns549 0 -7.87903859036e-05
Gc27_550 0 n54 ns550 0 -0.000562077813892
Gc27_551 0 n54 ns551 0 -0.000214336392134
Gc27_552 0 n54 ns552 0 -0.000516239979543
Gc27_553 0 n54 ns553 0 -3.9449543492e-05
Gc27_554 0 n54 ns554 0 -0.000358577142138
Gc27_555 0 n54 ns555 0 -0.00472460409885
Gc27_556 0 n54 ns556 0 -0.00139361778231
Gc27_557 0 n54 ns557 0 -0.00428455601844
Gc27_558 0 n54 ns558 0 -0.00117194281624
Gc27_559 0 n54 ns559 0 0.000619392284244
Gc27_560 0 n54 ns560 0 0.00170395320268
Gc27_561 0 n54 ns561 0 -0.000386942076821
Gc27_562 0 n54 ns562 0 -0.00049224809986
Gc27_563 0 n54 ns563 0 -0.00143217901851
Gc27_564 0 n54 ns564 0 -0.00162889643815
Gc27_565 0 n54 ns565 0 -0.000240540843888
Gc27_566 0 n54 ns566 0 -0.00133195590072
Gc27_567 0 n54 ns567 0 -0.000379980776316
Gc27_568 0 n54 ns568 0 -2.61898173284e-06
Gc27_569 0 n54 ns569 0 2.78845137477e-05
Gc27_570 0 n54 ns570 0 2.55609590252e-05
Gc27_571 0 n54 ns571 0 -0.000239849759023
Gc27_572 0 n54 ns572 0 0.000663149761036
Gc27_573 0 n54 ns573 0 -0.000542636788403
Gc27_574 0 n54 ns574 0 0.00106775759081
Gc27_575 0 n54 ns575 0 -1.3062056695e-05
Gc27_576 0 n54 ns576 0 0.000369214497102
Gc27_577 0 n54 ns577 0 1.98828108093e-05
Gc27_578 0 n54 ns578 0 -0.000259116075399
Gc27_579 0 n54 ns579 0 -0.000150442370704
Gc27_580 0 n54 ns580 0 -0.00014524233187
Gc27_581 0 n54 ns581 0 0.000102113843926
Gc27_582 0 n54 ns582 0 9.5240899825e-05
Gc27_583 0 n54 ns583 0 0.000422639236492
Gc27_584 0 n54 ns584 0 -0.000291546250046
Gc27_585 0 n54 ns585 0 9.84756476386e-05
Gc27_586 0 n54 ns586 0 -0.000657163688639
Gc27_587 0 n54 ns587 0 -0.000318286073075
Gc27_588 0 n54 ns588 0 -0.000374303087336
Gc27_589 0 n54 ns589 0 -0.000344787223612
Gc27_590 0 n54 ns590 0 -0.000322338918735
Gc27_591 0 n54 ns591 0 -0.000505858007448
Gc27_592 0 n54 ns592 0 -0.000102029696274
Gc27_593 0 n54 ns593 0 -0.00386365307422
Gc27_594 0 n54 ns594 0 0.00103746827702
Gc27_595 0 n54 ns595 0 -0.0033650699203
Gc27_596 0 n54 ns596 0 0.000963255995011
Gc27_597 0 n54 ns597 0 0.00066680347136
Gc27_598 0 n54 ns598 0 0.00123351535137
Gc27_599 0 n54 ns599 0 -0.000285605555868
Gc27_600 0 n54 ns600 0 -0.000251036317535
Gc27_601 0 n54 ns601 0 -0.00105447418313
Gc27_602 0 n54 ns602 0 -0.000973168266994
Gc27_603 0 n54 ns603 0 -0.000168092839272
Gc27_604 0 n54 ns604 0 -0.000758336849688
Gc27_605 0 n54 ns605 0 -0.000219634013047
Gc27_606 0 n54 ns606 0 2.95557759241e-07
Gc27_607 0 n54 ns607 0 1.54078711046e-05
Gc27_608 0 n54 ns608 0 2.58008719156e-05
Gc27_609 0 n54 ns609 0 0.000342233100088
Gc27_610 0 n54 ns610 0 -0.000621893909879
Gc27_611 0 n54 ns611 0 0.000991885763936
Gc27_612 0 n54 ns612 0 0.000301454521523
Gc27_613 0 n54 ns613 0 -0.000188566565273
Gc27_614 0 n54 ns614 0 0.00034929562203
Gc27_615 0 n54 ns615 0 -4.44986374538e-05
Gc27_616 0 n54 ns616 0 4.77350980673e-05
Gc27_617 0 n54 ns617 0 0.000639860230358
Gc27_618 0 n54 ns618 0 -0.00026930387764
Gc27_619 0 n54 ns619 0 0.000169656318101
Gc27_620 0 n54 ns620 0 4.44695956357e-05
Gc27_621 0 n54 ns621 0 2.38535974514e-05
Gc27_622 0 n54 ns622 0 -0.000442649217898
Gc27_623 0 n54 ns623 0 -0.001552852464
Gc27_624 0 n54 ns624 0 -0.000274511298837
Gc27_625 0 n54 ns625 0 0.000215634720476
Gc27_626 0 n54 ns626 0 -8.31770967548e-05
Gc27_627 0 n54 ns627 0 -0.000247040619129
Gc27_628 0 n54 ns628 0 -0.000717223817922
Gc27_629 0 n54 ns629 0 0.00140679562088
Gc27_630 0 n54 ns630 0 -0.00133406919426
Gc27_631 0 n54 ns631 0 -0.00134449974335
Gc27_632 0 n54 ns632 0 0.0019828943641
Gc27_633 0 n54 ns633 0 -0.00124113318065
Gc27_634 0 n54 ns634 0 0.00256390531044
Gc27_635 0 n54 ns635 0 -0.00161289171808
Gc27_636 0 n54 ns636 0 -0.00231340760446
Gc27_637 0 n54 ns637 0 0.000754063890559
Gc27_638 0 n54 ns638 0 -0.000914438331354
Gc27_639 0 n54 ns639 0 0.00120536211418
Gc27_640 0 n54 ns640 0 -0.000260612281754
Gc27_641 0 n54 ns641 0 -0.0012142374286
Gc27_642 0 n54 ns642 0 0.00250836918789
Gc27_643 0 n54 ns643 0 0.00149251738344
Gc27_644 0 n54 ns644 0 4.30069463251e-05
Gc27_645 0 n54 ns645 0 -0.000325510538347
Gc27_646 0 n54 ns646 0 0.000127411853175
Gc27_647 0 n54 ns647 0 0.000753600303056
Gc27_648 0 n54 ns648 0 -0.00220401171059
Gc27_649 0 n54 ns649 0 0.00189671921559
Gc27_650 0 n54 ns650 0 -0.00168368772399
Gc27_651 0 n54 ns651 0 -0.000399127580439
Gc27_652 0 n54 ns652 0 -8.92910581294e-05
Gc27_653 0 n54 ns653 0 5.08886247232e-05
Gc27_654 0 n54 ns654 0 3.49050277152e-05
Gc27_655 0 n54 ns655 0 0.00054291310056
Gc27_656 0 n54 ns656 0 -0.000359643471251
Gc27_657 0 n54 ns657 0 0.000172420349982
Gc27_658 0 n54 ns658 0 7.98774536929e-05
Gc27_659 0 n54 ns659 0 -0.000112705495572
Gc27_660 0 n54 ns660 0 0.000229360257927
Gc27_661 0 n54 ns661 0 -0.00129829462366
Gc27_662 0 n54 ns662 0 -0.000232594580853
Gc27_663 0 n54 ns663 0 0.000372953801698
Gc27_664 0 n54 ns664 0 9.8490821157e-06
Gc27_665 0 n54 ns665 0 -0.000249800600088
Gc27_666 0 n54 ns666 0 -0.000596771218003
Gc27_667 0 n54 ns667 0 0.00159980759873
Gc27_668 0 n54 ns668 0 -0.000937714537383
Gc27_669 0 n54 ns669 0 -0.000782865331184
Gc27_670 0 n54 ns670 0 0.00208087467801
Gc27_671 0 n54 ns671 0 -0.000838118819914
Gc27_672 0 n54 ns672 0 0.00279545862687
Gc27_673 0 n54 ns673 0 -0.000970673734909
Gc27_674 0 n54 ns674 0 -0.0026280863964
Gc27_675 0 n54 ns675 0 0.000987815553452
Gc27_676 0 n54 ns676 0 -0.000991333175729
Gc27_677 0 n54 ns677 0 0.00115585408506
Gc27_678 0 n54 ns678 0 -0.000168129466489
Gc27_679 0 n54 ns679 0 -0.00194440660188
Gc27_680 0 n54 ns680 0 0.00272694824367
Gc27_681 0 n54 ns681 0 0.00208606759924
Gc27_682 0 n54 ns682 0 1.81882268417e-05
Gc27_683 0 n54 ns683 0 -0.000262814547684
Gc27_684 0 n54 ns684 0 9.83460493725e-05
Gc27_685 0 n54 ns685 0 0.00115918439931
Gc27_686 0 n54 ns686 0 -0.00500780334854
Gc27_687 0 n54 ns687 0 0.00102874573695
Gc27_688 0 n54 ns688 0 -0.0037883181259
Gc27_689 0 n54 ns689 0 -0.00115518961381
Gc27_690 0 n54 ns690 0 -0.000769234153587
Gc27_691 0 n54 ns691 0 0.000597916857373
Gc27_692 0 n54 ns692 0 -9.06553009876e-05
Gc27_693 0 n54 ns693 0 -0.000124609687313
Gc27_694 0 n54 ns694 0 0.000193195413724
Gc27_695 0 n54 ns695 0 0.000280393822543
Gc27_696 0 n54 ns696 0 5.59867620276e-05
Gc27_697 0 n54 ns697 0 -0.000365508412146
Gc27_698 0 n54 ns698 0 0.000668078805679
Gc27_699 0 n54 ns699 0 0.000675405043482
Gc27_700 0 n54 ns700 0 9.30563151713e-06
Gc27_701 0 n54 ns701 0 0.000940069654734
Gc27_702 0 n54 ns702 0 -4.85176453549e-05
Gc27_703 0 n54 ns703 0 0.00031335132343
Gc27_704 0 n54 ns704 0 -0.000587830245146
Gc27_705 0 n54 ns705 0 0.000305410004783
Gc27_706 0 n54 ns706 0 0.00131099612524
Gc27_707 0 n54 ns707 0 0.0035910412632
Gc27_708 0 n54 ns708 0 0.00631338962855
Gc27_709 0 n54 ns709 0 0.00254615007962
Gc27_710 0 n54 ns710 0 0.00630515716035
Gc27_711 0 n54 ns711 0 0.00206729297378
Gc27_712 0 n54 ns712 0 0.00174560909016
Gc27_713 0 n54 ns713 0 0.00107925075284
Gc27_714 0 n54 ns714 0 -0.00093838365279
Gc27_715 0 n54 ns715 0 -0.00347107722468
Gc27_716 0 n54 ns716 0 -0.00112784035112
Gc27_717 0 n54 ns717 0 -0.000451975463721
Gc27_718 0 n54 ns718 0 -0.00197961927869
Gc27_719 0 n54 ns719 0 0.00383847384672
Gc27_720 0 n54 ns720 0 9.33220371818e-07
Gc27_721 0 n54 ns721 0 -0.000101327226448
Gc27_722 0 n54 ns722 0 -1.13554725518e-05
Gc27_723 0 n54 ns723 0 0.000988751983134
Gc27_724 0 n54 ns724 0 -0.00408983799193
Gc27_725 0 n54 ns725 0 -0.000437253361443
Gc27_726 0 n54 ns726 0 -0.00148284682268
Gc27_727 0 n54 ns727 0 -0.00092926030436
Gc27_728 0 n54 ns728 0 -0.000145980728401
Gc27_729 0 n54 ns729 0 0.000456838684661
Gc27_730 0 n54 ns730 0 -0.000125088060398
Gc27_731 0 n54 ns731 0 -4.51248224023e-05
Gc27_732 0 n54 ns732 0 0.000420273896453
Gc27_733 0 n54 ns733 0 0.000289202551854
Gc27_734 0 n54 ns734 0 -1.00522595789e-05
Gc27_735 0 n54 ns735 0 -0.000361334168361
Gc27_736 0 n54 ns736 0 -0.000318592303557
Gc27_737 0 n54 ns737 0 0.000337729211042
Gc27_738 0 n54 ns738 0 -6.28787060411e-05
Gc27_739 0 n54 ns739 0 0.000546125760715
Gc27_740 0 n54 ns740 0 -0.000416697291236
Gc27_741 0 n54 ns741 0 -0.000115590237838
Gc27_742 0 n54 ns742 0 -0.00132800340646
Gc27_743 0 n54 ns743 0 -0.000276469082564
Gc27_744 0 n54 ns744 0 0.000355675505437
Gc27_745 0 n54 ns745 0 0.00686441121352
Gc27_746 0 n54 ns746 0 0.00735519953271
Gc27_747 0 n54 ns747 0 0.00519011234371
Gc27_748 0 n54 ns748 0 0.00703955715447
Gc27_749 0 n54 ns749 0 0.000672390219182
Gc27_750 0 n54 ns750 0 0.00528660886882
Gc27_751 0 n54 ns751 0 0.000858287038082
Gc27_752 0 n54 ns752 0 -0.000917446869394
Gc27_753 0 n54 ns753 0 -0.0063351714816
Gc27_754 0 n54 ns754 0 -0.0019787063975
Gc27_755 0 n54 ns755 0 0.00324862278749
Gc27_756 0 n54 ns756 0 -0.00524263016316
Gc27_757 0 n54 ns757 0 0.00456084392654
Gc27_758 0 n54 ns758 0 -4.5044477952e-07
Gc27_759 0 n54 ns759 0 -2.04289468394e-06
Gc27_760 0 n54 ns760 0 -5.85200019892e-05
Gc27_761 0 n54 ns761 0 0.000460317746338
Gc27_762 0 n54 ns762 0 -0.00188856643426
Gc27_763 0 n54 ns763 0 0.00112152145979
Gc27_764 0 n54 ns764 0 -0.00153685909092
Gc27_765 0 n54 ns765 0 -0.000786586557016
Gc27_766 0 n54 ns766 0 -7.31341739064e-05
Gc27_767 0 n54 ns767 0 0.000170909298096
Gc27_768 0 n54 ns768 0 -0.00022191652795
Gc27_769 0 n54 ns769 0 0.000271540309133
Gc27_770 0 n54 ns770 0 0.000153965892809
Gc27_771 0 n54 ns771 0 0.000191253909669
Gc27_772 0 n54 ns772 0 -2.79080211126e-05
Gc27_773 0 n54 ns773 0 4.12010738258e-05
Gc27_774 0 n54 ns774 0 0.000413842348192
Gc27_775 0 n54 ns775 0 0.000160689857715
Gc27_776 0 n54 ns776 0 -0.000907430376163
Gc27_777 0 n54 ns777 0 0.000679133814457
Gc27_778 0 n54 ns778 0 -0.000478326611512
Gc27_779 0 n54 ns779 0 0.000326140523255
Gc27_780 0 n54 ns780 0 -0.000793306653584
Gc27_781 0 n54 ns781 0 0.00162958276422
Gc27_782 0 n54 ns782 0 0.00115080828365
Gc27_783 0 n54 ns783 0 0.0023971347047
Gc27_784 0 n54 ns784 0 0.00377323615679
Gc27_785 0 n54 ns785 0 0.00192915574835
Gc27_786 0 n54 ns786 0 0.00400813282451
Gc27_787 0 n54 ns787 0 0.00146892344453
Gc27_788 0 n54 ns788 0 -0.00202849228003
Gc27_789 0 n54 ns789 0 0.000861819010054
Gc27_790 0 n54 ns790 0 -0.00092077330903
Gc27_791 0 n54 ns791 0 -0.00036492432923
Gc27_792 0 n54 ns792 0 -0.00026064324824
Gc27_793 0 n54 ns793 0 -0.00322182775089
Gc27_794 0 n54 ns794 0 0.00260591344942
Gc27_795 0 n54 ns795 0 0.0026878346507
Gc27_796 0 n54 ns796 0 2.83563237972e-05
Gc27_797 0 n54 ns797 0 -0.000118187187318
Gc27_798 0 n54 ns798 0 1.76143978501e-05
Gc27_799 0 n54 ns799 0 -0.000323352035013
Gc27_800 0 n54 ns800 0 0.000124337285056
Gc27_801 0 n54 ns801 0 -0.000633292896155
Gc27_802 0 n54 ns802 0 0.000518333119682
Gc27_803 0 n54 ns803 0 -0.000109155320946
Gc27_804 0 n54 ns804 0 0.000434426985704
Gc27_805 0 n54 ns805 0 4.76664583515e-05
Gc27_806 0 n54 ns806 0 -8.40872987129e-05
Gc27_807 0 n54 ns807 0 9.89320880856e-05
Gc27_808 0 n54 ns808 0 -0.000241063682452
Gc27_809 0 n54 ns809 0 0.000150242977671
Gc27_810 0 n54 ns810 0 -7.52086761846e-05
Gc27_811 0 n54 ns811 0 1.68962331093e-05
Gc27_812 0 n54 ns812 0 -0.00034458022654
Gc27_813 0 n54 ns813 0 -0.000581969162243
Gc27_814 0 n54 ns814 0 0.000300022764461
Gc27_815 0 n54 ns815 0 0.000199405037062
Gc27_816 0 n54 ns816 0 -0.000342092216477
Gc27_817 0 n54 ns817 0 -0.000327404857483
Gc27_818 0 n54 ns818 0 -0.000512316253005
Gc27_819 0 n54 ns819 0 0.000284643911607
Gc27_820 0 n54 ns820 0 -0.00112925551697
Gc27_821 0 n54 ns821 0 0.00139188935697
Gc27_822 0 n54 ns822 0 0.00238729447526
Gc27_823 0 n54 ns823 0 0.00146400725785
Gc27_824 0 n54 ns824 0 0.00264100784621
Gc27_825 0 n54 ns825 0 -0.00213511746549
Gc27_826 0 n54 ns826 0 -0.000700560841765
Gc27_827 0 n54 ns827 0 0.000234454415279
Gc27_828 0 n54 ns828 0 -0.000980336808856
Gc27_829 0 n54 ns829 0 0.000482538214656
Gc27_830 0 n54 ns830 0 -0.000928414954766
Gc27_831 0 n54 ns831 0 -0.000834092801774
Gc27_832 0 n54 ns832 0 0.0024032351636
Gc27_833 0 n54 ns833 0 0.00113155051335
Gc27_834 0 n54 ns834 0 2.0269742853e-05
Gc27_835 0 n54 ns835 0 -0.000172558831385
Gc27_836 0 n54 ns836 0 4.85094078519e-05
Gc27_837 0 n54 ns837 0 -0.000106208543437
Gc27_838 0 n54 ns838 0 0.000157607793836
Gc27_839 0 n54 ns839 0 3.16536556791e-05
Gc27_840 0 n54 ns840 0 0.00105427560339
Gc27_841 0 n54 ns841 0 7.05216012043e-07
Gc27_842 0 n54 ns842 0 0.000151931983487
Gc27_843 0 n54 ns843 0 0.000115989097676
Gc27_844 0 n54 ns844 0 -0.000153542701549
Gc27_845 0 n54 ns845 0 -0.000183663977769
Gc27_846 0 n54 ns846 0 0.00010963563076
Gc27_847 0 n54 ns847 0 0.000101557284418
Gc27_848 0 n54 ns848 0 -0.000159640131164
Gc27_849 0 n54 ns849 0 -0.000258990881721
Gc27_850 0 n54 ns850 0 -0.000293260260379
Gc27_851 0 n54 ns851 0 0.000547365744994
Gc27_852 0 n54 ns852 0 0.00022841320802
Gc27_853 0 n54 ns853 0 0.000284490126497
Gc27_854 0 n54 ns854 0 -0.000505848010807
Gc27_855 0 n54 ns855 0 8.93179409143e-05
Gc27_856 0 n54 ns856 0 -0.000395770885074
Gc27_857 0 n54 ns857 0 -0.000489519414152
Gc27_858 0 n54 ns858 0 0.000296770195917
Gc27_859 0 n54 ns859 0 0.00261137595599
Gc27_860 0 n54 ns860 0 0.0032782157955
Gc27_861 0 n54 ns861 0 0.00261321998041
Gc27_862 0 n54 ns862 0 0.00291974741734
Gc27_863 0 n54 ns863 0 -0.000485800108814
Gc27_864 0 n54 ns864 0 0.00134077017222
Gc27_865 0 n54 ns865 0 -0.000269178757587
Gc27_866 0 n54 ns866 0 -0.000700084280827
Gc27_867 0 n54 ns867 0 -0.000903605352671
Gc27_868 0 n54 ns868 0 -0.00169350233897
Gc27_869 0 n54 ns869 0 -0.000600792028249
Gc27_870 0 n54 ns870 0 -6.27602761672e-05
Gc27_871 0 n54 ns871 0 0.000224492844434
Gc27_872 0 n54 ns872 0 1.04344779112e-05
Gc27_873 0 n54 ns873 0 -7.55452490813e-05
Gc27_874 0 n54 ns874 0 -7.52827688606e-06
Gc27_875 0 n54 ns875 0 -1.59113257069e-05
Gc27_876 0 n54 ns876 0 0.000367067709756
Gc27_877 0 n54 ns877 0 4.55001521885e-05
Gc27_878 0 n54 ns878 0 0.000507139714172
Gc27_879 0 n54 ns879 0 -7.69378299308e-05
Gc27_880 0 n54 ns880 0 3.87983203982e-05
Gc27_881 0 n54 ns881 0 -1.2953638333e-05
Gc27_882 0 n54 ns882 0 -2.17008152161e-05
Gc27_883 0 n54 ns883 0 -4.15191366418e-05
Gc27_884 0 n54 ns884 0 0.000368598971766
Gc27_885 0 n54 ns885 0 -1.80368285236e-06
Gc27_886 0 n54 ns886 0 -0.000118446709244
Gc27_887 0 n54 ns887 0 1.73482124508e-06
Gc27_888 0 n54 ns888 0 -0.000234396927026
Gc27_889 0 n54 ns889 0 0.000452821930432
Gc27_890 0 n54 ns890 0 -0.000595692875337
Gc27_891 0 n54 ns891 0 -7.21331579536e-05
Gc27_892 0 n54 ns892 0 -0.000564346835427
Gc27_893 0 n54 ns893 0 -5.66558651231e-06
Gc27_894 0 n54 ns894 0 -0.000526758934298
Gc27_895 0 n54 ns895 0 0.000227661460281
Gc27_896 0 n54 ns896 0 0.000679730016642
Gc27_897 0 n54 ns897 0 0.00348770443078
Gc27_898 0 n54 ns898 0 0.000997351675228
Gc27_899 0 n54 ns899 0 0.00316636585514
Gc27_900 0 n54 ns900 0 0.000743370475897
Gc27_901 0 n54 ns901 0 0.000389815292211
Gc27_902 0 n54 ns902 0 0.000924884139207
Gc27_903 0 n54 ns903 0 -0.000302130789941
Gc27_904 0 n54 ns904 0 -0.000331688874735
Gc27_905 0 n54 ns905 0 -0.00113424358846
Gc27_906 0 n54 ns906 0 -0.000897005727632
Gc27_907 0 n54 ns907 0 -0.000476411770643
Gc27_908 0 n54 ns908 0 -0.000198891827173
Gc27_909 0 n54 ns909 0 9.55079920789e-05
Gc27_910 0 n54 ns910 0 1.49175213968e-05
Gc27_911 0 n54 ns911 0 -1.77479835854e-05
Gc27_912 0 n54 ns912 0 -1.24391784126e-05
Gc27_913 0 n54 ns913 0 0.000449617326574
Gc27_914 0 n54 ns914 0 5.18422086798e-05
Gc27_915 0 n54 ns915 0 0.00143965644913
Gc27_916 0 n54 ns916 0 -7.65231612527e-05
Gc27_917 0 n54 ns917 0 0.000119312301951
Gc27_918 0 n54 ns918 0 -6.74089827271e-05
Gc27_919 0 n54 ns919 0 -4.10290815558e-05
Gc27_920 0 n54 ns920 0 0.000108075829913
Gc27_921 0 n54 ns921 0 0.000260121976329
Gc27_922 0 n54 ns922 0 0.000164348760796
Gc27_923 0 n54 ns923 0 -5.97464769275e-05
Gc27_924 0 n54 ns924 0 -6.71404989444e-05
Gc27_925 0 n54 ns925 0 -0.000310785134077
Gc27_926 0 n54 ns926 0 -0.00021965144984
Gc27_927 0 n54 ns927 0 -0.000288295042326
Gc27_928 0 n54 ns928 0 -0.000674133234811
Gc27_929 0 n54 ns929 0 -0.000383401730349
Gc27_930 0 n54 ns930 0 -0.0003795675457
Gc27_931 0 n54 ns931 0 -0.000382076057979
Gc27_932 0 n54 ns932 0 -0.000543647761761
Gc27_933 0 n54 ns933 0 0.000723217552992
Gc27_934 0 n54 ns934 0 0.000246053143956
Gc27_935 0 n54 ns935 0 0.00277864885312
Gc27_936 0 n54 ns936 0 -0.00059114795359
Gc27_937 0 n54 ns937 0 0.00239424727101
Gc27_938 0 n54 ns938 0 -0.000609402380435
Gc27_939 0 n54 ns939 0 0.000533817822107
Gc27_940 0 n54 ns940 0 0.000289855305311
Gc27_941 0 n54 ns941 0 -0.000190214441013
Gc27_942 0 n54 ns942 0 -0.000121842339203
Gc27_943 0 n54 ns943 0 -0.000830827455102
Gc27_944 0 n54 ns944 0 -0.000319520873145
Gc27_945 0 n54 ns945 0 -0.000341406497238
Gc27_946 0 n54 ns946 0 -0.000220041330931
Gc27_947 0 n54 ns947 0 3.61254025626e-05
Gc27_948 0 n54 ns948 0 1.25604403896e-05
Gc27_949 0 n54 ns949 0 -6.65932226669e-05
Gc27_950 0 n54 ns950 0 2.35655775858e-05
Gc27_951 0 n54 ns951 0 0.000310363648253
Gc27_952 0 n54 ns952 0 -0.00266941253643
Gc27_953 0 n54 ns953 0 0.00016940300261
Gc27_954 0 n54 ns954 0 -0.00155195626373
Gc27_955 0 n54 ns955 0 -0.000902046117846
Gc27_956 0 n54 ns956 0 1.98296837463e-05
Gc27_957 0 n54 ns957 0 0.000422516338789
Gc27_958 0 n54 ns958 0 -0.000386103894402
Gc27_959 0 n54 ns959 0 0.000123860221272
Gc27_960 0 n54 ns960 0 -1.79007840676e-05
Gc27_961 0 n54 ns961 0 0.000265365586269
Gc27_962 0 n54 ns962 0 8.62591040425e-05
Gc27_963 0 n54 ns963 0 -0.00024799594327
Gc27_964 0 n54 ns964 0 0.000498837731653
Gc27_965 0 n54 ns965 0 0.000589379944135
Gc27_966 0 n54 ns966 0 7.42028855132e-05
Gc27_967 0 n54 ns967 0 0.0010908348313
Gc27_968 0 n54 ns968 0 0.000184794561685
Gc27_969 0 n54 ns969 0 0.000544228929924
Gc27_970 0 n54 ns970 0 -0.000126808306781
Gc27_971 0 n54 ns971 0 0.000153104365053
Gc27_972 0 n54 ns972 0 0.00151964200289
Gc27_973 0 n54 ns973 0 -0.000171736076445
Gc27_974 0 n54 ns974 0 0.00463920892539
Gc27_975 0 n54 ns975 0 -0.000429598091095
Gc27_976 0 n54 ns976 0 0.00496146925573
Gc27_977 0 n54 ns977 0 0.00265598034903
Gc27_978 0 n54 ns978 0 9.32662412586e-05
Gc27_979 0 n54 ns979 0 0.00112307309257
Gc27_980 0 n54 ns980 0 -0.00098266717917
Gc27_981 0 n54 ns981 0 -0.000929558516686
Gc27_982 0 n54 ns982 0 -0.00114910608041
Gc27_983 0 n54 ns983 0 -0.00362179207757
Gc27_984 0 n54 ns984 0 0.000178913789659
Gc27_985 0 n54 ns985 0 0.00316747285277
Gc27_986 0 n54 ns986 0 2.55392482551e-05
Gc27_987 0 n54 ns987 0 -0.000134021895897
Gc27_988 0 n54 ns988 0 4.10453890743e-06
Gc27_989 0 n54 ns989 0 0.000130377800328
Gc27_990 0 n54 ns990 0 -0.00236602235025
Gc27_991 0 n54 ns991 0 -0.00242671837516
Gc27_992 0 n54 ns992 0 3.4556195996e-05
Gc27_993 0 n54 ns993 0 -0.000744777482255
Gc27_994 0 n54 ns994 0 0.000176547193591
Gc27_995 0 n54 ns995 0 0.000402932770944
Gc27_996 0 n54 ns996 0 -0.000278943249191
Gc27_997 0 n54 ns997 0 -0.000202383237524
Gc27_998 0 n54 ns998 0 0.000317685724927
Gc27_999 0 n54 ns999 0 0.000314202206071
Gc27_1000 0 n54 ns1000 0 4.52611257362e-05
Gc27_1001 0 n54 ns1001 0 -0.000308221040539
Gc27_1002 0 n54 ns1002 0 -0.000305399846923
Gc27_1003 0 n54 ns1003 0 0.000729699629359
Gc27_1004 0 n54 ns1004 0 0.000487580950083
Gc27_1005 0 n54 ns1005 0 0.000695465997295
Gc27_1006 0 n54 ns1006 0 -8.3649816606e-05
Gc27_1007 0 n54 ns1007 0 -7.57088986683e-05
Gc27_1008 0 n54 ns1008 0 -0.000828492520918
Gc27_1009 0 n54 ns1009 0 -0.00112618789723
Gc27_1010 0 n54 ns1010 0 0.000350405444987
Gc27_1011 0 n54 ns1011 0 0.00611342265107
Gc27_1012 0 n54 ns1012 0 0.00624621667542
Gc27_1013 0 n54 ns1013 0 0.00455536692053
Gc27_1014 0 n54 ns1014 0 0.00618944172811
Gc27_1015 0 n54 ns1015 0 0.000647896050774
Gc27_1016 0 n54 ns1016 0 0.0055061849761
Gc27_1017 0 n54 ns1017 0 0.000981243300467
Gc27_1018 0 n54 ns1018 0 -0.000847571709542
Gc27_1019 0 n54 ns1019 0 -0.00571491783383
Gc27_1020 0 n54 ns1020 0 -0.0016408502665
Gc27_1021 0 n54 ns1021 0 0.00286918120256
Gc27_1022 0 n54 ns1022 0 -0.00439680148745
Gc27_1023 0 n54 ns1023 0 0.00473016677396
Gc27_1024 0 n54 ns1024 0 -4.6773640924e-06
Gc27_1025 0 n54 ns1025 0 0.000137756890285
Gc27_1026 0 n54 ns1026 0 -0.000164430561006
Gc27_1027 0 n54 ns1027 0 0.000490826271979
Gc27_1028 0 n54 ns1028 0 -0.00223930239873
Gc27_1029 0 n54 ns1029 0 0.00100106297959
Gc27_1030 0 n54 ns1030 0 -0.000597512423016
Gc27_1031 0 n54 ns1031 0 -0.000757555495148
Gc27_1032 0 n54 ns1032 0 0.000210438701402
Gc27_1033 0 n54 ns1033 0 0.000259896213712
Gc27_1034 0 n54 ns1034 0 -0.000411634136812
Gc27_1035 0 n54 ns1035 0 0.000263970246791
Gc27_1036 0 n54 ns1036 0 0.00042748266488
Gc27_1037 0 n54 ns1037 0 0.000251857141433
Gc27_1038 0 n54 ns1038 0 -5.05280384606e-05
Gc27_1039 0 n54 ns1039 0 -0.000399051630361
Gc27_1040 0 n54 ns1040 0 -2.24784921172e-06
Gc27_1041 0 n54 ns1041 0 0.000743348246055
Gc27_1042 0 n54 ns1042 0 -0.000995353590273
Gc27_1043 0 n54 ns1043 0 0.000867383815641
Gc27_1044 0 n54 ns1044 0 -0.000528340758186
Gc27_1045 0 n54 ns1045 0 0.000470323969071
Gc27_1046 0 n54 ns1046 0 -0.00103414641633
Gc27_1047 0 n54 ns1047 0 0.000996107082999
Gc27_1048 0 n54 ns1048 0 0.00225848008215
Gc27_1049 0 n54 ns1049 0 0.00325456819217
Gc27_1050 0 n54 ns1050 0 0.00489501672426
Gc27_1051 0 n54 ns1051 0 0.00252174500114
Gc27_1052 0 n54 ns1052 0 0.005010815077
Gc27_1053 0 n54 ns1053 0 0.00362876246127
Gc27_1054 0 n54 ns1054 0 0.000381758378372
Gc27_1055 0 n54 ns1055 0 0.000896933995599
Gc27_1056 0 n54 ns1056 0 -0.000977019299316
Gc27_1057 0 n54 ns1057 0 -0.0019080415443
Gc27_1058 0 n54 ns1058 0 -0.00130922361749
Gc27_1059 0 n54 ns1059 0 -0.00391992972635
Gc27_1060 0 n54 ns1060 0 -0.000287176402379
Gc27_1061 0 n54 ns1061 0 0.00308873785632
Gc27_1062 0 n54 ns1062 0 5.61898617528e-05
Gc27_1063 0 n54 ns1063 0 -0.000169867945017
Gc27_1064 0 n54 ns1064 0 4.96219854117e-05
Gc27_1065 0 n54 ns1065 0 1.98295968662e-05
Gc27_1066 0 n54 ns1066 0 -0.000570953843947
Gc27_1067 0 n54 ns1067 0 0.000206548121978
Gc27_1068 0 n54 ns1068 0 -0.000225277881584
Gc27_1069 0 n54 ns1069 0 -0.000366077491094
Gc27_1070 0 n54 ns1070 0 0.000372733940073
Gc27_1071 0 n54 ns1071 0 3.12466714256e-05
Gc27_1072 0 n54 ns1072 0 -0.000113523987138
Gc27_1073 0 n54 ns1073 0 0.00030713012641
Gc27_1074 0 n54 ns1074 0 -0.000136879033596
Gc27_1075 0 n54 ns1075 0 0.000177397726588
Gc27_1076 0 n54 ns1076 0 -6.58241868412e-05
Gc27_1077 0 n54 ns1077 0 6.98728188566e-05
Gc27_1078 0 n54 ns1078 0 -0.00025570937131
Gc27_1079 0 n54 ns1079 0 -0.000765430731818
Gc27_1080 0 n54 ns1080 0 -0.000289817673497
Gc27_1081 0 n54 ns1081 0 0.000256291926046
Gc27_1082 0 n54 ns1082 0 -0.000505668418687
Gc27_1083 0 n54 ns1083 0 -0.000261686880318
Gc27_1084 0 n54 ns1084 0 -0.00087589022228
Gc27_1085 0 n54 ns1085 0 0.00115847994782
Gc27_1086 0 n54 ns1086 0 -0.000803007556597
Gc27_1087 0 n54 ns1087 0 0.00195703669772
Gc27_1088 0 n54 ns1088 0 0.00270906309833
Gc27_1089 0 n54 ns1089 0 0.00181474187405
Gc27_1090 0 n54 ns1090 0 0.00304503983297
Gc27_1091 0 n54 ns1091 0 -0.00145225771031
Gc27_1092 0 n54 ns1092 0 -0.00162230747835
Gc27_1093 0 n54 ns1093 0 0.000440347151918
Gc27_1094 0 n54 ns1094 0 -0.00101700283345
Gc27_1095 0 n54 ns1095 0 0.000387824927439
Gc27_1096 0 n54 ns1096 0 -0.000541608480827
Gc27_1097 0 n54 ns1097 0 -0.00137923641856
Gc27_1098 0 n54 ns1098 0 0.00287505864926
Gc27_1099 0 n54 ns1099 0 0.00157165584554
Gc27_1100 0 n54 ns1100 0 1.96311370646e-05
Gc27_1101 0 n54 ns1101 0 -0.000178812619166
Gc27_1102 0 n54 ns1102 0 4.91160628703e-05
Gc27_1103 0 n54 ns1103 0 -0.000141720346269
Gc27_1104 0 n54 ns1104 0 0.0001268441735
Gc27_1105 0 n54 ns1105 0 -1.11983997296e-05
Gc27_1106 0 n54 ns1106 0 0.00101219859112
Gc27_1107 0 n54 ns1107 0 1.96980345131e-05
Gc27_1108 0 n54 ns1108 0 0.000176546762933
Gc27_1109 0 n54 ns1109 0 0.000155959412095
Gc27_1110 0 n54 ns1110 0 -8.38953384056e-05
Gc27_1111 0 n54 ns1111 0 -0.000130905582464
Gc27_1112 0 n54 ns1112 0 -6.49780101038e-05
Gc27_1113 0 n54 ns1113 0 0.000142213612341
Gc27_1114 0 n54 ns1114 0 -0.000143610402981
Gc27_1115 0 n54 ns1115 0 -0.000285296792159
Gc27_1116 0 n54 ns1116 0 -0.000366590841263
Gc27_1117 0 n54 ns1117 0 0.000185442365047
Gc27_1118 0 n54 ns1118 0 0.000489541027023
Gc27_1119 0 n54 ns1119 0 0.000302570544478
Gc27_1120 0 n54 ns1120 0 -0.000432212610955
Gc27_1121 0 n54 ns1121 0 -7.38147363091e-05
Gc27_1122 0 n54 ns1122 0 -0.00038398125177
Gc27_1123 0 n54 ns1123 0 -0.000489842678002
Gc27_1124 0 n54 ns1124 0 -0.000241315643149
Gc27_1125 0 n54 ns1125 0 0.00207844702824
Gc27_1126 0 n54 ns1126 0 0.00339778735779
Gc27_1127 0 n54 ns1127 0 0.00218588830421
Gc27_1128 0 n54 ns1128 0 0.00319205849521
Gc27_1129 0 n54 ns1129 0 -0.00111242332548
Gc27_1130 0 n54 ns1130 0 0.000986498954784
Gc27_1131 0 n54 ns1131 0 -0.000157986646457
Gc27_1132 0 n54 ns1132 0 -0.000838333762945
Gc27_1133 0 n54 ns1133 0 -0.00052130640627
Gc27_1134 0 n54 ns1134 0 -0.00167470668575
Gc27_1135 0 n54 ns1135 0 -0.000641328090842
Gc27_1136 0 n54 ns1136 0 0.000534042650805
Gc27_1137 0 n54 ns1137 0 0.000446602816322
Gc27_1138 0 n54 ns1138 0 2.44037148444e-05
Gc27_1139 0 n54 ns1139 0 -0.000135922719381
Gc27_1140 0 n54 ns1140 0 1.5891964709e-05
Gc27_1141 0 n54 ns1141 0 -0.000335683270914
Gc27_1142 0 n54 ns1142 0 0.000607401693423
Gc27_1143 0 n54 ns1143 0 -0.00069759562402
Gc27_1144 0 n54 ns1144 0 0.00145532265915
Gc27_1145 0 n54 ns1145 0 -0.000222794639361
Gc27_1146 0 n54 ns1146 0 0.000344102639642
Gc27_1147 0 n54 ns1147 0 9.41502198152e-05
Gc27_1148 0 n54 ns1148 0 -0.000246133164847
Gc27_1149 0 n54 ns1149 0 -0.000133784527885
Gc27_1150 0 n54 ns1150 0 0.000448041174626
Gc27_1151 0 n54 ns1151 0 7.5564933484e-05
Gc27_1152 0 n54 ns1152 0 -0.000156652305721
Gc27_1153 0 n54 ns1153 0 4.77718729232e-05
Gc27_1154 0 n54 ns1154 0 -0.000477908028398
Gc27_1155 0 n54 ns1155 0 0.000819861210943
Gc27_1156 0 n54 ns1156 0 -0.000480521098946
Gc27_1157 0 n54 ns1157 0 0.000211217156637
Gc27_1158 0 n54 ns1158 0 -0.000681279765973
Gc27_1159 0 n54 ns1159 0 0.000316709579826
Gc27_1160 0 n54 ns1160 0 -0.000595743670994
Gc27_1161 0 n54 ns1161 0 -0.00010678755604
Gc27_1162 0 n54 ns1162 0 0.000947061490362
Gc27_1163 0 n54 ns1163 0 0.00327795655652
Gc27_1164 0 n54 ns1164 0 0.00256343220359
Gc27_1165 0 n54 ns1165 0 0.00308078662294
Gc27_1166 0 n54 ns1166 0 0.00211070484174
Gc27_1167 0 n54 ns1167 0 0.000402911370613
Gc27_1168 0 n54 ns1168 0 0.00138146513185
Gc27_1169 0 n54 ns1169 0 -0.00034902203561
Gc27_1170 0 n54 ns1170 0 -0.000470214198832
Gc27_1171 0 n54 ns1171 0 -0.00129796910962
Gc27_1172 0 n54 ns1172 0 -0.00139785529934
Gc27_1173 0 n54 ns1173 0 -0.000559110159414
Gc27_1174 0 n54 ns1174 0 -0.000555526552216
Gc27_1175 0 n54 ns1175 0 3.17708423898e-05
Gc27_1176 0 n54 ns1176 0 8.77817098179e-07
Gc27_1177 0 n54 ns1177 0 -5.55301684576e-06
Gc27_1178 0 n54 ns1178 0 -3.7974971369e-05
Gc27_1179 0 n54 ns1179 0 0.000162564032132
Gc27_1180 0 n54 ns1180 0 0.000370404789103
Gc27_1181 0 n54 ns1181 0 0.000741724267856
Gc27_1182 0 n54 ns1182 0 0.000409017865793
Gc27_1183 0 n54 ns1183 0 -2.28089856155e-05
Gc27_1184 0 n54 ns1184 0 0.000112136062659
Gc27_1185 0 n54 ns1185 0 8.24379489983e-07
Gc27_1186 0 n54 ns1186 0 2.80086060487e-07
Gc27_1187 0 n54 ns1187 0 0.000227371820687
Gc27_1188 0 n54 ns1188 0 0.000316089720581
Gc27_1189 0 n54 ns1189 0 -3.97215237376e-05
Gc27_1190 0 n54 ns1190 0 -9.37796229191e-05
Gc27_1191 0 n54 ns1191 0 -0.000194728899382
Gc27_1192 0 n54 ns1192 0 -0.000365079896455
Gc27_1193 0 n54 ns1193 0 -4.91838100885e-05
Gc27_1194 0 n54 ns1194 0 -0.000821541789916
Gc27_1195 0 n54 ns1195 0 -0.000312214463532
Gc27_1196 0 n54 ns1196 0 -0.00051642908879
Gc27_1197 0 n54 ns1197 0 -0.000250924023943
Gc27_1198 0 n54 ns1198 0 -0.000648286976172
Gc27_1199 0 n54 ns1199 0 0.000659090889616
Gc27_1200 0 n54 ns1200 0 0.000474260646038
Gc27_1201 0 n54 ns1201 0 0.00318100177752
Gc27_1202 0 n54 ns1202 0 -0.000101809600734
Gc27_1203 0 n54 ns1203 0 0.00278293863018
Gc27_1204 0 n54 ns1204 0 -0.000214928026718
Gc27_1205 0 n54 ns1205 0 0.000625744306204
Gc27_1206 0 n54 ns1206 0 0.000526118979029
Gc27_1207 0 n54 ns1207 0 -0.000245578469663
Gc27_1208 0 n54 ns1208 0 -0.000180330960332
Gc27_1209 0 n54 ns1209 0 -0.00102233353105
Gc27_1210 0 n54 ns1210 0 -0.000522737903866
Gc27_1211 0 n54 ns1211 0 -0.00041643166778
Gc27_1212 0 n54 ns1212 0 -0.000314550882206
Gc27_1213 0 n54 ns1213 0 3.19889949095e-05
Gc27_1214 0 n54 ns1214 0 8.97069456861e-06
Gc27_1215 0 n54 ns1215 0 -2.16791147167e-05
Gc27_1216 0 n54 ns1216 0 -4.31748382671e-06
Gd27_1 0 n54 ni1 0 0.000507782366111
Gd27_2 0 n54 ni2 0 0.000495136703185
Gd27_3 0 n54 ni3 0 -0.00241871922708
Gd27_4 0 n54 ni4 0 -0.00300928595585
Gd27_5 0 n54 ni5 0 0.000649288067402
Gd27_6 0 n54 ni6 0 -0.000590004975045
Gd27_7 0 n54 ni7 0 6.17135945647e-05
Gd27_8 0 n54 ni8 0 -0.000479987443314
Gd27_9 0 n54 ni9 0 0.00101283562431
Gd27_10 0 n54 ni10 0 -0.000383577924306
Gd27_11 0 n54 ni11 0 0.000501873983736
Gd27_12 0 n54 ni12 0 0.00053467647744
Gd27_13 0 n54 ni13 0 -0.000308560320264
Gd27_14 0 n54 ni14 0 0.000143978533602
Gd27_15 0 n54 ni15 0 -0.000459993194308
Gd27_16 0 n54 ni16 0 0.000623823410572
Gd27_17 0 n54 ni17 0 -0.000305865009261
Gd27_18 0 n54 ni18 0 -0.00182579554452
Gd27_19 0 n54 ni19 0 -0.00323071142048
Gd27_20 0 n54 ni20 0 -0.000852545561226
Gd27_21 0 n54 ni21 0 -0.00157316265755
Gd27_22 0 n54 ni22 0 0.00053246574493
Gd27_23 0 n54 ni23 0 0.000419374731366
Gd27_24 0 n54 ni24 0 0.000248906095789
Gd27_25 0 n54 ni25 0 -0.000373383617425
Gd27_26 0 n54 ni26 0 -0.00193471249095
Gd27_27 0 n54 ni27 0 0.00112438569642
Gd27_28 0 n54 ni28 0 -0.0018324352683
Gd27_29 0 n54 ni29 0 -0.000251993097952
Gd27_30 0 n54 ni30 0 0.000483145679285
Gd27_31 0 n54 ni31 0 0.000719976539245
Gd27_32 0 n54 ni32 0 2.76520315162e-05
Gc28_1 0 n56 ns1 0 -0.000164830205965
Gc28_2 0 n56 ns2 0 -0.000384909217156
Gc28_3 0 n56 ns3 0 -0.000531242403684
Gc28_4 0 n56 ns4 0 0.000595651933931
Gc28_5 0 n56 ns5 0 -0.00020144947807
Gc28_6 0 n56 ns6 0 -2.55271442306e-05
Gc28_7 0 n56 ns7 0 -7.01257278773e-05
Gc28_8 0 n56 ns8 0 0.000113987434464
Gc28_9 0 n56 ns9 0 0.000368699905046
Gc28_10 0 n56 ns10 0 0.000687243634574
Gc28_11 0 n56 ns11 0 -0.000117277420144
Gc28_12 0 n56 ns12 0 -2.77420056798e-05
Gc28_13 0 n56 ns13 0 -0.000356181185655
Gc28_14 0 n56 ns14 0 -0.00037549643437
Gc28_15 0 n56 ns15 0 0.00038618530671
Gc28_16 0 n56 ns16 0 0.00116078275686
Gc28_17 0 n56 ns17 0 0.000852757646576
Gc28_18 0 n56 ns18 0 -1.49106135422e-05
Gc28_19 0 n56 ns19 0 0.000655506802291
Gc28_20 0 n56 ns20 0 0.000156345427328
Gc28_21 0 n56 ns21 0 0.000398494832185
Gc28_22 0 n56 ns22 0 0.000197021146974
Gc28_23 0 n56 ns23 0 -0.00093384384391
Gc28_24 0 n56 ns24 0 -0.00618632096997
Gc28_25 0 n56 ns25 0 -0.0011537239757
Gc28_26 0 n56 ns26 0 -0.00566537373234
Gc28_27 0 n56 ns27 0 -0.00143909395812
Gc28_28 0 n56 ns28 0 0.00104369601481
Gc28_29 0 n56 ns29 0 2.81957656154e-05
Gc28_30 0 n56 ns30 0 -0.000880591993603
Gc28_31 0 n56 ns31 0 0.000152271599474
Gc28_32 0 n56 ns32 0 -0.00200687125406
Gc28_33 0 n56 ns33 0 0.000364495937369
Gc28_34 0 n56 ns34 0 -0.00110963355726
Gc28_35 0 n56 ns35 0 -0.000523275263278
Gc28_36 0 n56 ns36 0 -7.74228598161e-06
Gc28_37 0 n56 ns37 0 7.48099078033e-05
Gc28_38 0 n56 ns38 0 4.61848992863e-07
Gc28_39 0 n56 ns39 0 9.99586383665e-05
Gc28_40 0 n56 ns40 0 -0.000895253864868
Gc28_41 0 n56 ns41 0 0.000183195380728
Gc28_42 0 n56 ns42 0 0.000281632799107
Gc28_43 0 n56 ns43 0 -7.83948144686e-05
Gc28_44 0 n56 ns44 0 -0.000239943367739
Gc28_45 0 n56 ns45 0 -8.61813303043e-05
Gc28_46 0 n56 ns46 0 0.000143700200725
Gc28_47 0 n56 ns47 0 0.000203988442276
Gc28_48 0 n56 ns48 0 0.000596059327305
Gc28_49 0 n56 ns49 0 -0.000173019812544
Gc28_50 0 n56 ns50 0 2.52544577409e-05
Gc28_51 0 n56 ns51 0 -9.82758451319e-05
Gc28_52 0 n56 ns52 0 -0.000258951183151
Gc28_53 0 n56 ns53 0 0.000147063098487
Gc28_54 0 n56 ns54 0 0.00108718495018
Gc28_55 0 n56 ns55 0 0.000847344568302
Gc28_56 0 n56 ns56 0 -7.63936598796e-05
Gc28_57 0 n56 ns57 0 0.000480820292004
Gc28_58 0 n56 ns58 0 2.71285031174e-05
Gc28_59 0 n56 ns59 0 0.000254839225774
Gc28_60 0 n56 ns60 0 0.000356618329817
Gc28_61 0 n56 ns61 0 -0.00086786363928
Gc28_62 0 n56 ns62 0 -0.00652116578678
Gc28_63 0 n56 ns63 0 -0.00111742550391
Gc28_64 0 n56 ns64 0 -0.00610797883348
Gc28_65 0 n56 ns65 0 -0.00153323059221
Gc28_66 0 n56 ns66 0 0.000997090530812
Gc28_67 0 n56 ns67 0 0.000111209091157
Gc28_68 0 n56 ns68 0 -0.00108273564638
Gc28_69 0 n56 ns69 0 0.000230099065835
Gc28_70 0 n56 ns70 0 -0.00239198043098
Gc28_71 0 n56 ns71 0 0.000553587580216
Gc28_72 0 n56 ns72 0 -0.00169778140312
Gc28_73 0 n56 ns73 0 -0.000792126790558
Gc28_74 0 n56 ns74 0 -1.09513453347e-05
Gc28_75 0 n56 ns75 0 5.68198724227e-05
Gc28_76 0 n56 ns76 0 4.76198369743e-06
Gc28_77 0 n56 ns77 0 -0.00088244558007
Gc28_78 0 n56 ns78 0 0.000130067900599
Gc28_79 0 n56 ns79 0 -0.00249110408243
Gc28_80 0 n56 ns80 0 0.0021101346831
Gc28_81 0 n56 ns81 0 -0.000480948626736
Gc28_82 0 n56 ns82 0 0.000887017707544
Gc28_83 0 n56 ns83 0 0.000412844732075
Gc28_84 0 n56 ns84 0 -0.000472907947965
Gc28_85 0 n56 ns85 0 -0.00026440168056
Gc28_86 0 n56 ns86 0 0.00032519540616
Gc28_87 0 n56 ns87 0 -0.000175839601352
Gc28_88 0 n56 ns88 0 9.37032143651e-05
Gc28_89 0 n56 ns89 0 0.00106170615522
Gc28_90 0 n56 ns90 0 -0.000272359464278
Gc28_91 0 n56 ns91 0 0.000159654625685
Gc28_92 0 n56 ns92 0 -0.000670548123019
Gc28_93 0 n56 ns93 0 0.000847031527029
Gc28_94 0 n56 ns94 0 -0.000561484760482
Gc28_95 0 n56 ns95 0 0.000467409504505
Gc28_96 0 n56 ns96 0 -0.000894450347586
Gc28_97 0 n56 ns97 0 -0.001554534798
Gc28_98 0 n56 ns98 0 0.000681127864902
Gc28_99 0 n56 ns99 0 -0.00368898946958
Gc28_100 0 n56 ns100 0 -0.00271846452837
Gc28_101 0 n56 ns101 0 -0.00313475933264
Gc28_102 0 n56 ns102 0 -0.00326232333043
Gc28_103 0 n56 ns103 0 0.000440908297179
Gc28_104 0 n56 ns104 0 0.000783760257486
Gc28_105 0 n56 ns105 0 0.000578506137073
Gc28_106 0 n56 ns106 0 -0.00139514430397
Gc28_107 0 n56 ns107 0 -0.000177988017742
Gc28_108 0 n56 ns108 0 -0.00288548263422
Gc28_109 0 n56 ns109 0 0.00165628213604
Gc28_110 0 n56 ns110 0 -0.00343216989982
Gc28_111 0 n56 ns111 0 -0.00215259638027
Gc28_112 0 n56 ns112 0 -2.50444125613e-05
Gc28_113 0 n56 ns113 0 0.000137483180333
Gc28_114 0 n56 ns114 0 -2.11568182622e-05
Gc28_115 0 n56 ns115 0 0.000944003512334
Gc28_116 0 n56 ns116 0 -0.00220335156572
Gc28_117 0 n56 ns117 0 0.00153133982586
Gc28_118 0 n56 ns118 0 -0.00422254716656
Gc28_119 0 n56 ns119 0 -0.00244335088558
Gc28_120 0 n56 ns120 0 -0.00108995871677
Gc28_121 0 n56 ns121 0 0.000870654909138
Gc28_122 0 n56 ns122 0 0.000321769356225
Gc28_123 0 n56 ns123 0 -0.000466252982226
Gc28_124 0 n56 ns124 0 -0.000422738016069
Gc28_125 0 n56 ns125 0 -0.000209568713127
Gc28_126 0 n56 ns126 0 4.13339184069e-05
Gc28_127 0 n56 ns127 0 0.000216381058556
Gc28_128 0 n56 ns128 0 1.76696382237e-05
Gc28_129 0 n56 ns129 0 0.0012564619758
Gc28_130 0 n56 ns130 0 -0.000518682113791
Gc28_131 0 n56 ns131 0 0.00092116446767
Gc28_132 0 n56 ns132 0 -2.29807237013e-05
Gc28_133 0 n56 ns133 0 0.000430138152829
Gc28_134 0 n56 ns134 0 -0.000114865639913
Gc28_135 0 n56 ns135 0 -0.000915241018053
Gc28_136 0 n56 ns136 0 -0.00216156199314
Gc28_137 0 n56 ns137 0 -0.00574349042688
Gc28_138 0 n56 ns138 0 -0.00434286585684
Gc28_139 0 n56 ns139 0 -0.00445950666122
Gc28_140 0 n56 ns140 0 -0.00454073958897
Gc28_141 0 n56 ns141 0 0.00443469661652
Gc28_142 0 n56 ns142 0 0.00413313158828
Gc28_143 0 n56 ns143 0 0.000937924904014
Gc28_144 0 n56 ns144 0 -0.00113661755443
Gc28_145 0 n56 ns145 0 -0.00314056162716
Gc28_146 0 n56 ns146 0 -0.00337658249126
Gc28_147 0 n56 ns147 0 0.00221283329367
Gc28_148 0 n56 ns148 0 0.0015238355378
Gc28_149 0 n56 ns149 0 -0.00374140543171
Gc28_150 0 n56 ns150 0 -1.88659667726e-06
Gc28_151 0 n56 ns151 0 0.000320529354619
Gc28_152 0 n56 ns152 0 -0.000140577395887
Gc28_153 0 n56 ns153 0 0.00275460487426
Gc28_154 0 n56 ns154 0 -0.00382744920635
Gc28_155 0 n56 ns155 0 0.00637240436387
Gc28_156 0 n56 ns156 0 -0.0078556064779
Gc28_157 0 n56 ns157 0 -0.00296192898899
Gc28_158 0 n56 ns158 0 -0.00265540634739
Gc28_159 0 n56 ns159 0 0.000887685462784
Gc28_160 0 n56 ns160 0 0.000847578139163
Gc28_161 0 n56 ns161 0 -0.000508197326234
Gc28_162 0 n56 ns162 0 -0.000682793048971
Gc28_163 0 n56 ns163 0 -0.000247083311824
Gc28_164 0 n56 ns164 0 3.81276376875e-06
Gc28_165 0 n56 ns165 0 -0.000582891374758
Gc28_166 0 n56 ns166 0 -0.000214578212419
Gc28_167 0 n56 ns167 0 0.000953099103529
Gc28_168 0 n56 ns168 0 0.000167392883159
Gc28_169 0 n56 ns169 0 0.000673642189381
Gc28_170 0 n56 ns170 0 0.000459186430173
Gc28_171 0 n56 ns171 0 -3.96057934263e-05
Gc28_172 0 n56 ns172 0 0.000713503554742
Gc28_173 0 n56 ns173 0 0.000785542733787
Gc28_174 0 n56 ns174 0 -0.00302626261295
Gc28_175 0 n56 ns175 0 -0.00227801393163
Gc28_176 0 n56 ns176 0 -0.00679262558581
Gc28_177 0 n56 ns177 0 -0.00158982981718
Gc28_178 0 n56 ns178 0 -0.0064345350506
Gc28_179 0 n56 ns179 0 0.00585018401168
Gc28_180 0 n56 ns180 0 0.00789499583806
Gc28_181 0 n56 ns181 0 0.000750854515166
Gc28_182 0 n56 ns182 0 -0.00115454994641
Gc28_183 0 n56 ns183 0 -0.00560562623095
Gc28_184 0 n56 ns184 0 -0.00573561188041
Gc28_185 0 n56 ns185 0 0.00135886288109
Gc28_186 0 n56 ns186 0 0.0053627140168
Gc28_187 0 n56 ns187 0 -0.0042655001393
Gc28_188 0 n56 ns188 0 -1.82783537232e-06
Gc28_189 0 n56 ns189 0 0.000422453058361
Gc28_190 0 n56 ns190 0 -0.000231535284948
Gc28_191 0 n56 ns191 0 -0.000965544307147
Gc28_192 0 n56 ns192 0 0.000373423567531
Gc28_193 0 n56 ns193 0 -0.00259009927816
Gc28_194 0 n56 ns194 0 0.00160097240276
Gc28_195 0 n56 ns195 0 -0.000328703444967
Gc28_196 0 n56 ns196 0 0.00121103548388
Gc28_197 0 n56 ns197 0 0.000245805392915
Gc28_198 0 n56 ns198 0 -0.000509653658829
Gc28_199 0 n56 ns199 0 -0.000217457334493
Gc28_200 0 n56 ns200 0 0.000292985644616
Gc28_201 0 n56 ns201 0 -0.000153328749698
Gc28_202 0 n56 ns202 0 1.56832066742e-05
Gc28_203 0 n56 ns203 0 0.000624896863731
Gc28_204 0 n56 ns204 0 -8.00397707528e-05
Gc28_205 0 n56 ns205 0 0.000186396799127
Gc28_206 0 n56 ns206 0 -0.000848038940486
Gc28_207 0 n56 ns207 0 0.000748708440901
Gc28_208 0 n56 ns208 0 -0.000445922136722
Gc28_209 0 n56 ns209 0 0.000511445402054
Gc28_210 0 n56 ns210 0 -0.000836042238727
Gc28_211 0 n56 ns211 0 -0.00222816839077
Gc28_212 0 n56 ns212 0 0.00030206255291
Gc28_213 0 n56 ns213 0 -0.00575894445585
Gc28_214 0 n56 ns214 0 -0.000852779227185
Gc28_215 0 n56 ns215 0 -0.00467058300948
Gc28_216 0 n56 ns216 0 -0.0016289693262
Gc28_217 0 n56 ns217 0 0.00229713121732
Gc28_218 0 n56 ns218 0 0.00040355284413
Gc28_219 0 n56 ns219 0 0.000708325563058
Gc28_220 0 n56 ns220 0 -0.00120949602579
Gc28_221 0 n56 ns221 0 -0.000955065504967
Gc28_222 0 n56 ns222 0 -0.00222064210776
Gc28_223 0 n56 ns223 0 0.00224305899439
Gc28_224 0 n56 ns224 0 -0.00327556604095
Gc28_225 0 n56 ns225 0 -0.00266972050243
Gc28_226 0 n56 ns226 0 -6.68509132965e-06
Gc28_227 0 n56 ns227 0 0.000188079951892
Gc28_228 0 n56 ns228 0 -6.1068916443e-05
Gc28_229 0 n56 ns229 0 0.000287619758625
Gc28_230 0 n56 ns230 0 -0.000724723824721
Gc28_231 0 n56 ns231 0 0.000893715575879
Gc28_232 0 n56 ns232 0 7.09074911474e-05
Gc28_233 0 n56 ns233 0 4.71351061466e-05
Gc28_234 0 n56 ns234 0 -0.000291823376582
Gc28_235 0 n56 ns235 0 -7.95351241435e-05
Gc28_236 0 n56 ns236 0 2.5569976985e-05
Gc28_237 0 n56 ns237 0 -0.000165341500997
Gc28_238 0 n56 ns238 0 0.000308644023288
Gc28_239 0 n56 ns239 0 -0.000100555135797
Gc28_240 0 n56 ns240 0 0.000120705521064
Gc28_241 0 n56 ns241 0 0.000417586178442
Gc28_242 0 n56 ns242 0 -0.000359247430928
Gc28_243 0 n56 ns243 0 -0.00038838606407
Gc28_244 0 n56 ns244 0 0.0003997961112
Gc28_245 0 n56 ns245 0 0.000281303262982
Gc28_246 0 n56 ns246 0 -0.00017061296779
Gc28_247 0 n56 ns247 0 -0.000230362012426
Gc28_248 0 n56 ns248 0 -8.48875104421e-05
Gc28_249 0 n56 ns249 0 -0.000442843582579
Gc28_250 0 n56 ns250 0 0.00071700126542
Gc28_251 0 n56 ns251 0 -0.002273226776
Gc28_252 0 n56 ns252 0 -0.00322475292945
Gc28_253 0 n56 ns253 0 -0.00223313617155
Gc28_254 0 n56 ns254 0 -0.0033323888212
Gc28_255 0 n56 ns255 0 -0.000681147720763
Gc28_256 0 n56 ns256 0 0.00117738908948
Gc28_257 0 n56 ns257 0 7.87487691496e-05
Gc28_258 0 n56 ns258 0 -0.00120905480469
Gc28_259 0 n56 ns259 0 -0.000324173430513
Gc28_260 0 n56 ns260 0 -0.00284704467921
Gc28_261 0 n56 ns261 0 0.00054465762328
Gc28_262 0 n56 ns262 0 -0.00280639558645
Gc28_263 0 n56 ns263 0 -0.00114443716785
Gc28_264 0 n56 ns264 0 -3.38374677466e-05
Gc28_265 0 n56 ns265 0 9.50097572012e-05
Gc28_266 0 n56 ns266 0 -1.09824189035e-06
Gc28_267 0 n56 ns267 0 -0.000105155933217
Gc28_268 0 n56 ns268 0 -0.000130616110675
Gc28_269 0 n56 ns269 0 -0.000258520641443
Gc28_270 0 n56 ns270 0 0.000249820315208
Gc28_271 0 n56 ns271 0 -4.47027345739e-05
Gc28_272 0 n56 ns272 0 0.000123700636916
Gc28_273 0 n56 ns273 0 -5.18755759216e-05
Gc28_274 0 n56 ns274 0 -9.63326098324e-06
Gc28_275 0 n56 ns275 0 0.000292865615923
Gc28_276 0 n56 ns276 0 -4.61612956108e-05
Gc28_277 0 n56 ns277 0 -6.72621137051e-05
Gc28_278 0 n56 ns278 0 0.000141836355115
Gc28_279 0 n56 ns279 0 2.74882405142e-07
Gc28_280 0 n56 ns280 0 9.70062985706e-05
Gc28_281 0 n56 ns281 0 0.000638386202705
Gc28_282 0 n56 ns282 0 0.000300311178089
Gc28_283 0 n56 ns283 0 0.000291980273234
Gc28_284 0 n56 ns284 0 -0.000470798145596
Gc28_285 0 n56 ns285 0 0.000100658802745
Gc28_286 0 n56 ns286 0 -0.00028017402303
Gc28_287 0 n56 ns287 0 -4.02337964409e-05
Gc28_288 0 n56 ns288 0 -0.000366947279119
Gc28_289 0 n56 ns289 0 -0.00484158241494
Gc28_290 0 n56 ns290 0 -0.00426862912314
Gc28_291 0 n56 ns291 0 -0.00448050705891
Gc28_292 0 n56 ns292 0 -0.00376543284142
Gc28_293 0 n56 ns293 0 -0.00037742610134
Gc28_294 0 n56 ns294 0 0.00185828597267
Gc28_295 0 n56 ns295 0 -0.000288754384819
Gc28_296 0 n56 ns296 0 -0.000742482716364
Gc28_297 0 n56 ns297 0 -0.000898101571234
Gc28_298 0 n56 ns298 0 -0.00206135853744
Gc28_299 0 n56 ns299 0 1.75539112882e-05
Gc28_300 0 n56 ns300 0 -0.00123475342101
Gc28_301 0 n56 ns301 0 -0.000433759382446
Gc28_302 0 n56 ns302 0 -1.30605002087e-05
Gc28_303 0 n56 ns303 0 4.25598545559e-05
Gc28_304 0 n56 ns304 0 1.34139295588e-05
Gc28_305 0 n56 ns305 0 -0.000268036576238
Gc28_306 0 n56 ns306 0 0.000516124160284
Gc28_307 0 n56 ns307 0 -0.00053651332494
Gc28_308 0 n56 ns308 0 0.000819473737353
Gc28_309 0 n56 ns309 0 -7.32146347767e-05
Gc28_310 0 n56 ns310 0 0.000350060895894
Gc28_311 0 n56 ns311 0 0.000159330047282
Gc28_312 0 n56 ns312 0 -0.000192885907946
Gc28_313 0 n56 ns313 0 0.000273704167642
Gc28_314 0 n56 ns314 0 -0.000410865422813
Gc28_315 0 n56 ns315 0 -6.39187383807e-05
Gc28_316 0 n56 ns316 0 0.000146868581564
Gc28_317 0 n56 ns317 0 0.000259022156659
Gc28_318 0 n56 ns318 0 0.000339530191489
Gc28_319 0 n56 ns319 0 0.000742807465408
Gc28_320 0 n56 ns320 0 -0.000501457891273
Gc28_321 0 n56 ns321 0 6.27283781992e-05
Gc28_322 0 n56 ns322 0 -0.000713111037328
Gc28_323 0 n56 ns323 0 2.31926569517e-05
Gc28_324 0 n56 ns324 0 -0.00072888256225
Gc28_325 0 n56 ns325 0 -0.000117519716021
Gc28_326 0 n56 ns326 0 -0.000471711106376
Gc28_327 0 n56 ns327 0 -0.00444476025209
Gc28_328 0 n56 ns328 0 -0.00179539346479
Gc28_329 0 n56 ns329 0 -0.00398782582629
Gc28_330 0 n56 ns330 0 -0.00149184755844
Gc28_331 0 n56 ns331 0 0.00022199729721
Gc28_332 0 n56 ns332 0 0.00145264114383
Gc28_333 0 n56 ns333 0 -0.000284012604314
Gc28_334 0 n56 ns334 0 -0.000407621586877
Gc28_335 0 n56 ns335 0 -0.000976239647714
Gc28_336 0 n56 ns336 0 -0.00129065630556
Gc28_337 0 n56 ns337 0 -0.000109808731065
Gc28_338 0 n56 ns338 0 -0.000702305666055
Gc28_339 0 n56 ns339 0 -0.000237088169524
Gc28_340 0 n56 ns340 0 3.5366532828e-07
Gc28_341 0 n56 ns341 0 4.33967362715e-05
Gc28_342 0 n56 ns342 0 1.85438098996e-05
Gc28_343 0 n56 ns343 0 -0.000439619510791
Gc28_344 0 n56 ns344 0 9.61627718524e-05
Gc28_345 0 n56 ns345 0 -0.000962018494273
Gc28_346 0 n56 ns346 0 0.00245791001539
Gc28_347 0 n56 ns347 0 -0.000141149859533
Gc28_348 0 n56 ns348 0 0.000410658026006
Gc28_349 0 n56 ns349 0 0.000196283326691
Gc28_350 0 n56 ns350 0 -0.000269496888191
Gc28_351 0 n56 ns351 0 1.60029262782e-05
Gc28_352 0 n56 ns352 0 0.00052308320812
Gc28_353 0 n56 ns353 0 -0.00017131775498
Gc28_354 0 n56 ns354 0 5.53044661897e-05
Gc28_355 0 n56 ns355 0 0.000648946179287
Gc28_356 0 n56 ns356 0 -0.00050139138285
Gc28_357 0 n56 ns357 0 2.92196735157e-05
Gc28_358 0 n56 ns358 0 -0.000130415691657
Gc28_359 0 n56 ns359 0 0.00081535144
Gc28_360 0 n56 ns360 0 -0.000519114707523
Gc28_361 0 n56 ns361 0 0.000419539725243
Gc28_362 0 n56 ns362 0 -0.000760224492681
Gc28_363 0 n56 ns363 0 -0.000712288581915
Gc28_364 0 n56 ns364 0 0.00100370948749
Gc28_365 0 n56 ns365 0 -0.0018080142271
Gc28_366 0 n56 ns366 0 -0.0035298912094
Gc28_367 0 n56 ns367 0 -0.00172261872915
Gc28_368 0 n56 ns368 0 -0.00384522330638
Gc28_369 0 n56 ns369 0 -0.000578915379897
Gc28_370 0 n56 ns370 0 0.000816979848899
Gc28_371 0 n56 ns371 0 0.00037431141013
Gc28_372 0 n56 ns372 0 -0.00136029302111
Gc28_373 0 n56 ns373 0 9.93417416682e-05
Gc28_374 0 n56 ns374 0 -0.0029753551107
Gc28_375 0 n56 ns375 0 0.00108845538939
Gc28_376 0 n56 ns376 0 -0.00332134319729
Gc28_377 0 n56 ns377 0 -0.00160301279247
Gc28_378 0 n56 ns378 0 -2.34823539514e-05
Gc28_379 0 n56 ns379 0 8.04176045952e-05
Gc28_380 0 n56 ns380 0 7.1192147645e-06
Gc28_381 0 n56 ns381 0 -0.00133328679605
Gc28_382 0 n56 ns382 0 -5.96278512106e-05
Gc28_383 0 n56 ns383 0 -0.00472630911906
Gc28_384 0 n56 ns384 0 -0.000592557312875
Gc28_385 0 n56 ns385 0 -0.00211159116348
Gc28_386 0 n56 ns386 0 0.00146791002621
Gc28_387 0 n56 ns387 0 0.000955171807239
Gc28_388 0 n56 ns388 0 -0.000670353401888
Gc28_389 0 n56 ns389 0 -0.000350343030536
Gc28_390 0 n56 ns390 0 0.000158175401986
Gc28_391 0 n56 ns391 0 -0.00016446863298
Gc28_392 0 n56 ns392 0 5.90620939863e-05
Gc28_393 0 n56 ns393 0 0.000848353915337
Gc28_394 0 n56 ns394 0 -2.82418742652e-05
Gc28_395 0 n56 ns395 0 0.00111256528837
Gc28_396 0 n56 ns396 0 -0.00102381583213
Gc28_397 0 n56 ns397 0 0.0011483157415
Gc28_398 0 n56 ns398 0 -0.000433854028415
Gc28_399 0 n56 ns399 0 0.00101025014939
Gc28_400 0 n56 ns400 0 -0.000699894704383
Gc28_401 0 n56 ns401 0 -0.00219268183759
Gc28_402 0 n56 ns402 0 -0.000856103931872
Gc28_403 0 n56 ns403 0 -0.00647608742722
Gc28_404 0 n56 ns404 0 -0.0032131283347
Gc28_405 0 n56 ns405 0 -0.00514619084414
Gc28_406 0 n56 ns406 0 -0.00361206476361
Gc28_407 0 n56 ns407 0 0.00336087181439
Gc28_408 0 n56 ns408 0 0.00220214719868
Gc28_409 0 n56 ns409 0 0.000861248441203
Gc28_410 0 n56 ns410 0 -0.00123311602039
Gc28_411 0 n56 ns411 0 -0.00202443390233
Gc28_412 0 n56 ns412 0 -0.00310741917135
Gc28_413 0 n56 ns413 0 0.0024861118944
Gc28_414 0 n56 ns414 0 -0.000705242647852
Gc28_415 0 n56 ns415 0 -0.00322061728678
Gc28_416 0 n56 ns416 0 -4.79641528395e-05
Gc28_417 0 n56 ns417 0 0.000383949786148
Gc28_418 0 n56 ns418 0 -0.000176631464628
Gc28_419 0 n56 ns419 0 2.42678020285e-05
Gc28_420 0 n56 ns420 0 -0.000703715036168
Gc28_421 0 n56 ns421 0 0.00184144916355
Gc28_422 0 n56 ns422 0 0.00161068260645
Gc28_423 0 n56 ns423 0 0.00164612582172
Gc28_424 0 n56 ns424 0 -0.00120055236467
Gc28_425 0 n56 ns425 0 -0.000558539100726
Gc28_426 0 n56 ns426 0 0.00014659177616
Gc28_427 0 n56 ns427 0 4.46090738311e-05
Gc28_428 0 n56 ns428 0 -3.51337002825e-05
Gc28_429 0 n56 ns429 0 -0.000141868736559
Gc28_430 0 n56 ns430 0 4.23006725729e-05
Gc28_431 0 n56 ns431 0 0.00191253951323
Gc28_432 0 n56 ns432 0 -0.000636671512596
Gc28_433 0 n56 ns433 0 -0.000644144836899
Gc28_434 0 n56 ns434 0 0.00134993009101
Gc28_435 0 n56 ns435 0 -0.000523341728857
Gc28_436 0 n56 ns436 0 9.91429299281e-05
Gc28_437 0 n56 ns437 0 -0.00223221279159
Gc28_438 0 n56 ns438 0 -0.00114972825532
Gc28_439 0 n56 ns439 0 0.00292050651112
Gc28_440 0 n56 ns440 0 0.003660686251
Gc28_441 0 n56 ns441 0 -0.0105592988727
Gc28_442 0 n56 ns442 0 0.000529144992223
Gc28_443 0 n56 ns443 0 -0.0081147966156
Gc28_444 0 n56 ns444 0 -0.000763530263696
Gc28_445 0 n56 ns445 0 -0.0106205247354
Gc28_446 0 n56 ns446 0 -0.000244965449986
Gc28_447 0 n56 ns447 0 0.00141636109891
Gc28_448 0 n56 ns448 0 1.59779348503e-05
Gc28_449 0 n56 ns449 0 -0.003738848096
Gc28_450 0 n56 ns450 0 0.00841777319288
Gc28_451 0 n56 ns451 0 -0.0143173195504
Gc28_452 0 n56 ns452 0 -0.00428408156147
Gc28_453 0 n56 ns453 0 -0.00628571524306
Gc28_454 0 n56 ns454 0 -5.27580506369e-05
Gc28_455 0 n56 ns455 0 -0.000353307813752
Gc28_456 0 n56 ns456 0 0.000576464765853
Gc28_457 0 n56 ns457 0 -0.00090364719261
Gc28_458 0 n56 ns458 0 -0.000254870621754
Gc28_459 0 n56 ns459 0 -0.00332363235105
Gc28_460 0 n56 ns460 0 -0.00125755958358
Gc28_461 0 n56 ns461 0 -0.0018933623299
Gc28_462 0 n56 ns462 0 0.00129882380227
Gc28_463 0 n56 ns463 0 0.00082478734112
Gc28_464 0 n56 ns464 0 -0.000565336347346
Gc28_465 0 n56 ns465 0 -0.000300306566187
Gc28_466 0 n56 ns466 0 0.000191031428344
Gc28_467 0 n56 ns467 0 -0.000163584356767
Gc28_468 0 n56 ns468 0 -8.17108915589e-06
Gc28_469 0 n56 ns469 0 0.000462912725721
Gc28_470 0 n56 ns470 0 -7.1120350181e-05
Gc28_471 0 n56 ns471 0 0.000782449683738
Gc28_472 0 n56 ns472 0 -0.000961079784878
Gc28_473 0 n56 ns473 0 0.00101272153508
Gc28_474 0 n56 ns474 0 -0.000309732307962
Gc28_475 0 n56 ns475 0 0.000870473200953
Gc28_476 0 n56 ns476 0 -0.000595816506946
Gc28_477 0 n56 ns477 0 -0.0021025729549
Gc28_478 0 n56 ns478 0 -0.000575373642453
Gc28_479 0 n56 ns479 0 -0.00605615772836
Gc28_480 0 n56 ns480 0 -0.00180544714257
Gc28_481 0 n56 ns481 0 -0.00478108949631
Gc28_482 0 n56 ns482 0 -0.00242166721687
Gc28_483 0 n56 ns483 0 0.00399770968185
Gc28_484 0 n56 ns484 0 0.00227966911132
Gc28_485 0 n56 ns485 0 0.000778180886812
Gc28_486 0 n56 ns486 0 -0.00122712279008
Gc28_487 0 n56 ns487 0 -0.00251845136556
Gc28_488 0 n56 ns488 0 -0.00323154813706
Gc28_489 0 n56 ns489 0 0.00231536582889
Gc28_490 0 n56 ns490 0 -0.00121525268952
Gc28_491 0 n56 ns491 0 -0.00332616330913
Gc28_492 0 n56 ns492 0 -4.55059600902e-05
Gc28_493 0 n56 ns493 0 0.000358815022895
Gc28_494 0 n56 ns494 0 -0.000173717969657
Gc28_495 0 n56 ns495 0 -8.84277343552e-05
Gc28_496 0 n56 ns496 0 -6.24806836149e-05
Gc28_497 0 n56 ns497 0 9.20590239895e-05
Gc28_498 0 n56 ns498 0 0.00155728181157
Gc28_499 0 n56 ns499 0 9.98789039312e-05
Gc28_500 0 n56 ns500 0 0.000235484202862
Gc28_501 0 n56 ns501 0 2.9036114301e-06
Gc28_502 0 n56 ns502 0 -0.000229827366131
Gc28_503 0 n56 ns503 0 -0.000217662511346
Gc28_504 0 n56 ns504 0 0.00042267938444
Gc28_505 0 n56 ns505 0 -0.000106282271038
Gc28_506 0 n56 ns506 0 6.56034756127e-05
Gc28_507 0 n56 ns507 0 0.000607463569065
Gc28_508 0 n56 ns508 0 -0.000562802035989
Gc28_509 0 n56 ns509 0 -0.000461126184487
Gc28_510 0 n56 ns510 0 -0.000179541030315
Gc28_511 0 n56 ns511 0 0.000412122640117
Gc28_512 0 n56 ns512 0 -0.000336938915353
Gc28_513 0 n56 ns513 0 -6.70591187729e-05
Gc28_514 0 n56 ns514 0 -0.000489383372877
Gc28_515 0 n56 ns515 0 -0.000988194965538
Gc28_516 0 n56 ns516 0 0.00112090137478
Gc28_517 0 n56 ns517 0 -0.00260368924957
Gc28_518 0 n56 ns518 0 -0.00157146461357
Gc28_519 0 n56 ns519 0 -0.00238150218204
Gc28_520 0 n56 ns520 0 -0.00212815465617
Gc28_521 0 n56 ns521 0 0.000109067948999
Gc28_522 0 n56 ns522 0 0.000950929403757
Gc28_523 0 n56 ns523 0 0.00025136488891
Gc28_524 0 n56 ns524 0 -0.00133056628067
Gc28_525 0 n56 ns525 0 -0.000475217367617
Gc28_526 0 n56 ns526 0 -0.00299862908433
Gc28_527 0 n56 ns527 0 0.000918415520918
Gc28_528 0 n56 ns528 0 -0.003604837067
Gc28_529 0 n56 ns529 0 -0.00164503247162
Gc28_530 0 n56 ns530 0 -2.54467130992e-05
Gc28_531 0 n56 ns531 0 0.000103118083138
Gc28_532 0 n56 ns532 0 -1.69768822623e-06
Gc28_533 0 n56 ns533 0 -6.53440841232e-05
Gc28_534 0 n56 ns534 0 -0.000322616279568
Gc28_535 0 n56 ns535 0 -0.00017217646592
Gc28_536 0 n56 ns536 0 0.000235803310973
Gc28_537 0 n56 ns537 0 -0.000106589643099
Gc28_538 0 n56 ns538 0 1.95993465092e-05
Gc28_539 0 n56 ns539 0 -8.1856340373e-05
Gc28_540 0 n56 ns540 0 -6.7729455916e-06
Gc28_541 0 n56 ns541 0 0.000173610035813
Gc28_542 0 n56 ns542 0 0.000228353743062
Gc28_543 0 n56 ns543 0 -6.78190740798e-05
Gc28_544 0 n56 ns544 0 0.00012442899906
Gc28_545 0 n56 ns545 0 5.97182891673e-05
Gc28_546 0 n56 ns546 0 -0.000200135178829
Gc28_547 0 n56 ns547 0 0.00035080239088
Gc28_548 0 n56 ns548 0 0.000581604733441
Gc28_549 0 n56 ns549 0 0.000382497449349
Gc28_550 0 n56 ns550 0 -0.000299611010603
Gc28_551 0 n56 ns551 0 8.94743602841e-05
Gc28_552 0 n56 ns552 0 -6.24792414212e-05
Gc28_553 0 n56 ns553 0 -9.81237444927e-05
Gc28_554 0 n56 ns554 0 -2.76821308807e-05
Gc28_555 0 n56 ns555 0 -0.00416547445402
Gc28_556 0 n56 ns556 0 -0.00460662997046
Gc28_557 0 n56 ns557 0 -0.00393332737853
Gc28_558 0 n56 ns558 0 -0.00419926989689
Gc28_559 0 n56 ns559 0 -0.0006513122194
Gc28_560 0 n56 ns560 0 0.0018181319673
Gc28_561 0 n56 ns561 0 -0.000208202111483
Gc28_562 0 n56 ns562 0 -0.000925619757882
Gc28_563 0 n56 ns563 0 -0.000717952907318
Gc28_564 0 n56 ns564 0 -0.00243018679472
Gc28_565 0 n56 ns565 0 0.000143720622739
Gc28_566 0 n56 ns566 0 -0.00165986848763
Gc28_567 0 n56 ns567 0 -0.000611502346557
Gc28_568 0 n56 ns568 0 -1.93052210549e-05
Gc28_569 0 n56 ns569 0 7.65491045572e-05
Gc28_570 0 n56 ns570 0 1.57696069986e-06
Gc28_571 0 n56 ns571 0 -0.000172828199952
Gc28_572 0 n56 ns572 0 0.000156545033573
Gc28_573 0 n56 ns573 0 -0.000195527787492
Gc28_574 0 n56 ns574 0 0.000565340046943
Gc28_575 0 n56 ns575 0 -9.54865469845e-05
Gc28_576 0 n56 ns576 0 0.00026755788729
Gc28_577 0 n56 ns577 0 0.000150170155732
Gc28_578 0 n56 ns578 0 -0.000121394666824
Gc28_579 0 n56 ns579 0 0.000373799478963
Gc28_580 0 n56 ns580 0 -0.000365858374069
Gc28_581 0 n56 ns581 0 -8.26432499218e-05
Gc28_582 0 n56 ns582 0 0.000155476145671
Gc28_583 0 n56 ns583 0 0.000127265357453
Gc28_584 0 n56 ns584 0 0.000350300044299
Gc28_585 0 n56 ns585 0 0.000823694325963
Gc28_586 0 n56 ns586 0 -0.000339989672946
Gc28_587 0 n56 ns587 0 0.000137707589269
Gc28_588 0 n56 ns588 0 -0.00075682133389
Gc28_589 0 n56 ns589 0 5.87611748646e-05
Gc28_590 0 n56 ns590 0 -0.000728965230294
Gc28_591 0 n56 ns591 0 -8.45145731987e-05
Gc28_592 0 n56 ns592 0 -0.00049066499673
Gc28_593 0 n56 ns593 0 -0.00518381024951
Gc28_594 0 n56 ns594 0 -0.00256173521341
Gc28_595 0 n56 ns595 0 -0.00468567970836
Gc28_596 0 n56 ns596 0 -0.00217780191888
Gc28_597 0 n56 ns597 0 0.000175967913815
Gc28_598 0 n56 ns598 0 0.00186282152813
Gc28_599 0 n56 ns599 0 -0.000327095779944
Gc28_600 0 n56 ns600 0 -0.000539222035131
Gc28_601 0 n56 ns601 0 -0.0010974217122
Gc28_602 0 n56 ns602 0 -0.00177874243361
Gc28_603 0 n56 ns603 0 -0.000137661418696
Gc28_604 0 n56 ns604 0 -0.00123434868666
Gc28_605 0 n56 ns605 0 -0.000372194316304
Gc28_606 0 n56 ns606 0 8.2729210224e-07
Gc28_607 0 n56 ns607 0 5.16534303463e-05
Gc28_608 0 n56 ns608 0 1.12756689027e-05
Gc28_609 0 n56 ns609 0 1.66980332675e-05
Gc28_610 0 n56 ns610 0 -0.00067203017075
Gc28_611 0 n56 ns611 0 7.51960846165e-06
Gc28_612 0 n56 ns612 0 -0.000254882042877
Gc28_613 0 n56 ns613 0 0.000125444471107
Gc28_614 0 n56 ns614 0 -0.000222842707385
Gc28_615 0 n56 ns615 0 0.000145476834781
Gc28_616 0 n56 ns616 0 8.19823502521e-05
Gc28_617 0 n56 ns617 0 -0.000384492153527
Gc28_618 0 n56 ns618 0 -0.000545149635214
Gc28_619 0 n56 ns619 0 0.000163319379502
Gc28_620 0 n56 ns620 0 -1.70301165082e-05
Gc28_621 0 n56 ns621 0 -0.000145326036419
Gc28_622 0 n56 ns622 0 0.000198064572466
Gc28_623 0 n56 ns623 0 0.000112624355265
Gc28_624 0 n56 ns624 0 0.001469034024
Gc28_625 0 n56 ns625 0 0.000551812109809
Gc28_626 0 n56 ns626 0 0.000112378694764
Gc28_627 0 n56 ns627 0 1.00287262372e-06
Gc28_628 0 n56 ns628 0 0.000307542742667
Gc28_629 0 n56 ns629 0 -0.00118807500548
Gc28_630 0 n56 ns630 0 -0.000828051397722
Gc28_631 0 n56 ns631 0 -0.000499080800413
Gc28_632 0 n56 ns632 0 0.00390078646896
Gc28_633 0 n56 ns633 0 -2.22075198391e-05
Gc28_634 0 n56 ns634 0 0.00379201009866
Gc28_635 0 n56 ns635 0 -0.00190768846638
Gc28_636 0 n56 ns636 0 0.000505768152351
Gc28_637 0 n56 ns637 0 6.75583019247e-05
Gc28_638 0 n56 ns638 0 -0.000804955215045
Gc28_639 0 n56 ns639 0 0.000374929670361
Gc28_640 0 n56 ns640 0 -0.00136176490132
Gc28_641 0 n56 ns641 0 -0.000376947945566
Gc28_642 0 n56 ns642 0 0.00100770689589
Gc28_643 0 n56 ns643 0 0.000546184356765
Gc28_644 0 n56 ns644 0 -6.41762813415e-06
Gc28_645 0 n56 ns645 0 -0.000147236325959
Gc28_646 0 n56 ns646 0 6.24141011756e-06
Gc28_647 0 n56 ns647 0 -0.000157514665786
Gc28_648 0 n56 ns648 0 -0.000625623258549
Gc28_649 0 n56 ns649 0 -0.000539277450917
Gc28_650 0 n56 ns650 0 -0.000325087513052
Gc28_651 0 n56 ns651 0 9.13300990808e-05
Gc28_652 0 n56 ns652 0 -0.000101341583583
Gc28_653 0 n56 ns653 0 3.28270388814e-05
Gc28_654 0 n56 ns654 0 0.000101548610885
Gc28_655 0 n56 ns655 0 -0.000364564591795
Gc28_656 0 n56 ns656 0 -0.000568889168832
Gc28_657 0 n56 ns657 0 0.000204457992382
Gc28_658 0 n56 ns658 0 -6.29745331638e-06
Gc28_659 0 n56 ns659 0 6.77979090744e-05
Gc28_660 0 n56 ns660 0 0.000166098470955
Gc28_661 0 n56 ns661 0 -0.000105321851811
Gc28_662 0 n56 ns662 0 0.00138275367507
Gc28_663 0 n56 ns663 0 0.000584754064135
Gc28_664 0 n56 ns664 0 5.16233573164e-05
Gc28_665 0 n56 ns665 0 -7.11057455116e-05
Gc28_666 0 n56 ns666 0 0.000171966742089
Gc28_667 0 n56 ns667 0 -0.000889774052326
Gc28_668 0 n56 ns668 0 -0.00116879566683
Gc28_669 0 n56 ns669 0 -0.000233289304791
Gc28_670 0 n56 ns670 0 0.00384063515494
Gc28_671 0 n56 ns671 0 0.000206200968798
Gc28_672 0 n56 ns672 0 0.00390228353127
Gc28_673 0 n56 ns673 0 -0.00245881100846
Gc28_674 0 n56 ns674 0 -0.000169317902185
Gc28_675 0 n56 ns675 0 0.000209064942149
Gc28_676 0 n56 ns676 0 -0.000925360480397
Gc28_677 0 n56 ns677 0 0.000756182686269
Gc28_678 0 n56 ns678 0 -0.00109716208034
Gc28_679 0 n56 ns679 0 -0.000500932639346
Gc28_680 0 n56 ns680 0 0.00200049793609
Gc28_681 0 n56 ns681 0 0.000915114914931
Gc28_682 0 n56 ns682 0 -6.93431879761e-06
Gc28_683 0 n56 ns683 0 -0.000139727135906
Gc28_684 0 n56 ns684 0 4.44893966043e-06
Gc28_685 0 n56 ns685 0 0.000651825301348
Gc28_686 0 n56 ns686 0 -0.00187662374686
Gc28_687 0 n56 ns687 0 0.0017911478737
Gc28_688 0 n56 ns688 0 -0.00127906632721
Gc28_689 0 n56 ns689 0 -0.000334612925432
Gc28_690 0 n56 ns690 0 6.08824897673e-05
Gc28_691 0 n56 ns691 0 -0.000130405739326
Gc28_692 0 n56 ns692 0 -0.00012656127517
Gc28_693 0 n56 ns693 0 0.000246286398452
Gc28_694 0 n56 ns694 0 -4.23726547604e-05
Gc28_695 0 n56 ns695 0 0.000211885207549
Gc28_696 0 n56 ns696 0 -4.80174557825e-05
Gc28_697 0 n56 ns697 0 2.68089206109e-05
Gc28_698 0 n56 ns698 0 0.000105708614032
Gc28_699 0 n56 ns699 0 -0.00035997098475
Gc28_700 0 n56 ns700 0 -0.000809407091707
Gc28_701 0 n56 ns701 0 0.000581292497534
Gc28_702 0 n56 ns702 0 -0.000708975340557
Gc28_703 0 n56 ns703 0 0.000113113865234
Gc28_704 0 n56 ns704 0 -0.00126226787217
Gc28_705 0 n56 ns705 0 0.0017934301838
Gc28_706 0 n56 ns706 0 0.000187465297107
Gc28_707 0 n56 ns707 0 0.00295985828531
Gc28_708 0 n56 ns708 0 0.00422530270734
Gc28_709 0 n56 ns709 0 0.00253394444371
Gc28_710 0 n56 ns710 0 0.00445807391232
Gc28_711 0 n56 ns711 0 -9.61303166028e-05
Gc28_712 0 n56 ns712 0 -0.00190631941417
Gc28_713 0 n56 ns713 0 0.000678706245045
Gc28_714 0 n56 ns714 0 -0.00107150106855
Gc28_715 0 n56 ns715 0 2.62704749786e-05
Gc28_716 0 n56 ns716 0 -0.000639706233689
Gc28_717 0 n56 ns717 0 -0.00223257148454
Gc28_718 0 n56 ns718 0 0.00220162018092
Gc28_719 0 n56 ns719 0 0.00197656519555
Gc28_720 0 n56 ns720 0 2.01473814815e-05
Gc28_721 0 n56 ns721 0 -0.000208650670575
Gc28_722 0 n56 ns722 0 5.94937195515e-05
Gc28_723 0 n56 ns723 0 0.00122295016662
Gc28_724 0 n56 ns724 0 -0.00453622198832
Gc28_725 0 n56 ns725 0 0.00150397767876
Gc28_726 0 n56 ns726 0 -0.00304345710032
Gc28_727 0 n56 ns727 0 -0.0012035397572
Gc28_728 0 n56 ns728 0 -0.000620890086129
Gc28_729 0 n56 ns729 0 0.000625732576325
Gc28_730 0 n56 ns730 0 -6.30723572515e-05
Gc28_731 0 n56 ns731 0 0.000155966137159
Gc28_732 0 n56 ns732 0 0.000585356364399
Gc28_733 0 n56 ns733 0 0.000253042233795
Gc28_734 0 n56 ns734 0 -4.44098737427e-05
Gc28_735 0 n56 ns735 0 -0.000565915995881
Gc28_736 0 n56 ns736 0 0.000167236522789
Gc28_737 0 n56 ns737 0 0.000491259111713
Gc28_738 0 n56 ns738 0 -0.000847152758035
Gc28_739 0 n56 ns739 0 0.000603281437092
Gc28_740 0 n56 ns740 0 -0.000500202886442
Gc28_741 0 n56 ns741 0 5.37112477446e-05
Gc28_742 0 n56 ns742 0 -0.00121770120736
Gc28_743 0 n56 ns743 0 0.0010408101798
Gc28_744 0 n56 ns744 0 0.00163162667448
Gc28_745 0 n56 ns745 0 0.00589899095093
Gc28_746 0 n56 ns746 0 0.0055918567669
Gc28_747 0 n56 ns747 0 0.00450113934296
Gc28_748 0 n56 ns748 0 0.00556826629136
Gc28_749 0 n56 ns749 0 0.00269731806114
Gc28_750 0 n56 ns750 0 0.00185735660054
Gc28_751 0 n56 ns751 0 0.00093127076345
Gc28_752 0 n56 ns752 0 -0.000913446856305
Gc28_753 0 n56 ns753 0 -0.00410185782882
Gc28_754 0 n56 ns754 0 -0.00113591676019
Gc28_755 0 n56 ns755 0 -0.000640109094202
Gc28_756 0 n56 ns756 0 -0.00219985270815
Gc28_757 0 n56 ns757 0 0.00380416182699
Gc28_758 0 n56 ns758 0 2.06270739935e-05
Gc28_759 0 n56 ns759 0 -0.000112403357631
Gc28_760 0 n56 ns760 0 1.69565301446e-05
Gc28_761 0 n56 ns761 0 0.000708929277688
Gc28_762 0 n56 ns762 0 -0.00380338875488
Gc28_763 0 n56 ns763 0 -0.00115477100741
Gc28_764 0 n56 ns764 0 -0.00139430397941
Gc28_765 0 n56 ns765 0 -0.00125315125354
Gc28_766 0 n56 ns766 0 -6.57754898691e-05
Gc28_767 0 n56 ns767 0 0.00070845225203
Gc28_768 0 n56 ns768 0 -0.000148745611562
Gc28_769 0 n56 ns769 0 0.000126152091689
Gc28_770 0 n56 ns770 0 0.000525322840991
Gc28_771 0 n56 ns771 0 0.000278392379416
Gc28_772 0 n56 ns772 0 -1.39937223248e-05
Gc28_773 0 n56 ns773 0 -0.000415526848516
Gc28_774 0 n56 ns774 0 -0.000461374105241
Gc28_775 0 n56 ns775 0 5.98210492346e-05
Gc28_776 0 n56 ns776 0 -6.78478876562e-05
Gc28_777 0 n56 ns777 0 0.000340242190477
Gc28_778 0 n56 ns778 0 -0.00027752556131
Gc28_779 0 n56 ns779 0 -0.000366604008297
Gc28_780 0 n56 ns780 0 -0.00115072579817
Gc28_781 0 n56 ns781 0 -0.000297643419571
Gc28_782 0 n56 ns782 0 5.20810376272e-05
Gc28_783 0 n56 ns783 0 0.00642037487635
Gc28_784 0 n56 ns784 0 0.00586687789752
Gc28_785 0 n56 ns785 0 0.00479170059216
Gc28_786 0 n56 ns786 0 0.00575876554805
Gc28_787 0 n56 ns787 0 0.000532353772948
Gc28_788 0 n56 ns788 0 0.00533885077535
Gc28_789 0 n56 ns789 0 0.00083832669732
Gc28_790 0 n56 ns790 0 -0.000897198007813
Gc28_791 0 n56 ns791 0 -0.00629155491424
Gc28_792 0 n56 ns792 0 -0.00185710593309
Gc28_793 0 n56 ns793 0 0.003328624698
Gc28_794 0 n56 ns794 0 -0.00500438220337
Gc28_795 0 n56 ns795 0 0.00460371938479
Gc28_796 0 n56 ns796 0 -1.64325345998e-05
Gc28_797 0 n56 ns797 0 5.24184131195e-05
Gc28_798 0 n56 ns798 0 -8.94785626995e-05
Gc28_799 0 n56 ns799 0 0.000429088100392
Gc28_800 0 n56 ns800 0 -0.00170060004063
Gc28_801 0 n56 ns801 0 0.00118052974586
Gc28_802 0 n56 ns802 0 -0.00103855552181
Gc28_803 0 n56 ns803 0 -0.000788091604408
Gc28_804 0 n56 ns804 0 8.94477584245e-05
Gc28_805 0 n56 ns805 0 0.00019718437141
Gc28_806 0 n56 ns806 0 -0.000333262733463
Gc28_807 0 n56 ns807 0 0.00034046240383
Gc28_808 0 n56 ns808 0 0.000142108852605
Gc28_809 0 n56 ns809 0 0.000203764033564
Gc28_810 0 n56 ns810 0 -3.29502964765e-05
Gc28_811 0 n56 ns811 0 -2.4065366064e-05
Gc28_812 0 n56 ns812 0 0.000306268875868
Gc28_813 0 n56 ns813 0 0.000148918978528
Gc28_814 0 n56 ns814 0 -0.000918464753026
Gc28_815 0 n56 ns815 0 0.000728657056484
Gc28_816 0 n56 ns816 0 -0.000466098091708
Gc28_817 0 n56 ns817 0 0.000418504779191
Gc28_818 0 n56 ns818 0 -0.000805996646362
Gc28_819 0 n56 ns819 0 0.00160007744478
Gc28_820 0 n56 ns820 0 0.00120830250607
Gc28_821 0 n56 ns821 0 0.00194695696333
Gc28_822 0 n56 ns822 0 0.00375465508222
Gc28_823 0 n56 ns823 0 0.00154237326423
Gc28_824 0 n56 ns824 0 0.00398087443238
Gc28_825 0 n56 ns825 0 0.00161920487234
Gc28_826 0 n56 ns826 0 -0.00166666098812
Gc28_827 0 n56 ns827 0 0.000822913054152
Gc28_828 0 n56 ns828 0 -0.000971884671664
Gc28_829 0 n56 ns829 0 -0.000521735395526
Gc28_830 0 n56 ns830 0 -0.000597599254107
Gc28_831 0 n56 ns831 0 -0.00325894167546
Gc28_832 0 n56 ns832 0 0.00212239720502
Gc28_833 0 n56 ns833 0 0.0025655470386
Gc28_834 0 n56 ns834 0 4.00762566762e-05
Gc28_835 0 n56 ns835 0 -0.00015438459058
Gc28_836 0 n56 ns836 0 2.8470760748e-05
Gc28_837 0 n56 ns837 0 -0.000315522307463
Gc28_838 0 n56 ns838 0 0.000102962360372
Gc28_839 0 n56 ns839 0 -0.000617441114885
Gc28_840 0 n56 ns840 0 0.000498276660395
Gc28_841 0 n56 ns841 0 -0.000105181183867
Gc28_842 0 n56 ns842 0 0.000427560346377
Gc28_843 0 n56 ns843 0 4.59298688655e-05
Gc28_844 0 n56 ns844 0 -8.11898342335e-05
Gc28_845 0 n56 ns845 0 9.61119268448e-05
Gc28_846 0 n56 ns846 0 -0.000247139437545
Gc28_847 0 n56 ns847 0 0.000149859367105
Gc28_848 0 n56 ns848 0 -7.45144968994e-05
Gc28_849 0 n56 ns849 0 1.57463059345e-05
Gc28_850 0 n56 ns850 0 -0.000336327961413
Gc28_851 0 n56 ns851 0 -0.000585025882242
Gc28_852 0 n56 ns852 0 0.000308624188897
Gc28_853 0 n56 ns853 0 0.000198310639066
Gc28_854 0 n56 ns854 0 -0.000338915154461
Gc28_855 0 n56 ns855 0 -0.000332314308645
Gc28_856 0 n56 ns856 0 -0.00050760286768
Gc28_857 0 n56 ns857 0 0.000281734051937
Gc28_858 0 n56 ns858 0 -0.00113946486548
Gc28_859 0 n56 ns859 0 0.00138966286547
Gc28_860 0 n56 ns860 0 0.00237403381505
Gc28_861 0 n56 ns861 0 0.00146282360666
Gc28_862 0 n56 ns862 0 0.00263119927548
Gc28_863 0 n56 ns863 0 -0.00214756559228
Gc28_864 0 n56 ns864 0 -0.000707736048452
Gc28_865 0 n56 ns865 0 0.000235396441946
Gc28_866 0 n56 ns866 0 -0.000980825368351
Gc28_867 0 n56 ns867 0 0.000489046141149
Gc28_868 0 n56 ns868 0 -0.000922401799961
Gc28_869 0 n56 ns869 0 -0.000834834488521
Gc28_870 0 n56 ns870 0 0.00242517880769
Gc28_871 0 n56 ns871 0 0.00113846837259
Gc28_872 0 n56 ns872 0 1.9994379697e-05
Gc28_873 0 n56 ns873 0 -0.000173389439943
Gc28_874 0 n56 ns874 0 5.00429967606e-05
Gc28_875 0 n56 ns875 0 -6.91086380771e-05
Gc28_876 0 n56 ns876 0 -2.06804033581e-05
Gc28_877 0 n56 ns877 0 4.3689219475e-05
Gc28_878 0 n56 ns878 0 0.000585382924035
Gc28_879 0 n56 ns879 0 2.9432483544e-05
Gc28_880 0 n56 ns880 0 1.0977962672e-05
Gc28_881 0 n56 ns881 0 7.06765510429e-05
Gc28_882 0 n56 ns882 0 -5.62216626191e-05
Gc28_883 0 n56 ns883 0 -0.000246498690398
Gc28_884 0 n56 ns884 0 0.000108122104571
Gc28_885 0 n56 ns885 0 8.91680620084e-05
Gc28_886 0 n56 ns886 0 -0.000156219174512
Gc28_887 0 n56 ns887 0 -0.000209188345201
Gc28_888 0 n56 ns888 0 -0.000185813772496
Gc28_889 0 n56 ns889 0 0.000553423233595
Gc28_890 0 n56 ns890 0 0.000229314521072
Gc28_891 0 n56 ns891 0 0.000234837484466
Gc28_892 0 n56 ns892 0 -0.000534452788187
Gc28_893 0 n56 ns893 0 -8.25089220115e-06
Gc28_894 0 n56 ns894 0 -0.000407056104105
Gc28_895 0 n56 ns895 0 -0.000448747740904
Gc28_896 0 n56 ns896 0 0.000243928446665
Gc28_897 0 n56 ns897 0 0.00309132356625
Gc28_898 0 n56 ns898 0 0.00334286666045
Gc28_899 0 n56 ns899 0 0.00302877378644
Gc28_900 0 n56 ns900 0 0.00298738943825
Gc28_901 0 n56 ns901 0 -0.000609059028361
Gc28_902 0 n56 ns902 0 0.000997469738893
Gc28_903 0 n56 ns903 0 -0.000236038441238
Gc28_904 0 n56 ns904 0 -0.000652428241307
Gc28_905 0 n56 ns905 0 -0.000772338787953
Gc28_906 0 n56 ns906 0 -0.00137525351161
Gc28_907 0 n56 ns907 0 -0.000569961436036
Gc28_908 0 n56 ns908 0 0.000374740806587
Gc28_909 0 n56 ns909 0 0.000337225915688
Gc28_910 0 n56 ns910 0 -3.24640553243e-06
Gc28_911 0 n56 ns911 0 -5.30795609632e-05
Gc28_912 0 n56 ns912 0 -2.02703196416e-05
Gc28_913 0 n56 ns913 0 6.1895995925e-06
Gc28_914 0 n56 ns914 0 0.000265124696048
Gc28_915 0 n56 ns915 0 9.83611153224e-06
Gc28_916 0 n56 ns916 0 0.000874856007823
Gc28_917 0 n56 ns917 0 4.95511644911e-05
Gc28_918 0 n56 ns918 0 -2.54703481688e-05
Gc28_919 0 n56 ns919 0 -0.000156601582243
Gc28_920 0 n56 ns920 0 2.69348610464e-05
Gc28_921 0 n56 ns921 0 -0.000293952531987
Gc28_922 0 n56 ns922 0 0.000445802968967
Gc28_923 0 n56 ns923 0 5.92879148223e-05
Gc28_924 0 n56 ns924 0 -0.000116459182892
Gc28_925 0 n56 ns925 0 0.000272245347983
Gc28_926 0 n56 ns926 0 -0.000323825847779
Gc28_927 0 n56 ns927 0 0.000921583938503
Gc28_928 0 n56 ns928 0 -0.000698220889395
Gc28_929 0 n56 ns929 0 0.000243816467739
Gc28_930 0 n56 ns930 0 -0.000764759268833
Gc28_931 0 n56 ns931 0 0.000436753305753
Gc28_932 0 n56 ns932 0 -0.000747574404444
Gc28_933 0 n56 ns933 0 0.000143328083898
Gc28_934 0 n56 ns934 0 0.00116976046738
Gc28_935 0 n56 ns935 0 0.0036561930718
Gc28_936 0 n56 ns936 0 0.00292839790356
Gc28_937 0 n56 ns937 0 0.0033422597676
Gc28_938 0 n56 ns938 0 0.0023912277
Gc28_939 0 n56 ns939 0 0.00076347739721
Gc28_940 0 n56 ns940 0 0.0010279215833
Gc28_941 0 n56 ns941 0 -0.000341725285166
Gc28_942 0 n56 ns942 0 -0.000360646375352
Gc28_943 0 n56 ns943 0 -0.00145010775574
Gc28_944 0 n56 ns944 0 -0.00102482038901
Gc28_945 0 n56 ns945 0 -0.000550491219665
Gc28_946 0 n56 ns946 0 -0.000360587151104
Gc28_947 0 n56 ns947 0 6.4789123822e-05
Gc28_948 0 n56 ns948 0 6.3193643741e-06
Gc28_949 0 n56 ns949 0 -7.79353073704e-05
Gc28_950 0 n56 ns950 0 -2.71001654773e-06
Gc28_951 0 n56 ns951 0 0.000247099089113
Gc28_952 0 n56 ns952 0 -0.00107554171094
Gc28_953 0 n56 ns953 0 0.000645944391827
Gc28_954 0 n56 ns954 0 -0.000517399539474
Gc28_955 0 n56 ns955 0 -0.000121942041405
Gc28_956 0 n56 ns956 0 0.000245983931954
Gc28_957 0 n56 ns957 0 -0.0001690513688
Gc28_958 0 n56 ns958 0 -0.000112937750378
Gc28_959 0 n56 ns959 0 3.16207277953e-05
Gc28_960 0 n56 ns960 0 -0.000340832790652
Gc28_961 0 n56 ns961 0 0.000208541132469
Gc28_962 0 n56 ns962 0 -2.71701487362e-05
Gc28_963 0 n56 ns963 0 0.000238926213503
Gc28_964 0 n56 ns964 0 1.07427655262e-05
Gc28_965 0 n56 ns965 0 -0.000386275694367
Gc28_966 0 n56 ns966 0 -2.74864793433e-05
Gc28_967 0 n56 ns967 0 0.000593807558469
Gc28_968 0 n56 ns968 0 -0.000505400593191
Gc28_969 0 n56 ns969 0 0.000114185297328
Gc28_970 0 n56 ns970 0 -0.000846665392558
Gc28_971 0 n56 ns971 0 0.000916599040323
Gc28_972 0 n56 ns972 0 -0.000574886666711
Gc28_973 0 n56 ns973 0 0.0015776486866
Gc28_974 0 n56 ns974 0 0.00431901050814
Gc28_975 0 n56 ns975 0 0.00152070129909
Gc28_976 0 n56 ns976 0 0.00446098897423
Gc28_977 0 n56 ns977 0 -0.00148854587575
Gc28_978 0 n56 ns978 0 -0.00155381436726
Gc28_979 0 n56 ns979 0 0.000491424317406
Gc28_980 0 n56 ns980 0 -0.00106718393425
Gc28_981 0 n56 ns981 0 0.000493412015889
Gc28_982 0 n56 ns982 0 -0.000783661861797
Gc28_983 0 n56 ns983 0 -0.00140907223807
Gc28_984 0 n56 ns984 0 0.00256904706434
Gc28_985 0 n56 ns985 0 0.00151275444263
Gc28_986 0 n56 ns986 0 2.40786783492e-05
Gc28_987 0 n56 ns987 0 -0.000217474902113
Gc28_988 0 n56 ns988 0 6.80164905245e-05
Gc28_989 0 n56 ns989 0 0.000490826367904
Gc28_990 0 n56 ns990 0 -0.00223930240053
Gc28_991 0 n56 ns991 0 0.00100106329297
Gc28_992 0 n56 ns992 0 -0.00059751222365
Gc28_993 0 n56 ns993 0 -0.000757555444314
Gc28_994 0 n56 ns994 0 0.000210438752799
Gc28_995 0 n56 ns995 0 0.000259896190796
Gc28_996 0 n56 ns996 0 -0.000411634165545
Gc28_997 0 n56 ns997 0 0.000263970286667
Gc28_998 0 n56 ns998 0 0.000427482677229
Gc28_999 0 n56 ns999 0 0.000251857144848
Gc28_1000 0 n56 ns1000 0 -5.05280515451e-05
Gc28_1001 0 n56 ns1001 0 -0.000399051699632
Gc28_1002 0 n56 ns1002 0 -2.24792220577e-06
Gc28_1003 0 n56 ns1003 0 0.000743348238034
Gc28_1004 0 n56 ns1004 0 -0.000995353672819
Gc28_1005 0 n56 ns1005 0 0.000867383821956
Gc28_1006 0 n56 ns1006 0 -0.000528340816991
Gc28_1007 0 n56 ns1007 0 0.000470323997111
Gc28_1008 0 n56 ns1008 0 -0.00103414651419
Gc28_1009 0 n56 ns1009 0 0.000996107141897
Gc28_1010 0 n56 ns1010 0 0.00225848019041
Gc28_1011 0 n56 ns1011 0 0.00325456827305
Gc28_1012 0 n56 ns1012 0 0.00489501703628
Gc28_1013 0 n56 ns1013 0 0.00252174506876
Gc28_1014 0 n56 ns1014 0 0.00501081533368
Gc28_1015 0 n56 ns1015 0 0.00362876261396
Gc28_1016 0 n56 ns1016 0 0.000381758504892
Gc28_1017 0 n56 ns1017 0 0.000896933980225
Gc28_1018 0 n56 ns1018 0 -0.00097701931796
Gc28_1019 0 n56 ns1019 0 -0.00190804164722
Gc28_1020 0 n56 ns1020 0 -0.00130922377877
Gc28_1021 0 n56 ns1021 0 -0.00391992974295
Gc28_1022 0 n56 ns1022 0 -0.000287176765152
Gc28_1023 0 n56 ns1023 0 0.0030887377528
Gc28_1024 0 n56 ns1024 0 5.61898661934e-05
Gc28_1025 0 n56 ns1025 0 -0.00016986799214
Gc28_1026 0 n56 ns1026 0 4.96220294442e-05
Gc28_1027 0 n56 ns1027 0 -2.73190833516e-05
Gc28_1028 0 n56 ns1028 0 -0.00195095896921
Gc28_1029 0 n56 ns1029 0 -0.00270679468508
Gc28_1030 0 n56 ns1030 0 0.000585876783031
Gc28_1031 0 n56 ns1031 0 -0.001000947709
Gc28_1032 0 n56 ns1032 0 0.000318439103998
Gc28_1033 0 n56 ns1033 0 0.000627967157721
Gc28_1034 0 n56 ns1034 0 -0.000282873876659
Gc28_1035 0 n56 ns1035 0 0.000102473251705
Gc28_1036 0 n56 ns1036 0 0.000568594573273
Gc28_1037 0 n56 ns1037 0 0.000295433336979
Gc28_1038 0 n56 ns1038 0 -7.62830810843e-06
Gc28_1039 0 n56 ns1039 0 -0.000518524146996
Gc28_1040 0 n56 ns1040 0 -0.000666594062241
Gc28_1041 0 n56 ns1041 0 0.0003583263902
Gc28_1042 0 n56 ns1042 0 0.000157891818876
Gc28_1043 0 n56 ns1043 0 0.000372012880227
Gc28_1044 0 n56 ns1044 0 -0.000127699458404
Gc28_1045 0 n56 ns1045 0 -0.000423398900332
Gc28_1046 0 n56 ns1046 0 -0.000925298306003
Gc28_1047 0 n56 ns1047 0 -0.000855737737454
Gc28_1048 0 n56 ns1048 0 0.000200904655486
Gc28_1049 0 n56 ns1049 0 0.00653534613798
Gc28_1050 0 n56 ns1050 0 0.00479688459668
Gc28_1051 0 n56 ns1051 0 0.00488800316945
Gc28_1052 0 n56 ns1052 0 0.00490995287467
Gc28_1053 0 n56 ns1053 0 0.000786471709467
Gc28_1054 0 n56 ns1054 0 0.00550608455418
Gc28_1055 0 n56 ns1055 0 0.000920179647883
Gc28_1056 0 n56 ns1056 0 -0.000813105111498
Gc28_1057 0 n56 ns1057 0 -0.00589057309163
Gc28_1058 0 n56 ns1058 0 -0.00147536404555
Gc28_1059 0 n56 ns1059 0 0.0028372298682
Gc28_1060 0 n56 ns1060 0 -0.00416149900256
Gc28_1061 0 n56 ns1061 0 0.00478132690331
Gc28_1062 0 n56 ns1062 0 -1.30938083665e-05
Gc28_1063 0 n56 ns1063 0 0.000144322714787
Gc28_1064 0 n56 ns1064 0 -0.000152804561033
Gc28_1065 0 n56 ns1065 0 0.000264457659827
Gc28_1066 0 n56 ns1066 0 -0.00188601012594
Gc28_1067 0 n56 ns1067 0 0.000497584374789
Gc28_1068 0 n56 ns1068 0 -8.45712887721e-05
Gc28_1069 0 n56 ns1069 0 -0.000920580890118
Gc28_1070 0 n56 ns1070 0 0.000407235849896
Gc28_1071 0 n56 ns1071 0 0.00039699176722
Gc28_1072 0 n56 ns1072 0 -0.000534274259018
Gc28_1073 0 n56 ns1073 0 0.000368279891814
Gc28_1074 0 n56 ns1074 0 0.000462032992064
Gc28_1075 0 n56 ns1075 0 0.000261874355112
Gc28_1076 0 n56 ns1076 0 -5.09875622465e-05
Gc28_1077 0 n56 ns1077 0 -0.000428492950976
Gc28_1078 0 n56 ns1078 0 -0.000138208320259
Gc28_1079 0 n56 ns1079 0 0.000681450160392
Gc28_1080 0 n56 ns1080 0 -0.000957698522414
Gc28_1081 0 n56 ns1081 0 0.000868912304264
Gc28_1082 0 n56 ns1082 0 -0.00043369441062
Gc28_1083 0 n56 ns1083 0 0.000501540158948
Gc28_1084 0 n56 ns1084 0 -0.000920093140705
Gc28_1085 0 n56 ns1085 0 0.000885026765514
Gc28_1086 0 n56 ns1086 0 0.0022033300281
Gc28_1087 0 n56 ns1087 0 0.00253226405299
Gc28_1088 0 n56 ns1088 0 0.00441917145288
Gc28_1089 0 n56 ns1089 0 0.00189914735546
Gc28_1090 0 n56 ns1090 0 0.0045957532607
Gc28_1091 0 n56 ns1091 0 0.00365486376086
Gc28_1092 0 n56 ns1092 0 0.000695770799033
Gc28_1093 0 n56 ns1093 0 0.000868998774676
Gc28_1094 0 n56 ns1094 0 -0.00101098282594
Gc28_1095 0 n56 ns1095 0 -0.00196850773571
Gc28_1096 0 n56 ns1096 0 -0.00153579539032
Gc28_1097 0 n56 ns1097 0 -0.00390362142583
Gc28_1098 0 n56 ns1098 0 -0.000564360659727
Gc28_1099 0 n56 ns1099 0 0.00300815540665
Gc28_1100 0 n56 ns1100 0 5.66251084164e-05
Gc28_1101 0 n56 ns1101 0 -0.00017706561625
Gc28_1102 0 n56 ns1102 0 3.87083853529e-05
Gc28_1103 0 n56 ns1103 0 0.000116450150972
Gc28_1104 0 n56 ns1104 0 -0.000535480878286
Gc28_1105 0 n56 ns1105 0 0.000594046506376
Gc28_1106 0 n56 ns1106 0 4.63959495825e-05
Gc28_1107 0 n56 ns1107 0 -0.000286638215655
Gc28_1108 0 n56 ns1108 0 0.000467624457317
Gc28_1109 0 n56 ns1109 0 -4.24791318794e-06
Gc28_1110 0 n56 ns1110 0 -0.000185117481608
Gc28_1111 0 n56 ns1111 0 0.000350615717567
Gc28_1112 0 n56 ns1112 0 -0.000170937832801
Gc28_1113 0 n56 ns1113 0 0.000181533844802
Gc28_1114 0 n56 ns1114 0 -7.33647618743e-05
Gc28_1115 0 n56 ns1115 0 -1.38276616868e-05
Gc28_1116 0 n56 ns1116 0 -0.000309272794511
Gc28_1117 0 n56 ns1117 0 -0.000762143162749
Gc28_1118 0 n56 ns1118 0 -0.000337817880109
Gc28_1119 0 n56 ns1119 0 0.000297255727956
Gc28_1120 0 n56 ns1120 0 -0.000549291529098
Gc28_1121 0 n56 ns1121 0 -0.000188144015199
Gc28_1122 0 n56 ns1122 0 -0.00096452056966
Gc28_1123 0 n56 ns1123 0 0.00120977321768
Gc28_1124 0 n56 ns1124 0 -0.000694376449765
Gc28_1125 0 n56 ns1125 0 0.00190377397433
Gc28_1126 0 n56 ns1126 0 0.00295665558613
Gc28_1127 0 n56 ns1127 0 0.00176716078977
Gc28_1128 0 n56 ns1128 0 0.00324426961552
Gc28_1129 0 n56 ns1129 0 -0.00125808021778
Gc28_1130 0 n56 ns1130 0 -0.00138875159105
Gc28_1131 0 n56 ns1131 0 0.000407993120747
Gc28_1132 0 n56 ns1132 0 -0.00105510934714
Gc28_1133 0 n56 ns1133 0 0.000213311411284
Gc28_1134 0 n56 ns1134 0 -0.000799862692607
Gc28_1135 0 n56 ns1135 0 -0.00144861947483
Gc28_1136 0 n56 ns1136 0 0.00247193466612
Gc28_1137 0 n56 ns1137 0 0.00148022229063
Gc28_1138 0 n56 ns1138 0 3.21496239758e-05
Gc28_1139 0 n56 ns1139 0 -0.000216828322575
Gc28_1140 0 n56 ns1140 0 6.46921802842e-05
Gc28_1141 0 n56 ns1141 0 -0.000189992952729
Gc28_1142 0 n56 ns1142 0 4.91156519812e-05
Gc28_1143 0 n56 ns1143 0 -0.000248923026057
Gc28_1144 0 n56 ns1144 0 0.000551942626887
Gc28_1145 0 n56 ns1145 0 -1.63094299511e-05
Gc28_1146 0 n56 ns1146 0 6.88053545111e-05
Gc28_1147 0 n56 ns1147 0 0.000155814221034
Gc28_1148 0 n56 ns1148 0 -1.08083904502e-05
Gc28_1149 0 n56 ns1149 0 -0.000180405803715
Gc28_1150 0 n56 ns1150 0 -7.14809601071e-05
Gc28_1151 0 n56 ns1151 0 0.000130556409456
Gc28_1152 0 n56 ns1152 0 -0.000133041672775
Gc28_1153 0 n56 ns1153 0 -0.000221763451804
Gc28_1154 0 n56 ns1154 0 -0.000258110763878
Gc28_1155 0 n56 ns1155 0 0.000159467605398
Gc28_1156 0 n56 ns1156 0 0.00054694835146
Gc28_1157 0 n56 ns1157 0 0.000241547477875
Gc28_1158 0 n56 ns1158 0 -0.000397564749979
Gc28_1159 0 n56 ns1159 0 -0.000188373391119
Gc28_1160 0 n56 ns1160 0 -0.000308539714236
Gc28_1161 0 n56 ns1161 0 -0.00050880539274
Gc28_1162 0 n56 ns1162 0 -0.000367348007524
Gc28_1163 0 n56 ns1163 0 0.00229195018762
Gc28_1164 0 n56 ns1164 0 0.00317753090824
Gc28_1165 0 n56 ns1165 0 0.00237149316932
Gc28_1166 0 n56 ns1166 0 0.0030189093883
Gc28_1167 0 n56 ns1167 0 -0.00130291998943
Gc28_1168 0 n56 ns1168 0 0.000682236644764
Gc28_1169 0 n56 ns1169 0 -0.000123585269155
Gc28_1170 0 n56 ns1170 0 -0.00079254084303
Gc28_1171 0 n56 ns1171 0 -0.00034728830264
Gc28_1172 0 n56 ns1172 0 -0.00136140896165
Gc28_1173 0 n56 ns1173 0 -0.000578748153227
Gc28_1174 0 n56 ns1174 0 0.000991996587189
Gc28_1175 0 n56 ns1175 0 0.000554823823115
Gc28_1176 0 n56 ns1176 0 5.00890739282e-06
Gc28_1177 0 n56 ns1177 0 -9.58941001802e-05
Gc28_1178 0 n56 ns1178 0 -3.88479296414e-06
Gc28_1179 0 n56 ns1179 0 -2.14827392523e-05
Gc28_1180 0 n56 ns1180 0 0.000204888818932
Gc28_1181 0 n56 ns1181 0 0.000135176609628
Gc28_1182 0 n56 ns1182 0 0.00129304266725
Gc28_1183 0 n56 ns1183 0 3.87321492105e-05
Gc28_1184 0 n56 ns1184 0 0.000215443361304
Gc28_1185 0 n56 ns1185 0 -9.89723681541e-05
Gc28_1186 0 n56 ns1186 0 -0.000169398717776
Gc28_1187 0 n56 ns1187 0 -0.00021955810621
Gc28_1188 0 n56 ns1188 0 0.00040409784699
Gc28_1189 0 n56 ns1189 0 6.80505562591e-05
Gc28_1190 0 n56 ns1190 0 -0.000167273629358
Gc28_1191 0 n56 ns1191 0 3.32251358195e-05
Gc28_1192 0 n56 ns1192 0 -0.000380559022275
Gc28_1193 0 n56 ns1193 0 0.000965729571785
Gc28_1194 0 n56 ns1194 0 -0.000580213647582
Gc28_1195 0 n56 ns1195 0 0.00028650210149
Gc28_1196 0 n56 ns1196 0 -0.0008486824049
Gc28_1197 0 n56 ns1197 0 0.000404829046089
Gc28_1198 0 n56 ns1198 0 -0.00081839963647
Gc28_1199 0 n56 ns1199 0 2.88322543969e-05
Gc28_1200 0 n56 ns1200 0 0.00116423443242
Gc28_1201 0 n56 ns1201 0 0.00402716652024
Gc28_1202 0 n56 ns1202 0 0.00356277403454
Gc28_1203 0 n56 ns1203 0 0.00373086217876
Gc28_1204 0 n56 ns1204 0 0.00296636706502
Gc28_1205 0 n56 ns1205 0 0.000529417343035
Gc28_1206 0 n56 ns1206 0 0.00122312424692
Gc28_1207 0 n56 ns1207 0 -0.000328718312655
Gc28_1208 0 n56 ns1208 0 -0.000467009928415
Gc28_1209 0 n56 ns1209 0 -0.00133712784901
Gc28_1210 0 n56 ns1210 0 -0.00138107516053
Gc28_1211 0 n56 ns1211 0 -0.000637047968844
Gc28_1212 0 n56 ns1212 0 -0.000627781539939
Gc28_1213 0 n56 ns1213 0 4.44114686924e-05
Gc28_1214 0 n56 ns1214 0 1.37225183372e-05
Gc28_1215 0 n56 ns1215 0 -7.08908267954e-05
Gc28_1216 0 n56 ns1216 0 1.21142632296e-06
Gd28_1 0 n56 ni1 0 3.8595360789e-05
Gd28_2 0 n56 ni2 0 -0.000452130060211
Gd28_3 0 n56 ni3 0 0.000716158586579
Gd28_4 0 n56 ni4 0 -0.00183119517267
Gd28_5 0 n56 ni5 0 -0.00397110410089
Gd28_6 0 n56 ni6 0 0.000681823034081
Gd28_7 0 n56 ni7 0 -0.00058945455622
Gd28_8 0 n56 ni8 0 1.6694883223e-05
Gd28_9 0 n56 ni9 0 0.000538823602236
Gd28_10 0 n56 ni10 0 0.000591542025956
Gd28_11 0 n56 ni11 0 0.000523421004445
Gd28_12 0 n56 ni12 0 -0.000383736179186
Gd28_13 0 n56 ni13 0 -3.91196766002e-05
Gd28_14 0 n56 ni14 0 8.87335078136e-05
Gd28_15 0 n56 ni15 0 -0.000103851450421
Gd28_16 0 n56 ni16 0 0.000228290086675
Gd28_17 0 n56 ni17 0 -5.79759939924e-05
Gd28_18 0 n56 ni18 0 9.31329627547e-05
Gd28_19 0 n56 ni19 0 -0.00164658218186
Gd28_20 0 n56 ni20 0 -0.00304276561416
Gd28_21 0 n56 ni21 0 -0.000524208388432
Gd28_22 0 n56 ni22 0 -0.00138365800237
Gd28_23 0 n56 ni23 0 0.000515080816205
Gd28_24 0 n56 ni24 0 0.000235143506303
Gd28_25 0 n56 ni25 0 0.000251916774195
Gd28_26 0 n56 ni26 0 -0.000654895889065
Gd28_27 0 n56 ni27 0 -0.00183243532462
Gd28_28 0 n56 ni28 0 0.00147042853216
Gd28_29 0 n56 ni29 0 -0.00143001642541
Gd28_30 0 n56 ni30 0 -0.000266935738725
Gd28_31 0 n56 ni31 0 0.000412669408494
Gd28_32 0 n56 ni32 0 0.000284070273608
Gc29_1 0 n58 ns1 0 -8.31754084907e-05
Gc29_2 0 n58 ns2 0 1.34688466303e-06
Gc29_3 0 n58 ns3 0 7.87890728182e-06
Gc29_4 0 n58 ns4 0 0.000323616881983
Gc29_5 0 n58 ns5 0 -3.15728091061e-05
Gc29_6 0 n58 ns6 0 0.00012233207162
Gc29_7 0 n58 ns7 0 0.000126500028331
Gc29_8 0 n58 ns8 0 2.38014358824e-05
Gc29_9 0 n58 ns9 0 0.000527509416461
Gc29_10 0 n58 ns10 0 -0.000333294178848
Gc29_11 0 n58 ns11 0 -0.000150339883942
Gc29_12 0 n58 ns12 0 0.000118699064585
Gc29_13 0 n58 ns13 0 -9.45641461444e-05
Gc29_14 0 n58 ns14 0 0.000556448406792
Gc29_15 0 n58 ns15 0 0.000927719483082
Gc29_16 0 n58 ns16 0 -9.22463099413e-05
Gc29_17 0 n58 ns17 0 0.000312620796368
Gc29_18 0 n58 ns18 0 -0.000715266622678
Gc29_19 0 n58 ns19 0 0.000233911800491
Gc29_20 0 n58 ns20 0 -0.000715424121486
Gc29_21 0 n58 ns21 0 0.000152400350755
Gc29_22 0 n58 ns22 0 -0.000571885787668
Gc29_23 0 n58 ns23 0 -0.00426915011776
Gc29_24 0 n58 ns24 0 -0.00355835085689
Gc29_25 0 n58 ns25 0 -0.00392148047417
Gc29_26 0 n58 ns26 0 -0.00305316856425
Gc29_27 0 n58 ns27 0 -0.000158629990416
Gc29_28 0 n58 ns28 0 0.00154294967902
Gc29_29 0 n58 ns29 0 -0.000248103673701
Gc29_30 0 n58 ns30 0 -0.000516041418019
Gc29_31 0 n58 ns31 0 -0.000774087720756
Gc29_32 0 n58 ns32 0 -0.00156127716332
Gc29_33 0 n58 ns33 0 -5.48813255785e-05
Gc29_34 0 n58 ns34 0 -0.000919167657551
Gc29_35 0 n58 ns35 0 -0.000309201318486
Gc29_36 0 n58 ns36 0 -2.74458649388e-06
Gc29_37 0 n58 ns37 0 6.73849049946e-05
Gc29_38 0 n58 ns38 0 1.13481117219e-05
Gc29_39 0 n58 ns39 0 -0.000249037785463
Gc29_40 0 n58 ns40 0 -1.32412830909e-05
Gc29_41 0 n58 ns41 0 -0.00040470056149
Gc29_42 0 n58 ns42 0 0.00046434818728
Gc29_43 0 n58 ns43 0 -0.000131375822975
Gc29_44 0 n58 ns44 0 0.00019870622393
Gc29_45 0 n58 ns45 0 0.000114160748808
Gc29_46 0 n58 ns46 0 -2.44427527484e-05
Gc29_47 0 n58 ns47 0 0.000554827553232
Gc29_48 0 n58 ns48 0 -0.000198733593534
Gc29_49 0 n58 ns49 0 -0.000156549296913
Gc29_50 0 n58 ns50 0 0.000137592251754
Gc29_51 0 n58 ns51 0 -7.45924010076e-05
Gc29_52 0 n58 ns52 0 0.000432331078938
Gc29_53 0 n58 ns53 0 0.000990372604771
Gc29_54 0 n58 ns54 0 0.000151992874468
Gc29_55 0 n58 ns55 0 0.000436132786352
Gc29_56 0 n58 ns56 0 -0.000684918596402
Gc29_57 0 n58 ns57 0 0.000307331353029
Gc29_58 0 n58 ns58 0 -0.000593136225356
Gc29_59 0 n58 ns59 0 8.19420157624e-05
Gc29_60 0 n58 ns60 0 -0.000535488554137
Gc29_61 0 n58 ns61 0 -0.00494965120683
Gc29_62 0 n58 ns62 0 -0.00448467234129
Gc29_63 0 n58 ns63 0 -0.00456731092186
Gc29_64 0 n58 ns64 0 -0.00390169047685
Gc29_65 0 n58 ns65 0 -0.000368474517034
Gc29_66 0 n58 ns66 0 0.00183974003045
Gc29_67 0 n58 ns67 0 -0.000270682392402
Gc29_68 0 n58 ns68 0 -0.000666397329202
Gc29_69 0 n58 ns69 0 -0.00080622712696
Gc29_70 0 n58 ns70 0 -0.00194442677539
Gc29_71 0 n58 ns71 0 -1.13417240969e-05
Gc29_72 0 n58 ns72 0 -0.00114525708013
Gc29_73 0 n58 ns73 0 -0.000388387194873
Gc29_74 0 n58 ns74 0 -8.86134706075e-06
Gc29_75 0 n58 ns75 0 9.57034848324e-05
Gc29_76 0 n58 ns76 0 -1.3853891391e-05
Gc29_77 0 n58 ns77 0 -0.00019013440321
Gc29_78 0 n58 ns78 0 -0.000319966344626
Gc29_79 0 n58 ns79 0 -0.000539800134418
Gc29_80 0 n58 ns80 0 0.000670484807505
Gc29_81 0 n58 ns81 0 -0.000171205004197
Gc29_82 0 n58 ns82 0 2.54510952209e-05
Gc29_83 0 n58 ns83 0 -3.02897350799e-05
Gc29_84 0 n58 ns84 0 -0.000102784303359
Gc29_85 0 n58 ns85 0 -4.05352559413e-05
Gc29_86 0 n58 ns86 0 0.00038315091258
Gc29_87 0 n58 ns87 0 -8.22866786102e-05
Gc29_88 0 n58 ns88 0 0.000141904017488
Gc29_89 0 n58 ns89 0 0.000419131532002
Gc29_90 0 n58 ns90 0 -0.000407174719699
Gc29_91 0 n58 ns91 0 0.0001103401213
Gc29_92 0 n58 ns92 0 0.000574679708335
Gc29_93 0 n58 ns93 0 0.000487339819167
Gc29_94 0 n58 ns94 0 -0.000261342713872
Gc29_95 0 n58 ns95 0 7.50074839025e-05
Gc29_96 0 n58 ns96 0 -7.20080912995e-05
Gc29_97 0 n58 ns97 0 -0.000293741698247
Gc29_98 0 n58 ns98 0 0.000276394423187
Gc29_99 0 n58 ns99 0 -0.00352136902495
Gc29_100 0 n58 ns100 0 -0.00495909179269
Gc29_101 0 n58 ns101 0 -0.00337789490613
Gc29_102 0 n58 ns102 0 -0.00468642974104
Gc29_103 0 n58 ns103 0 -0.000975784858467
Gc29_104 0 n58 ns104 0 0.00160890048331
Gc29_105 0 n58 ns105 0 -5.30833339261e-05
Gc29_106 0 n58 ns106 0 -0.00111473973684
Gc29_107 0 n58 ns107 0 -0.000363723040536
Gc29_108 0 n58 ns108 0 -0.00271188730877
Gc29_109 0 n58 ns109 0 0.000393864311468
Gc29_110 0 n58 ns110 0 -0.00203370396139
Gc29_111 0 n58 ns111 0 -0.000836587326549
Gc29_112 0 n58 ns112 0 -2.09316737335e-05
Gc29_113 0 n58 ns113 0 0.000108257703451
Gc29_114 0 n58 ns114 0 -1.54106315568e-05
Gc29_115 0 n58 ns115 0 -0.000290774405123
Gc29_116 0 n58 ns116 0 -0.000492377477094
Gc29_117 0 n58 ns117 0 -0.000883249055325
Gc29_118 0 n58 ns118 0 0.000780969327677
Gc29_119 0 n58 ns119 0 -0.000103872388683
Gc29_120 0 n58 ns120 0 0.000501402935693
Gc29_121 0 n58 ns121 0 0.000130284427188
Gc29_122 0 n58 ns122 0 -0.000287705289007
Gc29_123 0 n58 ns123 0 -0.000488223976955
Gc29_124 0 n58 ns124 0 0.000204278820391
Gc29_125 0 n58 ns125 0 -0.000141718325669
Gc29_126 0 n58 ns126 0 8.96695382584e-05
Gc29_127 0 n58 ns127 0 0.000894242151517
Gc29_128 0 n58 ns128 0 -0.000172675201825
Gc29_129 0 n58 ns129 0 -0.000347396997419
Gc29_130 0 n58 ns130 0 -0.000554619351845
Gc29_131 0 n58 ns131 0 0.000499805074494
Gc29_132 0 n58 ns132 0 -0.000323671448799
Gc29_133 0 n58 ns133 0 1.58191926644e-05
Gc29_134 0 n58 ns134 0 -0.000589155747753
Gc29_135 0 n58 ns135 0 -0.00166453224907
Gc29_136 0 n58 ns136 0 0.000709508755934
Gc29_137 0 n58 ns137 0 -0.00377789129024
Gc29_138 0 n58 ns138 0 -0.00141882308487
Gc29_139 0 n58 ns139 0 -0.0031961617279
Gc29_140 0 n58 ns140 0 -0.00212027019178
Gc29_141 0 n58 ns141 0 0.000911234795578
Gc29_142 0 n58 ns142 0 0.000634885114583
Gc29_143 0 n58 ns143 0 0.000508322115807
Gc29_144 0 n58 ns144 0 -0.00133355134207
Gc29_145 0 n58 ns145 0 -0.000534400265959
Gc29_146 0 n58 ns146 0 -0.00268303653877
Gc29_147 0 n58 ns147 0 0.00155331021419
Gc29_148 0 n58 ns148 0 -0.00342760391325
Gc29_149 0 n58 ns149 0 -0.00213466795264
Gc29_150 0 n58 ns150 0 -2.3568293846e-05
Gc29_151 0 n58 ns151 0 0.000133344916912
Gc29_152 0 n58 ns152 0 -1.36383696055e-05
Gc29_153 0 n58 ns153 0 0.00104515735962
Gc29_154 0 n58 ns154 0 -0.00190119670213
Gc29_155 0 n58 ns155 0 0.00211083381529
Gc29_156 0 n58 ns156 0 -0.00412920299438
Gc29_157 0 n58 ns157 0 -0.00241822108461
Gc29_158 0 n58 ns158 0 -0.00102211052375
Gc29_159 0 n58 ns159 0 0.000878717006158
Gc29_160 0 n58 ns160 0 0.000310423495369
Gc29_161 0 n58 ns161 0 -0.000304231210011
Gc29_162 0 n58 ns162 0 -0.000280837850275
Gc29_163 0 n58 ns163 0 -0.000206962537182
Gc29_164 0 n58 ns164 0 -3.93455905483e-05
Gc29_165 0 n58 ns165 0 -0.000120820447003
Gc29_166 0 n58 ns166 0 -0.000178726750502
Gc29_167 0 n58 ns167 0 0.00111151287964
Gc29_168 0 n58 ns168 0 -0.000542676500604
Gc29_169 0 n58 ns169 0 0.000910313585382
Gc29_170 0 n58 ns170 0 7.3505758561e-06
Gc29_171 0 n58 ns171 0 0.00047775247842
Gc29_172 0 n58 ns172 0 -0.000125988177186
Gc29_173 0 n58 ns173 0 -0.000813139766313
Gc29_174 0 n58 ns174 0 -0.00180489951864
Gc29_175 0 n58 ns175 0 -0.00536456502944
Gc29_176 0 n58 ns176 0 -0.00304469335232
Gc29_177 0 n58 ns177 0 -0.00412959363309
Gc29_178 0 n58 ns178 0 -0.00345421100186
Gc29_179 0 n58 ns179 0 0.00500658759877
Gc29_180 0 n58 ns180 0 0.00434171229361
Gc29_181 0 n58 ns181 0 0.000862208155331
Gc29_182 0 n58 ns182 0 -0.00115697171224
Gc29_183 0 n58 ns183 0 -0.00359085914307
Gc29_184 0 n58 ns184 0 -0.00363651173238
Gc29_185 0 n58 ns185 0 0.00205028021296
Gc29_186 0 n58 ns186 0 0.000895399897729
Gc29_187 0 n58 ns187 0 -0.00387670039056
Gc29_188 0 n58 ns188 0 -1.94366478665e-07
Gc29_189 0 n58 ns189 0 0.000304910076518
Gc29_190 0 n58 ns190 0 -0.000147986848806
Gc29_191 0 n58 ns191 0 0.00273663066511
Gc29_192 0 n58 ns192 0 -0.00385943549943
Gc29_193 0 n58 ns193 0 0.00629786172142
Gc29_194 0 n58 ns194 0 -0.00783696309923
Gc29_195 0 n58 ns195 0 -0.00298701220354
Gc29_196 0 n58 ns196 0 -0.00265388753902
Gc29_197 0 n58 ns197 0 0.000901739332609
Gc29_198 0 n58 ns198 0 0.000851141797275
Gc29_199 0 n58 ns199 0 -0.000515185433209
Gc29_200 0 n58 ns200 0 -0.000665462428382
Gc29_201 0 n58 ns201 0 -0.000244651030927
Gc29_202 0 n58 ns202 0 4.92444502707e-06
Gc29_203 0 n58 ns203 0 -0.00056339605871
Gc29_204 0 n58 ns204 0 -0.000228198995825
Gc29_205 0 n58 ns205 0 0.00096647762417
Gc29_206 0 n58 ns206 0 0.000167919003703
Gc29_207 0 n58 ns207 0 0.000685886393166
Gc29_208 0 n58 ns208 0 0.000456797900543
Gc29_209 0 n58 ns209 0 -2.37536548074e-05
Gc29_210 0 n58 ns210 0 0.000714196163287
Gc29_211 0 n58 ns211 0 0.0007674442236
Gc29_212 0 n58 ns212 0 -0.00302005873909
Gc29_213 0 n58 ns213 0 -0.00233244959678
Gc29_214 0 n58 ns214 0 -0.00681304689984
Gc29_215 0 n58 ns215 0 -0.00163706968979
Gc29_216 0 n58 ns216 0 -0.0064542945866
Gc29_217 0 n58 ns217 0 0.00583866441836
Gc29_218 0 n58 ns218 0 0.00788710920801
Gc29_219 0 n58 ns219 0 0.000749893118559
Gc29_220 0 n58 ns220 0 -0.00115799423871
Gc29_221 0 n58 ns221 0 -0.0055985590618
Gc29_222 0 n58 ns222 0 -0.00572972059176
Gc29_223 0 n58 ns223 0 0.00136699497009
Gc29_224 0 n58 ns224 0 0.00536118259894
Gc29_225 0 n58 ns225 0 -0.00426046874487
Gc29_226 0 n58 ns226 0 -2.07197898558e-06
Gc29_227 0 n58 ns227 0 0.000417866212521
Gc29_228 0 n58 ns228 0 -0.000230230410173
Gc29_229 0 n58 ns229 0 -0.00105576586651
Gc29_230 0 n58 ns230 0 5.94428258232e-05
Gc29_231 0 n58 ns231 0 -0.00313251659079
Gc29_232 0 n58 ns232 0 0.00153569751508
Gc29_233 0 n58 ns233 0 -0.000339376406135
Gc29_234 0 n58 ns234 0 0.001141234444
Gc29_235 0 n58 ns235 0 0.0002289796092
Gc29_236 0 n58 ns236 0 -0.000495544951083
Gc29_237 0 n58 ns237 0 -0.00037417640005
Gc29_238 0 n58 ns238 0 0.000152428677107
Gc29_239 0 n58 ns239 0 -0.000155240348715
Gc29_240 0 n58 ns240 0 9.57719873898e-05
Gc29_241 0 n58 ns241 0 0.00095184820376
Gc29_242 0 n58 ns242 0 0.000111341938903
Gc29_243 0 n58 ns243 0 0.000332665887105
Gc29_244 0 n58 ns244 0 -0.00082670079342
Gc29_245 0 n58 ns245 0 0.000758769528652
Gc29_246 0 n58 ns246 0 -0.00048097630467
Gc29_247 0 n58 ns247 0 0.000465891641405
Gc29_248 0 n58 ns248 0 -0.000832395510327
Gc29_249 0 n58 ns249 0 -0.00231590047995
Gc29_250 0 n58 ns250 0 -5.62841286382e-05
Gc29_251 0 n58 ns251 0 -0.00610258953754
Gc29_252 0 n58 ns252 0 -0.00215750432322
Gc29_253 0 n58 ns253 0 -0.00496969511695
Gc29_254 0 n58 ns254 0 -0.00272002287948
Gc29_255 0 n58 ns255 0 0.00173607289709
Gc29_256 0 n58 ns256 0 0.000178299763637
Gc29_257 0 n58 ns257 0 0.000783798367229
Gc29_258 0 n58 ns258 0 -0.00118442708376
Gc29_259 0 n58 ns259 0 -0.000511786204576
Gc29_260 0 n58 ns260 0 -0.00193599201641
Gc29_261 0 n58 ns261 0 0.00240504612417
Gc29_262 0 n58 ns262 0 -0.00261257327798
Gc29_263 0 n58 ns263 0 -0.00252567624853
Gc29_264 0 n58 ns264 0 -8.95931590998e-06
Gc29_265 0 n58 ns265 0 0.00019701473963
Gc29_266 0 n58 ns266 0 -5.19548488504e-05
Gc29_267 0 n58 ns267 0 -0.000309043357009
Gc29_268 0 n58 ns268 0 -0.000117915400931
Gc29_269 0 n58 ns269 0 -0.00071497079635
Gc29_270 0 n58 ns270 0 0.00141514585939
Gc29_271 0 n58 ns271 0 -0.000344359191089
Gc29_272 0 n58 ns272 0 0.00010060684282
Gc29_273 0 n58 ns273 0 0.000214579349025
Gc29_274 0 n58 ns274 0 -0.000165717615679
Gc29_275 0 n58 ns275 0 6.20172348494e-05
Gc29_276 0 n58 ns276 0 0.00042928168082
Gc29_277 0 n58 ns277 0 -0.00013297270737
Gc29_278 0 n58 ns278 0 0.000124995181059
Gc29_279 0 n58 ns279 0 0.000588827672223
Gc29_280 0 n58 ns280 0 -0.000466213014188
Gc29_281 0 n58 ns281 0 0.000125545377515
Gc29_282 0 n58 ns282 0 0.000272068590869
Gc29_283 0 n58 ns283 0 0.000630406913889
Gc29_284 0 n58 ns284 0 -0.000412287119786
Gc29_285 0 n58 ns285 0 0.000230115304124
Gc29_286 0 n58 ns286 0 -0.000396270908829
Gc29_287 0 n58 ns287 0 -0.000335723752175
Gc29_288 0 n58 ns288 0 0.000700827191945
Gc29_289 0 n58 ns289 0 -0.00219552975794
Gc29_290 0 n58 ns290 0 -0.00447655907796
Gc29_291 0 n58 ns291 0 -0.00217874052552
Gc29_292 0 n58 ns292 0 -0.00443346592655
Gc29_293 0 n58 ns293 0 -0.001123082837
Gc29_294 0 n58 ns294 0 0.0013427965567
Gc29_295 0 n58 ns295 0 0.000147033708961
Gc29_296 0 n58 ns296 0 -0.00126974331434
Gc29_297 0 n58 ns297 0 1.40914440111e-05
Gc29_298 0 n58 ns298 0 -0.00306171681435
Gc29_299 0 n58 ns299 0 0.000639920431957
Gc29_300 0 n58 ns300 0 -0.00282988042421
Gc29_301 0 n58 ns301 0 -0.00116639031718
Gc29_302 0 n58 ns302 0 -3.8730598142e-05
Gc29_303 0 n58 ns303 0 0.00010276591016
Gc29_304 0 n58 ns304 0 -1.11745670856e-05
Gc29_305 0 n58 ns305 0 8.56639629483e-05
Gc29_306 0 n58 ns306 0 -0.000582105300546
Gc29_307 0 n58 ns307 0 0.00022328233452
Gc29_308 0 n58 ns308 0 -2.67608388624e-05
Gc29_309 0 n58 ns309 0 -3.50301504218e-06
Gc29_310 0 n58 ns310 0 -0.000105590926716
Gc29_311 0 n58 ns311 0 -7.59434748028e-05
Gc29_312 0 n58 ns312 0 0.000223165231043
Gc29_313 0 n58 ns313 0 0.000563896220816
Gc29_314 0 n58 ns314 0 0.000186351405861
Gc29_315 0 n58 ns315 0 -0.000161203933555
Gc29_316 0 n58 ns316 0 2.82337029259e-05
Gc29_317 0 n58 ns317 0 -0.000499173869826
Gc29_318 0 n58 ns318 0 0.000237078024052
Gc29_319 0 n58 ns319 0 0.000729465035363
Gc29_320 0 n58 ns320 0 0.000823092141342
Gc29_321 0 n58 ns321 0 0.000675010262764
Gc29_322 0 n58 ns322 0 -0.000300404885281
Gc29_323 0 n58 ns323 0 0.000531551392609
Gc29_324 0 n58 ns324 0 -0.000179242652917
Gc29_325 0 n58 ns325 0 0.000468322471064
Gc29_326 0 n58 ns326 0 -0.00029865280445
Gc29_327 0 n58 ns327 0 -0.00241121284421
Gc29_328 0 n58 ns328 0 -0.00585587184635
Gc29_329 0 n58 ns329 0 -0.00241652788295
Gc29_330 0 n58 ns330 0 -0.00520370112886
Gc29_331 0 n58 ns331 0 -0.0009589432612
Gc29_332 0 n58 ns332 0 0.00128030510106
Gc29_333 0 n58 ns333 0 -0.000119731355445
Gc29_334 0 n58 ns334 0 -0.000716127900111
Gc29_335 0 n58 ns335 0 -0.000282549285949
Gc29_336 0 n58 ns336 0 -0.00176985700001
Gc29_337 0 n58 ns337 0 0.000165995321214
Gc29_338 0 n58 ns338 0 -0.000876075449863
Gc29_339 0 n58 ns339 0 -0.000381062150854
Gc29_340 0 n58 ns340 0 4.99998918916e-07
Gc29_341 0 n58 ns341 0 4.23554533472e-05
Gc29_342 0 n58 ns342 0 1.98254567338e-05
Gc29_343 0 n58 ns343 0 -0.000575869153452
Gc29_344 0 n58 ns344 0 0.000337861822817
Gc29_345 0 n58 ns345 0 -0.00151428677728
Gc29_346 0 n58 ns346 0 0.00133385890639
Gc29_347 0 n58 ns347 0 -0.000419444932323
Gc29_348 0 n58 ns348 0 0.000382558194137
Gc29_349 0 n58 ns349 0 0.000134920147543
Gc29_350 0 n58 ns350 0 -0.000198387114291
Gc29_351 0 n58 ns351 0 0.000303620585833
Gc29_352 0 n58 ns352 0 0.000356117895424
Gc29_353 0 n58 ns353 0 -6.38363917016e-05
Gc29_354 0 n58 ns354 0 0.000123297589208
Gc29_355 0 n58 ns355 0 0.00021182037409
Gc29_356 0 n58 ns356 0 -0.000398174441527
Gc29_357 0 n58 ns357 0 0.000653876632042
Gc29_358 0 n58 ns358 0 0.000432252873949
Gc29_359 0 n58 ns359 0 0.000567978943214
Gc29_360 0 n58 ns360 0 -0.000456085165124
Gc29_361 0 n58 ns361 0 0.000358756014429
Gc29_362 0 n58 ns362 0 -0.000247849329296
Gc29_363 0 n58 ns363 0 -0.000113946735085
Gc29_364 0 n58 ns364 0 3.17139576618e-05
Gc29_365 0 n58 ns365 0 -0.00437236941658
Gc29_366 0 n58 ns366 0 -0.00496096236182
Gc29_367 0 n58 ns367 0 -0.00411129014312
Gc29_368 0 n58 ns368 0 -0.00451676425552
Gc29_369 0 n58 ns369 0 -0.000809915155611
Gc29_370 0 n58 ns370 0 0.00200354678558
Gc29_371 0 n58 ns371 0 -0.000188377893695
Gc29_372 0 n58 ns372 0 -0.000966748497333
Gc29_373 0 n58 ns373 0 -0.000604726780176
Gc29_374 0 n58 ns374 0 -0.00261587155228
Gc29_375 0 n58 ns375 0 0.000179459154175
Gc29_376 0 n58 ns376 0 -0.00176819471157
Gc29_377 0 n58 ns377 0 -0.000645223961577
Gc29_378 0 n58 ns378 0 -1.93295994772e-05
Gc29_379 0 n58 ns379 0 9.85532428856e-05
Gc29_380 0 n58 ns380 0 -2.23007315385e-05
Gc29_381 0 n58 ns381 0 7.72234595366e-05
Gc29_382 0 n58 ns382 0 -0.00055253982711
Gc29_383 0 n58 ns383 0 0.000356348370554
Gc29_384 0 n58 ns384 0 0.000999703935138
Gc29_385 0 n58 ns385 0 0.00019388267796
Gc29_386 0 n58 ns386 0 4.90419476549e-05
Gc29_387 0 n58 ns387 0 -7.04063598737e-05
Gc29_388 0 n58 ns388 0 -0.000152618597484
Gc29_389 0 n58 ns389 0 -0.000342305105378
Gc29_390 0 n58 ns390 0 0.000268551696563
Gc29_391 0 n58 ns391 0 -0.000117670014325
Gc29_392 0 n58 ns392 0 0.000114369580705
Gc29_393 0 n58 ns393 0 0.000728987547229
Gc29_394 0 n58 ns394 0 -0.000337927195052
Gc29_395 0 n58 ns395 0 -0.000485964402078
Gc29_396 0 n58 ns396 0 -0.00011403485317
Gc29_397 0 n58 ns397 0 0.000349375188588
Gc29_398 0 n58 ns398 0 -0.000307638062586
Gc29_399 0 n58 ns399 0 -0.000196744940919
Gc29_400 0 n58 ns400 0 -0.000435831174813
Gc29_401 0 n58 ns401 0 -0.00100967422544
Gc29_402 0 n58 ns402 0 0.000879218248258
Gc29_403 0 n58 ns403 0 -0.00267287532326
Gc29_404 0 n58 ns404 0 -0.00224664693295
Gc29_405 0 n58 ns405 0 -0.00244444857487
Gc29_406 0 n58 ns406 0 -0.00268694414046
Gc29_407 0 n58 ns407 0 -0.000155020734438
Gc29_408 0 n58 ns408 0 0.000740845587546
Gc29_409 0 n58 ns409 0 0.000291025766107
Gc29_410 0 n58 ns410 0 -0.00129850444025
Gc29_411 0 n58 ns411 0 -0.000253208960653
Gc29_412 0 n58 ns412 0 -0.00276340588997
Gc29_413 0 n58 ns413 0 0.000998889162545
Gc29_414 0 n58 ns414 0 -0.00320513006718
Gc29_415 0 n58 ns415 0 -0.00155637229967
Gc29_416 0 n58 ns416 0 -2.41475858323e-05
Gc29_417 0 n58 ns417 0 0.000103557277158
Gc29_418 0 n58 ns418 0 7.66425234361e-07
Gc29_419 0 n58 ns419 0 -0.000908562291055
Gc29_420 0 n58 ns420 0 -0.000257130384662
Gc29_421 0 n58 ns421 0 -0.00333925187352
Gc29_422 0 n58 ns422 0 -0.00126623512218
Gc29_423 0 n58 ns423 0 -0.00189832405453
Gc29_424 0 n58 ns424 0 0.00129629377855
Gc29_425 0 n58 ns425 0 0.000827902660693
Gc29_426 0 n58 ns426 0 -0.000564153928899
Gc29_427 0 n58 ns427 0 -0.000302532202357
Gc29_428 0 n58 ns428 0 0.00019124578587
Gc29_429 0 n58 ns429 0 -0.000163521211652
Gc29_430 0 n58 ns430 0 -7.55913095097e-06
Gc29_431 0 n58 ns431 0 0.000467474613031
Gc29_432 0 n58 ns432 0 -6.957889526e-05
Gc29_433 0 n58 ns433 0 0.000782587634626
Gc29_434 0 n58 ns434 0 -0.000958289685065
Gc29_435 0 n58 ns435 0 0.00101269999895
Gc29_436 0 n58 ns436 0 -0.000307364404317
Gc29_437 0 n58 ns437 0 0.000869534154098
Gc29_438 0 n58 ns438 0 -0.000591415672493
Gc29_439 0 n58 ns439 0 -0.00210531132237
Gc29_440 0 n58 ns440 0 -0.000577408019712
Gc29_441 0 n58 ns441 0 -0.00605908419693
Gc29_442 0 n58 ns442 0 -0.00181129056352
Gc29_443 0 n58 ns443 0 -0.00478402001619
Gc29_444 0 n58 ns444 0 -0.00242640160944
Gc29_445 0 n58 ns445 0 0.00399184818521
Gc29_446 0 n58 ns446 0 0.00227704566367
Gc29_447 0 n58 ns447 0 0.000777891453601
Gc29_448 0 n58 ns448 0 -0.0012266795122
Gc29_449 0 n58 ns449 0 -0.0025161570391
Gc29_450 0 n58 ns450 0 -0.00322695683173
Gc29_451 0 n58 ns451 0 0.00231217103694
Gc29_452 0 n58 ns452 0 -0.00119806800543
Gc29_453 0 n58 ns453 0 -0.00331962630049
Gc29_454 0 n58 ns454 0 -4.51920342733e-05
Gc29_455 0 n58 ns455 0 0.000360788453375
Gc29_456 0 n58 ns456 0 -0.000174349442108
Gc29_457 0 n58 ns457 0 -0.00014659567027
Gc29_458 0 n58 ns458 0 -0.000197022697859
Gc29_459 0 n58 ns459 0 0.00156660525208
Gc29_460 0 n58 ns460 0 0.00224114836512
Gc29_461 0 n58 ns461 0 0.00158915474471
Gc29_462 0 n58 ns462 0 -0.000984412016402
Gc29_463 0 n58 ns463 0 -0.000509773805457
Gc29_464 0 n58 ns464 0 5.30555483466e-05
Gc29_465 0 n58 ns465 0 0.000177736172946
Gc29_466 0 n58 ns466 0 0.000110565538882
Gc29_467 0 n58 ns467 0 -0.000130681513688
Gc29_468 0 n58 ns468 0 -8.98433630179e-06
Gc29_469 0 n58 ns469 0 0.00176934532077
Gc29_470 0 n58 ns470 0 -0.000857827846681
Gc29_471 0 n58 ns471 0 -0.000646178675008
Gc29_472 0 n58 ns472 0 0.00128028313384
Gc29_473 0 n58 ns473 0 -0.000483639824565
Gc29_474 0 n58 ns474 0 6.53803134285e-05
Gc29_475 0 n58 ns475 0 -0.00213825367125
Gc29_476 0 n58 ns476 0 -0.00121601363188
Gc29_477 0 n58 ns477 0 0.00297516242008
Gc29_478 0 n58 ns478 0 0.00384920773387
Gc29_479 0 n58 ns479 0 -0.0103505418709
Gc29_480 0 n58 ns480 0 0.00102860424762
Gc29_481 0 n58 ns481 0 -0.0079335395599
Gc29_482 0 n58 ns482 0 -0.000348719294209
Gc29_483 0 n58 ns483 0 -0.0104127659759
Gc29_484 0 n58 ns484 0 -0.000139694860172
Gc29_485 0 n58 ns485 0 0.00138230122469
Gc29_486 0 n58 ns486 0 4.3242445763e-06
Gc29_487 0 n58 ns487 0 -0.00392393867286
Gc29_488 0 n58 ns488 0 0.00830444324522
Gc29_489 0 n58 ns489 0 -0.0143896703429
Gc29_490 0 n58 ns490 0 -0.00445351992745
Gc29_491 0 n58 ns491 0 -0.00631515674501
Gc29_492 0 n58 ns492 0 -5.36744623716e-05
Gc29_493 0 n58 ns493 0 -0.00036496400789
Gc29_494 0 n58 ns494 0 0.000581547539577
Gc29_495 0 n58 ns495 0 -0.000887006782255
Gc29_496 0 n58 ns496 0 -0.000633318406166
Gc29_497 0 n58 ns497 0 -0.00354586718087
Gc29_498 0 n58 ns498 0 -0.00146644933259
Gc29_499 0 n58 ns499 0 -0.00183510626928
Gc29_500 0 n58 ns500 0 0.0011646705709
Gc29_501 0 n58 ns501 0 0.000762363577265
Gc29_502 0 n58 ns502 0 -0.000505115977293
Gc29_503 0 n58 ns503 0 -0.000464535828975
Gc29_504 0 n58 ns504 0 7.58886800162e-05
Gc29_505 0 n58 ns505 0 -0.000160877295837
Gc29_506 0 n58 ns506 0 5.3875219e-05
Gc29_507 0 n58 ns507 0 0.000705930040335
Gc29_508 0 n58 ns508 0 9.61857217085e-05
Gc29_509 0 n58 ns509 0 0.000836864549951
Gc29_510 0 n58 ns510 0 -0.000904426182192
Gc29_511 0 n58 ns511 0 0.000989112480103
Gc29_512 0 n58 ns512 0 -0.000297103808271
Gc29_513 0 n58 ns513 0 0.000785073862662
Gc29_514 0 n58 ns514 0 -0.000538878885462
Gc29_515 0 n58 ns515 0 -0.00218552198123
Gc29_516 0 n58 ns516 0 -0.000863115401462
Gc29_517 0 n58 ns517 0 -0.00630599222228
Gc29_518 0 n58 ns518 0 -0.00277345154163
Gc29_519 0 n58 ns519 0 -0.00500029686035
Gc29_520 0 n58 ns520 0 -0.00322827750531
Gc29_521 0 n58 ns521 0 0.00355812900676
Gc29_522 0 n58 ns522 0 0.0020665808036
Gc29_523 0 n58 ns523 0 0.000833276535262
Gc29_524 0 n58 ns524 0 -0.00120136285609
Gc29_525 0 n58 ns525 0 -0.00218019556095
Gc29_526 0 n58 ns526 0 -0.0029681676761
Gc29_527 0 n58 ns527 0 0.00243880585257
Gc29_528 0 n58 ns528 0 -0.000620388945606
Gc29_529 0 n58 ns529 0 -0.00319505695727
Gc29_530 0 n58 ns530 0 -4.35714053306e-05
Gc29_531 0 n58 ns531 0 0.000364600351608
Gc29_532 0 n58 ns532 0 -0.000161640990681
Gc29_533 0 n58 ns533 0 -0.000584695938384
Gc29_534 0 n58 ns534 0 0.000312766475818
Gc29_535 0 n58 ns535 0 -0.00135001607254
Gc29_536 0 n58 ns536 0 0.00256701304357
Gc29_537 0 n58 ns537 0 -0.000198440878212
Gc29_538 0 n58 ns538 0 0.000542628979665
Gc29_539 0 n58 ns539 0 0.000209726023656
Gc29_540 0 n58 ns540 0 -0.000409334088049
Gc29_541 0 n58 ns541 0 -0.000150779676006
Gc29_542 0 n58 ns542 0 0.000436198101507
Gc29_543 0 n58 ns543 0 -0.000114823662407
Gc29_544 0 n58 ns544 0 0.000110479344283
Gc29_545 0 n58 ns545 0 0.000913806954924
Gc29_546 0 n58 ns546 0 -0.000606322135311
Gc29_547 0 n58 ns547 0 -5.63095951741e-05
Gc29_548 0 n58 ns548 0 -0.000325046146917
Gc29_549 0 n58 ns549 0 0.000622224382122
Gc29_550 0 n58 ns550 0 -0.000535515074233
Gc29_551 0 n58 ns551 0 0.000200584545438
Gc29_552 0 n58 ns552 0 -0.000715560676604
Gc29_553 0 n58 ns553 0 -0.0010061136801
Gc29_554 0 n58 ns554 0 0.000981352987023
Gc29_555 0 n58 ns555 0 -0.00291189077651
Gc29_556 0 n58 ns556 0 -0.00274063574705
Gc29_557 0 n58 ns557 0 -0.00265060096475
Gc29_558 0 n58 ns558 0 -0.00313325884589
Gc29_559 0 n58 ns559 0 -0.000352532586733
Gc29_560 0 n58 ns560 0 0.00104661412828
Gc29_561 0 n58 ns561 0 0.000314993545678
Gc29_562 0 n58 ns562 0 -0.00136710518354
Gc29_563 0 n58 ns563 0 -0.000125203817625
Gc29_564 0 n58 ns564 0 -0.0030836124697
Gc29_565 0 n58 ns565 0 0.00102818327122
Gc29_566 0 n58 ns566 0 -0.00341829745033
Gc29_567 0 n58 ns567 0 -0.00161378237185
Gc29_568 0 n58 ns568 0 -2.92551608694e-05
Gc29_569 0 n58 ns569 0 0.000112283753946
Gc29_570 0 n58 ns570 0 -6.43120973533e-06
Gc29_571 0 n58 ns571 0 -6.92583976066e-05
Gc29_572 0 n58 ns572 0 -0.000584385056584
Gc29_573 0 n58 ns573 0 -0.000173200182503
Gc29_574 0 n58 ns574 0 0.000305326259723
Gc29_575 0 n58 ns575 0 -0.000237258831925
Gc29_576 0 n58 ns576 0 -3.64916154439e-05
Gc29_577 0 n58 ns577 0 5.0620215303e-05
Gc29_578 0 n58 ns578 0 9.36024548348e-05
Gc29_579 0 n58 ns579 0 0.000484558555959
Gc29_580 0 n58 ns580 0 0.000342270119107
Gc29_581 0 n58 ns581 0 -0.000164779061314
Gc29_582 0 n58 ns582 0 6.30619638809e-05
Gc29_583 0 n58 ns583 0 -0.000231897683509
Gc29_584 0 n58 ns584 0 -2.66788401657e-05
Gc29_585 0 n58 ns585 0 0.000642993693187
Gc29_586 0 n58 ns586 0 0.000850049555133
Gc29_587 0 n58 ns587 0 0.000766339887814
Gc29_588 0 n58 ns588 0 -0.000328899299885
Gc29_589 0 n58 ns589 0 0.000541321628033
Gc29_590 0 n58 ns590 0 -0.00018414809257
Gc29_591 0 n58 ns591 0 0.000324973369232
Gc29_592 0 n58 ns592 0 -2.64691328436e-05
Gc29_593 0 n58 ns593 0 -0.00264324087806
Gc29_594 0 n58 ns594 0 -0.00624243098988
Gc29_595 0 n58 ns595 0 -0.00265508590487
Gc29_596 0 n58 ns596 0 -0.00566085881413
Gc29_597 0 n58 ns597 0 -0.00114412409582
Gc29_598 0 n58 ns598 0 0.00157939459595
Gc29_599 0 n58 ns599 0 -9.01914121089e-05
Gc29_600 0 n58 ns600 0 -0.000944647742183
Gc29_601 0 n58 ns601 0 -0.000262478401787
Gc29_602 0 n58 ns602 0 -0.00239725732062
Gc29_603 0 n58 ns603 0 0.00026188684277
Gc29_604 0 n58 ns604 0 -0.00156301741632
Gc29_605 0 n58 ns605 0 -0.000617382212049
Gc29_606 0 n58 ns606 0 -1.40171753979e-05
Gc29_607 0 n58 ns607 0 6.61207455688e-05
Gc29_608 0 n58 ns608 0 -2.6834260764e-06
Gc29_609 0 n58 ns609 0 -4.14553249106e-06
Gc29_610 0 n58 ns610 0 -2.5700862607e-05
Gc29_611 0 n58 ns611 0 -5.81426439598e-05
Gc29_612 0 n58 ns612 0 0.00102745619286
Gc29_613 0 n58 ns613 0 0.0001136199259
Gc29_614 0 n58 ns614 0 0.000130318200429
Gc29_615 0 n58 ns615 0 -0.000172073946123
Gc29_616 0 n58 ns616 0 -0.000182984070255
Gc29_617 0 n58 ns617 0 -0.000440179248501
Gc29_618 0 n58 ns618 0 0.000239327615578
Gc29_619 0 n58 ns619 0 9.75854421382e-05
Gc29_620 0 n58 ns620 0 -0.000123450458887
Gc29_621 0 n58 ns621 0 0.000204304107119
Gc29_622 0 n58 ns622 0 -0.000155763818088
Gc29_623 0 n58 ns623 0 0.00118377212107
Gc29_624 0 n58 ns624 0 -0.000244618165687
Gc29_625 0 n58 ns625 0 0.000492131398186
Gc29_626 0 n58 ns626 0 -0.000717187470699
Gc29_627 0 n58 ns627 0 0.000601562718984
Gc29_628 0 n58 ns628 0 -0.000596327284646
Gc29_629 0 n58 ns629 0 -0.000303188892472
Gc29_630 0 n58 ns630 0 0.00113390672587
Gc29_631 0 n58 ns631 0 0.00321914262702
Gc29_632 0 n58 ns632 0 0.00407235819988
Gc29_633 0 n58 ns633 0 0.0030637124108
Gc29_634 0 n58 ns634 0 0.00344146408639
Gc29_635 0 n58 ns635 0 0.000340703406672
Gc29_636 0 n58 ns636 0 0.00124243398958
Gc29_637 0 n58 ns637 0 -0.000284251231211
Gc29_638 0 n58 ns638 0 -0.000472716463681
Gc29_639 0 n58 ns639 0 -0.00113380048524
Gc29_640 0 n58 ns640 0 -0.00139501461624
Gc29_641 0 n58 ns641 0 -0.000546205228907
Gc29_642 0 n58 ns642 0 -0.000611268437535
Gc29_643 0 n58 ns643 0 3.39897196676e-05
Gc29_644 0 n58 ns644 0 -3.11482048097e-06
Gc29_645 0 n58 ns645 0 -9.41794544871e-05
Gc29_646 0 n58 ns646 0 2.03609333615e-06
Gc29_647 0 n58 ns647 0 -0.000105891357816
Gc29_648 0 n58 ns648 0 -0.000151293707057
Gc29_649 0 n58 ns649 0 -0.000257927951715
Gc29_650 0 n58 ns650 0 0.000658088556002
Gc29_651 0 n58 ns651 0 4.10860136009e-05
Gc29_652 0 n58 ns652 0 -2.32664193145e-05
Gc29_653 0 n58 ns653 0 -5.41030245736e-05
Gc29_654 0 n58 ns654 0 -8.67209377995e-05
Gc29_655 0 n58 ns655 0 -0.000514710826077
Gc29_656 0 n58 ns656 0 0.000163759766519
Gc29_657 0 n58 ns657 0 0.000122692271588
Gc29_658 0 n58 ns658 0 -0.000132845563482
Gc29_659 0 n58 ns659 0 0.000170040049694
Gc29_660 0 n58 ns660 0 -0.00010165580123
Gc29_661 0 n58 ns661 0 0.0011353974549
Gc29_662 0 n58 ns662 0 8.57295559499e-05
Gc29_663 0 n58 ns663 0 0.000521275523983
Gc29_664 0 n58 ns664 0 -0.000664051073437
Gc29_665 0 n58 ns665 0 0.000477345014316
Gc29_666 0 n58 ns666 0 -0.000475226977919
Gc29_667 0 n58 ns667 0 -0.000533828541907
Gc29_668 0 n58 ns668 0 0.000847969584152
Gc29_669 0 n58 ns669 0 0.00323798303495
Gc29_670 0 n58 ns670 0 0.00436022322039
Gc29_671 0 n58 ns671 0 0.00315983693709
Gc29_672 0 n58 ns672 0 0.00377333986784
Gc29_673 0 n58 ns673 0 -0.000106492539037
Gc29_674 0 n58 ns674 0 0.00121118144651
Gc29_675 0 n58 ns675 0 -0.000274282428326
Gc29_676 0 n58 ns676 0 -0.000581915532624
Gc29_677 0 n58 ns677 0 -0.000996192618685
Gc29_678 0 n58 ns678 0 -0.00145658957717
Gc29_679 0 n58 ns679 0 -0.000588590508462
Gc29_680 0 n58 ns680 0 -0.000137792753258
Gc29_681 0 n58 ns681 0 0.000199100931299
Gc29_682 0 n58 ns682 0 2.05578358927e-06
Gc29_683 0 n58 ns683 0 -6.62334645494e-05
Gc29_684 0 n58 ns684 0 -1.37065354935e-05
Gc29_685 0 n58 ns685 0 -6.84220677093e-05
Gc29_686 0 n58 ns686 0 -6.7050645273e-05
Gc29_687 0 n58 ns687 0 9.83801065545e-05
Gc29_688 0 n58 ns688 0 0.000360327540048
Gc29_689 0 n58 ns689 0 8.62590256449e-05
Gc29_690 0 n58 ns690 0 9.93116370021e-05
Gc29_691 0 n58 ns691 0 3.21583149038e-05
Gc29_692 0 n58 ns692 0 8.90113612992e-05
Gc29_693 0 n58 ns693 0 -5.2125689139e-05
Gc29_694 0 n58 ns694 0 -0.000205138296877
Gc29_695 0 n58 ns695 0 0.000166778381206
Gc29_696 0 n58 ns696 0 -0.000112236613216
Gc29_697 0 n58 ns697 0 -0.000198753120708
Gc29_698 0 n58 ns698 0 -0.000315261139011
Gc29_699 0 n58 ns699 0 -0.000312689654698
Gc29_700 0 n58 ns700 0 0.000504616120936
Gc29_701 0 n58 ns701 0 0.000230706239738
Gc29_702 0 n58 ns702 0 -0.000422719283464
Gc29_703 0 n58 ns703 0 -0.000351052398057
Gc29_704 0 n58 ns704 0 -0.000501085098593
Gc29_705 0 n58 ns705 0 -9.77755758787e-05
Gc29_706 0 n58 ns706 0 -0.000816219520396
Gc29_707 0 n58 ns707 0 0.00224355952348
Gc29_708 0 n58 ns708 0 0.00324183334017
Gc29_709 0 n58 ns709 0 0.00230145909798
Gc29_710 0 n58 ns710 0 0.00326399710246
Gc29_711 0 n58 ns711 0 -0.00174717045507
Gc29_712 0 n58 ns712 0 -5.52855728236e-05
Gc29_713 0 n58 ns713 0 4.37658886674e-05
Gc29_714 0 n58 ns714 0 -0.000905797638917
Gc29_715 0 n58 ns715 0 3.57870667887e-05
Gc29_716 0 n58 ns716 0 -0.00112612724662
Gc29_717 0 n58 ns717 0 -0.000708966988499
Gc29_718 0 n58 ns718 0 0.00172037219111
Gc29_719 0 n58 ns719 0 0.000860225933731
Gc29_720 0 n58 ns720 0 2.070556576e-05
Gc29_721 0 n58 ns721 0 -0.000155172866474
Gc29_722 0 n58 ns722 0 2.38563427944e-05
Gc29_723 0 n58 ns723 0 0.000366034325552
Gc29_724 0 n58 ns724 0 -0.00148590796205
Gc29_725 0 n58 ns725 0 0.00109766401924
Gc29_726 0 n58 ns726 0 -0.00114014497544
Gc29_727 0 n58 ns727 0 -0.000605567205238
Gc29_728 0 n58 ns728 0 0.00018391290176
Gc29_729 0 n58 ns729 0 8.57380487509e-05
Gc29_730 0 n58 ns730 0 -0.000173936597867
Gc29_731 0 n58 ns731 0 0.000428890274713
Gc29_732 0 n58 ns732 0 3.92402113103e-05
Gc29_733 0 n58 ns733 0 0.000194572954533
Gc29_734 0 n58 ns734 0 -5.19256244041e-05
Gc29_735 0 n58 ns735 0 -5.0926271458e-05
Gc29_736 0 n58 ns736 0 -2.14369163881e-05
Gc29_737 0 n58 ns737 0 -0.00064636380381
Gc29_738 0 n58 ns738 0 -0.000809897060631
Gc29_739 0 n58 ns739 0 0.000369911420029
Gc29_740 0 n58 ns740 0 -0.000567653791864
Gc29_741 0 n58 ns741 0 -0.000141889500523
Gc29_742 0 n58 ns742 0 -0.00108541822464
Gc29_743 0 n58 ns743 0 0.0017839846477
Gc29_744 0 n58 ns744 0 -0.00011174530942
Gc29_745 0 n58 ns745 0 0.00255222753185
Gc29_746 0 n58 ns746 0 0.00276113394731
Gc29_747 0 n58 ns747 0 0.0021650817666
Gc29_748 0 n58 ns748 0 0.00319462126558
Gc29_749 0 n58 ns749 0 -0.000224793990845
Gc29_750 0 n58 ns750 0 -0.00188587284972
Gc29_751 0 n58 ns751 0 0.000658577980648
Gc29_752 0 n58 ns752 0 -0.0010429587254
Gc29_753 0 n58 ns753 0 7.2131433212e-05
Gc29_754 0 n58 ns754 0 -0.00049284126785
Gc29_755 0 n58 ns755 0 -0.00215476774824
Gc29_756 0 n58 ns756 0 0.00246026863094
Gc29_757 0 n58 ns757 0 0.00201728056289
Gc29_758 0 n58 ns758 0 9.03034523007e-06
Gc29_759 0 n58 ns759 0 -0.000163514419097
Gc29_760 0 n58 ns760 0 3.03253113695e-05
Gc29_761 0 n58 ns761 0 0.00119992586252
Gc29_762 0 n58 ns762 0 -0.00436696644032
Gc29_763 0 n58 ns763 0 0.00157840150368
Gc29_764 0 n58 ns764 0 -0.00255236008888
Gc29_765 0 n58 ns765 0 -0.00119691991903
Gc29_766 0 n58 ns766 0 -0.000455759650373
Gc29_767 0 n58 ns767 0 0.000649038648393
Gc29_768 0 n58 ns768 0 -0.000178573201117
Gc29_769 0 n58 ns769 0 0.000225157734664
Gc29_770 0 n58 ns770 0 0.000564239381991
Gc29_771 0 n58 ns771 0 0.000261190783774
Gc29_772 0 n58 ns772 0 -4.77646983621e-05
Gc29_773 0 n58 ns773 0 -0.000635218069381
Gc29_774 0 n58 ns774 0 7.34168820419e-05
Gc29_775 0 n58 ns775 0 0.000482615967398
Gc29_776 0 n58 ns776 0 -0.000847587201813
Gc29_777 0 n58 ns777 0 0.000650726591465
Gc29_778 0 n58 ns778 0 -0.000477359953708
Gc29_779 0 n58 ns779 0 0.000147055740817
Gc29_780 0 n58 ns780 0 -0.00121545473316
Gc29_781 0 n58 ns781 0 0.00100054948807
Gc29_782 0 n58 ns782 0 0.00169208819946
Gc29_783 0 n58 ns783 0 0.00541192140961
Gc29_784 0 n58 ns784 0 0.00556494366691
Gc29_785 0 n58 ns785 0 0.00407992661439
Gc29_786 0 n58 ns786 0 0.00553184259851
Gc29_787 0 n58 ns787 0 0.00284777676007
Gc29_788 0 n58 ns788 0 0.00221657800171
Gc29_789 0 n58 ns789 0 0.000896532788203
Gc29_790 0 n58 ns790 0 -0.000962870552995
Gc29_791 0 n58 ns791 0 -0.00424892926377
Gc29_792 0 n58 ns792 0 -0.00147372296258
Gc29_793 0 n58 ns793 0 -0.000687449562742
Gc29_794 0 n58 ns794 0 -0.00267109073524
Gc29_795 0 n58 ns795 0 0.00368742350962
Gc29_796 0 n58 ns796 0 3.40408932256e-05
Gc29_797 0 n58 ns797 0 -0.000150304782724
Gc29_798 0 n58 ns798 0 2.90694819892e-05
Gc29_799 0 n58 ns799 0 0.000747815135703
Gc29_800 0 n58 ns800 0 -0.00387457802998
Gc29_801 0 n58 ns801 0 -0.00105303965249
Gc29_802 0 n58 ns802 0 -0.00149347385774
Gc29_803 0 n58 ns803 0 -0.00124012952379
Gc29_804 0 n58 ns804 0 -9.97582453465e-05
Gc29_805 0 n58 ns805 0 0.000700721919841
Gc29_806 0 n58 ns806 0 -0.000130655694445
Gc29_807 0 n58 ns807 0 0.000119200819717
Gc29_808 0 n58 ns808 0 0.000512541572866
Gc29_809 0 n58 ns809 0 0.000277610168221
Gc29_810 0 n58 ns810 0 -1.35368700816e-05
Gc29_811 0 n58 ns811 0 -0.000421458578367
Gc29_812 0 n58 ns812 0 -0.000440458514848
Gc29_813 0 n58 ns813 0 4.47070352934e-05
Gc29_814 0 n58 ns814 0 -6.12313831664e-05
Gc29_815 0 n58 ns815 0 0.000333688324077
Gc29_816 0 n58 ns816 0 -0.000280227914506
Gc29_817 0 n58 ns817 0 -0.00038201111188
Gc29_818 0 n58 ns818 0 -0.00115651927024
Gc29_819 0 n58 ns819 0 -0.000278843448564
Gc29_820 0 n58 ns820 0 3.24880628507e-05
Gc29_821 0 n58 ns821 0 0.00648104391435
Gc29_822 0 n58 ns822 0 0.00585758585691
Gc29_823 0 n58 ns823 0 0.00484423837921
Gc29_824 0 n58 ns824 0 0.00575316348969
Gc29_825 0 n58 ns825 0 0.000508542071906
Gc29_826 0 n58 ns826 0 0.00532240643154
Gc29_827 0 n58 ns827 0 0.000836769299542
Gc29_828 0 n58 ns828 0 -0.000900064912556
Gc29_829 0 n58 ns829 0 -0.00629180263362
Gc29_830 0 n58 ns830 0 -0.00184890655965
Gc29_831 0 n58 ns831 0 0.00335354559628
Gc29_832 0 n58 ns832 0 -0.00500586461549
Gc29_833 0 n58 ns833 0 0.0045947918101
Gc29_834 0 n58 ns834 0 -1.72142904056e-05
Gc29_835 0 n58 ns835 0 4.88814188081e-05
Gc29_836 0 n58 ns836 0 -8.82391524442e-05
Gc29_837 0 n58 ns837 0 0.000447288540447
Gc29_838 0 n58 ns838 0 -0.0018714917007
Gc29_839 0 n58 ns839 0 0.00109086348882
Gc29_840 0 n58 ns840 0 -0.00154389751345
Gc29_841 0 n58 ns841 0 -0.000789348622039
Gc29_842 0 n58 ns842 0 -7.54555206236e-05
Gc29_843 0 n58 ns843 0 0.000171603856188
Gc29_844 0 n58 ns844 0 -0.000219258489017
Gc29_845 0 n58 ns845 0 0.000267189218013
Gc29_846 0 n58 ns846 0 0.000152636303378
Gc29_847 0 n58 ns847 0 0.000192419582138
Gc29_848 0 n58 ns848 0 -2.75466724891e-05
Gc29_849 0 n58 ns849 0 4.83967020843e-05
Gc29_850 0 n58 ns850 0 0.00041681875446
Gc29_851 0 n58 ns851 0 0.00016185191826
Gc29_852 0 n58 ns852 0 -0.000899952802072
Gc29_853 0 n58 ns853 0 0.000680948431843
Gc29_854 0 n58 ns854 0 -0.00047631000165
Gc29_855 0 n58 ns855 0 0.000324232246585
Gc29_856 0 n58 ns856 0 -0.000787447093903
Gc29_857 0 n58 ns857 0 0.00162087163395
Gc29_858 0 n58 ns858 0 0.00114269842428
Gc29_859 0 n58 ns859 0 0.00238927970852
Gc29_860 0 n58 ns860 0 0.00376523751133
Gc29_861 0 n58 ns861 0 0.00192523534044
Gc29_862 0 n58 ns862 0 0.00400366688824
Gc29_863 0 n58 ns863 0 0.00145966362067
Gc29_864 0 n58 ns864 0 -0.0020229495562
Gc29_865 0 n58 ns865 0 0.000860961697709
Gc29_866 0 n58 ns866 0 -0.00092296170003
Gc29_867 0 n58 ns867 0 -0.000362437514202
Gc29_868 0 n58 ns868 0 -0.00026250001263
Gc29_869 0 n58 ns869 0 -0.00322193726224
Gc29_870 0 n58 ns870 0 0.00261173505385
Gc29_871 0 n58 ns871 0 0.00269114833377
Gc29_872 0 n58 ns872 0 2.77567106719e-05
Gc29_873 0 n58 ns873 0 -0.000114351867914
Gc29_874 0 n58 ns874 0 1.47734506112e-05
Gc29_875 0 n58 ns875 0 -3.4193834871e-05
Gc29_876 0 n58 ns876 0 -0.000288439352417
Gc29_877 0 n58 ns877 0 6.73479092814e-05
Gc29_878 0 n58 ns878 0 0.000410890174916
Gc29_879 0 n58 ns879 0 0.000178675274238
Gc29_880 0 n58 ns880 0 0.000314376109797
Gc29_881 0 n58 ns881 0 -0.000179802908418
Gc29_882 0 n58 ns882 0 -3.76095520162e-05
Gc29_883 0 n58 ns883 0 -8.72422461593e-05
Gc29_884 0 n58 ns884 0 -0.000328459737174
Gc29_885 0 n58 ns885 0 0.000166231833839
Gc29_886 0 n58 ns886 0 -7.00019134341e-05
Gc29_887 0 n58 ns887 0 9.78826313636e-05
Gc29_888 0 n58 ns888 0 -0.000210832491108
Gc29_889 0 n58 ns889 0 -0.000292019653283
Gc29_890 0 n58 ns890 0 0.000304872268164
Gc29_891 0 n58 ns891 0 0.000411121911079
Gc29_892 0 n58 ns892 0 -0.000479206411577
Gc29_893 0 n58 ns893 0 -7.07971157379e-05
Gc29_894 0 n58 ns894 0 -0.000681893756379
Gc29_895 0 n58 ns895 0 0.000285113592838
Gc29_896 0 n58 ns896 0 -0.000834700709873
Gc29_897 0 n58 ns897 0 0.00177010510714
Gc29_898 0 n58 ns898 0 0.00383107889888
Gc29_899 0 n58 ns899 0 0.0018071875455
Gc29_900 0 n58 ns900 0 0.00388694177925
Gc29_901 0 n58 ns901 0 -0.00202053411893
Gc29_902 0 n58 ns902 0 -0.000723313133132
Gc29_903 0 n58 ns903 0 0.000258933719469
Gc29_904 0 n58 ns904 0 -0.00100823445462
Gc29_905 0 n58 ns905 0 0.000451477882976
Gc29_906 0 n58 ns906 0 -0.00107361783046
Gc29_907 0 n58 ns907 0 -0.000913702412497
Gc29_908 0 n58 ns908 0 0.00216428145119
Gc29_909 0 n58 ns909 0 0.0010992524911
Gc29_910 0 n58 ns910 0 2.92362168861e-05
Gc29_911 0 n58 ns911 0 -0.000229867831
Gc29_912 0 n58 ns912 0 8.29854917195e-05
Gc29_913 0 n58 ns913 0 -1.68110188538e-05
Gc29_914 0 n58 ns914 0 -0.000511466747136
Gc29_915 0 n58 ns915 0 -0.000128943152078
Gc29_916 0 n58 ns916 0 7.87998323365e-05
Gc29_917 0 n58 ns917 0 0.00016905388681
Gc29_918 0 n58 ns918 0 -0.000132191638512
Gc29_919 0 n58 ns919 0 -5.54812701513e-06
Gc29_920 0 n58 ns920 0 -8.37588001643e-05
Gc29_921 0 n58 ns921 0 -0.000539437468398
Gc29_922 0 n58 ns922 0 -0.000285919023669
Gc29_923 0 n58 ns923 0 0.00012939449307
Gc29_924 0 n58 ns924 0 -6.34155916614e-05
Gc29_925 0 n58 ns925 0 -3.37622192082e-05
Gc29_926 0 n58 ns926 0 0.000259026606862
Gc29_927 0 n58 ns927 0 0.000763468374151
Gc29_928 0 n58 ns928 0 0.00102416726286
Gc29_929 0 n58 ns929 0 0.000590675949663
Gc29_930 0 n58 ns930 0 -0.000148834281892
Gc29_931 0 n58 ns931 0 0.000281880653642
Gc29_932 0 n58 ns932 0 0.000135098073336
Gc29_933 0 n58 ns933 0 -0.00115214181835
Gc29_934 0 n58 ns934 0 1.86900961636e-06
Gc29_935 0 n58 ns935 0 0.000846258000889
Gc29_936 0 n58 ns936 0 0.00422625529108
Gc29_937 0 n58 ns937 0 0.0011345515391
Gc29_938 0 n58 ns938 0 0.00385397969886
Gc29_939 0 n58 ns939 0 -0.00108301736765
Gc29_940 0 n58 ns940 0 0.00098587554222
Gc29_941 0 n58 ns941 0 -0.00010623440911
Gc29_942 0 n58 ns942 0 -0.000674144214378
Gc29_943 0 n58 ns943 0 -0.000243851142574
Gc29_944 0 n58 ns944 0 -0.00143476855391
Gc29_945 0 n58 ns945 0 -0.000402747977517
Gc29_946 0 n58 ns946 0 0.000396687591949
Gc29_947 0 n58 ns947 0 0.000329320714059
Gc29_948 0 n58 ns948 0 -2.07940405045e-05
Gc29_949 0 n58 ns949 0 -0.000100666250632
Gc29_950 0 n58 ns950 0 -1.03797437737e-05
Gc29_951 0 n58 ns951 0 8.55696137157e-05
Gc29_952 0 n58 ns952 0 -0.0002456371578
Gc29_953 0 n58 ns953 0 0.00049673757535
Gc29_954 0 n58 ns954 0 0.000476723955895
Gc29_955 0 n58 ns955 0 0.000185476989267
Gc29_956 0 n58 ns956 0 -2.98877315349e-05
Gc29_957 0 n58 ns957 0 1.7179292615e-05
Gc29_958 0 n58 ns958 0 4.51476289174e-05
Gc29_959 0 n58 ns959 0 -0.000239675085569
Gc29_960 0 n58 ns960 0 -0.000102198747046
Gc29_961 0 n58 ns961 0 0.000132574930595
Gc29_962 0 n58 ns962 0 -0.000142025285852
Gc29_963 0 n58 ns963 0 -0.000252215168573
Gc29_964 0 n58 ns964 0 -0.000224773413885
Gc29_965 0 n58 ns965 0 0.000246894943454
Gc29_966 0 n58 ns966 0 0.000455494746403
Gc29_967 0 n58 ns967 0 0.000301076740933
Gc29_968 0 n58 ns968 0 -0.000527219835365
Gc29_969 0 n58 ns969 0 -0.000109912867316
Gc29_970 0 n58 ns970 0 -0.000498143358297
Gc29_971 0 n58 ns971 0 -0.000383654371043
Gc29_972 0 n58 ns972 0 -0.000196027521721
Gc29_973 0 n58 ns973 0 0.00278081252335
Gc29_974 0 n58 ns974 0 0.00386012175119
Gc29_975 0 n58 ns975 0 0.00279214216036
Gc29_976 0 n58 ns976 0 0.00359800161086
Gc29_977 0 n58 ns977 0 -0.0011474270771
Gc29_978 0 n58 ns978 0 0.000673939670573
Gc29_979 0 n58 ns979 0 -0.000126390672878
Gc29_980 0 n58 ns980 0 -0.000806182365527
Gc29_981 0 n58 ns981 0 -0.000450221573879
Gc29_982 0 n58 ns982 0 -0.0014529247956
Gc29_983 0 n58 ns983 0 -0.000656201974269
Gc29_984 0 n58 ns984 0 0.000800895122011
Gc29_985 0 n58 ns985 0 0.000527194163585
Gc29_986 0 n58 ns986 0 2.02112269037e-05
Gc29_987 0 n58 ns987 0 -0.000138450428009
Gc29_988 0 n58 ns988 0 2.41324574888e-05
Gc29_989 0 n58 ns989 0 1.98296113383e-05
Gc29_990 0 n58 ns990 0 -0.000570953837761
Gc29_991 0 n58 ns991 0 0.00020654818399
Gc29_992 0 n58 ns992 0 -0.000225277815587
Gc29_993 0 n58 ns993 0 -0.000366077497165
Gc29_994 0 n58 ns994 0 0.000372733962348
Gc29_995 0 n58 ns995 0 3.12466785206e-05
Gc29_996 0 n58 ns996 0 -0.000113524001261
Gc29_997 0 n58 ns997 0 0.000307130141438
Gc29_998 0 n58 ns998 0 -0.000136879023634
Gc29_999 0 n58 ns999 0 0.000177397728239
Gc29_1000 0 n58 ns1000 0 -6.58241910337e-05
Gc29_1001 0 n58 ns1001 0 6.98728035925e-05
Gc29_1002 0 n58 ns1002 0 -0.000255709400828
Gc29_1003 0 n58 ns1003 0 -0.000765430725917
Gc29_1004 0 n58 ns1004 0 -0.000289817699119
Gc29_1005 0 n58 ns1005 0 0.000256291934033
Gc29_1006 0 n58 ns1006 0 -0.000505668435154
Gc29_1007 0 n58 ns1007 0 -0.000261686861027
Gc29_1008 0 n58 ns1008 0 -0.000875890247709
Gc29_1009 0 n58 ns1009 0 0.00115847995054
Gc29_1010 0 n58 ns1010 0 -0.000803007510151
Gc29_1011 0 n58 ns1011 0 0.0019570366649
Gc29_1012 0 n58 ns1012 0 0.00270906323543
Gc29_1013 0 n58 ns1013 0 0.0018147418465
Gc29_1014 0 n58 ns1014 0 0.00304503994625
Gc29_1015 0 n58 ns1015 0 -0.00145225765516
Gc29_1016 0 n58 ns1016 0 -0.00162230740165
Gc29_1017 0 n58 ns1017 0 0.000440347147344
Gc29_1018 0 n58 ns1018 0 -0.00101700284491
Gc29_1019 0 n58 ns1019 0 0.000387824895747
Gc29_1020 0 n58 ns1020 0 -0.000541608572512
Gc29_1021 0 n58 ns1021 0 -0.00137923640891
Gc29_1022 0 n58 ns1022 0 0.00287505844515
Gc29_1023 0 n58 ns1023 0 0.00157165577879
Gc29_1024 0 n58 ns1024 0 1.96311451324e-05
Gc29_1025 0 n58 ns1025 0 -0.00017881262144
Gc29_1026 0 n58 ns1026 0 4.91160675007e-05
Gc29_1027 0 n58 ns1027 0 0.000264457881369
Gc29_1028 0 n58 ns1028 0 -0.00188601017301
Gc29_1029 0 n58 ns1029 0 0.000497585079039
Gc29_1030 0 n58 ns1030 0 -8.45708909492e-05
Gc29_1031 0 n58 ns1031 0 -0.000920580728969
Gc29_1032 0 n58 ns1032 0 0.00040723594027
Gc29_1033 0 n58 ns1033 0 0.000396991683555
Gc29_1034 0 n58 ns1034 0 -0.00053427430445
Gc29_1035 0 n58 ns1035 0 0.000368279968937
Gc29_1036 0 n58 ns1036 0 0.000462032994899
Gc29_1037 0 n58 ns1037 0 0.000261874357332
Gc29_1038 0 n58 ns1038 0 -5.09875866718e-05
Gc29_1039 0 n58 ns1039 0 -0.000428493105067
Gc29_1040 0 n58 ns1040 0 -0.000138208437508
Gc29_1041 0 n58 ns1041 0 0.000681450123555
Gc29_1042 0 n58 ns1042 0 -0.000957698681509
Gc29_1043 0 n58 ns1043 0 0.000868912301324
Gc29_1044 0 n58 ns1044 0 -0.00043369452896
Gc29_1045 0 n58 ns1045 0 0.000501540186519
Gc29_1046 0 n58 ns1046 0 -0.000920093343161
Gc29_1047 0 n58 ns1047 0 0.000885026924621
Gc29_1048 0 n58 ns1048 0 0.00220333020702
Gc29_1049 0 n58 ns1049 0 0.00253226437788
Gc29_1050 0 n58 ns1050 0 0.00441917197802
Gc29_1051 0 n58 ns1051 0 0.00189914762637
Gc29_1052 0 n58 ns1052 0 0.00459575369207
Gc29_1053 0 n58 ns1053 0 0.00365486405884
Gc29_1054 0 n58 ns1054 0 0.000695770894926
Gc29_1055 0 n58 ns1055 0 0.000868998739557
Gc29_1056 0 n58 ns1056 0 -0.00101098283752
Gc29_1057 0 n58 ns1057 0 -0.00196850796404
Gc29_1058 0 n58 ns1058 0 -0.00153579552849
Gc29_1059 0 n58 ns1059 0 -0.00390362153078
Gc29_1060 0 n58 ns1060 0 -0.000564360964049
Gc29_1061 0 n58 ns1061 0 0.00300815535674
Gc29_1062 0 n58 ns1062 0 5.6625097062e-05
Gc29_1063 0 n58 ns1063 0 -0.000177065719171
Gc29_1064 0 n58 ns1064 0 3.87084739644e-05
Gc29_1065 0 n58 ns1065 0 6.60528125376e-05
Gc29_1066 0 n58 ns1066 0 -0.00187888109884
Gc29_1067 0 n58 ns1067 0 -0.00233615505802
Gc29_1068 0 n58 ns1068 0 0.000837971010637
Gc29_1069 0 n58 ns1069 0 -0.000876943144666
Gc29_1070 0 n58 ns1070 0 0.000433543215244
Gc29_1071 0 n58 ns1071 0 0.000555345997886
Gc29_1072 0 n58 ns1072 0 -0.000366826315028
Gc29_1073 0 n58 ns1073 0 0.000140997864534
Gc29_1074 0 n58 ns1074 0 0.00050443537803
Gc29_1075 0 n58 ns1075 0 0.000292353094372
Gc29_1076 0 n58 ns1076 0 -9.88899361885e-06
Gc29_1077 0 n58 ns1077 0 -0.000599569483898
Gc29_1078 0 n58 ns1078 0 -0.000682984380007
Gc29_1079 0 n58 ns1079 0 0.00034851551039
Gc29_1080 0 n58 ns1080 0 0.000129730282833
Gc29_1081 0 n58 ns1081 0 0.000400876180261
Gc29_1082 0 n58 ns1082 0 -0.000157129388716
Gc29_1083 0 n58 ns1083 0 -0.00036761283711
Gc29_1084 0 n58 ns1084 0 -0.000995298944187
Gc29_1085 0 n58 ns1085 0 -0.000801219352735
Gc29_1086 0 n58 ns1086 0 0.00027113607217
Gc29_1087 0 n58 ns1087 0 0.00649431341143
Gc29_1088 0 n58 ns1088 0 0.00495635175623
Gc29_1089 0 n58 ns1089 0 0.00484757718193
Gc29_1090 0 n58 ns1090 0 0.00503442851447
Gc29_1091 0 n58 ns1091 0 0.000935470714366
Gc29_1092 0 n58 ns1092 0 0.00567226637854
Gc29_1093 0 n58 ns1093 0 0.000893095528308
Gc29_1094 0 n58 ns1094 0 -0.000840589691925
Gc29_1095 0 n58 ns1095 0 -0.00603898708749
Gc29_1096 0 n58 ns1096 0 -0.00166537358326
Gc29_1097 0 n58 ns1097 0 0.00276212376884
Gc29_1098 0 n58 ns1098 0 -0.00440844848411
Gc29_1099 0 n58 ns1099 0 0.00473915786733
Gc29_1100 0 n58 ns1100 0 -1.91483767834e-05
Gc29_1101 0 n58 ns1101 0 0.000100939460961
Gc29_1102 0 n58 ns1102 0 -0.000114962920886
Gc29_1103 0 n58 ns1103 0 0.00018790566422
Gc29_1104 0 n58 ns1104 0 -0.00192954459957
Gc29_1105 0 n58 ns1105 0 0.000178389820092
Gc29_1106 0 n58 ns1106 0 -0.00052276350734
Gc29_1107 0 n58 ns1107 0 -0.000984705848925
Gc29_1108 0 n58 ns1108 0 0.000307238988197
Gc29_1109 0 n58 ns1109 0 0.000414401522622
Gc29_1110 0 n58 ns1110 0 -0.000463500965015
Gc29_1111 0 n58 ns1111 0 0.000319254802014
Gc29_1112 0 n58 ns1112 0 0.000467762091779
Gc29_1113 0 n58 ns1113 0 0.000253662436728
Gc29_1114 0 n58 ns1114 0 -4.20519412737e-05
Gc29_1115 0 n58 ns1115 0 -0.000354414154787
Gc29_1116 0 n58 ns1116 0 -4.65787725539e-05
Gc29_1117 0 n58 ns1117 0 0.00066266150966
Gc29_1118 0 n58 ns1118 0 -0.000899307729864
Gc29_1119 0 n58 ns1119 0 0.00081400805273
Gc29_1120 0 n58 ns1120 0 -0.000400212587009
Gc29_1121 0 n58 ns1121 0 0.000394442019703
Gc29_1122 0 n58 ns1122 0 -0.000842883146116
Gc29_1123 0 n58 ns1123 0 0.000854456275529
Gc29_1124 0 n58 ns1124 0 0.00207968169287
Gc29_1125 0 n58 ns1125 0 0.00273751823915
Gc29_1126 0 n58 ns1126 0 0.00421480681995
Gc29_1127 0 n58 ns1127 0 0.00208089537521
Gc29_1128 0 n58 ns1128 0 0.00443733997212
Gc29_1129 0 n58 ns1129 0 0.00346318089901
Gc29_1130 0 n58 ns1130 0 0.000412579324235
Gc29_1131 0 n58 ns1131 0 0.000899483184304
Gc29_1132 0 n58 ns1132 0 -0.000968866533498
Gc29_1133 0 n58 ns1133 0 -0.00180411482736
Gc29_1134 0 n58 ns1134 0 -0.00123613752267
Gc29_1135 0 n58 ns1135 0 -0.00384512072986
Gc29_1136 0 n58 ns1136 0 -0.000106450713853
Gc29_1137 0 n58 ns1137 0 0.00311896331051
Gc29_1138 0 n58 ns1138 0 4.15582900061e-05
Gc29_1139 0 n58 ns1139 0 -0.000127574822297
Gc29_1140 0 n58 ns1140 0 1.12230308427e-05
Gc29_1141 0 n58 ns1141 0 0.000334334794417
Gc29_1142 0 n58 ns1142 0 -0.000806458906841
Gc29_1143 0 n58 ns1143 0 0.00112779614263
Gc29_1144 0 n58 ns1144 0 -7.43834919762e-05
Gc29_1145 0 n58 ns1145 0 -9.59418248153e-05
Gc29_1146 0 n58 ns1146 0 0.000342124615012
Gc29_1147 0 n58 ns1147 0 -0.000157368536394
Gc29_1148 0 n58 ns1148 0 -0.000100348906451
Gc29_1149 0 n58 ns1149 0 0.000248374955703
Gc29_1150 0 n58 ns1150 0 -0.000167797098876
Gc29_1151 0 n58 ns1151 0 0.00018424959434
Gc29_1152 0 n58 ns1152 0 -8.26623452646e-05
Gc29_1153 0 n58 ns1153 0 2.65727820293e-05
Gc29_1154 0 n58 ns1154 0 -0.000259656925684
Gc29_1155 0 n58 ns1155 0 -0.000591611452325
Gc29_1156 0 n58 ns1156 0 -0.000443268318903
Gc29_1157 0 n58 ns1157 0 0.000385524649003
Gc29_1158 0 n58 ns1158 0 -0.000705119261813
Gc29_1159 0 n58 ns1159 0 -7.21162783074e-05
Gc29_1160 0 n58 ns1160 0 -0.00116518552595
Gc29_1161 0 n58 ns1161 0 0.00131872544627
Gc29_1162 0 n58 ns1162 0 -0.000466471659137
Gc29_1163 0 n58 ns1163 0 0.00258374903915
Gc29_1164 0 n58 ns1164 0 0.00394049510782
Gc29_1165 0 n58 ns1165 0 0.00235694535009
Gc29_1166 0 n58 ns1166 0 0.00408536004821
Gc29_1167 0 n58 ns1167 0 -0.00115349908767
Gc29_1168 0 n58 ns1168 0 -0.001528486376
Gc29_1169 0 n58 ns1169 0 0.000426799426252
Gc29_1170 0 n58 ns1170 0 -0.00105464848983
Gc29_1171 0 n58 ns1171 0 0.000180340022593
Gc29_1172 0 n58 ns1172 0 -0.000791601175384
Gc29_1173 0 n58 ns1173 0 -0.00151356402893
Gc29_1174 0 n58 ns1174 0 0.00242029490012
Gc29_1175 0 n58 ns1175 0 0.00148945719873
Gc29_1176 0 n58 ns1176 0 3.69726370583e-05
Gc29_1177 0 n58 ns1177 0 -0.000251057892966
Gc29_1178 0 n58 ns1178 0 8.83226218725e-05
Gc29_1179 0 n58 ns1179 0 -0.000185477043225
Gc29_1180 0 n58 ns1180 0 -0.000391083482165
Gc29_1181 0 n58 ns1181 0 -0.000519924071335
Gc29_1182 0 n58 ns1182 0 0.000294949693815
Gc29_1183 0 n58 ns1183 0 0.000130330357041
Gc29_1184 0 n58 ns1184 0 -5.04636492163e-05
Gc29_1185 0 n58 ns1185 0 1.84508411043e-05
Gc29_1186 0 n58 ns1186 0 -2.06090556618e-05
Gc29_1187 0 n58 ns1187 0 -0.000501118091313
Gc29_1188 0 n58 ns1188 0 -0.000297232771664
Gc29_1189 0 n58 ns1189 0 0.000171296119676
Gc29_1190 0 n58 ns1190 0 -7.48742638277e-05
Gc29_1191 0 n58 ns1191 0 2.95343556409e-05
Gc29_1192 0 n58 ns1192 0 7.5379688317e-05
Gc29_1193 0 n58 ns1193 0 0.000539485065189
Gc29_1194 0 n58 ns1194 0 0.00105779027476
Gc29_1195 0 n58 ns1195 0 0.000607614193389
Gc29_1196 0 n58 ns1196 0 -0.000211365891277
Gc29_1197 0 n58 ns1197 0 0.000181408671892
Gc29_1198 0 n58 ns1198 0 2.26297617583e-06
Gc29_1199 0 n58 ns1199 0 -0.00103460713643
Gc29_1200 0 n58 ns1200 0 -0.00035200451636
Gc29_1201 0 n58 ns1201 0 0.00102157595223
Gc29_1202 0 n58 ns1202 0 0.00440947618403
Gc29_1203 0 n58 ns1203 0 0.00132154011431
Gc29_1204 0 n58 ns1204 0 0.00414519347056
Gc29_1205 0 n58 ns1205 0 -0.00164872818212
Gc29_1206 0 n58 ns1206 0 0.000672090261789
Gc29_1207 0 n58 ns1207 0 -2.36535111123e-05
Gc29_1208 0 n58 ns1208 0 -0.000823355376859
Gc29_1209 0 n58 ns1209 0 3.84719453015e-05
Gc29_1210 0 n58 ns1210 0 -0.0014544193257
Gc29_1211 0 n58 ns1211 0 -0.000496373341482
Gc29_1212 0 n58 ns1212 0 0.00101294166867
Gc29_1213 0 n58 ns1213 0 0.000566501780516
Gc29_1214 0 n58 ns1214 0 -7.60902221308e-06
Gc29_1215 0 n58 ns1215 0 -0.00011603637401
Gc29_1216 0 n58 ns1216 0 -1.4040017578e-06
Gd29_1 0 n58 ni1 0 9.08850401691e-05
Gd29_2 0 n58 ni2 0 0.000212963972822
Gd29_3 0 n58 ni3 0 5.8922103753e-05
Gd29_4 0 n58 ni4 0 -0.000211114858791
Gd29_5 0 n58 ni5 0 -0.00181918207451
Gd29_6 0 n58 ni6 0 -0.00397472922699
Gd29_7 0 n58 ni7 0 0.000662966371414
Gd29_8 0 n58 ni8 0 0.000331413696667
Gd29_9 0 n58 ni9 0 -0.000342857276455
Gd29_10 0 n58 ni10 0 0.000724644655136
Gd29_11 0 n58 ni11 0 -0.000303890018295
Gd29_12 0 n58 ni12 0 -3.78673615149e-05
Gd29_13 0 n58 ni13 0 4.09470704434e-05
Gd29_14 0 n58 ni14 0 -0.00019462798805
Gd29_15 0 n58 ni15 0 0.000798067523955
Gd29_16 0 n58 ni16 0 -0.000213794354295
Gd29_17 0 n58 ni17 0 0.000185983329304
Gd29_18 0 n58 ni18 0 0.000189088515138
Gd29_19 0 n58 ni19 0 0.000278899244584
Gd29_20 0 n58 ni20 0 -0.00125290536955
Gd29_21 0 n58 ni21 0 -0.00287063853137
Gd29_22 0 n58 ni22 0 -0.000598837009444
Gd29_23 0 n58 ni23 0 -0.00155322373267
Gd29_24 0 n58 ni24 0 0.000133641740331
Gd29_25 0 n58 ni25 0 1.64310217017e-05
Gd29_26 0 n58 ni26 0 6.62081117884e-05
Gd29_27 0 n58 ni27 0 -0.000251993105602
Gd29_28 0 n58 ni28 0 -0.00143001656517
Gd29_29 0 n58 ni29 0 0.00148092367892
Gd29_30 0 n58 ni30 0 -0.0014609888363
Gd29_31 0 n58 ni31 0 -0.000570989628701
Gd29_32 0 n58 ni32 0 0.000247420065562
Gc30_1 0 n60 ns1 0 -0.000702830311248
Gc30_2 0 n60 ns2 0 0.00130218650729
Gc30_3 0 n60 ns3 0 -0.00179526639402
Gc30_4 0 n60 ns4 0 0.00184008273341
Gc30_5 0 n60 ns5 0 -0.000237012154779
Gc30_6 0 n60 ns6 0 0.000684360965505
Gc30_7 0 n60 ns7 0 0.000168329523863
Gc30_8 0 n60 ns8 0 -0.000436149412378
Gc30_9 0 n60 ns9 0 -6.16709778142e-05
Gc30_10 0 n60 ns10 0 -0.000114316110599
Gc30_11 0 n60 ns11 0 9.31070645411e-05
Gc30_12 0 n60 ns12 0 0.000114905507448
Gc30_13 0 n60 ns13 0 0.000589267186014
Gc30_14 0 n60 ns14 0 -0.000349277379548
Gc30_15 0 n60 ns15 0 0.000347010004467
Gc30_16 0 n60 ns16 0 -0.000740124347106
Gc30_17 0 n60 ns17 0 -0.000192825427576
Gc30_18 0 n60 ns18 0 -0.000483628503957
Gc30_19 0 n60 ns19 0 -0.000181339804573
Gc30_20 0 n60 ns20 0 -0.000432268690604
Gc30_21 0 n60 ns21 0 -0.000556556268274
Gc30_22 0 n60 ns22 0 -0.000163260497443
Gc30_23 0 n60 ns23 0 -0.00416921237155
Gc30_24 0 n60 ns24 0 0.000465076872993
Gc30_25 0 n60 ns25 0 -0.00362933607041
Gc30_26 0 n60 ns26 0 0.000471962757328
Gc30_27 0 n60 ns27 0 0.000430724645311
Gc30_28 0 n60 ns28 0 0.00131487983536
Gc30_29 0 n60 ns29 0 -0.000253897996657
Gc30_30 0 n60 ns30 0 -0.000274624381946
Gc30_31 0 n60 ns31 0 -0.000877400069876
Gc30_32 0 n60 ns32 0 -0.00104148335801
Gc30_33 0 n60 ns33 0 -0.000121926674949
Gc30_34 0 n60 ns34 0 -0.00066314425473
Gc30_35 0 n60 ns35 0 -0.000201479687212
Gc30_36 0 n60 ns36 0 2.47178203137e-06
Gc30_37 0 n60 ns37 0 6.62689613642e-05
Gc30_38 0 n60 ns38 0 -7.67182111155e-06
Gc30_39 0 n60 ns39 0 -0.000515599723586
Gc30_40 0 n60 ns40 0 0.000743412340763
Gc30_41 0 n60 ns41 0 -0.00125453624802
Gc30_42 0 n60 ns42 0 0.000725614977529
Gc30_43 0 n60 ns43 0 -0.000174602754327
Gc30_44 0 n60 ns44 0 0.000370784501909
Gc30_45 0 n60 ns45 0 0.000147397305544
Gc30_46 0 n60 ns46 0 -0.000260840102952
Gc30_47 0 n60 ns47 0 -5.30392837208e-05
Gc30_48 0 n60 ns48 0 -0.000334308248246
Gc30_49 0 n60 ns49 0 3.64935381182e-05
Gc30_50 0 n60 ns50 0 0.000172443869648
Gc30_51 0 n60 ns51 0 0.0005800058843
Gc30_52 0 n60 ns52 0 7.86078018472e-05
Gc30_53 0 n60 ns53 0 0.00042906724052
Gc30_54 0 n60 ns54 0 -0.000570122012853
Gc30_55 0 n60 ns55 0 -0.000225128973757
Gc30_56 0 n60 ns56 0 -0.000498266723897
Gc30_57 0 n60 ns57 0 -0.000305582177845
Gc30_58 0 n60 ns58 0 -0.000384439270363
Gc30_59 0 n60 ns59 0 -0.000572151315125
Gc30_60 0 n60 ns60 0 -0.00044013387704
Gc30_61 0 n60 ns61 0 -0.00504103315271
Gc30_62 0 n60 ns62 0 -0.00037311605499
Gc30_63 0 n60 ns63 0 -0.0044310348913
Gc30_64 0 n60 ns64 0 -0.000226169972683
Gc30_65 0 n60 ns65 0 0.000314866804587
Gc30_66 0 n60 ns66 0 0.00135121648399
Gc30_67 0 n60 ns67 0 -0.000280265161712
Gc30_68 0 n60 ns68 0 -0.000322976215972
Gc30_69 0 n60 ns69 0 -0.00091626693218
Gc30_70 0 n60 ns70 0 -0.00107011696072
Gc30_71 0 n60 ns71 0 -0.000100433835287
Gc30_72 0 n60 ns72 0 -0.000572220937025
Gc30_73 0 n60 ns73 0 -0.000185014959694
Gc30_74 0 n60 ns74 0 -1.51740580535e-05
Gc30_75 0 n60 ns75 0 0.000106730063207
Gc30_76 0 n60 ns76 0 -2.59281065914e-05
Gc30_77 0 n60 ns77 0 0.000320171840313
Gc30_78 0 n60 ns78 0 -0.000585118031431
Gc30_79 0 n60 ns79 0 0.00113128880366
Gc30_80 0 n60 ns80 0 -0.000923879210061
Gc30_81 0 n60 ns81 0 0.000237376279677
Gc30_82 0 n60 ns82 0 -0.000183252861359
Gc30_83 0 n60 ns83 0 -0.000166836442211
Gc30_84 0 n60 ns84 0 0.000155703574526
Gc30_85 0 n60 ns85 0 0.000321427583874
Gc30_86 0 n60 ns86 0 -0.000327666162471
Gc30_87 0 n60 ns87 0 -0.000123310029258
Gc30_88 0 n60 ns88 0 0.000137646289693
Gc30_89 0 n60 ns89 0 -0.0002262024768
Gc30_90 0 n60 ns90 0 0.000545629596078
Gc30_91 0 n60 ns91 0 0.000476723867878
Gc30_92 0 n60 ns92 0 0.000275255373213
Gc30_93 0 n60 ns93 0 8.01454996719e-05
Gc30_94 0 n60 ns94 0 -0.000441506795703
Gc30_95 0 n60 ns95 0 -0.000161910703154
Gc30_96 0 n60 ns96 0 -0.000276611526008
Gc30_97 0 n60 ns97 0 -3.8062352463e-05
Gc30_98 0 n60 ns98 0 -0.000529277500212
Gc30_99 0 n60 ns99 0 -0.00506889727304
Gc30_100 0 n60 ns100 0 -0.00321945912634
Gc30_101 0 n60 ns101 0 -0.00465613746688
Gc30_102 0 n60 ns102 0 -0.00278643241115
Gc30_103 0 n60 ns103 0 7.05217301432e-05
Gc30_104 0 n60 ns104 0 0.0016854081222
Gc30_105 0 n60 ns105 0 -0.000343380510591
Gc30_106 0 n60 ns106 0 -0.000605631927274
Gc30_107 0 n60 ns107 0 -0.00114717007934
Gc30_108 0 n60 ns108 0 -0.00173138071778
Gc30_109 0 n60 ns109 0 -0.000102106261044
Gc30_110 0 n60 ns110 0 -0.0011431048854
Gc30_111 0 n60 ns111 0 -0.000371465509852
Gc30_112 0 n60 ns112 0 -1.03775815316e-05
Gc30_113 0 n60 ns113 0 8.99952214056e-05
Gc30_114 0 n60 ns114 0 -7.65216224984e-06
Gc30_115 0 n60 ns115 0 -0.000116143206959
Gc30_116 0 n60 ns116 0 2.23841005831e-05
Gc30_117 0 n60 ns117 0 -5.05721465045e-05
Gc30_118 0 n60 ns118 0 0.000747896782622
Gc30_119 0 n60 ns119 0 -0.000144123128661
Gc30_120 0 n60 ns120 0 0.000103583981347
Gc30_121 0 n60 ns121 0 -2.84195737087e-05
Gc30_122 0 n60 ns122 0 -0.000118465246534
Gc30_123 0 n60 ns123 0 0.000114188118835
Gc30_124 0 n60 ns124 0 0.000515679457134
Gc30_125 0 n60 ns125 0 -8.14582866098e-05
Gc30_126 0 n60 ns126 0 6.39621513619e-05
Gc30_127 0 n60 ns127 0 9.51705978349e-05
Gc30_128 0 n60 ns128 0 -0.000581540614225
Gc30_129 0 n60 ns129 0 -3.08985373373e-05
Gc30_130 0 n60 ns130 0 0.000567534867419
Gc30_131 0 n60 ns131 0 0.000475011081769
Gc30_132 0 n60 ns132 0 -0.000217930631826
Gc30_133 0 n60 ns133 0 0.000115502586205
Gc30_134 0 n60 ns134 0 -6.0572561483e-05
Gc30_135 0 n60 ns135 0 -0.000217843047452
Gc30_136 0 n60 ns136 0 0.000607617188762
Gc30_137 0 n60 ns137 0 -0.00319704560012
Gc30_138 0 n60 ns138 0 -0.00371936590883
Gc30_139 0 n60 ns139 0 -0.00309324839011
Gc30_140 0 n60 ns140 0 -0.00364693395042
Gc30_141 0 n60 ns141 0 -0.000450876021508
Gc30_142 0 n60 ns142 0 0.001811483017
Gc30_143 0 n60 ns143 0 -0.000122047582957
Gc30_144 0 n60 ns144 0 -0.00113520608929
Gc30_145 0 n60 ns145 0 -0.000772983754533
Gc30_146 0 n60 ns146 0 -0.00296746012062
Gc30_147 0 n60 ns147 0 0.000251697119273
Gc30_148 0 n60 ns148 0 -0.00265603069129
Gc30_149 0 n60 ns149 0 -0.000975782133491
Gc30_150 0 n60 ns150 0 -1.68582500317e-05
Gc30_151 0 n60 ns151 0 0.000105327574346
Gc30_152 0 n60 ns152 0 -2.28156927442e-05
Gc30_153 0 n60 ns153 0 -0.000306093712486
Gc30_154 0 n60 ns154 0 -0.000484520792054
Gc30_155 0 n60 ns155 0 -0.000920807343295
Gc30_156 0 n60 ns156 0 0.000806893285301
Gc30_157 0 n60 ns157 0 -0.000112844526654
Gc30_158 0 n60 ns158 0 0.000510347584716
Gc30_159 0 n60 ns159 0 0.000134020188539
Gc30_160 0 n60 ns160 0 -0.000292717244091
Gc30_161 0 n60 ns161 0 -0.00048510589201
Gc30_162 0 n60 ns162 0 0.000212588897938
Gc30_163 0 n60 ns163 0 -0.000141787760928
Gc30_164 0 n60 ns164 0 8.98566895834e-05
Gc30_165 0 n60 ns165 0 0.000896773165313
Gc30_166 0 n60 ns166 0 -0.000181319309889
Gc30_167 0 n60 ns167 0 -0.000341569251058
Gc30_168 0 n60 ns168 0 -0.000548855650306
Gc30_169 0 n60 ns169 0 0.000505864965808
Gc30_170 0 n60 ns170 0 -0.000324377478548
Gc30_171 0 n60 ns171 0 2.16192953747e-05
Gc30_172 0 n60 ns172 0 -0.000586421474295
Gc30_173 0 n60 ns173 0 -0.00167054012848
Gc30_174 0 n60 ns174 0 0.000711923762312
Gc30_175 0 n60 ns175 0 -0.00381613982043
Gc30_176 0 n60 ns176 0 -0.0014390238794
Gc30_177 0 n60 ns177 0 -0.00323078913406
Gc30_178 0 n60 ns178 0 -0.00213849978827
Gc30_179 0 n60 ns179 0 0.000903480639174
Gc30_180 0 n60 ns180 0 0.000648287636159
Gc30_181 0 n60 ns181 0 0.000507335662215
Gc30_182 0 n60 ns182 0 -0.00133748773562
Gc30_183 0 n60 ns183 0 -0.000532718699298
Gc30_184 0 n60 ns184 0 -0.00269655164626
Gc30_185 0 n60 ns185 0 0.0015586693373
Gc30_186 0 n60 ns186 0 -0.00344313360937
Gc30_187 0 n60 ns187 0 -0.00214109554391
Gc30_188 0 n60 ns188 0 -2.29593334155e-05
Gc30_189 0 n60 ns189 0 0.000134472774946
Gc30_190 0 n60 ns190 0 -1.36874044514e-05
Gc30_191 0 n60 ns191 0 0.00091500606044
Gc30_192 0 n60 ns192 0 -0.002229210462
Gc30_193 0 n60 ns193 0 0.00143429179782
Gc30_194 0 n60 ns194 0 -0.00419391457682
Gc30_195 0 n60 ns195 0 -0.0024773709158
Gc30_196 0 n60 ns196 0 -0.00108773435967
Gc30_197 0 n60 ns197 0 0.000889608857701
Gc30_198 0 n60 ns198 0 0.000322245411117
Gc30_199 0 n60 ns199 0 -0.000476046573627
Gc30_200 0 n60 ns200 0 -0.000407544693057
Gc30_201 0 n60 ns201 0 -0.000207927462487
Gc30_202 0 n60 ns202 0 4.39382248374e-05
Gc30_203 0 n60 ns203 0 0.000245396995423
Gc30_204 0 n60 ns204 0 2.03346187859e-06
Gc30_205 0 n60 ns205 0 0.00127277013283
Gc30_206 0 n60 ns206 0 -0.000517944057046
Gc30_207 0 n60 ns207 0 0.000934861176931
Gc30_208 0 n60 ns208 0 -2.30522043004e-05
Gc30_209 0 n60 ns209 0 0.000443194615425
Gc30_210 0 n60 ns210 0 -0.000107466171414
Gc30_211 0 n60 ns211 0 -0.000941478252515
Gc30_212 0 n60 ns212 0 -0.00215854781468
Gc30_213 0 n60 ns213 0 -0.00583267857598
Gc30_214 0 n60 ns214 0 -0.00436696253628
Gc30_215 0 n60 ns215 0 -0.00453741684924
Gc30_216 0 n60 ns216 0 -0.00456588552188
Gc30_217 0 n60 ns217 0 0.00441768458034
Gc30_218 0 n60 ns218 0 0.00415677725304
Gc30_219 0 n60 ns219 0 0.000937128991172
Gc30_220 0 n60 ns220 0 -0.00114541424273
Gc30_221 0 n60 ns221 0 -0.00313519557582
Gc30_222 0 n60 ns222 0 -0.0033937613664
Gc30_223 0 n60 ns223 0 0.00222023073009
Gc30_224 0 n60 ns224 0 0.00152060014417
Gc30_225 0 n60 ns225 0 -0.00374543059621
Gc30_226 0 n60 ns226 0 -1.93350211988e-06
Gc30_227 0 n60 ns227 0 0.000321914839727
Gc30_228 0 n60 ns228 0 -0.000144176879126
Gc30_229 0 n60 ns229 0 0.00216302185085
Gc30_230 0 n60 ns230 0 -0.00322850719038
Gc30_231 0 n60 ns231 0 0.00475010669464
Gc30_232 0 n60 ns232 0 -0.00642015817379
Gc30_233 0 n60 ns233 0 -0.00337006846436
Gc30_234 0 n60 ns234 0 -0.00225769330981
Gc30_235 0 n60 ns235 0 0.00119353050064
Gc30_236 0 n60 ns236 0 0.000655869481128
Gc30_237 0 n60 ns237 0 -0.000275532613026
Gc30_238 0 n60 ns238 0 -0.000539090163888
Gc30_239 0 n60 ns239 0 -0.000276316368893
Gc30_240 0 n60 ns240 0 4.89648158886e-06
Gc30_241 0 n60 ns241 0 -0.000410671633329
Gc30_242 0 n60 ns242 0 -0.000356111772128
Gc30_243 0 n60 ns243 0 0.00147790668221
Gc30_244 0 n60 ns244 0 2.44296362374e-05
Gc30_245 0 n60 ns245 0 0.00103065828308
Gc30_246 0 n60 ns246 0 0.000204329765372
Gc30_247 0 n60 ns247 0 0.000430960046
Gc30_248 0 n60 ns248 0 0.000387007793324
Gc30_249 0 n60 ns249 0 0.000883028947949
Gc30_250 0 n60 ns250 0 -0.00303070419156
Gc30_251 0 n60 ns251 0 -0.00227297012257
Gc30_252 0 n60 ns252 0 -0.00802845552664
Gc30_253 0 n60 ns253 0 -0.00159861814673
Gc30_254 0 n60 ns254 0 -0.00752582536913
Gc30_255 0 n60 ns255 0 0.00539644826652
Gc30_256 0 n60 ns256 0 0.00811255999785
Gc30_257 0 n60 ns257 0 0.000817655610057
Gc30_258 0 n60 ns258 0 -0.00123151462612
Gc30_259 0 n60 ns259 0 -0.00526545325582
Gc30_260 0 n60 ns260 0 -0.00600770414935
Gc30_261 0 n60 ns261 0 0.00145772032449
Gc30_262 0 n60 ns262 0 0.00524583408483
Gc30_263 0 n60 ns263 0 -0.0043108966504
Gc30_264 0 n60 ns264 0 2.38475381819e-06
Gc30_265 0 n60 ns265 0 0.000421236290576
Gc30_266 0 n60 ns266 0 -0.000231688452622
Gc30_267 0 n60 ns267 0 -0.000729872643646
Gc30_268 0 n60 ns268 0 -0.000497024548566
Gc30_269 0 n60 ns269 0 -0.00229655673903
Gc30_270 0 n60 ns270 0 0.00106942725388
Gc30_271 0 n60 ns271 0 -0.000232825633335
Gc30_272 0 n60 ns272 0 0.000869531160613
Gc30_273 0 n60 ns273 0 0.000168807147561
Gc30_274 0 n60 ns274 0 -0.000246533452987
Gc30_275 0 n60 ns275 0 -0.000119016343539
Gc30_276 0 n60 ns276 0 0.000351504162021
Gc30_277 0 n60 ns277 0 -0.000249178392141
Gc30_278 0 n60 ns278 0 -2.27333301347e-05
Gc30_279 0 n60 ns279 0 0.000407714552349
Gc30_280 0 n60 ns280 0 0.000271693072533
Gc30_281 0 n60 ns281 0 0.000353425672315
Gc30_282 0 n60 ns282 0 -0.000329724349727
Gc30_283 0 n60 ns283 0 0.00110501459667
Gc30_284 0 n60 ns284 0 -0.000307860303834
Gc30_285 0 n60 ns285 0 0.00085396827693
Gc30_286 0 n60 ns286 0 -0.000753547572645
Gc30_287 0 n60 ns287 0 -0.00174049016625
Gc30_288 0 n60 ns288 0 3.75573351189e-05
Gc30_289 0 n60 ns289 0 -0.00340167292018
Gc30_290 0 n60 ns290 0 -0.00364079094064
Gc30_291 0 n60 ns291 0 -0.00267244412286
Gc30_292 0 n60 ns292 0 -0.00407543418886
Gc30_293 0 n60 ns293 0 0.00120483530668
Gc30_294 0 n60 ns294 0 -0.000415088304807
Gc30_295 0 n60 ns295 0 0.00093798746264
Gc30_296 0 n60 ns296 0 -0.0011620447596
Gc30_297 0 n60 ns297 0 4.36469987044e-05
Gc30_298 0 n60 ns298 0 -0.001654010669
Gc30_299 0 n60 ns299 0 0.00254072605887
Gc30_300 0 n60 ns300 0 -0.00235160851204
Gc30_301 0 n60 ns301 0 -0.00248861220038
Gc30_302 0 n60 ns302 0 2.07519441061e-06
Gc30_303 0 n60 ns303 0 0.00013130045584
Gc30_304 0 n60 ns304 0 -2.93206651271e-05
Gc30_305 0 n60 ns305 0 -0.000316675476121
Gc30_306 0 n60 ns306 0 -0.000190953817866
Gc30_307 0 n60 ns307 0 -0.00100109192682
Gc30_308 0 n60 ns308 0 0.000809640467599
Gc30_309 0 n60 ns309 0 -0.000336897015408
Gc30_310 0 n60 ns310 0 -0.00014242364943
Gc30_311 0 n60 ns311 0 7.04972973799e-05
Gc30_312 0 n60 ns312 0 -8.18575348851e-05
Gc30_313 0 n60 ns313 0 -0.00035149685862
Gc30_314 0 n60 ns314 0 0.000855783836675
Gc30_315 0 n60 ns315 0 -5.36612156983e-05
Gc30_316 0 n60 ns316 0 -2.69261153734e-06
Gc30_317 0 n60 ns317 0 0.000546931725821
Gc30_318 0 n60 ns318 0 -0.000858674027459
Gc30_319 0 n60 ns319 0 -0.000646447568466
Gc30_320 0 n60 ns320 0 0.000858818350057
Gc30_321 0 n60 ns321 0 0.000590108481751
Gc30_322 0 n60 ns322 0 0.000357340116256
Gc30_323 0 n60 ns323 0 0.00017424550693
Gc30_324 0 n60 ns324 0 0.00043791896329
Gc30_325 0 n60 ns325 0 -0.000291752107105
Gc30_326 0 n60 ns326 0 0.00107802456243
Gc30_327 0 n60 ns327 0 0.0018544177447
Gc30_328 0 n60 ns328 0 -0.00391134551939
Gc30_329 0 n60 ns329 0 0.00141802793066
Gc30_330 0 n60 ns330 0 -0.00404906712833
Gc30_331 0 n60 ns331 0 -0.00177172894891
Gc30_332 0 n60 ns332 0 -0.000114899107192
Gc30_333 0 n60 ns333 0 0.000458636044229
Gc30_334 0 n60 ns334 0 -0.00108056131762
Gc30_335 0 n60 ns335 0 0.00104878963341
Gc30_336 0 n60 ns336 0 -0.00199671587601
Gc30_337 0 n60 ns337 0 0.000934382915201
Gc30_338 0 n60 ns338 0 -0.00178116783259
Gc30_339 0 n60 ns339 0 -0.000977749031263
Gc30_340 0 n60 ns340 0 -3.59567495754e-05
Gc30_341 0 n60 ns341 0 0.000151001677829
Gc30_342 0 n60 ns342 0 -2.984444586e-05
Gc30_343 0 n60 ns343 0 0.00048774326183
Gc30_344 0 n60 ns344 0 -0.000678548185583
Gc30_345 0 n60 ns345 0 0.00149752426561
Gc30_346 0 n60 ns346 0 -0.000947805305042
Gc30_347 0 n60 ns347 0 0.000305677994144
Gc30_348 0 n60 ns348 0 -0.000218733159903
Gc30_349 0 n60 ns349 0 -0.000135357461321
Gc30_350 0 n60 ns350 0 0.000133818237507
Gc30_351 0 n60 ns351 0 0.000181341076673
Gc30_352 0 n60 ns352 0 -0.000530679873828
Gc30_353 0 n60 ns353 0 -8.34473229757e-05
Gc30_354 0 n60 ns354 0 0.000159350902006
Gc30_355 0 n60 ns355 0 -5.37645364401e-05
Gc30_356 0 n60 ns356 0 0.000607595459038
Gc30_357 0 n60 ns357 0 0.000399938807625
Gc30_358 0 n60 ns358 0 -0.000139723570663
Gc30_359 0 n60 ns359 0 -0.000131581207515
Gc30_360 0 n60 ns360 0 -0.000536542225168
Gc30_361 0 n60 ns361 0 -0.000330666035163
Gc30_362 0 n60 ns362 0 -0.000460881837684
Gc30_363 0 n60 ns363 0 -7.46665284048e-05
Gc30_364 0 n60 ns364 0 -0.000585841705343
Gc30_365 0 n60 ns365 0 -0.00488706858575
Gc30_366 0 n60 ns366 0 -0.0020477589203
Gc30_367 0 n60 ns367 0 -0.00443020754787
Gc30_368 0 n60 ns368 0 -0.00171421384369
Gc30_369 0 n60 ns369 0 0.00036928161452
Gc30_370 0 n60 ns370 0 0.00153514338121
Gc30_371 0 n60 ns371 0 -0.000352952379302
Gc30_372 0 n60 ns372 0 -0.000468693841097
Gc30_373 0 n60 ns373 0 -0.00123132916723
Gc30_374 0 n60 ns374 0 -0.00143423545714
Gc30_375 0 n60 ns375 0 -0.000168756538666
Gc30_376 0 n60 ns376 0 -0.000972016722883
Gc30_377 0 n60 ns377 0 -0.000299408535143
Gc30_378 0 n60 ns378 0 -4.44638999831e-06
Gc30_379 0 n60 ns379 0 2.74537690152e-05
Gc30_380 0 n60 ns380 0 2.67484687681e-05
Gc30_381 0 n60 ns381 0 -0.000135632127965
Gc30_382 0 n60 ns382 0 0.000133213342284
Gc30_383 0 n60 ns383 0 -0.000101042392783
Gc30_384 0 n60 ns384 0 0.000565701699653
Gc30_385 0 n60 ns385 0 -0.000183425906348
Gc30_386 0 n60 ns386 0 0.000194152552139
Gc30_387 0 n60 ns387 0 -1.00023146059e-05
Gc30_388 0 n60 ns388 0 -8.70798775833e-05
Gc30_389 0 n60 ns389 0 0.00034302930225
Gc30_390 0 n60 ns390 0 0.000363358261989
Gc30_391 0 n60 ns391 0 -6.77388427445e-05
Gc30_392 0 n60 ns392 0 6.06747883816e-05
Gc30_393 0 n60 ns393 0 -0.000171027072943
Gc30_394 0 n60 ns394 0 -0.000395689768004
Gc30_395 0 n60 ns395 0 0.000308727506654
Gc30_396 0 n60 ns396 0 0.000523978126262
Gc30_397 0 n60 ns397 0 0.00041641339742
Gc30_398 0 n60 ns398 0 -0.000313022810073
Gc30_399 0 n60 ns399 0 0.00018804780675
Gc30_400 0 n60 ns400 0 -0.000114999113682
Gc30_401 0 n60 ns401 0 -3.25664536581e-05
Gc30_402 0 n60 ns402 0 0.000266370045999
Gc30_403 0 n60 ns403 0 -0.00395567543861
Gc30_404 0 n60 ns404 0 -0.00365601181757
Gc30_405 0 n60 ns405 0 -0.00374901554747
Gc30_406 0 n60 ns406 0 -0.00340814572591
Gc30_407 0 n60 ns407 0 -0.000238051949485
Gc30_408 0 n60 ns408 0 0.00205096510338
Gc30_409 0 n60 ns409 0 -0.00026314311346
Gc30_410 0 n60 ns410 0 -0.000955890160206
Gc30_411 0 n60 ns411 0 -0.0010438006957
Gc30_412 0 n60 ns412 0 -0.00271028645292
Gc30_413 0 n60 ns413 0 3.0976170055e-05
Gc30_414 0 n60 ns414 0 -0.00224736840327
Gc30_415 0 n60 ns415 0 -0.000746921194876
Gc30_416 0 n60 ns416 0 -1.79805144683e-05
Gc30_417 0 n60 ns417 0 8.41861163864e-05
Gc30_418 0 n60 ns418 0 -1.31468423407e-05
Gc30_419 0 n60 ns419 0 -9.53497322243e-05
Gc30_420 0 n60 ns420 0 -5.36085057202e-05
Gc30_421 0 n60 ns421 0 7.38333112687e-05
Gc30_422 0 n60 ns422 0 0.00157513819378
Gc30_423 0 n60 ns423 0 9.55307171273e-05
Gc30_424 0 n60 ns424 0 0.000240601990508
Gc30_425 0 n60 ns425 0 5.32221604398e-06
Gc30_426 0 n60 ns426 0 -0.00023216261464
Gc30_427 0 n60 ns427 0 -0.000216519968455
Gc30_428 0 n60 ns428 0 0.000426320100941
Gc30_429 0 n60 ns429 0 -0.000105550117006
Gc30_430 0 n60 ns430 0 6.52621397052e-05
Gc30_431 0 n60 ns431 0 0.000609330945104
Gc30_432 0 n60 ns432 0 -0.000568262485602
Gc30_433 0 n60 ns433 0 -0.000457000841882
Gc30_434 0 n60 ns434 0 -0.000181412093169
Gc30_435 0 n60 ns435 0 0.000414753692344
Gc30_436 0 n60 ns436 0 -0.000337968958181
Gc30_437 0 n60 ns437 0 -6.22767441324e-05
Gc30_438 0 n60 ns438 0 -0.000490081108621
Gc30_439 0 n60 ns439 0 -0.000991376672935
Gc30_440 0 n60 ns440 0 0.00112451125985
Gc30_441 0 n60 ns441 0 -0.002615550897
Gc30_442 0 n60 ns442 0 -0.00156243980701
Gc30_443 0 n60 ns443 0 -0.00239126952489
Gc30_444 0 n60 ns444 0 -0.00212048994547
Gc30_445 0 n60 ns445 0 0.000110080330614
Gc30_446 0 n60 ns446 0 0.000959745107731
Gc30_447 0 n60 ns447 0 0.000251369778602
Gc30_448 0 n60 ns448 0 -0.0013316651822
Gc30_449 0 n60 ns449 0 -0.000474728727681
Gc30_450 0 n60 ns450 0 -0.00300734480376
Gc30_451 0 n60 ns451 0 0.00092066141782
Gc30_452 0 n60 ns452 0 -0.00362137399731
Gc30_453 0 n60 ns453 0 -0.00165086069153
Gc30_454 0 n60 ns454 0 -2.49544746607e-05
Gc30_455 0 n60 ns455 0 0.000102634386389
Gc30_456 0 n60 ns456 0 -8.45295610675e-07
Gc30_457 0 n60 ns457 0 -0.000878392764014
Gc30_458 0 n60 ns458 0 -0.000654240953193
Gc30_459 0 n60 ns459 0 -0.0035268841419
Gc30_460 0 n60 ns460 0 -0.00150441243789
Gc30_461 0 n60 ns461 0 -0.00183265340871
Gc30_462 0 n60 ns462 0 0.00115343634341
Gc30_463 0 n60 ns463 0 0.000760889101477
Gc30_464 0 n60 ns464 0 -0.000500177032901
Gc30_465 0 n60 ns465 0 -0.000468544146357
Gc30_466 0 n60 ns466 0 7.02324437902e-05
Gc30_467 0 n60 ns467 0 -0.000162081973477
Gc30_468 0 n60 ns468 0 5.52818442935e-05
Gc30_469 0 n60 ns469 0 0.000707454155469
Gc30_470 0 n60 ns470 0 0.00010667027883
Gc30_471 0 n60 ns471 0 0.000832206392568
Gc30_472 0 n60 ns472 0 -0.000897375578082
Gc30_473 0 n60 ns473 0 0.0009858310503
Gc30_474 0 n60 ns474 0 -0.000292766108292
Gc30_475 0 n60 ns475 0 0.000778352954719
Gc30_476 0 n60 ns476 0 -0.000532334200017
Gc30_477 0 n60 ns477 0 -0.00218545716421
Gc30_478 0 n60 ns478 0 -0.000871455698444
Gc30_479 0 n60 ns479 0 -0.00630547499559
Gc30_480 0 n60 ns480 0 -0.00279790123594
Gc30_481 0 n60 ns481 0 -0.00500039620881
Gc30_482 0 n60 ns482 0 -0.00324840170353
Gc30_483 0 n60 ns483 0 0.00354827402577
Gc30_484 0 n60 ns484 0 0.00206297148046
Gc30_485 0 n60 ns485 0 0.000834495306549
Gc30_486 0 n60 ns486 0 -0.00120083576369
Gc30_487 0 n60 ns487 0 -0.00217225450238
Gc30_488 0 n60 ns488 0 -0.00296478396781
Gc30_489 0 n60 ns489 0 0.00244217033418
Gc30_490 0 n60 ns490 0 -0.000617360735525
Gc30_491 0 n60 ns491 0 -0.00319545409664
Gc30_492 0 n60 ns492 0 -4.37372890624e-05
Gc30_493 0 n60 ns493 0 0.000364466071931
Gc30_494 0 n60 ns494 0 -0.000160388021288
Gc30_495 0 n60 ns495 0 -0.000635126385024
Gc30_496 0 n60 ns496 0 5.91078892125e-05
Gc30_497 0 n60 ns497 0 9.45600622485e-05
Gc30_498 0 n60 ns498 0 0.00314292503763
Gc30_499 0 n60 ns499 0 0.00126322663667
Gc30_500 0 n60 ns500 0 -0.000711891976634
Gc30_501 0 n60 ns501 0 -0.00029148468603
Gc30_502 0 n60 ns502 0 -0.000110486760152
Gc30_503 0 n60 ns503 0 0.000226447309217
Gc30_504 0 n60 ns504 0 0.000120740219645
Gc30_505 0 n60 ns505 0 -0.000142712276991
Gc30_506 0 n60 ns506 0 4.02383706702e-05
Gc30_507 0 n60 ns507 0 0.00209250739086
Gc30_508 0 n60 ns508 0 -0.000876515421348
Gc30_509 0 n60 ns509 0 -0.000253105981522
Gc30_510 0 n60 ns510 0 0.00115728921617
Gc30_511 0 n60 ns511 0 -0.000285432308009
Gc30_512 0 n60 ns512 0 -0.000121639465047
Gc30_513 0 n60 ns513 0 -0.00190626533088
Gc30_514 0 n60 ns514 0 -0.00141897202979
Gc30_515 0 n60 ns515 0 0.0029519946634
Gc30_516 0 n60 ns516 0 0.00365266997961
Gc30_517 0 n60 ns517 0 -0.0106142491257
Gc30_518 0 n60 ns518 0 -0.000324285904926
Gc30_519 0 n60 ns519 0 -0.00816805404562
Gc30_520 0 n60 ns520 0 -0.00151223108455
Gc30_521 0 n60 ns521 0 -0.011007107107
Gc30_522 0 n60 ns522 0 -0.000138958706054
Gc30_523 0 n60 ns523 0 0.00146645138106
Gc30_524 0 n60 ns524 0 -3.09228251758e-05
Gc30_525 0 n60 ns525 0 -0.00345285718736
Gc30_526 0 n60 ns526 0 0.00830607957989
Gc30_527 0 n60 ns527 0 -0.0142211032468
Gc30_528 0 n60 ns528 0 -0.0042031787987
Gc30_529 0 n60 ns529 0 -0.00627678561762
Gc30_530 0 n60 ns530 0 -5.8468193046e-05
Gc30_531 0 n60 ns531 0 -0.000348302178096
Gc30_532 0 n60 ns532 0 0.000588299643482
Gc30_533 0 n60 ns533 0 -0.000792388583482
Gc30_534 0 n60 ns534 0 -0.00100255033958
Gc30_535 0 n60 ns535 0 -0.00330166494593
Gc30_536 0 n60 ns536 0 -0.00169717006432
Gc30_537 0 n60 ns537 0 -0.0019363399001
Gc30_538 0 n60 ns538 0 0.00101962842662
Gc30_539 0 n60 ns539 0 0.000882053563309
Gc30_540 0 n60 ns540 0 -0.000362106261937
Gc30_541 0 n60 ns541 0 -0.000167315576312
Gc30_542 0 n60 ns542 0 0.00014386131393
Gc30_543 0 n60 ns543 0 -0.000265788933211
Gc30_544 0 n60 ns544 0 -1.88549230082e-06
Gc30_545 0 n60 ns545 0 0.000396068160242
Gc30_546 0 n60 ns546 0 0.000345627958022
Gc30_547 0 n60 ns547 0 0.00109608750727
Gc30_548 0 n60 ns548 0 -0.000619281472934
Gc30_549 0 n60 ns549 0 0.00134023653709
Gc30_550 0 n60 ns550 0 -0.000316526473302
Gc30_551 0 n60 ns551 0 0.00118673626597
Gc30_552 0 n60 ns552 0 -0.000651188371127
Gc30_553 0 n60 ns553 0 -0.001734585165
Gc30_554 0 n60 ns554 0 -0.000900850606754
Gc30_555 0 n60 ns555 0 -0.00471366298053
Gc30_556 0 n60 ns556 0 -0.00443687878785
Gc30_557 0 n60 ns557 0 -0.00366373009148
Gc30_558 0 n60 ns558 0 -0.0047078978222
Gc30_559 0 n60 ns559 0 0.00305094266058
Gc30_560 0 n60 ns560 0 0.00180281303111
Gc30_561 0 n60 ns561 0 0.00094965153499
Gc30_562 0 n60 ns562 0 -0.00121984490024
Gc30_563 0 n60 ns563 0 -0.00172068444504
Gc30_564 0 n60 ns564 0 -0.00292271719613
Gc30_565 0 n60 ns565 0 0.00254680931999
Gc30_566 0 n60 ns566 0 -0.000548798645931
Gc30_567 0 n60 ns567 0 -0.00319496941817
Gc30_568 0 n60 ns568 0 -3.82968291705e-05
Gc30_569 0 n60 ns569 0 0.000337044191113
Gc30_570 0 n60 ns570 0 -0.000161935784586
Gc30_571 0 n60 ns571 0 -0.000397210675202
Gc30_572 0 n60 ns572 0 -5.19546796404e-05
Gc30_573 0 n60 ns573 0 -0.00108909004307
Gc30_574 0 n60 ns574 0 0.00187070888959
Gc30_575 0 n60 ns575 0 -8.65487276255e-05
Gc30_576 0 n60 ns576 0 0.000263615307248
Gc30_577 0 n60 ns577 0 1.92077925404e-05
Gc30_578 0 n60 ns578 0 -0.000212178761474
Gc30_579 0 n60 ns579 0 -0.000254857852401
Gc30_580 0 n60 ns580 0 0.000829390497569
Gc30_581 0 n60 ns581 0 -0.000113754150246
Gc30_582 0 n60 ns582 0 -3.39592524914e-05
Gc30_583 0 n60 ns583 0 0.000527193725132
Gc30_584 0 n60 ns584 0 -0.000770856605263
Gc30_585 0 n60 ns585 0 -0.000551547382423
Gc30_586 0 n60 ns586 0 0.000392314906406
Gc30_587 0 n60 ns587 0 0.000758842985544
Gc30_588 0 n60 ns588 0 7.59569317083e-05
Gc30_589 0 n60 ns589 0 0.00033023735526
Gc30_590 0 n60 ns590 0 -7.66334315682e-05
Gc30_591 0 n60 ns591 0 -0.000665015940887
Gc30_592 0 n60 ns592 0 0.00122372230131
Gc30_593 0 n60 ns593 0 0.00100925888718
Gc30_594 0 n60 ns594 0 -0.0033601914605
Gc30_595 0 n60 ns595 0 0.000769340590447
Gc30_596 0 n60 ns596 0 -0.00376419225969
Gc30_597 0 n60 ns597 0 -0.00112303917383
Gc30_598 0 n60 ns598 0 -0.000218383814948
Gc30_599 0 n60 ns599 0 0.000587817728579
Gc30_600 0 n60 ns600 0 -0.00123799181734
Gc30_601 0 n60 ns601 0 0.000846942375718
Gc30_602 0 n60 ns602 0 -0.00222144027028
Gc30_603 0 n60 ns603 0 0.00132666012306
Gc30_604 0 n60 ns604 0 -0.00255910893297
Gc30_605 0 n60 ns605 0 -0.00146945689412
Gc30_606 0 n60 ns606 0 -2.13544569272e-05
Gc30_607 0 n60 ns607 0 8.98215051784e-05
Gc30_608 0 n60 ns608 0 5.16700101949e-07
Gc30_609 0 n60 ns609 0 0.000573442273928
Gc30_610 0 n60 ns610 0 -1.24291533834e-05
Gc30_611 0 n60 ns611 0 0.0018060320917
Gc30_612 0 n60 ns612 0 0.000438492180937
Gc30_613 0 n60 ns613 0 0.000272201960322
Gc30_614 0 n60 ns614 0 2.0945603727e-05
Gc30_615 0 n60 ns615 0 -0.00019481394283
Gc30_616 0 n60 ns616 0 4.98045283635e-05
Gc30_617 0 n60 ns617 0 0.000184165126382
Gc30_618 0 n60 ns618 0 0.000260736862531
Gc30_619 0 n60 ns619 0 -4.43897812058e-05
Gc30_620 0 n60 ns620 0 -0.0001062663661
Gc30_621 0 n60 ns621 0 -0.000275445407641
Gc30_622 0 n60 ns622 0 -0.000324694164905
Gc30_623 0 n60 ns623 0 9.71827963354e-06
Gc30_624 0 n60 ns624 0 -0.000949635033638
Gc30_625 0 n60 ns625 0 -0.000277061251359
Gc30_626 0 n60 ns626 0 -0.000669499544352
Gc30_627 0 n60 ns627 0 -0.00019867777628
Gc30_628 0 n60 ns628 0 -0.000877434945423
Gc30_629 0 n60 ns629 0 0.000830564271672
Gc30_630 0 n60 ns630 0 0.000654520859085
Gc30_631 0 n60 ns631 0 0.00376802142503
Gc30_632 0 n60 ns632 0 0.00055126475512
Gc30_633 0 n60 ns633 0 0.00328451401407
Gc30_634 0 n60 ns634 0 0.000334447976353
Gc30_635 0 n60 ns635 0 0.000821905257491
Gc30_636 0 n60 ns636 0 0.000519967257729
Gc30_637 0 n60 ns637 0 -0.000252789603096
Gc30_638 0 n60 ns638 0 -0.000189517177437
Gc30_639 0 n60 ns639 0 -0.00115368440311
Gc30_640 0 n60 ns640 0 -0.000608889134717
Gc30_641 0 n60 ns641 0 -0.000489978628293
Gc30_642 0 n60 ns642 0 -0.000541936903004
Gc30_643 0 n60 ns643 0 -6.63200102727e-06
Gc30_644 0 n60 ns644 0 2.71637685544e-05
Gc30_645 0 n60 ns645 0 -0.000128295197039
Gc30_646 0 n60 ns646 0 5.2301307405e-05
Gc30_647 0 n60 ns647 0 0.000112962786673
Gc30_648 0 n60 ns648 0 0.000324532101724
Gc30_649 0 n60 ns649 0 0.000564607043277
Gc30_650 0 n60 ns650 0 0.000679593745335
Gc30_651 0 n60 ns651 0 -4.58874253138e-05
Gc30_652 0 n60 ns652 0 1.57860335253e-05
Gc30_653 0 n60 ns653 0 -2.18701336836e-05
Gc30_654 0 n60 ns654 0 5.93145207035e-05
Gc30_655 0 n60 ns655 0 5.01365701357e-05
Gc30_656 0 n60 ns656 0 0.000507359318279
Gc30_657 0 n60 ns657 0 3.82586786618e-06
Gc30_658 0 n60 ns658 0 -0.000146295571569
Gc30_659 0 n60 ns659 0 -7.01657653966e-05
Gc30_660 0 n60 ns660 0 -0.000481111462153
Gc30_661 0 n60 ns661 0 0.000341815566761
Gc30_662 0 n60 ns662 0 -0.000954253200849
Gc30_663 0 n60 ns663 0 -0.000151117211204
Gc30_664 0 n60 ns664 0 -0.000756088063907
Gc30_665 0 n60 ns665 0 -3.54619744693e-05
Gc30_666 0 n60 ns666 0 -0.000865131718676
Gc30_667 0 n60 ns667 0 0.000619971900936
Gc30_668 0 n60 ns668 0 0.000823401590525
Gc30_669 0 n60 ns669 0 0.00415982079524
Gc30_670 0 n60 ns670 0 0.0010525628484
Gc30_671 0 n60 ns671 0 0.00369244336289
Gc30_672 0 n60 ns672 0 0.00075851209352
Gc30_673 0 n60 ns673 0 0.00068471314965
Gc30_674 0 n60 ns674 0 0.000732508618484
Gc30_675 0 n60 ns675 0 -0.000291929556039
Gc30_676 0 n60 ns676 0 -0.000266693259739
Gc30_677 0 n60 ns677 0 -0.00121026543792
Gc30_678 0 n60 ns678 0 -0.000778365489625
Gc30_679 0 n60 ns679 0 -0.000508490019483
Gc30_680 0 n60 ns680 0 -0.000453315662434
Gc30_681 0 n60 ns681 0 2.87125351167e-05
Gc30_682 0 n60 ns682 0 1.31029997395e-05
Gc30_683 0 n60 ns683 0 -3.68129878544e-05
Gc30_684 0 n60 ns684 0 -6.56379056838e-06
Gc30_685 0 n60 ns685 0 -0.000378666021536
Gc30_686 0 n60 ns686 0 0.000296768470272
Gc30_687 0 n60 ns687 0 -0.000872676754997
Gc30_688 0 n60 ns688 0 0.000868667504022
Gc30_689 0 n60 ns689 0 -0.000227470275491
Gc30_690 0 n60 ns690 0 0.000133588559264
Gc30_691 0 n60 ns691 0 0.000164505683098
Gc30_692 0 n60 ns692 0 -0.000153629724334
Gc30_693 0 n60 ns693 0 -0.000303570268078
Gc30_694 0 n60 ns694 0 0.000256153483003
Gc30_695 0 n60 ns695 0 0.000105170042151
Gc30_696 0 n60 ns696 0 -0.000144439516494
Gc30_697 0 n60 ns697 0 5.60955968961e-05
Gc30_698 0 n60 ns698 0 -0.000262196199988
Gc30_699 0 n60 ns699 0 0.000836185995429
Gc30_700 0 n60 ns700 0 4.57624253368e-05
Gc30_701 0 n60 ns701 0 0.000304750609126
Gc30_702 0 n60 ns702 0 -0.000548192690661
Gc30_703 0 n60 ns703 0 0.000223941019315
Gc30_704 0 n60 ns704 0 -0.000341219690787
Gc30_705 0 n60 ns705 0 -0.000501459902283
Gc30_706 0 n60 ns706 0 0.000588418241666
Gc30_707 0 n60 ns707 0 0.0029377015458
Gc30_708 0 n60 ns708 0 0.00298942033073
Gc30_709 0 n60 ns709 0 0.00288213654
Gc30_710 0 n60 ns710 0 0.00258463106871
Gc30_711 0 n60 ns711 0 -0.000165029063569
Gc30_712 0 n60 ns712 0 0.00126609833399
Gc30_713 0 n60 ns713 0 -0.000312680441098
Gc30_714 0 n60 ns714 0 -0.000561127831469
Gc30_715 0 n60 ns715 0 -0.00102945942158
Gc30_716 0 n60 ns716 0 -0.0013470819991
Gc30_717 0 n60 ns717 0 -0.000531712692616
Gc30_718 0 n60 ns718 0 6.60546940536e-05
Gc30_719 0 n60 ns719 0 0.000223170628703
Gc30_720 0 n60 ns720 0 1.23272376367e-06
Gc30_721 0 n60 ns721 0 -1.79633563082e-05
Gc30_722 0 n60 ns722 0 -4.4909454006e-05
Gc30_723 0 n60 ns723 0 -9.69100166957e-05
Gc30_724 0 n60 ns724 0 9.8911176218e-05
Gc30_725 0 n60 ns725 0 0.000152515607759
Gc30_726 0 n60 ns726 0 0.000877623518701
Gc30_727 0 n60 ns727 0 7.77009536678e-05
Gc30_728 0 n60 ns728 0 0.000261000680175
Gc30_729 0 n60 ns729 0 6.47587993314e-05
Gc30_730 0 n60 ns730 0 -2.39158447586e-05
Gc30_731 0 n60 ns731 0 1.56160066778e-05
Gc30_732 0 n60 ns732 0 -0.000211554788622
Gc30_733 0 n60 ns733 0 0.000178503818102
Gc30_734 0 n60 ns734 0 -0.000117382116077
Gc30_735 0 n60 ns735 0 -0.000261442717961
Gc30_736 0 n60 ns736 0 -0.00042513242343
Gc30_737 0 n60 ns737 0 -0.000311024917085
Gc30_738 0 n60 ns738 0 0.000490884575521
Gc30_739 0 n60 ns739 0 0.000284827386006
Gc30_740 0 n60 ns740 0 -0.000408204430385
Gc30_741 0 n60 ns741 0 -0.000245120360999
Gc30_742 0 n60 ns742 0 -0.000509303027486
Gc30_743 0 n60 ns743 0 -0.000128252873369
Gc30_744 0 n60 ns744 0 -0.000739550694555
Gc30_745 0 n60 ns745 0 0.00179624912057
Gc30_746 0 n60 ns746 0 0.00324302629352
Gc30_747 0 n60 ns747 0 0.0019144327675
Gc30_748 0 n60 ns748 0 0.00324999758497
Gc30_749 0 n60 ns749 0 -0.00158623929477
Gc30_750 0 n60 ns750 0 0.000297229308021
Gc30_751 0 n60 ns751 0 5.87464782501e-06
Gc30_752 0 n60 ns752 0 -0.000953117893948
Gc30_753 0 n60 ns753 0 -0.000124171901
Gc30_754 0 n60 ns754 0 -0.00145208424696
Gc30_755 0 n60 ns755 0 -0.000750933352407
Gc30_756 0 n60 ns756 0 0.00126187912989
Gc30_757 0 n60 ns757 0 0.000744863800861
Gc30_758 0 n60 ns758 0 3.52603963364e-05
Gc30_759 0 n60 ns759 0 -0.000193687258723
Gc30_760 0 n60 ns760 0 3.8696329865e-05
Gc30_761 0 n60 ns761 0 0.000359747716103
Gc30_762 0 n60 ns762 0 -0.00148082180269
Gc30_763 0 n60 ns763 0 0.001083511723
Gc30_764 0 n60 ns764 0 -0.00113098116622
Gc30_765 0 n60 ns765 0 -0.000604485773085
Gc30_766 0 n60 ns766 0 0.000185896861373
Gc30_767 0 n60 ns767 0 8.55681675168e-05
Gc30_768 0 n60 ns768 0 -0.000174540712219
Gc30_769 0 n60 ns769 0 0.000426407942744
Gc30_770 0 n60 ns770 0 3.63252064258e-05
Gc30_771 0 n60 ns771 0 0.0001961616726
Gc30_772 0 n60 ns772 0 -5.20912862862e-05
Gc30_773 0 n60 ns773 0 -5.00053410733e-05
Gc30_774 0 n60 ns774 0 -2.13339804103e-05
Gc30_775 0 n60 ns775 0 -0.000644921659279
Gc30_776 0 n60 ns776 0 -0.000800952049165
Gc30_777 0 n60 ns777 0 0.000372950889427
Gc30_778 0 n60 ns778 0 -0.000566748715153
Gc30_779 0 n60 ns779 0 -0.000142587061214
Gc30_780 0 n60 ns780 0 -0.00108169775982
Gc30_781 0 n60 ns781 0 0.00177443067271
Gc30_782 0 n60 ns782 0 -0.00011724267274
Gc30_783 0 n60 ns783 0 0.00254812607595
Gc30_784 0 n60 ns784 0 0.00276638682143
Gc30_785 0 n60 ns785 0 0.00216469059235
Gc30_786 0 n60 ns786 0 0.00320087724747
Gc30_787 0 n60 ns787 0 -0.000234641905586
Gc30_788 0 n60 ns788 0 -0.00188081569359
Gc30_789 0 n60 ns789 0 0.000657659579738
Gc30_790 0 n60 ns790 0 -0.00104497697659
Gc30_791 0 n60 ns791 0 7.53475091203e-05
Gc30_792 0 n60 ns792 0 -0.000495695292402
Gc30_793 0 n60 ns793 0 -0.00215463224504
Gc30_794 0 n60 ns794 0 0.00246731165499
Gc30_795 0 n60 ns795 0 0.00201945547636
Gc30_796 0 n60 ns796 0 9.02111829587e-06
Gc30_797 0 n60 ns797 0 -0.000162901974071
Gc30_798 0 n60 ns798 0 3.02812747025e-05
Gc30_799 0 n60 ns799 0 0.00123463342535
Gc30_800 0 n60 ns800 0 -0.00460014662176
Gc30_801 0 n60 ns801 0 0.00153326135357
Gc30_802 0 n60 ns802 0 -0.00317297167004
Gc30_803 0 n60 ns803 0 -0.00121263810452
Gc30_804 0 n60 ns804 0 -0.000661306884586
Gc30_805 0 n60 ns805 0 0.000628858590274
Gc30_806 0 n60 ns806 0 -3.98442661898e-05
Gc30_807 0 n60 ns807 0 0.000144125523093
Gc30_808 0 n60 ns808 0 0.000583320881276
Gc30_809 0 n60 ns809 0 0.000254975067593
Gc30_810 0 n60 ns810 0 -4.35889637523e-05
Gc30_811 0 n60 ns811 0 -0.000558064189346
Gc30_812 0 n60 ns812 0 0.000184149332125
Gc30_813 0 n60 ns813 0 0.00047951313646
Gc30_814 0 n60 ns814 0 -0.000841304312285
Gc30_815 0 n60 ns815 0 0.0005986202799
Gc30_816 0 n60 ns816 0 -0.00050209340424
Gc30_817 0 n60 ns817 0 3.67979433214e-05
Gc30_818 0 n60 ns818 0 -0.00122099437351
Gc30_819 0 n60 ns819 0 0.00105461145927
Gc30_820 0 n60 ns820 0 0.00160753834414
Gc30_821 0 n60 ns821 0 0.0059626008522
Gc30_822 0 n60 ns822 0 0.00556576926693
Gc30_823 0 n60 ns823 0 0.00455727989562
Gc30_824 0 n60 ns824 0 0.00555172213495
Gc30_825 0 n60 ns825 0 0.00267758370659
Gc30_826 0 n60 ns826 0 0.0018492086778
Gc30_827 0 n60 ns827 0 0.000928934808282
Gc30_828 0 n60 ns828 0 -0.000917770115965
Gc30_829 0 n60 ns829 0 -0.00411128932084
Gc30_830 0 n60 ns830 0 -0.00112508213493
Gc30_831 0 n60 ns831 0 -0.000620637671862
Gc30_832 0 n60 ns832 0 -0.00218986096402
Gc30_833 0 n60 ns833 0 0.00380707888445
Gc30_834 0 n60 ns834 0 1.74881952238e-05
Gc30_835 0 n60 ns835 0 -0.00010617016831
Gc30_836 0 n60 ns836 0 1.12076917173e-05
Gc30_837 0 n60 ns837 0 0.00105589331842
Gc30_838 0 n60 ns838 0 -0.00419599305867
Gc30_839 0 n60 ns839 0 -0.000270405746449
Gc30_840 0 n60 ns840 0 -0.00159816109905
Gc30_841 0 n60 ns841 0 -0.000915731491714
Gc30_842 0 n60 ns842 0 -0.00018695070932
Gc30_843 0 n60 ns843 0 0.000449080089401
Gc30_844 0 n60 ns844 0 -0.000106884427397
Gc30_845 0 n60 ns845 0 -4.90763208395e-05
Gc30_846 0 n60 ns846 0 0.000408898562806
Gc30_847 0 n60 ns847 0 0.00028825400361
Gc30_848 0 n60 ns848 0 -1.03366381869e-05
Gc30_849 0 n60 ns849 0 -0.000377545015529
Gc30_850 0 n60 ns850 0 -0.00029609539445
Gc30_851 0 n60 ns851 0 0.000321751531953
Gc30_852 0 n60 ns852 0 -7.00487300827e-05
Gc30_853 0 n60 ns853 0 0.000536242230168
Gc30_854 0 n60 ns854 0 -0.000426393096559
Gc30_855 0 n60 ns855 0 -0.000137731614412
Gc30_856 0 n60 ns856 0 -0.0013457207766
Gc30_857 0 n60 ns857 0 -0.000244632972767
Gc30_858 0 n60 ns858 0 0.000350085450147
Gc30_859 0 n60 ns859 0 0.00695622977885
Gc30_860 0 n60 ns860 0 0.00733588415848
Gc30_861 0 n60 ns861 0 0.00526750815203
Gc30_862 0 n60 ns862 0 0.00702745227243
Gc30_863 0 n60 ns863 0 0.000688462079017
Gc30_864 0 n60 ns864 0 0.00527117837318
Gc30_865 0 n60 ns865 0 0.000856897193663
Gc30_866 0 n60 ns866 0 -0.000921095230693
Gc30_867 0 n60 ns867 0 -0.00634987061415
Gc30_868 0 n60 ns868 0 -0.00196556313998
Gc30_869 0 n60 ns869 0 0.00325287415581
Gc30_870 0 n60 ns870 0 -0.00526275613623
Gc30_871 0 n60 ns871 0 0.00455560076633
Gc30_872 0 n60 ns872 0 -5.00378457577e-07
Gc30_873 0 n60 ns873 0 -1.21915335988e-05
Gc30_874 0 n60 ns874 0 -5.26532968452e-05
Gc30_875 0 n60 ns875 0 0.000363264228608
Gc30_876 0 n60 ns876 0 -0.00240802510938
Gc30_877 0 n60 ns877 0 0.000506768501624
Gc30_878 0 n60 ns878 0 -0.00223772480024
Gc30_879 0 n60 ns879 0 -0.000796512483398
Gc30_880 0 n60 ns880 0 -0.000239209593994
Gc30_881 0 n60 ns881 0 0.000179070761436
Gc30_882 0 n60 ns882 0 -0.00023629574076
Gc30_883 0 n60 ns883 0 -2.11404412197e-05
Gc30_884 0 n60 ns884 0 -0.000208618067471
Gc30_885 0 n60 ns885 0 0.000227447759544
Gc30_886 0 n60 ns886 0 7.29252189459e-05
Gc30_887 0 n60 ns887 0 0.000283746420168
Gc30_888 0 n60 ns888 0 0.000886508249584
Gc30_889 0 n60 ns889 0 0.000363554924144
Gc30_890 0 n60 ns890 0 -5.46947436707e-05
Gc30_891 0 n60 ns891 0 0.00102871203948
Gc30_892 0 n60 ns892 0 -2.79534314129e-05
Gc30_893 0 n60 ns893 0 0.000600576508382
Gc30_894 0 n60 ns894 0 -0.000155884774313
Gc30_895 0 n60 ns895 0 0.00087049042348
Gc30_896 0 n60 ns896 0 0.000814795650396
Gc30_897 0 n60 ns897 0 2.76635764334e-05
Gc30_898 0 n60 ns898 0 0.00443244372917
Gc30_899 0 n60 ns899 0 -7.26258465985e-05
Gc30_900 0 n60 ns900 0 0.00469589005617
Gc30_901 0 n60 ns901 0 0.00078261082913
Gc30_902 0 n60 ns902 0 -0.00212233741496
Gc30_903 0 n60 ns903 0 0.00101384355381
Gc30_904 0 n60 ns904 0 -0.000952150678571
Gc30_905 0 n60 ns905 0 0.000306162411016
Gc30_906 0 n60 ns906 0 -0.000267599390374
Gc30_907 0 n60 ns907 0 -0.00302138096734
Gc30_908 0 n60 ns908 0 0.00284391371368
Gc30_909 0 n60 ns909 0 0.00272457545985
Gc30_910 0 n60 ns910 0 1.40417792911e-06
Gc30_911 0 n60 ns911 0 -0.000106613337038
Gc30_912 0 n60 ns912 0 -1.13265330853e-05
Gc30_913 0 n60 ns913 0 9.28847023604e-05
Gc30_914 0 n60 ns914 0 -0.000431202360614
Gc30_915 0 n60 ns915 0 0.000334412406114
Gc30_916 0 n60 ns916 0 0.000389188716927
Gc30_917 0 n60 ns917 0 0.000132279224968
Gc30_918 0 n60 ns918 0 0.000217130791539
Gc30_919 0 n60 ns919 0 1.02166586097e-05
Gc30_920 0 n60 ns920 0 0.000123172320783
Gc30_921 0 n60 ns921 0 0.000238173215724
Gc30_922 0 n60 ns922 0 -0.000589644732164
Gc30_923 0 n60 ns923 0 0.000158441082004
Gc30_924 0 n60 ns924 0 3.69837362316e-05
Gc30_925 0 n60 ns925 0 -8.97018244868e-05
Gc30_926 0 n60 ns926 0 -0.000269779148355
Gc30_927 0 n60 ns927 0 -0.00121577220311
Gc30_928 0 n60 ns928 0 0.000793607300015
Gc30_929 0 n60 ns929 0 0.000250813896013
Gc30_930 0 n60 ns930 0 0.000140498646993
Gc30_931 0 n60 ns931 0 -0.000369585804148
Gc30_932 0 n60 ns932 0 -0.000162391105362
Gc30_933 0 n60 ns933 0 0.000130043167365
Gc30_934 0 n60 ns934 0 -0.00180951827663
Gc30_935 0 n60 ns935 0 -0.00178568269929
Gc30_936 0 n60 ns936 0 0.00220951415746
Gc30_937 0 n60 ns937 0 -0.00138463857815
Gc30_938 0 n60 ns938 0 0.00266407463614
Gc30_939 0 n60 ns939 0 -0.00263751990022
Gc30_940 0 n60 ns940 0 -0.00124359190707
Gc30_941 0 n60 ns941 0 0.000516068586454
Gc30_942 0 n60 ns942 0 -0.000939361811671
Gc30_943 0 n60 ns943 0 0.00135961168508
Gc30_944 0 n60 ns944 0 -0.000752167286473
Gc30_945 0 n60 ns945 0 -0.000643166876791
Gc30_946 0 n60 ns946 0 0.00229781313976
Gc30_947 0 n60 ns947 0 0.00110754516245
Gc30_948 0 n60 ns948 0 3.25974342078e-05
Gc30_949 0 n60 ns949 0 -0.000326966719892
Gc30_950 0 n60 ns950 0 0.000129604089559
Gc30_951 0 n60 ns951 0 -0.00045110096144
Gc30_952 0 n60 ns952 0 0.000587779586052
Gc30_953 0 n60 ns953 0 -0.00109853264004
Gc30_954 0 n60 ns954 0 0.00123757504718
Gc30_955 0 n60 ns955 0 -0.000302284755025
Gc30_956 0 n60 ns956 0 0.000274394678622
Gc30_957 0 n60 ns957 0 0.000129967308352
Gc30_958 0 n60 ns958 0 -0.0001894380253
Gc30_959 0 n60 ns959 0 -0.000171943622233
Gc30_960 0 n60 ns960 0 0.000481908691392
Gc30_961 0 n60 ns961 0 7.32264369211e-05
Gc30_962 0 n60 ns962 0 -0.000151441439821
Gc30_963 0 n60 ns963 0 0.000125707058765
Gc30_964 0 n60 ns964 0 -0.000436375323277
Gc30_965 0 n60 ns965 0 0.000823134267239
Gc30_966 0 n60 ns966 0 -0.00043685871599
Gc30_967 0 n60 ns967 0 0.000175082239378
Gc30_968 0 n60 ns968 0 -0.000648028752905
Gc30_969 0 n60 ns969 0 0.000247427473696
Gc30_970 0 n60 ns970 0 -0.000517956046927
Gc30_971 0 n60 ns971 0 -0.00016349020474
Gc30_972 0 n60 ns972 0 0.000849008880867
Gc30_973 0 n60 ns973 0 0.00333548944853
Gc30_974 0 n60 ns974 0 0.00235805255008
Gc30_975 0 n60 ns975 0 0.00313603938641
Gc30_976 0 n60 ns976 0 0.00194690961226
Gc30_977 0 n60 ns977 0 0.000231636142196
Gc30_978 0 n60 ns978 0 0.0011660579332
Gc30_979 0 n60 ns979 0 -0.000322854152993
Gc30_980 0 n60 ns980 0 -0.000433372429355
Gc30_981 0 n60 ns981 0 -0.0011468201842
Gc30_982 0 n60 ns982 0 -0.00114905480931
Gc30_983 0 n60 ns983 0 -0.000501121250268
Gc30_984 0 n60 ns984 0 -0.000159565957593
Gc30_985 0 n60 ns985 0 0.000126185414188
Gc30_986 0 n60 ns986 0 -1.65811876303e-05
Gc30_987 0 n60 ns987 0 1.74117547514e-05
Gc30_988 0 n60 ns988 0 -4.73261676249e-05
Gc30_989 0 n60 ns989 0 -0.000141720268613
Gc30_990 0 n60 ns990 0 0.000126844161552
Gc30_991 0 n60 ns991 0 -1.11981937644e-05
Gc30_992 0 n60 ns992 0 0.00101219867135
Gc30_993 0 n60 ns993 0 1.96981126527e-05
Gc30_994 0 n60 ns994 0 0.000176546777978
Gc30_995 0 n60 ns995 0 0.000155959362269
Gc30_996 0 n60 ns996 0 -8.38953428273e-05
Gc30_997 0 n60 ns997 0 -0.000130905573775
Gc30_998 0 n60 ns998 0 -6.49780235556e-05
Gc30_999 0 n60 ns999 0 0.000142213611313
Gc30_1000 0 n60 ns1000 0 -0.000143610407538
Gc30_1001 0 n60 ns1001 0 -0.000285296832477
Gc30_1002 0 n60 ns1002 0 -0.000366590847827
Gc30_1003 0 n60 ns1003 0 0.00018544234827
Gc30_1004 0 n60 ns1004 0 0.000489541003573
Gc30_1005 0 n60 ns1005 0 0.000302570538026
Gc30_1006 0 n60 ns1006 0 -0.000432212629769
Gc30_1007 0 n60 ns1007 0 -7.38147414191e-05
Gc30_1008 0 n60 ns1008 0 -0.000383981286796
Gc30_1009 0 n60 ns1009 0 -0.000489842641586
Gc30_1010 0 n60 ns1010 0 -0.000241315620034
Gc30_1011 0 n60 ns1011 0 0.00207844711282
Gc30_1012 0 n60 ns1012 0 0.00339778741912
Gc30_1013 0 n60 ns1013 0 0.00218588837468
Gc30_1014 0 n60 ns1014 0 0.00319205854482
Gc30_1015 0 n60 ns1015 0 -0.00111242328855
Gc30_1016 0 n60 ns1016 0 0.00098649896104
Gc30_1017 0 n60 ns1017 0 -0.000157986648458
Gc30_1018 0 n60 ns1018 0 -0.000838333762329
Gc30_1019 0 n60 ns1019 0 -0.000521306422027
Gc30_1020 0 n60 ns1020 0 -0.00167470670138
Gc30_1021 0 n60 ns1021 0 -0.000641328079031
Gc30_1022 0 n60 ns1022 0 0.000534042554453
Gc30_1023 0 n60 ns1023 0 0.000446602780705
Gc30_1024 0 n60 ns1024 0 2.44037789226e-05
Gc30_1025 0 n60 ns1025 0 -0.00013592270426
Gc30_1026 0 n60 ns1026 0 1.58919256329e-05
Gc30_1027 0 n60 ns1027 0 0.000116450037368
Gc30_1028 0 n60 ns1028 0 -0.000535480877509
Gc30_1029 0 n60 ns1029 0 0.000594046151175
Gc30_1030 0 n60 ns1030 0 4.63957529455e-05
Gc30_1031 0 n60 ns1031 0 -0.000286638281188
Gc30_1032 0 n60 ns1032 0 0.00046762440693
Gc30_1033 0 n60 ns1033 0 -4.24788453738e-06
Gc30_1034 0 n60 ns1034 0 -0.000185117451977
Gc30_1035 0 n60 ns1035 0 0.000350615670437
Gc30_1036 0 n60 ns1036 0 -0.000170937833171
Gc30_1037 0 n60 ns1037 0 0.000181533845312
Gc30_1038 0 n60 ns1038 0 -7.33647495666e-05
Gc30_1039 0 n60 ns1039 0 -1.38275807691e-05
Gc30_1040 0 n60 ns1040 0 -0.000309272735946
Gc30_1041 0 n60 ns1041 0 -0.000762143144107
Gc30_1042 0 n60 ns1042 0 -0.000337817799737
Gc30_1043 0 n60 ns1043 0 0.000297255730809
Gc30_1044 0 n60 ns1044 0 -0.000549291469778
Gc30_1045 0 n60 ns1045 0 -0.000188144026418
Gc30_1046 0 n60 ns1046 0 -0.000964520469755
Gc30_1047 0 n60 ns1047 0 0.00120977315699
Gc30_1048 0 n60 ns1048 0 -0.00069437653052
Gc30_1049 0 n60 ns1049 0 0.0019037739205
Gc30_1050 0 n60 ns1050 0 0.00295665539074
Gc30_1051 0 n60 ns1051 0 0.00176716074594
Gc30_1052 0 n60 ns1052 0 0.00324426945789
Gc30_1053 0 n60 ns1053 0 -0.00125808033329
Gc30_1054 0 n60 ns1054 0 -0.00138875174927
Gc30_1055 0 n60 ns1055 0 0.000407993129669
Gc30_1056 0 n60 ns1056 0 -0.00105510932208
Gc30_1057 0 n60 ns1057 0 0.000213311476928
Gc30_1058 0 n60 ns1058 0 -0.000799862489995
Gc30_1059 0 n60 ns1059 0 -0.00144861948197
Gc30_1060 0 n60 ns1060 0 0.00247193512597
Gc30_1061 0 n60 ns1061 0 0.00148022242653
Gc30_1062 0 n60 ns1062 0 3.21496488855e-05
Gc30_1063 0 n60 ns1063 0 -0.00021682827662
Gc30_1064 0 n60 ns1064 0 6.4692172216e-05
Gc30_1065 0 n60 ns1065 0 0.000187905604533
Gc30_1066 0 n60 ns1066 0 -0.00192954456026
Gc30_1067 0 n60 ns1067 0 0.000178389674621
Gc30_1068 0 n60 ns1068 0 -0.000522763591408
Gc30_1069 0 n60 ns1069 0 -0.000984705899911
Gc30_1070 0 n60 ns1070 0 0.000307238984078
Gc30_1071 0 n60 ns1071 0 0.000414401551502
Gc30_1072 0 n60 ns1072 0 -0.000463500968653
Gc30_1073 0 n60 ns1073 0 0.000319254793423
Gc30_1074 0 n60 ns1074 0 0.000467762093177
Gc30_1075 0 n60 ns1075 0 0.000253662436146
Gc30_1076 0 n60 ns1076 0 -4.20519363503e-05
Gc30_1077 0 n60 ns1077 0 -0.000354414124227
Gc30_1078 0 n60 ns1078 0 -4.65787569613e-05
Gc30_1079 0 n60 ns1079 0 0.000662661522538
Gc30_1080 0 n60 ns1080 0 -0.000899307703324
Gc30_1081 0 n60 ns1081 0 0.000814008059067
Gc30_1082 0 n60 ns1082 0 -0.000400212564783
Gc30_1083 0 n60 ns1083 0 0.000394442026428
Gc30_1084 0 n60 ns1084 0 -0.000842883107037
Gc30_1085 0 n60 ns1085 0 0.000854456232777
Gc30_1086 0 n60 ns1086 0 0.0020796816798
Gc30_1087 0 n60 ns1087 0 0.00273751811571
Gc30_1088 0 n60 ns1088 0 0.00421480677254
Gc30_1089 0 n60 ns1089 0 0.0020808952725
Gc30_1090 0 n60 ns1090 0 0.00443733993301
Gc30_1091 0 n60 ns1091 0 0.0034631808586
Gc30_1092 0 n60 ns1092 0 0.000412579387112
Gc30_1093 0 n60 ns1093 0 0.000899483190871
Gc30_1094 0 n60 ns1094 0 -0.000968866545175
Gc30_1095 0 n60 ns1095 0 -0.00180411478722
Gc30_1096 0 n60 ns1096 0 -0.0012361375934
Gc30_1097 0 n60 ns1097 0 -0.00384512068853
Gc30_1098 0 n60 ns1098 0 -0.000106450861644
Gc30_1099 0 n60 ns1099 0 0.00311896324972
Gc30_1100 0 n60 ns1100 0 4.15583103264e-05
Gc30_1101 0 n60 ns1101 0 -0.000127574776256
Gc30_1102 0 n60 ns1102 0 1.12229796914e-05
Gc30_1103 0 n60 ns1103 0 0.000312251016031
Gc30_1104 0 n60 ns1104 0 -0.00220467654024
Gc30_1105 0 n60 ns1105 0 -0.00173656817945
Gc30_1106 0 n60 ns1106 0 0.000572225694485
Gc30_1107 0 n60 ns1107 0 -0.000672009778284
Gc30_1108 0 n60 ns1108 0 0.000270889601099
Gc30_1109 0 n60 ns1109 0 0.000388524980434
Gc30_1110 0 n60 ns1110 0 -0.000262878132957
Gc30_1111 0 n60 ns1111 0 2.48054601062e-05
Gc30_1112 0 n60 ns1112 0 0.000495263948933
Gc30_1113 0 n60 ns1113 0 0.000296625369989
Gc30_1114 0 n60 ns1114 0 -1.72273838967e-05
Gc30_1115 0 n60 ns1115 0 -0.000563676506693
Gc30_1116 0 n60 ns1116 0 -0.000602850339423
Gc30_1117 0 n60 ns1117 0 0.000505708015489
Gc30_1118 0 n60 ns1118 0 3.23645165293e-05
Gc30_1119 0 n60 ns1119 0 0.000481761953093
Gc30_1120 0 n60 ns1120 0 -0.000315035963242
Gc30_1121 0 n60 ns1121 0 -0.000278813032276
Gc30_1122 0 n60 ns1122 0 -0.00120064819259
Gc30_1123 0 n60 ns1123 0 -0.00066314040482
Gc30_1124 0 n60 ns1124 0 0.00047983263008
Gc30_1125 0 n60 ns1125 0 0.00730733496696
Gc30_1126 0 n60 ns1126 0 0.00588919758292
Gc30_1127 0 n60 ns1127 0 0.00555226461369
Gc30_1128 0 n60 ns1128 0 0.00584026433503
Gc30_1129 0 n60 ns1129 0 0.00104874329851
Gc30_1130 0 n60 ns1130 0 0.00545300349805
Gc30_1131 0 n60 ns1131 0 0.000909798139873
Gc30_1132 0 n60 ns1132 0 -0.000831066062031
Gc30_1133 0 n60 ns1133 0 -0.00607074580672
Gc30_1134 0 n60 ns1134 0 -0.00156149036251
Gc30_1135 0 n60 ns1135 0 0.00269546150211
Gc30_1136 0 n60 ns1136 0 -0.00436240473401
Gc30_1137 0 n60 ns1137 0 0.0047756616371
Gc30_1138 0 n60 ns1138 0 -2.23747646008e-05
Gc30_1139 0 n60 ns1139 0 5.4221769836e-05
Gc30_1140 0 n60 ns1140 0 -7.70759321046e-05
Gc30_1141 0 n60 ns1141 0 0.000223036877108
Gc30_1142 0 n60 ns1142 0 -0.0023765017566
Gc30_1143 0 n60 ns1143 0 2.7066175908e-05
Gc30_1144 0 n60 ns1144 0 -0.000870047471255
Gc30_1145 0 n60 ns1145 0 -0.00083015962867
Gc30_1146 0 n60 ns1146 0 0.000196950795024
Gc30_1147 0 n60 ns1147 0 0.000272036659913
Gc30_1148 0 n60 ns1148 0 -0.000487883926669
Gc30_1149 0 n60 ns1149 0 1.44293044655e-05
Gc30_1150 0 n60 ns1150 0 0.00023081742946
Gc30_1151 0 n60 ns1151 0 0.000287567060968
Gc30_1152 0 n60 ns1152 0 1.38225523584e-05
Gc30_1153 0 n60 ns1153 0 -0.00013552927297
Gc30_1154 0 n60 ns1154 0 0.000302300590817
Gc30_1155 0 n60 ns1155 0 0.00102947219235
Gc30_1156 0 n60 ns1156 0 -0.000406690809223
Gc30_1157 0 n60 ns1157 0 0.00116810393516
Gc30_1158 0 n60 ns1158 0 -0.000224899993403
Gc30_1159 0 n60 ns1159 0 0.000755193413474
Gc30_1160 0 n60 ns1160 0 -0.00055446687984
Gc30_1161 0 n60 ns1161 0 0.000370516147098
Gc30_1162 0 n60 ns1162 0 0.0021227481082
Gc30_1163 0 n60 ns1163 0 0.00158187099664
Gc30_1164 0 n60 ns1164 0 0.0055274487736
Gc30_1165 0 n60 ns1165 0 0.00112463911906
Gc30_1166 0 n60 ns1166 0 0.00562642323099
Gc30_1167 0 n60 ns1167 0 0.00317248786396
Gc30_1168 0 n60 ns1168 0 0.000388286925189
Gc30_1169 0 n60 ns1169 0 0.000986336580629
Gc30_1170 0 n60 ns1170 0 -0.000998954486293
Gc30_1171 0 n60 ns1171 0 -0.00147530739185
Gc30_1172 0 n60 ns1172 0 -0.0013248743337
Gc30_1173 0 n60 ns1173 0 -0.00376851450712
Gc30_1174 0 n60 ns1174 0 -0.000108541361645
Gc30_1175 0 n60 ns1175 0 0.00311374025031
Gc30_1176 0 n60 ns1176 0 3.04710323833e-05
Gc30_1177 0 n60 ns1177 0 -0.000150443643081
Gc30_1178 0 n60 ns1178 0 9.03441157663e-06
Gc30_1179 0 n60 ns1179 0 0.000419174422509
Gc30_1180 0 n60 ns1180 0 -0.00145279542696
Gc30_1181 0 n60 ns1181 0 0.00103960633243
Gc30_1182 0 n60 ns1182 0 -0.000867071834963
Gc30_1183 0 n60 ns1183 0 -0.000104117148144
Gc30_1184 0 n60 ns1184 0 9.81170072789e-05
Gc30_1185 0 n60 ns1185 0 -2.88151676062e-05
Gc30_1186 0 n60 ns1186 0 7.35392750544e-06
Gc30_1187 0 n60 ns1187 0 0.000252582861362
Gc30_1188 0 n60 ns1188 0 -0.00062918688895
Gc30_1189 0 n60 ns1189 0 0.000180291794176
Gc30_1190 0 n60 ns1190 0 5.02758120768e-05
Gc30_1191 0 n60 ns1191 0 -5.13290835128e-06
Gc30_1192 0 n60 ns1192 0 0.000138029482687
Gc30_1193 0 n60 ns1193 0 -0.00111562596922
Gc30_1194 0 n60 ns1194 0 0.000515761247603
Gc30_1195 0 n60 ns1195 0 0.00041155387829
Gc30_1196 0 n60 ns1196 0 2.57737133708e-05
Gc30_1197 0 n60 ns1197 0 -0.000252645990883
Gc30_1198 0 n60 ns1198 0 -0.000334577795778
Gc30_1199 0 n60 ns1199 0 0.000687824109193
Gc30_1200 0 n60 ns1200 0 -0.00148483103141
Gc30_1201 0 n60 ns1201 0 -0.0010826030194
Gc30_1202 0 n60 ns1202 0 0.00275793823979
Gc30_1203 0 n60 ns1203 0 -0.000848295310385
Gc30_1204 0 n60 ns1204 0 0.00325970384001
Gc30_1205 0 n60 ns1205 0 -0.00218876269964
Gc30_1206 0 n60 ns1206 0 -0.00198465693999
Gc30_1207 0 n60 ns1207 0 0.00068889511779
Gc30_1208 0 n60 ns1208 0 -0.00102995716804
Gc30_1209 0 n60 ns1209 0 0.0012763852178
Gc30_1210 0 n60 ns1210 0 -0.000493898870189
Gc30_1211 0 n60 ns1211 0 -0.00120030651724
Gc30_1212 0 n60 ns1212 0 0.00298873590457
Gc30_1213 0 n60 ns1213 0 0.00160029735906
Gc30_1214 0 n60 ns1214 0 2.06809377347e-05
Gc30_1215 0 n60 ns1215 0 -0.000285128841726
Gc30_1216 0 n60 ns1216 0 0.000108207123726
Gd30_1 0 n60 ni1 0 0.00137664262349
Gd30_2 0 n60 ni2 0 0.000813641200796
Gd30_3 0 n60 ni3 0 -0.000683230307745
Gd30_4 0 n60 ni4 0 0.000111241242138
Gd30_5 0 n60 ni5 0 -0.000193998905767
Gd30_6 0 n60 ni6 0 -0.00182033492421
Gd30_7 0 n60 ni7 0 -0.00304384464256
Gd30_8 0 n60 ni8 0 0.000117054271907
Gd30_9 0 n60 ni9 0 0.000281204769763
Gd30_10 0 n60 ni10 0 -0.000843973083775
Gd30_11 0 n60 ni11 0 0.000144338629705
Gd30_12 0 n60 ni12 0 9.97456391936e-05
Gd30_13 0 n60 ni13 0 -0.000215707017776
Gd30_14 0 n60 ni14 0 0.000681720127151
Gd30_15 0 n60 ni15 0 -0.000466691277443
Gd30_16 0 n60 ni16 0 0.000436928951925
Gd30_17 0 n60 ni17 0 -0.000423167799385
Gd30_18 0 n60 ni18 0 9.79348964604e-05
Gd30_19 0 n60 ni19 0 0.000604106209944
Gd30_20 0 n60 ni20 0 0.00045738812371
Gd30_21 0 n60 ni21 0 -0.00124192226206
Gd30_22 0 n60 ni22 0 -0.00310757926146
Gd30_23 0 n60 ni23 0 -0.000968093375617
Gd30_24 0 n60 ni24 0 -0.00175241247464
Gd30_25 0 n60 ni25 0 9.20857180522e-05
Gd30_26 0 n60 ni26 0 0.000762211227723
Gd30_27 0 n60 ni27 0 0.000483145633645
Gd30_28 0 n60 ni28 0 -0.000266935673137
Gd30_29 0 n60 ni29 0 -0.00146098879322
Gd30_30 0 n60 ni30 0 0.00110615262493
Gd30_31 0 n60 ni31 0 -0.00168122706189
Gd30_32 0 n60 ni32 0 -0.000911857687652
Gc31_1 0 n62 ns1 0 0.000303822138327
Gc31_2 0 n62 ns2 0 -0.000319739028492
Gc31_3 0 n62 ns3 0 0.000714457991979
Gc31_4 0 n62 ns4 0 -0.000518263493637
Gc31_5 0 n62 ns5 0 0.00016834706932
Gc31_6 0 n62 ns6 0 -0.00022001513133
Gc31_7 0 n62 ns7 0 -0.000149618477179
Gc31_8 0 n62 ns8 0 9.98079237988e-05
Gc31_9 0 n62 ns9 0 -0.000267871200344
Gc31_10 0 n62 ns10 0 -3.98688810442e-06
Gc31_11 0 n62 ns11 0 8.43103262687e-05
Gc31_12 0 n62 ns12 0 9.58847289553e-06
Gc31_13 0 n62 ns13 0 6.88628231605e-05
Gc31_14 0 n62 ns14 0 -0.000152191296864
Gc31_15 0 n62 ns15 0 -0.000369637834191
Gc31_16 0 n62 ns16 0 -0.000118210935928
Gc31_17 0 n62 ns17 0 -0.000368652357146
Gc31_18 0 n62 ns18 0 9.49706406869e-05
Gc31_19 0 n62 ns19 0 -0.000456825131152
Gc31_20 0 n62 ns20 0 0.000181093164142
Gc31_21 0 n62 ns21 0 -0.000338636276229
Gc31_22 0 n62 ns22 0 -4.14452414386e-05
Gc31_23 0 n62 ns23 0 -0.00148733513665
Gc31_24 0 n62 ns24 0 0.00129995401869
Gc31_25 0 n62 ns25 0 -0.00127140961615
Gc31_26 0 n62 ns26 0 0.00116844063659
Gc31_27 0 n62 ns27 0 0.000431641414727
Gc31_28 0 n62 ns28 0 0.000332018815776
Gc31_29 0 n62 ns29 0 -0.000145350338497
Gc31_30 0 n62 ns30 0 -7.23104240275e-05
Gc31_31 0 n62 ns31 0 -0.000568248481426
Gc31_32 0 n62 ns32 0 -0.000212541557584
Gc31_33 0 n62 ns33 0 -7.13412749595e-05
Gc31_34 0 n62 ns34 0 -0.000130244181717
Gc31_35 0 n62 ns35 0 -6.48132208162e-05
Gc31_36 0 n62 ns36 0 -1.16969605016e-05
Gc31_37 0 n62 ns37 0 2.0461575934e-05
Gc31_38 0 n62 ns38 0 7.8696513819e-06
Gc31_39 0 n62 ns39 0 4.15893374294e-05
Gc31_40 0 n62 ns40 0 0.000141538118276
Gc31_41 0 n62 ns41 0 0.000146635188651
Gc31_42 0 n62 ns42 0 -2.08755070697e-05
Gc31_43 0 n62 ns43 0 5.96486959731e-05
Gc31_44 0 n62 ns44 0 9.73343269484e-06
Gc31_45 0 n62 ns45 0 -7.6744002838e-05
Gc31_46 0 n62 ns46 0 -4.6538080533e-05
Gc31_47 0 n62 ns47 0 -0.000252241801051
Gc31_48 0 n62 ns48 0 -4.52754750271e-06
Gc31_49 0 n62 ns49 0 0.000106940105036
Gc31_50 0 n62 ns50 0 2.66049940387e-05
Gc31_51 0 n62 ns51 0 0.000184400389787
Gc31_52 0 n62 ns52 0 -0.000272093258596
Gc31_53 0 n62 ns53 0 -0.00028516209858
Gc31_54 0 n62 ns54 0 -0.000284720696733
Gc31_55 0 n62 ns55 0 -0.000391338686689
Gc31_56 0 n62 ns56 0 1.96551014397e-06
Gc31_57 0 n62 ns57 0 -0.000451931956197
Gc31_58 0 n62 ns58 0 0.0001016465155
Gc31_59 0 n62 ns59 0 -0.000462593774583
Gc31_60 0 n62 ns60 0 6.75460918122e-06
Gc31_61 0 n62 ns61 0 -0.0023055084066
Gc31_62 0 n62 ns62 0 0.00166092052891
Gc31_63 0 n62 ns63 0 -0.00197969060859
Gc31_64 0 n62 ns64 0 0.00148722732964
Gc31_65 0 n62 ns65 0 0.000608662889803
Gc31_66 0 n62 ns66 0 0.000624747795979
Gc31_67 0 n62 ns67 0 -0.000204705417395
Gc31_68 0 n62 ns68 0 -0.00012016575957
Gc31_69 0 n62 ns69 0 -0.000793894551947
Gc31_70 0 n62 ns70 0 -0.000443446291633
Gc31_71 0 n62 ns71 0 -0.000117129181322
Gc31_72 0 n62 ns72 0 -0.000372866045013
Gc31_73 0 n62 ns73 0 -0.000122427139128
Gc31_74 0 n62 ns74 0 -1.54401536292e-05
Gc31_75 0 n62 ns75 0 2.76170800462e-05
Gc31_76 0 n62 ns76 0 1.37292684418e-06
Gc31_77 0 n62 ns77 0 -0.000456561097695
Gc31_78 0 n62 ns78 0 0.00102510375208
Gc31_79 0 n62 ns79 0 -0.000872653101858
Gc31_80 0 n62 ns80 0 0.000722679754396
Gc31_81 0 n62 ns81 0 -0.00019145440828
Gc31_82 0 n62 ns82 0 0.00041085110413
Gc31_83 0 n62 ns83 0 0.000174113460028
Gc31_84 0 n62 ns84 0 -0.000255936829941
Gc31_85 0 n62 ns85 0 7.62260625483e-05
Gc31_86 0 n62 ns86 0 -0.000187782989757
Gc31_87 0 n62 ns87 0 4.14585002249e-05
Gc31_88 0 n62 ns88 0 9.71056174954e-05
Gc31_89 0 n62 ns89 0 0.000292096997828
Gc31_90 0 n62 ns90 0 -9.23854870294e-05
Gc31_91 0 n62 ns91 0 0.000289986926684
Gc31_92 0 n62 ns92 0 -0.0005539173803
Gc31_93 0 n62 ns93 0 -0.000235878008218
Gc31_94 0 n62 ns94 0 -0.00043414470269
Gc31_95 0 n62 ns95 0 -0.000267899119189
Gc31_96 0 n62 ns96 0 -0.000340812616544
Gc31_97 0 n62 ns97 0 -0.000514597884391
Gc31_98 0 n62 ns98 0 -0.00013449317812
Gc31_99 0 n62 ns99 0 -0.00469441784131
Gc31_100 0 n62 ns100 0 0.000795736129607
Gc31_101 0 n62 ns101 0 -0.00412530404729
Gc31_102 0 n62 ns102 0 0.000755445852617
Gc31_103 0 n62 ns103 0 0.000778866336474
Gc31_104 0 n62 ns104 0 0.00149045027913
Gc31_105 0 n62 ns105 0 -0.000342799004516
Gc31_106 0 n62 ns106 0 -0.000332028489172
Gc31_107 0 n62 ns107 0 -0.0012756085436
Gc31_108 0 n62 ns108 0 -0.00124605049116
Gc31_109 0 n62 ns109 0 -0.000221614649942
Gc31_110 0 n62 ns110 0 -0.00107042731533
Gc31_111 0 n62 ns111 0 -0.000292050695648
Gc31_112 0 n62 ns112 0 -2.50662000187e-05
Gc31_113 0 n62 ns113 0 0.000100060378439
Gc31_114 0 n62 ns114 0 -2.83123288439e-05
Gc31_115 0 n62 ns115 0 0.000334470066001
Gc31_116 0 n62 ns116 0 -0.00059353682729
Gc31_117 0 n62 ns117 0 0.00116712670185
Gc31_118 0 n62 ns118 0 -0.00093784521286
Gc31_119 0 n62 ns119 0 0.000246673667578
Gc31_120 0 n62 ns120 0 -0.000187354522509
Gc31_121 0 n62 ns121 0 -0.000172464744157
Gc31_122 0 n62 ns122 0 0.000157508724259
Gc31_123 0 n62 ns123 0 0.000321307496755
Gc31_124 0 n62 ns124 0 -0.000330480534171
Gc31_125 0 n62 ns125 0 -0.000124099232211
Gc31_126 0 n62 ns126 0 0.000136594416301
Gc31_127 0 n62 ns127 0 -0.000233665079786
Gc31_128 0 n62 ns128 0 0.000549336735115
Gc31_129 0 n62 ns129 0 0.000469063731045
Gc31_130 0 n62 ns130 0 0.000276724971422
Gc31_131 0 n62 ns131 0 7.80125270581e-05
Gc31_132 0 n62 ns132 0 -0.000439672707781
Gc31_133 0 n62 ns133 0 -0.000165327169229
Gc31_134 0 n62 ns134 0 -0.000277669643864
Gc31_135 0 n62 ns135 0 -2.95130520062e-05
Gc31_136 0 n62 ns136 0 -0.000530259661881
Gc31_137 0 n62 ns137 0 -0.0050276274222
Gc31_138 0 n62 ns138 0 -0.00323027073227
Gc31_139 0 n62 ns139 0 -0.00462039300578
Gc31_140 0 n62 ns140 0 -0.0027964979778
Gc31_141 0 n62 ns141 0 6.95929147834e-05
Gc31_142 0 n62 ns142 0 0.00167568921886
Gc31_143 0 n62 ns143 0 -0.000341532597317
Gc31_144 0 n62 ns144 0 -0.000604160844382
Gc31_145 0 n62 ns145 0 -0.00114278369736
Gc31_146 0 n62 ns146 0 -0.00172533057822
Gc31_147 0 n62 ns147 0 -0.000100423409421
Gc31_148 0 n62 ns148 0 -0.00114335455799
Gc31_149 0 n62 ns149 0 -0.000372366982701
Gc31_150 0 n62 ns150 0 -9.57590667544e-06
Gc31_151 0 n62 ns151 0 8.85359770087e-05
Gc31_152 0 n62 ns152 0 -6.43715164692e-06
Gc31_153 0 n62 ns153 0 -0.000183850462179
Gc31_154 0 n62 ns154 0 -0.000323356124483
Gc31_155 0 n62 ns155 0 -0.000515648421849
Gc31_156 0 n62 ns156 0 0.000678907341683
Gc31_157 0 n62 ns157 0 -0.00016624259756
Gc31_158 0 n62 ns158 0 2.69766176553e-05
Gc31_159 0 n62 ns159 0 -3.2069502074e-05
Gc31_160 0 n62 ns160 0 -0.000102864422075
Gc31_161 0 n62 ns161 0 -3.68583966521e-05
Gc31_162 0 n62 ns162 0 0.000380693447691
Gc31_163 0 n62 ns163 0 -8.23990363374e-05
Gc31_164 0 n62 ns164 0 0.000141395417241
Gc31_165 0 n62 ns165 0 0.000413890422847
Gc31_166 0 n62 ns166 0 -0.000407044068172
Gc31_167 0 n62 ns167 0 0.000111448665058
Gc31_168 0 n62 ns168 0 0.000568955428724
Gc31_169 0 n62 ns169 0 0.000486663663821
Gc31_170 0 n62 ns170 0 -0.000264647815858
Gc31_171 0 n62 ns171 0 7.62923295363e-05
Gc31_172 0 n62 ns172 0 -7.7551400589e-05
Gc31_173 0 n62 ns173 0 -0.000291593441658
Gc31_174 0 n62 ns174 0 0.000280348615471
Gc31_175 0 n62 ns175 0 -0.00351948778767
Gc31_176 0 n62 ns176 0 -0.0049396702066
Gc31_177 0 n62 ns177 0 -0.00337537177362
Gc31_178 0 n62 ns178 0 -0.00466975530387
Gc31_179 0 n62 ns179 0 -0.000967184940617
Gc31_180 0 n62 ns180 0 0.00161903426748
Gc31_181 0 n62 ns181 0 -5.29515883207e-05
Gc31_182 0 n62 ns182 0 -0.00111567263722
Gc31_183 0 n62 ns183 0 -0.000367201901989
Gc31_184 0 n62 ns184 0 -0.00272428531532
Gc31_185 0 n62 ns185 0 0.000395034053596
Gc31_186 0 n62 ns186 0 -0.0020637475958
Gc31_187 0 n62 ns187 0 -0.000846001577564
Gc31_188 0 n62 ns188 0 -2.14158266635e-05
Gc31_189 0 n62 ns189 0 0.000105426758547
Gc31_190 0 n62 ns190 0 -1.32530561527e-05
Gc31_191 0 n62 ns191 0 -0.000886635865152
Gc31_192 0 n62 ns192 0 0.00012508078418
Gc31_193 0 n62 ns193 0 -0.00249391052473
Gc31_194 0 n62 ns194 0 0.00214383635249
Gc31_195 0 n62 ns195 0 -0.000486949764924
Gc31_196 0 n62 ns196 0 0.000894038190799
Gc31_197 0 n62 ns197 0 0.000417529161304
Gc31_198 0 n62 ns198 0 -0.000476801819013
Gc31_199 0 n62 ns199 0 -0.000259038776889
Gc31_200 0 n62 ns200 0 0.000330263276642
Gc31_201 0 n62 ns201 0 -0.000174839232742
Gc31_202 0 n62 ns202 0 9.33554107521e-05
Gc31_203 0 n62 ns203 0 0.00106043628139
Gc31_204 0 n62 ns204 0 -0.00028321694887
Gc31_205 0 n62 ns205 0 0.000165888922494
Gc31_206 0 n62 ns206 0 -0.000676723722911
Gc31_207 0 n62 ns207 0 0.000849809661653
Gc31_208 0 n62 ns208 0 -0.000567684207194
Gc31_209 0 n62 ns209 0 0.000473299266849
Gc31_210 0 n62 ns210 0 -0.000901222441658
Gc31_211 0 n62 ns211 0 -0.00155473378344
Gc31_212 0 n62 ns212 0 0.000687264680938
Gc31_213 0 n62 ns213 0 -0.00371311719789
Gc31_214 0 n62 ns214 0 -0.00270335681091
Gc31_215 0 n62 ns215 0 -0.00315568329041
Gc31_216 0 n62 ns216 0 -0.00324909383922
Gc31_217 0 n62 ns217 0 0.000451733036804
Gc31_218 0 n62 ns218 0 0.00080133573919
Gc31_219 0 n62 ns219 0 0.000576539571165
Gc31_220 0 n62 ns220 0 -0.0013969994809
Gc31_221 0 n62 ns221 0 -0.000188206007693
Gc31_222 0 n62 ns222 0 -0.002900434466
Gc31_223 0 n62 ns223 0 0.00165473692704
Gc31_224 0 n62 ns224 0 -0.00345106617606
Gc31_225 0 n62 ns225 0 -0.00215827295957
Gc31_226 0 n62 ns226 0 -2.50961180979e-05
Gc31_227 0 n62 ns227 0 0.000136198184827
Gc31_228 0 n62 ns228 0 -2.03213039583e-05
Gc31_229 0 n62 ns229 0 0.0012560899059
Gc31_230 0 n62 ns230 0 -0.00278421857209
Gc31_231 0 n62 ns231 0 0.00234272652216
Gc31_232 0 n62 ns232 0 -0.00460274980069
Gc31_233 0 n62 ns233 0 -0.00238499563123
Gc31_234 0 n62 ns234 0 -0.00136150834294
Gc31_235 0 n62 ns235 0 0.000847743509391
Gc31_236 0 n62 ns236 0 0.000567050095757
Gc31_237 0 n62 ns237 0 -0.000199151673947
Gc31_238 0 n62 ns238 0 -0.000192793526575
Gc31_239 0 n62 ns239 0 -0.00029691455558
Gc31_240 0 n62 ns240 0 -8.04706339752e-05
Gc31_241 0 n62 ns241 0 -0.000323008842943
Gc31_242 0 n62 ns242 0 0.000130871010046
Gc31_243 0 n62 ns243 0 0.00129527460099
Gc31_244 0 n62 ns244 0 -3.67525467566e-05
Gc31_245 0 n62 ns245 0 0.00127809885194
Gc31_246 0 n62 ns246 0 0.000140300589286
Gc31_247 0 n62 ns247 0 0.000844477386418
Gc31_248 0 n62 ns248 0 -4.50622906919e-05
Gc31_249 0 n62 ns249 0 -0.000345175372817
Gc31_250 0 n62 ns250 0 -0.00203277524158
Gc31_251 0 n62 ns251 0 -0.00309232830245
Gc31_252 0 n62 ns252 0 -0.00574457363394
Gc31_253 0 n62 ns253 0 -0.00220323755657
Gc31_254 0 n62 ns254 0 -0.00582531440986
Gc31_255 0 n62 ns255 0 0.00393267391119
Gc31_256 0 n62 ns256 0 0.00361223694552
Gc31_257 0 n62 ns257 0 0.00108674675577
Gc31_258 0 n62 ns258 0 -0.00112287009236
Gc31_259 0 n62 ns259 0 -0.00261530221874
Gc31_260 0 n62 ns260 0 -0.00316810073268
Gc31_261 0 n62 ns261 0 0.0023421275267
Gc31_262 0 n62 ns262 0 0.001700320869
Gc31_263 0 n62 ns263 0 -0.00372905104565
Gc31_264 0 n62 ns264 0 1.22310120164e-05
Gc31_265 0 n62 ns265 0 0.000245295204482
Gc31_266 0 n62 ns266 0 -0.000119082250886
Gc31_267 0 n62 ns267 0 0.00227640865863
Gc31_268 0 n62 ns268 0 -0.00344456650999
Gc31_269 0 n62 ns269 0 0.00477719491828
Gc31_270 0 n62 ns270 0 -0.0070788451484
Gc31_271 0 n62 ns271 0 -0.00337545555508
Gc31_272 0 n62 ns272 0 -0.00251234765807
Gc31_273 0 n62 ns273 0 0.00107643145839
Gc31_274 0 n62 ns274 0 0.000740786395624
Gc31_275 0 n62 ns275 0 -0.000651357501869
Gc31_276 0 n62 ns276 0 -0.000127287680215
Gc31_277 0 n62 ns277 0 -0.000190020441825
Gc31_278 0 n62 ns278 0 -0.000135602313826
Gc31_279 0 n62 ns279 0 -0.000524551493367
Gc31_280 0 n62 ns280 0 -0.000766025608655
Gc31_281 0 n62 ns281 0 0.000679739026767
Gc31_282 0 n62 ns282 0 0.000549665215185
Gc31_283 0 n62 ns283 0 0.00095123883544
Gc31_284 0 n62 ns284 0 0.000963381895389
Gc31_285 0 n62 ns285 0 0.000361060955134
Gc31_286 0 n62 ns286 0 0.00118993933784
Gc31_287 0 n62 ns287 0 0.000973173216659
Gc31_288 0 n62 ns288 0 -0.00257482261342
Gc31_289 0 n62 ns289 0 0.00201748138431
Gc31_290 0 n62 ns290 0 -0.0070508583072
Gc31_291 0 n62 ns291 0 0.0022192129184
Gc31_292 0 n62 ns292 0 -0.00678262384597
Gc31_293 0 n62 ns293 0 0.00480286685997
Gc31_294 0 n62 ns294 0 0.00665700573529
Gc31_295 0 n62 ns295 0 0.00113343731439
Gc31_296 0 n62 ns296 0 -0.00104892952423
Gc31_297 0 n62 ns297 0 -0.00425427360766
Gc31_298 0 n62 ns298 0 -0.00502214383842
Gc31_299 0 n62 ns299 0 0.00175475418166
Gc31_300 0 n62 ns300 0 0.00605748075777
Gc31_301 0 n62 ns301 0 -0.0041797750697
Gc31_302 0 n62 ns302 0 -1.02124895792e-05
Gc31_303 0 n62 ns303 0 0.00036917096931
Gc31_304 0 n62 ns304 0 -0.000218449949499
Gc31_305 0 n62 ns305 0 -0.00096935150629
Gc31_306 0 n62 ns306 0 0.000214299196928
Gc31_307 0 n62 ns307 0 -0.00297389228513
Gc31_308 0 n62 ns308 0 0.00109164332247
Gc31_309 0 n62 ns309 0 -0.000115959545984
Gc31_310 0 n62 ns310 0 0.000951231465405
Gc31_311 0 n62 ns311 0 0.000235869382803
Gc31_312 0 n62 ns312 0 -0.00040136665978
Gc31_313 0 n62 ns313 0 -0.000734764071694
Gc31_314 0 n62 ns314 0 -2.06706294561e-05
Gc31_315 0 n62 ns315 0 -0.000104529505907
Gc31_316 0 n62 ns316 0 -2.38661969972e-05
Gc31_317 0 n62 ns317 0 0.00104242812649
Gc31_318 0 n62 ns318 0 0.000354353595839
Gc31_319 0 n62 ns319 0 -0.000320728874816
Gc31_320 0 n62 ns320 0 -0.00114559894051
Gc31_321 0 n62 ns321 0 0.000448526391988
Gc31_322 0 n62 ns322 0 2.87331516592e-05
Gc31_323 0 n62 ns323 0 0.000283778282793
Gc31_324 0 n62 ns324 0 -0.000533329392029
Gc31_325 0 n62 ns325 0 -0.00252101144201
Gc31_326 0 n62 ns326 0 0.00014692399874
Gc31_327 0 n62 ns327 0 -0.00160261879673
Gc31_328 0 n62 ns328 0 0.00110189963745
Gc31_329 0 n62 ns329 0 -0.000771678923717
Gc31_330 0 n62 ns330 0 6.58395633261e-05
Gc31_331 0 n62 ns331 0 0.00195542235938
Gc31_332 0 n62 ns332 0 -0.00199354394102
Gc31_333 0 n62 ns333 0 0.00120972069454
Gc31_334 0 n62 ns334 0 -0.0006808172733
Gc31_335 0 n62 ns335 0 0.000489400591872
Gc31_336 0 n62 ns336 0 4.6653981135e-05
Gc31_337 0 n62 ns337 0 0.00271477275397
Gc31_338 0 n62 ns338 0 -0.00105273590548
Gc31_339 0 n62 ns339 0 -0.00226442066479
Gc31_340 0 n62 ns340 0 -1.09377102074e-05
Gc31_341 0 n62 ns341 0 0.000218018760769
Gc31_342 0 n62 ns342 0 -7.04332497113e-05
Gc31_343 0 n62 ns343 0 -0.000303865559703
Gc31_344 0 n62 ns344 0 0.00104671190968
Gc31_345 0 n62 ns345 0 -0.000504373322198
Gc31_346 0 n62 ns346 0 0.00130529038611
Gc31_347 0 n62 ns347 0 -9.78340319555e-05
Gc31_348 0 n62 ns348 0 0.000501457880785
Gc31_349 0 n62 ns349 0 9.28750741731e-05
Gc31_350 0 n62 ns350 0 -0.000315223232469
Gc31_351 0 n62 ns351 0 -5.6314111488e-06
Gc31_352 0 n62 ns352 0 -1.38316923439e-05
Gc31_353 0 n62 ns353 0 0.000103047701567
Gc31_354 0 n62 ns354 0 3.6171979903e-05
Gc31_355 0 n62 ns355 0 0.000217972053142
Gc31_356 0 n62 ns356 0 -0.000462621817306
Gc31_357 0 n62 ns357 0 5.64589915961e-05
Gc31_358 0 n62 ns358 0 -0.00068721314267
Gc31_359 0 n62 ns359 0 -0.0002859402736
Gc31_360 0 n62 ns360 0 -0.000367736431723
Gc31_361 0 n62 ns361 0 -0.00025485315239
Gc31_362 0 n62 ns362 0 -0.000343583679888
Gc31_363 0 n62 ns363 0 -0.000454989719151
Gc31_364 0 n62 ns364 0 0.000163833978291
Gc31_365 0 n62 ns365 0 -0.00363478120236
Gc31_366 0 n62 ns366 0 0.00192375532233
Gc31_367 0 n62 ns367 0 -0.00316317920757
Gc31_368 0 n62 ns368 0 0.00170248656214
Gc31_369 0 n62 ns369 0 0.00103334553175
Gc31_370 0 n62 ns370 0 0.00139977931854
Gc31_371 0 n62 ns371 0 -0.000336518837021
Gc31_372 0 n62 ns372 0 -0.00027044007219
Gc31_373 0 n62 ns373 0 -0.00134831253323
Gc31_374 0 n62 ns374 0 -0.0011706231659
Gc31_375 0 n62 ns375 0 -0.000271105304711
Gc31_376 0 n62 ns376 0 -0.00119549507951
Gc31_377 0 n62 ns377 0 -0.00031316888975
Gc31_378 0 n62 ns378 0 -6.55372422794e-06
Gc31_379 0 n62 ns379 0 1.39450968648e-05
Gc31_380 0 n62 ns380 0 1.68051888072e-05
Gc31_381 0 n62 ns381 0 0.000341523737492
Gc31_382 0 n62 ns382 0 -0.000184436833135
Gc31_383 0 n62 ns383 0 0.00125684495384
Gc31_384 0 n62 ns384 0 -0.000421393055636
Gc31_385 0 n62 ns385 0 0.000233779738828
Gc31_386 0 n62 ns386 0 -3.52748515981e-05
Gc31_387 0 n62 ns387 0 -7.82309550361e-05
Gc31_388 0 n62 ns388 0 5.81709630506e-05
Gc31_389 0 n62 ns389 0 0.000299193283911
Gc31_390 0 n62 ns390 0 -0.000389549354102
Gc31_391 0 n62 ns391 0 -7.29434810504e-05
Gc31_392 0 n62 ns392 0 0.000110105528041
Gc31_393 0 n62 ns393 0 -0.000180484829859
Gc31_394 0 n62 ns394 0 0.000401168942876
Gc31_395 0 n62 ns395 0 0.000411916017956
Gc31_396 0 n62 ns396 0 -0.000201304851553
Gc31_397 0 n62 ns397 0 -7.83661763345e-05
Gc31_398 0 n62 ns398 0 -0.00055787538999
Gc31_399 0 n62 ns399 0 -0.000214812201057
Gc31_400 0 n62 ns400 0 -0.000509082347196
Gc31_401 0 n62 ns401 0 -4.50463113695e-05
Gc31_402 0 n62 ns402 0 -0.000364043742351
Gc31_403 0 n62 ns403 0 -0.00473524219107
Gc31_404 0 n62 ns404 0 -0.00141045110075
Gc31_405 0 n62 ns405 0 -0.00429333836831
Gc31_406 0 n62 ns406 0 -0.00118583330275
Gc31_407 0 n62 ns407 0 0.000608779300212
Gc31_408 0 n62 ns408 0 0.00170141778441
Gc31_409 0 n62 ns409 0 -0.000385593459943
Gc31_410 0 n62 ns410 0 -0.000491675982601
Gc31_411 0 n62 ns411 0 -0.00142249517379
Gc31_412 0 n62 ns412 0 -0.00162470112222
Gc31_413 0 n62 ns413 0 -0.000234787151248
Gc31_414 0 n62 ns414 0 -0.00132905015202
Gc31_415 0 n62 ns415 0 -0.000380935158307
Gc31_416 0 n62 ns416 0 -2.59458387094e-06
Gc31_417 0 n62 ns417 0 2.9715885294e-05
Gc31_418 0 n62 ns418 0 2.61731949885e-05
Gc31_419 0 n62 ns419 0 -6.51826252838e-05
Gc31_420 0 n62 ns420 0 -0.000320456847098
Gc31_421 0 n62 ns421 0 -0.000167824565167
Gc31_422 0 n62 ns422 0 0.000243837180269
Gc31_423 0 n62 ns423 0 -0.000105053973973
Gc31_424 0 n62 ns424 0 2.21438486407e-05
Gc31_425 0 n62 ns425 0 -8.27395575689e-05
Gc31_426 0 n62 ns426 0 -8.05010726322e-06
Gc31_427 0 n62 ns427 0 0.000174962604827
Gc31_428 0 n62 ns428 0 0.000228501739348
Gc31_429 0 n62 ns429 0 -6.78309705519e-05
Gc31_430 0 n62 ns430 0 0.000124213058353
Gc31_431 0 n62 ns431 0 5.82843473263e-05
Gc31_432 0 n62 ns432 0 -0.000201670062709
Gc31_433 0 n62 ns433 0 0.000351656826196
Gc31_434 0 n62 ns434 0 0.00058001503112
Gc31_435 0 n62 ns435 0 0.000383115632627
Gc31_436 0 n62 ns436 0 -0.000300943970868
Gc31_437 0 n62 ns437 0 9.07772334344e-05
Gc31_438 0 n62 ns438 0 -6.42873648396e-05
Gc31_439 0 n62 ns439 0 -9.82705768134e-05
Gc31_440 0 n62 ns440 0 -2.54000386102e-05
Gc31_441 0 n62 ns441 0 -0.00417130107325
Gc31_442 0 n62 ns442 0 -0.00460164284844
Gc31_443 0 n62 ns443 0 -0.00393829634808
Gc31_444 0 n62 ns444 0 -0.00419517899245
Gc31_445 0 n62 ns445 0 -0.00065027038495
Gc31_446 0 n62 ns446 0 0.00182633341095
Gc31_447 0 n62 ns447 0 -0.000208012314485
Gc31_448 0 n62 ns448 0 -0.0009269289489
Gc31_449 0 n62 ns449 0 -0.000717106358062
Gc31_450 0 n62 ns450 0 -0.00244018007462
Gc31_451 0 n62 ns451 0 0.000146701350535
Gc31_452 0 n62 ns452 0 -0.00168283440114
Gc31_453 0 n62 ns453 0 -0.000619481846703
Gc31_454 0 n62 ns454 0 -1.873172552e-05
Gc31_455 0 n62 ns455 0 7.52106434933e-05
Gc31_456 0 n62 ns456 0 2.3189840941e-06
Gc31_457 0 n62 ns457 0 -0.000595742383277
Gc31_458 0 n62 ns458 0 0.000327271462263
Gc31_459 0 n62 ns459 0 -0.00137607988084
Gc31_460 0 n62 ns460 0 0.00259256909719
Gc31_461 0 n62 ns461 0 -0.000203410452657
Gc31_462 0 n62 ns462 0 0.000551821732199
Gc31_463 0 n62 ns463 0 0.000212217395963
Gc31_464 0 n62 ns464 0 -0.000414288589233
Gc31_465 0 n62 ns465 0 -0.000148988994994
Gc31_466 0 n62 ns466 0 0.000440701742978
Gc31_467 0 n62 ns467 0 -0.000114076029482
Gc31_468 0 n62 ns468 0 0.000109980375509
Gc31_469 0 n62 ns469 0 0.000915430572438
Gc31_470 0 n62 ns470 0 -0.000613927081773
Gc31_471 0 n62 ns471 0 -5.25382348764e-05
Gc31_472 0 n62 ns472 0 -0.000326839558172
Gc31_473 0 n62 ns473 0 0.000625065188982
Gc31_474 0 n62 ns474 0 -0.000536898572403
Gc31_475 0 n62 ns475 0 0.000205301726444
Gc31_476 0 n62 ns476 0 -0.000716525897945
Gc31_477 0 n62 ns477 0 -0.00100819090033
Gc31_478 0 n62 ns478 0 0.000985067010695
Gc31_479 0 n62 ns479 0 -0.00292094753111
Gc31_480 0 n62 ns480 0 -0.00273539498301
Gc31_481 0 n62 ns481 0 -0.00265828612404
Gc31_482 0 n62 ns482 0 -0.00312894598593
Gc31_483 0 n62 ns483 0 -0.000352570401815
Gc31_484 0 n62 ns484 0 0.00105353390483
Gc31_485 0 n62 ns485 0 0.000314804867004
Gc31_486 0 n62 ns486 0 -0.00136826745956
Gc31_487 0 n62 ns487 0 -0.000125667215056
Gc31_488 0 n62 ns488 0 -0.00309037908212
Gc31_489 0 n62 ns489 0 0.00102782630877
Gc31_490 0 n62 ns490 0 -0.00342516572701
Gc31_491 0 n62 ns491 0 -0.00161547857657
Gc31_492 0 n62 ns492 0 -2.88854373957e-05
Gc31_493 0 n62 ns493 0 0.00011277917367
Gc31_494 0 n62 ns494 0 -6.51370310599e-06
Gc31_495 0 n62 ns495 0 -0.000801625889079
Gc31_496 0 n62 ns496 0 -0.000982734255236
Gc31_497 0 n62 ns497 0 -0.00331928685684
Gc31_498 0 n62 ns498 0 -0.00166862512618
Gc31_499 0 n62 ns499 0 -0.00194043661768
Gc31_500 0 n62 ns500 0 0.00103160580478
Gc31_501 0 n62 ns501 0 0.000884765979387
Gc31_502 0 n62 ns502 0 -0.000368855039817
Gc31_503 0 n62 ns503 0 -0.000163086435067
Gc31_504 0 n62 ns504 0 0.000147443645567
Gc31_505 0 n62 ns505 0 -0.000265288481076
Gc31_506 0 n62 ns506 0 -2.98891847628e-06
Gc31_507 0 n62 ns507 0 0.000394151039677
Gc31_508 0 n62 ns508 0 0.000337899552362
Gc31_509 0 n62 ns509 0 0.00109839901869
Gc31_510 0 n62 ns510 0 -0.000624282528448
Gc31_511 0 n62 ns511 0 0.00134237724959
Gc31_512 0 n62 ns512 0 -0.000319400059877
Gc31_513 0 n62 ns513 0 0.00119094273948
Gc31_514 0 n62 ns514 0 -0.000655505091792
Gc31_515 0 n62 ns515 0 -0.00173605282013
Gc31_516 0 n62 ns516 0 -0.000894270261638
Gc31_517 0 n62 ns517 0 -0.00471958170555
Gc31_518 0 n62 ns518 0 -0.00441889800323
Gc31_519 0 n62 ns519 0 -0.00366855407791
Gc31_520 0 n62 ns520 0 -0.00469343876876
Gc31_521 0 n62 ns521 0 0.00305789118834
Gc31_522 0 n62 ns522 0 0.00180980240642
Gc31_523 0 n62 ns523 0 0.000948743859181
Gc31_524 0 n62 ns524 0 -0.00122135984674
Gc31_525 0 n62 ns525 0 -0.00172607326909
Gc31_526 0 n62 ns526 0 -0.00293114117111
Gc31_527 0 n62 ns527 0 0.00254502017739
Gc31_528 0 n62 ns528 0 -0.000561745136985
Gc31_529 0 n62 ns529 0 -0.00319817774746
Gc31_530 0 n62 ns530 0 -3.79686821253e-05
Gc31_531 0 n62 ns531 0 0.000337293188827
Gc31_532 0 n62 ns532 0 -0.000161448426952
Gc31_533 0 n62 ns533 0 -0.000458659001892
Gc31_534 0 n62 ns534 0 -0.000233520344105
Gc31_535 0 n62 ns535 0 0.000321232330144
Gc31_536 0 n62 ns536 0 0.00248983888054
Gc31_537 0 n62 ns537 0 0.00126629345526
Gc31_538 0 n62 ns538 0 -0.000984171815836
Gc31_539 0 n62 ns539 0 -0.000395311676746
Gc31_540 0 n62 ns540 0 8.18825705222e-05
Gc31_541 0 n62 ns541 0 0.000144877744269
Gc31_542 0 n62 ns542 0 0.000566777916905
Gc31_543 0 n62 ns543 0 -0.00012770910902
Gc31_544 0 n62 ns544 0 -0.000109329413364
Gc31_545 0 n62 ns545 0 0.00172330124578
Gc31_546 0 n62 ns546 0 -0.0011161347981
Gc31_547 0 n62 ns547 0 -0.00067612964267
Gc31_548 0 n62 ns548 0 0.00183540173258
Gc31_549 0 n62 ns549 0 -9.47129389833e-05
Gc31_550 0 n62 ns550 0 0.000473177194799
Gc31_551 0 n62 ns551 0 -0.00164971329117
Gc31_552 0 n62 ns552 0 -0.000795771535318
Gc31_553 0 n62 ns553 0 0.00325717061185
Gc31_554 0 n62 ns554 0 0.00409876830858
Gc31_555 0 n62 ns555 0 -0.00681825172997
Gc31_556 0 n62 ns556 0 -0.000231760215932
Gc31_557 0 n62 ns557 0 -0.00484642760191
Gc31_558 0 n62 ns558 0 -0.00153069808529
Gc31_559 0 n62 ns559 0 -0.0115371891252
Gc31_560 0 n62 ns560 0 -0.00118016447998
Gc31_561 0 n62 ns561 0 0.00170375342026
Gc31_562 0 n62 ns562 0 7.46155414566e-05
Gc31_563 0 n62 ns563 0 -0.00268353262544
Gc31_564 0 n62 ns564 0 0.00889749413589
Gc31_565 0 n62 ns565 0 -0.0140179623714
Gc31_566 0 n62 ns566 0 -0.00371210291916
Gc31_567 0 n62 ns567 0 -0.0061994420756
Gc31_568 0 n62 ns568 0 -5.93631289489e-05
Gc31_569 0 n62 ns569 0 -0.000410786544819
Gc31_570 0 n62 ns570 0 0.00060200086582
Gc31_571 0 n62 ns571 0 -0.00110399281186
Gc31_572 0 n62 ns572 0 -0.0004455748592
Gc31_573 0 n62 ns573 0 -0.00428941607258
Gc31_574 0 n62 ns574 0 -0.00161086678513
Gc31_575 0 n62 ns575 0 -0.00203458271031
Gc31_576 0 n62 ns576 0 0.00100181735639
Gc31_577 0 n62 ns577 0 0.000957480632099
Gc31_578 0 n62 ns578 0 -0.000489965155639
Gc31_579 0 n62 ns579 0 -0.000809113843673
Gc31_580 0 n62 ns580 0 0.000219937020374
Gc31_581 0 n62 ns581 0 -0.000113321231051
Gc31_582 0 n62 ns582 0 -5.78426436145e-05
Gc31_583 0 n62 ns583 0 0.000957793084944
Gc31_584 0 n62 ns584 0 -2.16621815613e-06
Gc31_585 0 n62 ns585 0 0.000258615165903
Gc31_586 0 n62 ns586 0 -0.000908933068168
Gc31_587 0 n62 ns587 0 0.000886590534986
Gc31_588 0 n62 ns588 0 0.000275571954216
Gc31_589 0 n62 ns589 0 0.000774704892341
Gc31_590 0 n62 ns590 0 -7.47127014564e-05
Gc31_591 0 n62 ns591 0 -0.00233910609286
Gc31_592 0 n62 ns592 0 -0.00046200026638
Gc31_593 0 n62 ns593 0 -0.00163750916663
Gc31_594 0 n62 ns594 0 -0.000699333307198
Gc31_595 0 n62 ns595 0 -0.000723848886672
Gc31_596 0 n62 ns596 0 -0.00152377667598
Gc31_597 0 n62 ns597 0 0.00301324208154
Gc31_598 0 n62 ns598 0 0.000147243416739
Gc31_599 0 n62 ns599 0 0.00132042319296
Gc31_600 0 n62 ns600 0 -0.000893169223654
Gc31_601 0 n62 ns601 0 -0.000744838525601
Gc31_602 0 n62 ns602 0 -0.00158387591774
Gc31_603 0 n62 ns603 0 0.00293290058875
Gc31_604 0 n62 ns604 0 0.000256368125931
Gc31_605 0 n62 ns605 0 -0.00312951489964
Gc31_606 0 n62 ns606 0 -3.05121828685e-05
Gc31_607 0 n62 ns607 0 0.000390493485254
Gc31_608 0 n62 ns608 0 -0.000224647535188
Gc31_609 0 n62 ns609 0 5.81576525004e-05
Gc31_610 0 n62 ns610 0 0.000243381523212
Gc31_611 0 n62 ns611 0 0.000236861178112
Gc31_612 0 n62 ns612 0 -0.000528743367769
Gc31_613 0 n62 ns613 0 -9.32683920016e-05
Gc31_614 0 n62 ns614 0 -2.7658475548e-05
Gc31_615 0 n62 ns615 0 0.000100979208382
Gc31_616 0 n62 ns616 0 2.93549728034e-05
Gc31_617 0 n62 ns617 0 0.000197038765472
Gc31_618 0 n62 ns618 0 -1.38261068081e-05
Gc31_619 0 n62 ns619 0 -5.52924549124e-05
Gc31_620 0 n62 ns620 0 -1.89046665228e-06
Gc31_621 0 n62 ns621 0 -0.000186430943531
Gc31_622 0 n62 ns622 0 2.57720260644e-05
Gc31_623 0 n62 ns623 0 -0.000406061907439
Gc31_624 0 n62 ns624 0 -0.000112138407066
Gc31_625 0 n62 ns625 0 -0.000353637630908
Gc31_626 0 n62 ns626 0 6.20057534936e-05
Gc31_627 0 n62 ns627 0 -0.000436140468256
Gc31_628 0 n62 ns628 0 6.40108124877e-05
Gc31_629 0 n62 ns629 0 0.000245249423374
Gc31_630 0 n62 ns630 0 -0.000251325622435
Gc31_631 0 n62 ns631 0 0.000810895910484
Gc31_632 0 n62 ns632 0 -0.00165541974762
Gc31_633 0 n62 ns633 0 0.000689814990409
Gc31_634 0 n62 ns634 0 -0.00145804663912
Gc31_635 0 n62 ns635 0 3.94031096051e-05
Gc31_636 0 n62 ns636 0 9.14752425743e-05
Gc31_637 0 n62 ns637 0 -0.000102987125294
Gc31_638 0 n62 ns638 0 -4.71772229369e-05
Gc31_639 0 n62 ns639 0 -0.000329331100017
Gc31_640 0 n62 ns640 0 2.99401767547e-05
Gc31_641 0 n62 ns641 0 -0.000118306212343
Gc31_642 0 n62 ns642 0 0.000339058886489
Gc31_643 0 n62 ns643 0 0.000133986768944
Gc31_644 0 n62 ns644 0 -1.04228522561e-05
Gc31_645 0 n62 ns645 0 6.25764122026e-06
Gc31_646 0 n62 ns646 0 -2.20710643168e-05
Gc31_647 0 n62 ns647 0 0.000160089636753
Gc31_648 0 n62 ns648 0 0.000351650280747
Gc31_649 0 n62 ns649 0 0.000719785423341
Gc31_650 0 n62 ns650 0 -0.000118336754976
Gc31_651 0 n62 ns651 0 2.33316968656e-05
Gc31_652 0 n62 ns652 0 6.5246697587e-05
Gc31_653 0 n62 ns653 0 2.38796170557e-05
Gc31_654 0 n62 ns654 0 -3.81411099267e-07
Gc31_655 0 n62 ns655 0 0.000276668705699
Gc31_656 0 n62 ns656 0 6.38111758259e-05
Gc31_657 0 n62 ns657 0 -6.2135262725e-05
Gc31_658 0 n62 ns658 0 -3.68209037154e-05
Gc31_659 0 n62 ns659 0 -0.000294718495347
Gc31_660 0 n62 ns660 0 -0.0001188960627
Gc31_661 0 n62 ns661 0 -0.000403446115334
Gc31_662 0 n62 ns662 0 -0.000387166972972
Gc31_663 0 n62 ns663 0 -0.000402218822893
Gc31_664 0 n62 ns664 0 -0.000127362425796
Gc31_665 0 n62 ns665 0 -0.000445984077003
Gc31_666 0 n62 ns666 0 -0.00020302322562
Gc31_667 0 n62 ns667 0 0.000466864034451
Gc31_668 0 n62 ns668 0 -4.79348849438e-05
Gc31_669 0 n62 ns669 0 0.00159210877034
Gc31_670 0 n62 ns670 0 -0.00138087598967
Gc31_671 0 n62 ns671 0 0.00136508106958
Gc31_672 0 n62 ns672 0 -0.00125914850204
Gc31_673 0 n62 ns673 0 0.000320757798386
Gc31_674 0 n62 ns674 0 0.000264205075595
Gc31_675 0 n62 ns675 0 -0.000167467502409
Gc31_676 0 n62 ns676 0 -8.83627589439e-05
Gc31_677 0 n62 ns677 0 -0.00063656925322
Gc31_678 0 n62 ns678 0 -0.000169981330278
Gc31_679 0 n62 ns679 0 -0.000248068613304
Gc31_680 0 n62 ns680 0 6.40226339321e-05
Gc31_681 0 n62 ns681 0 9.01951477556e-05
Gc31_682 0 n62 ns682 0 8.38783709436e-06
Gc31_683 0 n62 ns683 0 -2.59208871673e-05
Gc31_684 0 n62 ns684 0 -6.95660997447e-06
Gc31_685 0 n62 ns685 0 0.000102992178301
Gc31_686 0 n62 ns686 0 0.000523887794478
Gc31_687 0 n62 ns687 0 0.000663270052477
Gc31_688 0 n62 ns688 0 0.00112720080742
Gc31_689 0 n62 ns689 0 -2.74790277068e-05
Gc31_690 0 n62 ns690 0 0.000178443444304
Gc31_691 0 n62 ns691 0 -7.2492804498e-06
Gc31_692 0 n62 ns692 0 -5.56161919603e-05
Gc31_693 0 n62 ns693 0 0.000122927077833
Gc31_694 0 n62 ns694 0 0.000477381494108
Gc31_695 0 n62 ns695 0 1.05665148186e-05
Gc31_696 0 n62 ns696 0 -0.000148410438509
Gc31_697 0 n62 ns697 0 -0.000148885270866
Gc31_698 0 n62 ns698 0 -0.000562576295141
Gc31_699 0 n62 ns699 0 0.000317198598018
Gc31_700 0 n62 ns700 0 -0.000951722973672
Gc31_701 0 n62 ns701 0 -0.000110597407117
Gc31_702 0 n62 ns702 0 -0.000727416105914
Gc31_703 0 n62 ns703 0 4.81979165232e-05
Gc31_704 0 n62 ns704 0 -0.000859664668008
Gc31_705 0 n62 ns705 0 0.000599128918676
Gc31_706 0 n62 ns706 0 0.000877195388769
Gc31_707 0 n62 ns707 0 0.00371257329047
Gc31_708 0 n62 ns708 0 0.00101387489379
Gc31_709 0 n62 ns709 0 0.00330232564016
Gc31_710 0 n62 ns710 0 0.000712203269968
Gc31_711 0 n62 ns711 0 0.000845147990965
Gc31_712 0 n62 ns712 0 0.00105224064055
Gc31_713 0 n62 ns713 0 -0.000329973684864
Gc31_714 0 n62 ns714 0 -0.000307318975195
Gc31_715 0 n62 ns715 0 -0.00136710475475
Gc31_716 0 n62 ns716 0 -0.00107083826848
Gc31_717 0 n62 ns717 0 -0.00055091161278
Gc31_718 0 n62 ns718 0 -0.000876697359944
Gc31_719 0 n62 ns719 0 -7.86605049708e-05
Gc31_720 0 n62 ns720 0 3.1278619744e-05
Gc31_721 0 n62 ns721 0 -6.08143964994e-05
Gc31_722 0 n62 ns722 0 3.52457480019e-07
Gc31_723 0 n62 ns723 0 -0.000380701074578
Gc31_724 0 n62 ns724 0 0.000292675091194
Gc31_725 0 n62 ns725 0 -0.000888601015893
Gc31_726 0 n62 ns726 0 0.000868370337528
Gc31_727 0 n62 ns727 0 -0.000234068575042
Gc31_728 0 n62 ns728 0 0.000130587187735
Gc31_729 0 n62 ns729 0 0.000169016653787
Gc31_730 0 n62 ns730 0 -0.000151504736183
Gc31_731 0 n62 ns731 0 -0.000304351545874
Gc31_732 0 n62 ns732 0 0.000257978839915
Gc31_733 0 n62 ns733 0 0.000105852774239
Gc31_734 0 n62 ns734 0 -0.00014368146774
Gc31_735 0 n62 ns735 0 6.035774671e-05
Gc31_736 0 n62 ns736 0 -0.000263915388621
Gc31_737 0 n62 ns737 0 0.000835974657566
Gc31_738 0 n62 ns738 0 4.8771801982e-05
Gc31_739 0 n62 ns739 0 0.000306611315521
Gc31_740 0 n62 ns740 0 -0.000544576598037
Gc31_741 0 n62 ns741 0 0.000226159021107
Gc31_742 0 n62 ns742 0 -0.000337185078752
Gc31_743 0 n62 ns743 0 -0.000505124256104
Gc31_744 0 n62 ns744 0 0.000584742440597
Gc31_745 0 n62 ns745 0 0.00291777473549
Gc31_746 0 n62 ns746 0 0.00298601566455
Gc31_747 0 n62 ns747 0 0.00286440278003
Gc31_748 0 n62 ns748 0 0.00258287584928
Gc31_749 0 n62 ns749 0 -0.000174794223967
Gc31_750 0 n62 ns750 0 0.00126266226257
Gc31_751 0 n62 ns751 0 -0.000310045176625
Gc31_752 0 n62 ns752 0 -0.000561269591206
Gc31_753 0 n62 ns753 0 -0.00101942391958
Gc31_754 0 n62 ns754 0 -0.00134611654852
Gc31_755 0 n62 ns755 0 -0.000528180674329
Gc31_756 0 n62 ns756 0 6.96244201147e-05
Gc31_757 0 n62 ns757 0 0.000223214326788
Gc31_758 0 n62 ns758 0 1.20125633448e-06
Gc31_759 0 n62 ns759 0 -1.73213083986e-05
Gc31_760 0 n62 ns760 0 -4.48334691023e-05
Gc31_761 0 n62 ns761 0 -6.58709155569e-05
Gc31_762 0 n62 ns762 0 -7.77299368597e-05
Gc31_763 0 n62 ns763 0 0.000101953021198
Gc31_764 0 n62 ns764 0 0.000377793507291
Gc31_765 0 n62 ns765 0 8.74282450269e-05
Gc31_766 0 n62 ns766 0 9.93490663075e-05
Gc31_767 0 n62 ns767 0 3.12903976849e-05
Gc31_768 0 n62 ns768 0 8.90871917477e-05
Gc31_769 0 n62 ns769 0 -5.33450938302e-05
Gc31_770 0 n62 ns770 0 -0.000202226939591
Gc31_771 0 n62 ns771 0 0.000167219447352
Gc31_772 0 n62 ns772 0 -0.00011259294619
Gc31_773 0 n62 ns773 0 -0.000196963785931
Gc31_774 0 n62 ns774 0 -0.000318470828402
Gc31_775 0 n62 ns775 0 -0.000307684160111
Gc31_776 0 n62 ns776 0 0.000500111302159
Gc31_777 0 n62 ns777 0 0.000232634124108
Gc31_778 0 n62 ns778 0 -0.000424893752913
Gc31_779 0 n62 ns779 0 -0.000346388111279
Gc31_780 0 n62 ns780 0 -0.000503595234277
Gc31_781 0 n62 ns781 0 -9.76558586205e-05
Gc31_782 0 n62 ns782 0 -0.000809869138726
Gc31_783 0 n62 ns783 0 0.00224105201094
Gc31_784 0 n62 ns784 0 0.00324907428231
Gc31_785 0 n62 ns785 0 0.00229863839282
Gc31_786 0 n62 ns786 0 0.00326929815543
Gc31_787 0 n62 ns787 0 -0.00174421381488
Gc31_788 0 n62 ns788 0 -5.3251967311e-05
Gc31_789 0 n62 ns789 0 4.41183326269e-05
Gc31_790 0 n62 ns790 0 -0.000905544482498
Gc31_791 0 n62 ns791 0 3.50833105385e-05
Gc31_792 0 n62 ns792 0 -0.00112782119149
Gc31_793 0 n62 ns793 0 -0.000709498376996
Gc31_794 0 n62 ns794 0 0.0017190924589
Gc31_795 0 n62 ns795 0 0.000859894015545
Gc31_796 0 n62 ns796 0 1.96710803178e-05
Gc31_797 0 n62 ns797 0 -0.000157863017147
Gc31_798 0 n62 ns798 0 2.59793777135e-05
Gc31_799 0 n62 ns799 0 0.000646025575796
Gc31_800 0 n62 ns800 0 -0.00187428366185
Gc31_801 0 n62 ns801 0 0.00178120437722
Gc31_802 0 n62 ns802 0 -0.00123991308243
Gc31_803 0 n62 ns803 0 -0.000332382244015
Gc31_804 0 n62 ns804 0 7.2331998534e-05
Gc31_805 0 n62 ns805 0 -0.000131750825461
Gc31_806 0 n62 ns806 0 -0.000132205109551
Gc31_807 0 n62 ns807 0 0.000247569873837
Gc31_808 0 n62 ns808 0 -3.9563350402e-05
Gc31_809 0 n62 ns809 0 0.000212595051225
Gc31_810 0 n62 ns810 0 -4.93794916502e-05
Gc31_811 0 n62 ns811 0 2.57112747717e-05
Gc31_812 0 n62 ns812 0 9.77646286319e-05
Gc31_813 0 n62 ns813 0 -0.000353713926663
Gc31_814 0 n62 ns814 0 -0.000812899732481
Gc31_815 0 n62 ns815 0 0.000583938488649
Gc31_816 0 n62 ns816 0 -0.000712614553216
Gc31_817 0 n62 ns817 0 0.000118527927768
Gc31_818 0 n62 ns818 0 -0.00126531218018
Gc31_819 0 n62 ns819 0 0.0017897413884
Gc31_820 0 n62 ns820 0 0.000197260279741
Gc31_821 0 n62 ns821 0 0.00296209064148
Gc31_822 0 n62 ns822 0 0.00424436195893
Gc31_823 0 n62 ns823 0 0.00253666682063
Gc31_824 0 n62 ns824 0 0.00447285244675
Gc31_825 0 n62 ns825 0 -8.63761473835e-05
Gc31_826 0 n62 ns826 0 -0.00189717357962
Gc31_827 0 n62 ns827 0 0.00067694684455
Gc31_828 0 n62 ns828 0 -0.0010715451159
Gc31_829 0 n62 ns829 0 1.75540174714e-05
Gc31_830 0 n62 ns830 0 -0.000644294309721
Gc31_831 0 n62 ns831 0 -0.0022375420583
Gc31_832 0 n62 ns832 0 0.00220048444887
Gc31_833 0 n62 ns833 0 0.00197853948402
Gc31_834 0 n62 ns834 0 2.10997499294e-05
Gc31_835 0 n62 ns835 0 -0.000210706895776
Gc31_836 0 n62 ns836 0 6.14610550113e-05
Gc31_837 0 n62 ns837 0 0.00111459744575
Gc31_838 0 n62 ns838 0 -0.00495081722072
Gc31_839 0 n62 ns839 0 0.000927436975097
Gc31_840 0 n62 ns840 0 -0.00367820232976
Gc31_841 0 n62 ns841 0 -0.00117255031096
Gc31_842 0 n62 ns842 0 -0.000729599276932
Gc31_843 0 n62 ns843 0 0.000609420547993
Gc31_844 0 n62 ns844 0 -0.000111207810943
Gc31_845 0 n62 ns845 0 -0.000115277220021
Gc31_846 0 n62 ns846 0 0.000205573803025
Gc31_847 0 n62 ns847 0 0.000281940144447
Gc31_848 0 n62 ns848 0 5.35326089218e-05
Gc31_849 0 n62 ns849 0 -0.000360202286767
Gc31_850 0 n62 ns850 0 0.000641304621598
Gc31_851 0 n62 ns851 0 0.000689013730503
Gc31_852 0 n62 ns852 0 2.91524314754e-06
Gc31_853 0 n62 ns853 0 0.000948530450143
Gc31_854 0 n62 ns854 0 -5.18128460647e-05
Gc31_855 0 n62 ns855 0 0.000331306674475
Gc31_856 0 n62 ns856 0 -0.000588344218925
Gc31_857 0 n62 ns857 0 0.000290232617509
Gc31_858 0 n62 ns858 0 0.00132482647575
Gc31_859 0 n62 ns859 0 0.00354804890932
Gc31_860 0 n62 ns860 0 0.00634577660152
Gc31_861 0 n62 ns861 0 0.00251178541077
Gc31_862 0 n62 ns862 0 0.00633014621137
Gc31_863 0 n62 ns863 0 0.00206709309576
Gc31_864 0 n62 ns864 0 0.00177110681721
Gc31_865 0 n62 ns865 0 0.00107683163515
Gc31_866 0 n62 ns866 0 -0.00094150950695
Gc31_867 0 n62 ns867 0 -0.00347327265467
Gc31_868 0 n62 ns868 0 -0.0011544422046
Gc31_869 0 n62 ns869 0 -0.000460974469755
Gc31_870 0 n62 ns870 0 -0.00198831974728
Gc31_871 0 n62 ns871 0 0.00383570174468
Gc31_872 0 n62 ns872 0 2.07970575427e-06
Gc31_873 0 n62 ns873 0 -9.62167752328e-05
Gc31_874 0 n62 ns874 0 -1.42619433838e-05
Gc31_875 0 n62 ns875 0 0.00109912837755
Gc31_876 0 n62 ns876 0 -0.00433885195694
Gc31_877 0 n62 ns877 0 -0.000207998274317
Gc31_878 0 n62 ns878 0 -0.00208458001959
Gc31_879 0 n62 ns879 0 -0.000941780505518
Gc31_880 0 n62 ns880 0 -0.000258423848487
Gc31_881 0 n62 ns881 0 0.000604718484761
Gc31_882 0 n62 ns882 0 -3.14922880435e-06
Gc31_883 0 n62 ns883 0 0.000273474207091
Gc31_884 0 n62 ns884 0 3.07088463955e-05
Gc31_885 0 n62 ns885 0 0.000233054686342
Gc31_886 0 n62 ns886 0 0.000120928380601
Gc31_887 0 n62 ns887 0 -0.000562822003421
Gc31_888 0 n62 ns888 0 -0.000108128509756
Gc31_889 0 n62 ns889 0 -0.00063956756129
Gc31_890 0 n62 ns890 0 0.000560072884753
Gc31_891 0 n62 ns891 0 0.000308754098168
Gc31_892 0 n62 ns892 0 0.000317586075022
Gc31_893 0 n62 ns893 0 -0.000535660557619
Gc31_894 0 n62 ns894 0 -0.000642649461994
Gc31_895 0 n62 ns895 0 -0.000463459626062
Gc31_896 0 n62 ns896 0 -0.000806459526633
Gc31_897 0 n62 ns897 0 0.00313744675625
Gc31_898 0 n62 ns898 0 0.00516766962767
Gc31_899 0 n62 ns899 0 0.00183152818957
Gc31_900 0 n62 ns900 0 0.00533952533499
Gc31_901 0 n62 ns901 0 -0.000183351803173
Gc31_902 0 n62 ns902 0 0.00452660039781
Gc31_903 0 n62 ns903 0 0.00116043004997
Gc31_904 0 n62 ns904 0 -0.000838202889329
Gc31_905 0 n62 ns905 0 -0.00522688868528
Gc31_906 0 n62 ns906 0 -0.00148866791901
Gc31_907 0 n62 ns907 0 0.00350566036024
Gc31_908 0 n62 ns908 0 -0.00468171107635
Gc31_909 0 n62 ns909 0 0.00467977696453
Gc31_910 0 n62 ns910 0 -7.6165892045e-06
Gc31_911 0 n62 ns911 0 -5.7171421872e-05
Gc31_912 0 n62 ns912 0 -2.91175838908e-05
Gc31_913 0 n62 ns913 0 0.000659735559214
Gc31_914 0 n62 ns914 0 -0.00189661444169
Gc31_915 0 n62 ns915 0 0.00132827798754
Gc31_916 0 n62 ns916 0 -0.00162558975306
Gc31_917 0 n62 ns917 0 -0.00100238504016
Gc31_918 0 n62 ns918 0 -0.000194524838337
Gc31_919 0 n62 ns919 0 0.000160413616345
Gc31_920 0 n62 ns920 0 -0.000147405515838
Gc31_921 0 n62 ns921 0 0.000523550196158
Gc31_922 0 n62 ns922 0 0.000331258746538
Gc31_923 0 n62 ns923 0 0.000132275630183
Gc31_924 0 n62 ns924 0 0.000104751140045
Gc31_925 0 n62 ns925 0 0.000368201212061
Gc31_926 0 n62 ns926 0 0.000407699644433
Gc31_927 0 n62 ns927 0 -0.00023123241795
Gc31_928 0 n62 ns928 0 -0.00151989231719
Gc31_929 0 n62 ns929 0 0.000577892876426
Gc31_930 0 n62 ns930 0 -0.000115736228841
Gc31_931 0 n62 ns931 0 0.000573810313945
Gc31_932 0 n62 ns932 0 -0.000632103048057
Gc31_933 0 n62 ns933 0 0.00228402064704
Gc31_934 0 n62 ns934 0 0.00126277548726
Gc31_935 0 n62 ns935 0 -0.000627275938743
Gc31_936 0 n62 ns936 0 0.0017964427831
Gc31_937 0 n62 ns937 0 -0.00103673398011
Gc31_938 0 n62 ns938 0 0.00228862869409
Gc31_939 0 n62 ns939 0 0.00233010371033
Gc31_940 0 n62 ns940 0 -0.00297769274532
Gc31_941 0 n62 ns941 0 0.00117215155268
Gc31_942 0 n62 ns942 0 -0.000572863274992
Gc31_943 0 n62 ns943 0 0.000115994345377
Gc31_944 0 n62 ns944 0 0.000596581801809
Gc31_945 0 n62 ns945 0 -0.00310901884962
Gc31_946 0 n62 ns946 0 0.00208969532766
Gc31_947 0 n62 ns947 0 0.00260742913285
Gc31_948 0 n62 ns948 0 2.54162116539e-05
Gc31_949 0 n62 ns949 0 -0.000182596594613
Gc31_950 0 n62 ns950 0 3.50313956259e-05
Gc31_951 0 n62 ns951 0 0.000209603513961
Gc31_952 0 n62 ns952 0 0.000496844994971
Gc31_953 0 n62 ns953 0 0.000955223937111
Gc31_954 0 n62 ns954 0 0.000822590582864
Gc31_955 0 n62 ns955 0 3.70345168335e-05
Gc31_956 0 n62 ns956 0 0.000213267115733
Gc31_957 0 n62 ns957 0 -1.77530093985e-05
Gc31_958 0 n62 ns958 0 -6.61953343074e-05
Gc31_959 0 n62 ns959 0 0.000268272596258
Gc31_960 0 n62 ns960 0 0.000310437611062
Gc31_961 0 n62 ns961 0 -2.92179547978e-05
Gc31_962 0 n62 ns962 0 -0.000101853972622
Gc31_963 0 n62 ns963 0 -0.000257492452881
Gc31_964 0 n62 ns964 0 -0.000452752250604
Gc31_965 0 n62 ns965 0 -3.5394155437e-05
Gc31_966 0 n62 ns966 0 -0.000862013522031
Gc31_967 0 n62 ns967 0 -0.000259225332396
Gc31_968 0 n62 ns968 0 -0.000539786628467
Gc31_969 0 n62 ns969 0 -0.000152857252852
Gc31_970 0 n62 ns970 0 -0.000709760823184
Gc31_971 0 n62 ns971 0 0.000684131143275
Gc31_972 0 n62 ns972 0 0.000570715339376
Gc31_973 0 n62 ns973 0 0.00299786230526
Gc31_974 0 n62 ns974 0 4.25139834859e-05
Gc31_975 0 n62 ns975 0 0.00262149531995
Gc31_976 0 n62 ns976 0 -0.000104009434657
Gc31_977 0 n62 ns977 0 0.00078244651036
Gc31_978 0 n62 ns978 0 0.000782579675804
Gc31_979 0 n62 ns979 0 -0.000277502383663
Gc31_980 0 n62 ns980 0 -0.000219262854212
Gc31_981 0 n62 ns981 0 -0.00117234991883
Gc31_982 0 n62 ns982 0 -0.000783902418229
Gc31_983 0 n62 ns983 0 -0.000467808790627
Gc31_984 0 n62 ns984 0 -0.000693978939566
Gc31_985 0 n62 ns985 0 -5.955530558e-05
Gc31_986 0 n62 ns986 0 2.6350970963e-05
Gc31_987 0 n62 ns987 0 -6.0363290448e-05
Gc31_988 0 n62 ns988 0 1.52823555667e-05
Gc31_989 0 n62 ns989 0 -0.00033568322582
Gc31_990 0 n62 ns990 0 0.000607401741146
Gc31_991 0 n62 ns991 0 -0.000697595412308
Gc31_992 0 n62 ns992 0 0.00145532276233
Gc31_993 0 n62 ns993 0 -0.000222794640973
Gc31_994 0 n62 ns994 0 0.000344102712672
Gc31_995 0 n62 ns995 0 9.41502341748e-05
Gc31_996 0 n62 ns996 0 -0.000246133220072
Gc31_997 0 n62 ns997 0 -0.000133784466031
Gc31_998 0 n62 ns998 0 0.00044804117449
Gc31_999 0 n62 ns999 0 7.55649293604e-05
Gc31_1000 0 n62 ns1000 0 -0.000156652318725
Gc31_1001 0 n62 ns1001 0 4.77717876501e-05
Gc31_1002 0 n62 ns1002 0 -0.000477908073963
Gc31_1003 0 n62 ns1003 0 0.000819861182076
Gc31_1004 0 n62 ns1004 0 -0.000480521160534
Gc31_1005 0 n62 ns1005 0 0.000211217145888
Gc31_1006 0 n62 ns1006 0 -0.000681279811989
Gc31_1007 0 n62 ns1007 0 0.000316709575228
Gc31_1008 0 n62 ns1008 0 -0.000595743752523
Gc31_1009 0 n62 ns1009 0 -0.000106787490316
Gc31_1010 0 n62 ns1010 0 0.000947061545177
Gc31_1011 0 n62 ns1011 0 0.00327795663486
Gc31_1012 0 n62 ns1012 0 0.00256343234922
Gc31_1013 0 n62 ns1013 0 0.00308078668552
Gc31_1014 0 n62 ns1014 0 0.00211070495874
Gc31_1015 0 n62 ns1015 0 0.00040291151156
Gc31_1016 0 n62 ns1016 0 0.00138146520584
Gc31_1017 0 n62 ns1017 0 -0.000349022054513
Gc31_1018 0 n62 ns1018 0 -0.000470214210434
Gc31_1019 0 n62 ns1019 0 -0.0012979692305
Gc31_1020 0 n62 ns1020 0 -0.00139785539268
Gc31_1021 0 n62 ns1021 0 -0.000559110220084
Gc31_1022 0 n62 ns1022 0 -0.000555526708188
Gc31_1023 0 n62 ns1023 0 3.17708192712e-05
Gc31_1024 0 n62 ns1024 0 8.77823605403e-07
Gc31_1025 0 n62 ns1025 0 -5.55298361446e-06
Gc31_1026 0 n62 ns1026 0 -3.79750493201e-05
Gc31_1027 0 n62 ns1027 0 -0.000189993336813
Gc31_1028 0 n62 ns1028 0 4.91157167691e-05
Gc31_1029 0 n62 ns1029 0 -0.000248924238051
Gc31_1030 0 n62 ns1030 0 0.000551941989233
Gc31_1031 0 n62 ns1031 0 -1.6309716371e-05
Gc31_1032 0 n62 ns1032 0 6.88052006431e-05
Gc31_1033 0 n62 ns1033 0 0.000155814369806
Gc31_1034 0 n62 ns1034 0 -1.08083090066e-05
Gc31_1035 0 n62 ns1035 0 -0.000180405938475
Gc31_1036 0 n62 ns1036 0 -7.14809475732e-05
Gc31_1037 0 n62 ns1037 0 0.000130556410293
Gc31_1038 0 n62 ns1038 0 -0.000133041632275
Gc31_1039 0 n62 ns1039 0 -0.000221763178281
Gc31_1040 0 n62 ns1040 0 -0.000258110591492
Gc31_1041 0 n62 ns1041 0 0.000159467684059
Gc31_1042 0 n62 ns1042 0 0.000546948607679
Gc31_1043 0 n62 ns1043 0 0.000241547497807
Gc31_1044 0 n62 ns1044 0 -0.000397564556072
Gc31_1045 0 n62 ns1045 0 -0.000188373408811
Gc31_1046 0 n62 ns1046 0 -0.000308539380439
Gc31_1047 0 n62 ns1047 0 -0.000508805655067
Gc31_1048 0 n62 ns1048 0 -0.000367348260107
Gc31_1049 0 n62 ns1049 0 0.00229194970363
Gc31_1050 0 n62 ns1050 0 0.00317753021229
Gc31_1051 0 n62 ns1051 0 0.00237149276792
Gc31_1052 0 n62 ns1052 0 0.00301890882101
Gc31_1053 0 n62 ns1053 0 -0.00130292042574
Gc31_1054 0 n62 ns1054 0 0.00068223643964
Gc31_1055 0 n62 ns1055 0 -0.000123585221808
Gc31_1056 0 n62 ns1056 0 -0.000792540814748
Gc31_1057 0 n62 ns1057 0 -0.000347287985338
Gc31_1058 0 n62 ns1058 0 -0.00136140867122
Gc31_1059 0 n62 ns1059 0 -0.000578748027443
Gc31_1060 0 n62 ns1060 0 0.000991997254276
Gc31_1061 0 n62 ns1061 0 0.000554823967794
Gc31_1062 0 n62 ns1062 0 5.00894263111e-06
Gc31_1063 0 n62 ns1063 0 -9.58939536413e-05
Gc31_1064 0 n62 ns1064 0 -3.8848592749e-06
Gc31_1065 0 n62 ns1065 0 0.000334334701934
Gc31_1066 0 n62 ns1066 0 -0.000806458852974
Gc31_1067 0 n62 ns1067 0 0.00112779587074
Gc31_1068 0 n62 ns1068 0 -7.43836828906e-05
Gc31_1069 0 n62 ns1069 0 -9.59418892922e-05
Gc31_1070 0 n62 ns1070 0 0.000342124585556
Gc31_1071 0 n62 ns1071 0 -0.000157368505465
Gc31_1072 0 n62 ns1072 0 -0.000100348897441
Gc31_1073 0 n62 ns1073 0 0.000248374924609
Gc31_1074 0 n62 ns1074 0 -0.000167797107164
Gc31_1075 0 n62 ns1075 0 0.000184249592223
Gc31_1076 0 n62 ns1076 0 -8.2662334646e-05
Gc31_1077 0 n62 ns1077 0 2.65728421725e-05
Gc31_1078 0 n62 ns1078 0 -0.000259656870469
Gc31_1079 0 n62 ns1079 0 -0.000591611437454
Gc31_1080 0 n62 ns1080 0 -0.000443268251152
Gc31_1081 0 n62 ns1081 0 0.000385524650949
Gc31_1082 0 n62 ns1082 0 -0.0007051192113
Gc31_1083 0 n62 ns1083 0 -7.2116288005e-05
Gc31_1084 0 n62 ns1084 0 -0.00116518543987
Gc31_1085 0 n62 ns1085 0 0.00131872537268
Gc31_1086 0 n62 ns1086 0 -0.000466471725621
Gc31_1087 0 n62 ns1087 0 0.00258374886614
Gc31_1088 0 n62 ns1088 0 0.00394049490514
Gc31_1089 0 n62 ns1089 0 0.00235694520627
Gc31_1090 0 n62 ns1090 0 0.00408535988133
Gc31_1091 0 n62 ns1091 0 -0.00115349921337
Gc31_1092 0 n62 ns1092 0 -0.00152848634836
Gc31_1093 0 n62 ns1093 0 0.000426799443891
Gc31_1094 0 n62 ns1094 0 -0.00105464849767
Gc31_1095 0 n62 ns1095 0 0.000180340130642
Gc31_1096 0 n62 ns1096 0 -0.000791601204621
Gc31_1097 0 n62 ns1097 0 -0.00151356395787
Gc31_1098 0 n62 ns1098 0 0.00242029482819
Gc31_1099 0 n62 ns1099 0 0.00148945715167
Gc31_1100 0 n62 ns1100 0 3.6972648878e-05
Gc31_1101 0 n62 ns1101 0 -0.000251057842598
Gc31_1102 0 n62 ns1102 0 8.83225743293e-05
Gc31_1103 0 n62 ns1103 0 0.000223037015453
Gc31_1104 0 n62 ns1104 0 -0.0023765017953
Gc31_1105 0 n62 ns1105 0 2.70665788246e-05
Gc31_1106 0 n62 ns1106 0 -0.000870047364984
Gc31_1107 0 n62 ns1107 0 -0.000830159533216
Gc31_1108 0 n62 ns1108 0 0.000196950817983
Gc31_1109 0 n62 ns1109 0 0.000272036604886
Gc31_1110 0 n62 ns1110 0 -0.000487883939489
Gc31_1111 0 n62 ns1111 0 1.44293316999e-05
Gc31_1112 0 n62 ns1112 0 0.000230817415613
Gc31_1113 0 n62 ns1113 0 0.000287567059527
Gc31_1114 0 n62 ns1114 0 1.38225436247e-05
Gc31_1115 0 n62 ns1115 0 -0.000135529346186
Gc31_1116 0 n62 ns1116 0 0.00030230056081
Gc31_1117 0 n62 ns1117 0 0.00102947216911
Gc31_1118 0 n62 ns1118 0 -0.000406690870701
Gc31_1119 0 n62 ns1119 0 0.00116810393023
Gc31_1120 0 n62 ns1120 0 -0.000224900039731
Gc31_1121 0 n62 ns1121 0 0.000755193419763
Gc31_1122 0 n62 ns1122 0 -0.000554466961713
Gc31_1123 0 n62 ns1123 0 0.000370516214377
Gc31_1124 0 n62 ns1124 0 0.00212274818606
Gc31_1125 0 n62 ns1125 0 0.00158187111931
Gc31_1126 0 n62 ns1126 0 0.00552744898899
Gc31_1127 0 n62 ns1127 0 0.00112463922157
Gc31_1128 0 n62 ns1128 0 0.00562642340671
Gc31_1129 0 n62 ns1129 0 0.00317248797814
Gc31_1130 0 n62 ns1130 0 0.00038828702051
Gc31_1131 0 n62 ns1131 0 0.000986336571853
Gc31_1132 0 n62 ns1132 0 -0.000998954500421
Gc31_1133 0 n62 ns1133 0 -0.00147530745709
Gc31_1134 0 n62 ns1134 0 -0.0013248744667
Gc31_1135 0 n62 ns1135 0 -0.00376851450381
Gc31_1136 0 n62 ns1136 0 -0.000108541713431
Gc31_1137 0 n62 ns1137 0 0.00311374014586
Gc31_1138 0 n62 ns1138 0 3.04710574152e-05
Gc31_1139 0 n62 ns1139 0 -0.000150443666789
Gc31_1140 0 n62 ns1140 0 9.03441957519e-06
Gc31_1141 0 n62 ns1141 0 0.000413403501273
Gc31_1142 0 n62 ns1142 0 -0.00265530282944
Gc31_1143 0 n62 ns1143 0 -0.00162325873929
Gc31_1144 0 n62 ns1144 0 -0.000255998118926
Gc31_1145 0 n62 ns1145 0 -0.000538795975524
Gc31_1146 0 n62 ns1146 0 0.000114697931533
Gc31_1147 0 n62 ns1147 0 0.000423090533161
Gc31_1148 0 n62 ns1148 0 -0.000214594115951
Gc31_1149 0 n62 ns1149 0 6.30791303855e-05
Gc31_1150 0 n62 ns1150 0 -4.50409387408e-05
Gc31_1151 0 n62 ns1151 0 0.000268869347786
Gc31_1152 0 n62 ns1152 0 0.000114032164925
Gc31_1153 0 n62 ns1153 0 -0.000683338609119
Gc31_1154 0 n62 ns1154 0 -0.00013304745372
Gc31_1155 0 n62 ns1155 0 -6.62311090935e-05
Gc31_1156 0 n62 ns1156 0 0.00100387094945
Gc31_1157 0 n62 ns1157 0 0.000469946882991
Gc31_1158 0 n62 ns1158 0 0.000413448309853
Gc31_1159 0 n62 ns1159 0 -0.00050051162221
Gc31_1160 0 n62 ns1160 0 -0.000385367518238
Gc31_1161 0 n62 ns1161 0 -0.00124269010295
Gc31_1162 0 n62 ns1162 0 -0.000548879639521
Gc31_1163 0 n62 ns1163 0 0.00376540743994
Gc31_1164 0 n62 ns1164 0 0.0047919255565
Gc31_1165 0 n62 ns1165 0 0.00244392888222
Gc31_1166 0 n62 ns1166 0 0.00507033739804
Gc31_1167 0 n62 ns1167 0 2.72466265486e-05
Gc31_1168 0 n62 ns1168 0 0.00496608104223
Gc31_1169 0 n62 ns1169 0 0.00116551499387
Gc31_1170 0 n62 ns1170 0 -0.000804772269957
Gc31_1171 0 n62 ns1171 0 -0.00504943685713
Gc31_1172 0 n62 ns1172 0 -0.00128919699432
Gc31_1173 0 n62 ns1173 0 0.00300289488132
Gc31_1174 0 n62 ns1174 0 -0.0037588180857
Gc31_1175 0 n62 ns1175 0 0.00489652192943
Gc31_1176 0 n62 ns1176 0 -2.7882528781e-05
Gc31_1177 0 n62 ns1177 0 2.77987606113e-05
Gc31_1178 0 n62 ns1178 0 -8.23550509613e-05
Gc31_1179 0 n62 ns1179 0 0.000419948205404
Gc31_1180 0 n62 ns1180 0 -0.00225843044602
Gc31_1181 0 n62 ns1181 0 0.000530826592512
Gc31_1182 0 n62 ns1182 0 -0.000864843635098
Gc31_1183 0 n62 ns1183 0 -0.00096059381797
Gc31_1184 0 n62 ns1184 0 0.000206283793898
Gc31_1185 0 n62 ns1185 0 0.000331624744991
Gc31_1186 0 n62 ns1186 0 -0.000337494915494
Gc31_1187 0 n62 ns1187 0 0.00054862145864
Gc31_1188 0 n62 ns1188 0 0.000293419134081
Gc31_1189 0 n62 ns1189 0 0.000187561030799
Gc31_1190 0 n62 ns1190 0 0.000116541239047
Gc31_1191 0 n62 ns1191 0 -0.000112801946938
Gc31_1192 0 n62 ns1192 0 0.000108197404578
Gc31_1193 0 n62 ns1193 0 2.93268891082e-05
Gc31_1194 0 n62 ns1194 0 -0.000994837167462
Gc31_1195 0 n62 ns1195 0 0.000713966182409
Gc31_1196 0 n62 ns1196 0 0.000104799883342
Gc31_1197 0 n62 ns1197 0 0.000455982426971
Gc31_1198 0 n62 ns1198 0 -0.000508328558698
Gc31_1199 0 n62 ns1199 0 0.00124762133058
Gc31_1200 0 n62 ns1200 0 0.00160100981064
Gc31_1201 0 n62 ns1201 0 -0.000763818552664
Gc31_1202 0 n62 ns1202 0 0.0023681185722
Gc31_1203 0 n62 ns1203 0 -0.00123057322599
Gc31_1204 0 n62 ns1204 0 0.00293678242277
Gc31_1205 0 n62 ns1205 0 0.00341433674109
Gc31_1206 0 n62 ns1206 0 -0.00075945424069
Gc31_1207 0 n62 ns1207 0 0.00128567962722
Gc31_1208 0 n62 ns1208 0 -0.000744063738763
Gc31_1209 0 n62 ns1209 0 -0.000838131276132
Gc31_1210 0 n62 ns1210 0 -0.000458219988557
Gc31_1211 0 n62 ns1211 0 -0.0037142441823
Gc31_1212 0 n62 ns1212 0 0.000106623560626
Gc31_1213 0 n62 ns1213 0 0.0032068959296
Gc31_1214 0 n62 ns1214 0 5.12918008586e-05
Gc31_1215 0 n62 ns1215 0 -0.000225258290992
Gc31_1216 0 n62 ns1216 0 6.96869867349e-05
Gd31_1 0 n62 ni1 0 -0.00044914102487
Gd31_2 0 n62 ni2 0 8.88246537663e-06
Gd31_3 0 n62 ni3 0 0.000841377803605
Gd31_4 0 n62 ni4 0 -0.000698732106759
Gd31_5 0 n62 ni5 0 5.32154810625e-05
Gd31_6 0 n62 ni6 0 0.000719841082061
Gd31_7 0 n62 ni7 0 -0.00237199237434
Gd31_8 0 n62 ni8 0 -0.00328123166608
Gd31_9 0 n62 ni9 0 0.000688621759853
Gd31_10 0 n62 ni10 0 0.00082917874171
Gd31_11 0 n62 ni11 0 -0.000462130097294
Gd31_12 0 n62 ni12 0 -0.000102272926154
Gd31_13 0 n62 ni13 0 0.000815847310309
Gd31_14 0 n62 ni14 0 -0.000447635883654
Gd31_15 0 n62 ni15 0 0.000328410929697
Gd31_16 0 n62 ni16 0 0.000101946684864
Gd31_17 0 n62 ni17 0 -2.1683708907e-05
Gd31_18 0 n62 ni18 0 -3.86588695972e-06
Gd31_19 0 n62 ni19 0 0.000268699969651
Gd31_20 0 n62 ni20 0 0.00060391102102
Gd31_21 0 n62 ni21 0 0.000274423246057
Gd31_22 0 n62 ni22 0 -0.0016372553575
Gd31_23 0 n62 ni23 0 -0.0031601692247
Gd31_24 0 n62 ni24 0 -0.00103457450022
Gd31_25 0 n62 ni25 0 -0.00168938854556
Gd31_26 0 n62 ni26 0 0.000121125549342
Gd31_27 0 n62 ni27 0 0.000719976523598
Gd31_28 0 n62 ni28 0 0.000412669644909
Gd31_29 0 n62 ni29 0 -0.000570989563314
Gd31_30 0 n62 ni30 0 -0.00168122717267
Gd31_31 0 n62 ni31 0 0.000830525930907
Gd31_32 0 n62 ni32 0 -0.00177845463925
Gc32_1 0 n64 ns1 0 0.00011124715777
Gc32_2 0 n64 ns2 0 0.000562834010741
Gc32_3 0 n64 ns3 0 0.000645311243382
Gc32_4 0 n64 ns4 0 0.000779890080683
Gc32_5 0 n64 ns5 0 5.83244905533e-05
Gc32_6 0 n64 ns6 0 0.000257201033754
Gc32_7 0 n64 ns7 0 -1.73701787385e-05
Gc32_8 0 n64 ns8 0 -0.000101928559747
Gc32_9 0 n64 ns9 0 0.000200196333959
Gc32_10 0 n64 ns10 0 0.000250191464909
Gc32_11 0 n64 ns11 0 3.89590330513e-05
Gc32_12 0 n64 ns12 0 -0.000115358820147
Gc32_13 0 n64 ns13 0 -0.000407519819875
Gc32_14 0 n64 ns14 0 -0.000467006302167
Gc32_15 0 n64 ns15 0 -0.000194523435817
Gc32_16 0 n64 ns16 0 -0.0002062858208
Gc32_17 0 n64 ns17 0 -5.06220075942e-05
Gc32_18 0 n64 ns18 0 -4.53282282588e-05
Gc32_19 0 n64 ns19 0 4.39378777776e-05
Gc32_20 0 n64 ns20 0 -0.000120791479374
Gc32_21 0 n64 ns21 0 5.82957929357e-05
Gc32_22 0 n64 ns22 0 0.000545606530344
Gc32_23 0 n64 ns23 0 8.49382545871e-05
Gc32_24 0 n64 ns24 0 0.0022142225405
Gc32_25 0 n64 ns25 0 8.27240804753e-05
Gc32_26 0 n64 ns26 0 0.00187141969293
Gc32_27 0 n64 ns27 0 0.000881955194837
Gc32_28 0 n64 ns28 0 0.000476664449748
Gc32_29 0 n64 ns29 0 -0.000152309926542
Gc32_30 0 n64 ns30 0 -8.37368355502e-05
Gc32_31 0 n64 ns31 0 -0.000811264898132
Gc32_32 0 n64 ns32 0 -0.000529205818389
Gc32_33 0 n64 ns33 0 -0.000207539398619
Gc32_34 0 n64 ns34 0 -0.000897989519518
Gc32_35 0 n64 ns35 0 -0.000240164218427
Gc32_36 0 n64 ns36 0 1.22016145999e-05
Gc32_37 0 n64 ns37 0 -3.52673689701e-05
Gc32_38 0 n64 ns38 0 2.05514071886e-05
Gc32_39 0 n64 ns39 0 0.00015702474098
Gc32_40 0 n64 ns40 0 0.000171012993658
Gc32_41 0 n64 ns41 0 0.000698937408049
Gc32_42 0 n64 ns42 0 -6.73864857257e-05
Gc32_43 0 n64 ns43 0 9.22398472902e-06
Gc32_44 0 n64 ns44 0 -3.12975506219e-05
Gc32_45 0 n64 ns45 0 -3.25515199211e-06
Gc32_46 0 n64 ns46 0 4.61571926035e-05
Gc32_47 0 n64 ns47 0 4.08521489826e-05
Gc32_48 0 n64 ns48 0 0.000213245653712
Gc32_49 0 n64 ns49 0 5.08949647222e-05
Gc32_50 0 n64 ns50 0 -8.74685128699e-05
Gc32_51 0 n64 ns51 0 -0.000281666211175
Gc32_52 0 n64 ns52 0 -0.0003374711074
Gc32_53 0 n64 ns53 0 -0.000286173781044
Gc32_54 0 n64 ns54 0 -9.03752415192e-05
Gc32_55 0 n64 ns55 0 -0.00015207103405
Gc32_56 0 n64 ns56 0 7.39674227824e-05
Gc32_57 0 n64 ns57 0 -0.00011656375567
Gc32_58 0 n64 ns58 0 7.3650512421e-05
Gc32_59 0 n64 ns59 0 -9.05782197458e-05
Gc32_60 0 n64 ns60 0 0.000386641962667
Gc32_61 0 n64 ns61 0 -0.000334112111062
Gc32_62 0 n64 ns62 0 0.00208626645098
Gc32_63 0 n64 ns63 0 -0.00027303603124
Gc32_64 0 n64 ns64 0 0.00178677361616
Gc32_65 0 n64 ns65 0 0.000775719510646
Gc32_66 0 n64 ns66 0 0.000417190672206
Gc32_67 0 n64 ns67 0 -0.000154830383676
Gc32_68 0 n64 ns68 0 -7.35428914735e-05
Gc32_69 0 n64 ns69 0 -0.000748379051984
Gc32_70 0 n64 ns70 0 -0.000417875096816
Gc32_71 0 n64 ns71 0 -0.000158461939014
Gc32_72 0 n64 ns72 0 -0.000740896759657
Gc32_73 0 n64 ns73 0 -0.000209110352357
Gc32_74 0 n64 ns74 0 -1.77663932248e-05
Gc32_75 0 n64 ns75 0 4.55198249769e-06
Gc32_76 0 n64 ns76 0 -6.90220648359e-07
Gc32_77 0 n64 ns77 0 4.2265154431e-05
Gc32_78 0 n64 ns78 0 0.00014169522974
Gc32_79 0 n64 ns79 0 0.000150549082288
Gc32_80 0 n64 ns80 0 -3.17884382054e-05
Gc32_81 0 n64 ns81 0 5.81375292038e-05
Gc32_82 0 n64 ns82 0 9.42095493464e-06
Gc32_83 0 n64 ns83 0 -7.5959538658e-05
Gc32_84 0 n64 ns84 0 -4.73388388018e-05
Gc32_85 0 n64 ns85 0 -0.000252632710968
Gc32_86 0 n64 ns86 0 -5.38653445139e-06
Gc32_87 0 n64 ns87 0 0.000107050811198
Gc32_88 0 n64 ns88 0 2.66869291515e-05
Gc32_89 0 n64 ns89 0 0.00018367674947
Gc32_90 0 n64 ns90 0 -0.000271620723576
Gc32_91 0 n64 ns91 0 -0.000287811580981
Gc32_92 0 n64 ns92 0 -0.000284386916337
Gc32_93 0 n64 ns93 0 -0.000393355445522
Gc32_94 0 n64 ns94 0 3.2073037016e-06
Gc32_95 0 n64 ns95 0 -0.000454403699771
Gc32_96 0 n64 ns96 0 0.000103372902234
Gc32_97 0 n64 ns97 0 -0.000463659264811
Gc32_98 0 n64 ns98 0 7.79428535554e-06
Gc32_99 0 n64 ns99 0 -0.00230847807969
Gc32_100 0 n64 ns100 0 0.00167299021129
Gc32_101 0 n64 ns101 0 -0.00198214312929
Gc32_102 0 n64 ns102 0 0.00149769594539
Gc32_103 0 n64 ns103 0 0.000614391695192
Gc32_104 0 n64 ns104 0 0.000625108162221
Gc32_105 0 n64 ns105 0 -0.000205720849592
Gc32_106 0 n64 ns106 0 -0.000119906716443
Gc32_107 0 n64 ns107 0 -0.000798859398474
Gc32_108 0 n64 ns108 0 -0.00044319103652
Gc32_109 0 n64 ns109 0 -0.000119744691264
Gc32_110 0 n64 ns110 0 -0.000373126146526
Gc32_111 0 n64 ns111 0 -0.000121612879597
Gc32_112 0 n64 ns112 0 -1.47725371141e-05
Gc32_113 0 n64 ns113 0 3.00502020084e-05
Gc32_114 0 n64 ns114 0 -7.24175855668e-07
Gc32_115 0 n64 ns115 0 -0.000525967308586
Gc32_116 0 n64 ns116 0 0.000740481746085
Gc32_117 0 n64 ns117 0 -0.00129655028369
Gc32_118 0 n64 ns118 0 0.00072219316997
Gc32_119 0 n64 ns119 0 -0.00018271575523
Gc32_120 0 n64 ns120 0 0.000365451674049
Gc32_121 0 n64 ns121 0 0.000151947255017
Gc32_122 0 n64 ns122 0 -0.000256973379439
Gc32_123 0 n64 ns123 0 -5.78118281462e-05
Gc32_124 0 n64 ns124 0 -0.000332342601532
Gc32_125 0 n64 ns125 0 3.6833664976e-05
Gc32_126 0 n64 ns126 0 0.000173742330491
Gc32_127 0 n64 ns127 0 0.000591007864469
Gc32_128 0 n64 ns128 0 8.19468869021e-05
Gc32_129 0 n64 ns129 0 0.000434458944275
Gc32_130 0 n64 ns130 0 -0.000563138686028
Gc32_131 0 n64 ns131 0 -0.000222669666177
Gc32_132 0 n64 ns132 0 -0.00049304023985
Gc32_133 0 n64 ns133 0 -0.000303462115827
Gc32_134 0 n64 ns134 0 -0.000374740706311
Gc32_135 0 n64 ns135 0 -0.00058214017272
Gc32_136 0 n64 ns136 0 -0.000448490230906
Gc32_137 0 n64 ns137 0 -0.00505953045226
Gc32_138 0 n64 ns138 0 -0.00040375697571
Gc32_139 0 n64 ns139 0 -0.00444614899804
Gc32_140 0 n64 ns140 0 -0.000251510803782
Gc32_141 0 n64 ns141 0 0.000293855141756
Gc32_142 0 n64 ns142 0 0.0013479045836
Gc32_143 0 n64 ns143 0 -0.000277389806922
Gc32_144 0 n64 ns144 0 -0.000322337987206
Gc32_145 0 n64 ns145 0 -0.000897847948327
Gc32_146 0 n64 ns146 0 -0.00106412467447
Gc32_147 0 n64 ns147 0 -9.21131018563e-05
Gc32_148 0 n64 ns148 0 -0.000560125664991
Gc32_149 0 n64 ns149 0 -0.00018394471464
Gc32_150 0 n64 ns150 0 -1.58708389284e-05
Gc32_151 0 n64 ns151 0 0.000109301023723
Gc32_152 0 n64 ns152 0 -2.67897421157e-05
Gc32_153 0 n64 ns153 0 -0.000257282436528
Gc32_154 0 n64 ns154 0 -2.42120514304e-05
Gc32_155 0 n64 ns155 0 -0.000436030179383
Gc32_156 0 n64 ns156 0 0.000443026165844
Gc32_157 0 n64 ns157 0 -0.000135955906804
Gc32_158 0 n64 ns158 0 0.000189603572401
Gc32_159 0 n64 ns159 0 0.000116524931058
Gc32_160 0 n64 ns160 0 -1.92348463451e-05
Gc32_161 0 n64 ns161 0 0.000547775369872
Gc32_162 0 n64 ns162 0 -0.000202937019372
Gc32_163 0 n64 ns163 0 -0.000156640974148
Gc32_164 0 n64 ns164 0 0.000140585463682
Gc32_165 0 n64 ns165 0 -6.09721848798e-05
Gc32_166 0 n64 ns166 0 0.000442931727492
Gc32_167 0 n64 ns167 0 0.000995271796708
Gc32_168 0 n64 ns168 0 0.000159489606512
Gc32_169 0 n64 ns169 0 0.00043550615999
Gc32_170 0 n64 ns170 0 -0.00067932090938
Gc32_171 0 n64 ns171 0 0.000304897827342
Gc32_172 0 n64 ns172 0 -0.000581471039783
Gc32_173 0 n64 ns173 0 6.81311152409e-05
Gc32_174 0 n64 ns174 0 -0.000547415722391
Gc32_175 0 n64 ns175 0 -0.00499033197613
Gc32_176 0 n64 ns176 0 -0.00451196046629
Gc32_177 0 n64 ns177 0 -0.00460163629552
Gc32_178 0 n64 ns178 0 -0.00392333240001
Gc32_179 0 n64 ns179 0 -0.000386183341253
Gc32_180 0 n64 ns180 0 0.00183990876495
Gc32_181 0 n64 ns181 0 -0.000269011990755
Gc32_182 0 n64 ns182 0 -0.000665907670825
Gc32_183 0 n64 ns183 0 -0.000791973021538
Gc32_184 0 n64 ns184 0 -0.00193978792926
Gc32_185 0 n64 ns185 0 -3.91173272126e-06
Gc32_186 0 n64 ns186 0 -0.0011347344755
Gc32_187 0 n64 ns187 0 -0.000387524352309
Gc32_188 0 n64 ns188 0 -1.00063859968e-05
Gc32_189 0 n64 ns189 0 9.85673641848e-05
Gc32_190 0 n64 ns190 0 -1.55897629187e-05
Gc32_191 0 n64 ns191 0 9.0380014121e-05
Gc32_192 0 n64 ns192 0 -0.000884712335944
Gc32_193 0 n64 ns193 0 0.000160481533109
Gc32_194 0 n64 ns194 0 0.000287591654049
Gc32_195 0 n64 ns195 0 -7.53063489481e-05
Gc32_196 0 n64 ns196 0 -0.000234397965309
Gc32_197 0 n64 ns197 0 -9.00239726047e-05
Gc32_198 0 n64 ns198 0 0.000141082551497
Gc32_199 0 n64 ns199 0 0.000205454158407
Gc32_200 0 n64 ns200 0 0.000593620097569
Gc32_201 0 n64 ns201 0 -0.000174022890968
Gc32_202 0 n64 ns202 0 2.67325241933e-05
Gc32_203 0 n64 ns203 0 -9.70964906811e-05
Gc32_204 0 n64 ns204 0 -0.000254014471652
Gc32_205 0 n64 ns205 0 0.00015094011563
Gc32_206 0 n64 ns206 0 0.00109348014256
Gc32_207 0 n64 ns207 0 0.000847893593097
Gc32_208 0 n64 ns208 0 -7.61361496854e-05
Gc32_209 0 n64 ns209 0 0.000478963733002
Gc32_210 0 n64 ns210 0 3.11020110918e-05
Gc32_211 0 n64 ns211 0 0.000250032809437
Gc32_212 0 n64 ns212 0 0.000348403170913
Gc32_213 0 n64 ns213 0 -0.000903764839394
Gc32_214 0 n64 ns214 0 -0.0065476711211
Gc32_215 0 n64 ns215 0 -0.00114985427698
Gc32_216 0 n64 ns216 0 -0.00612965944028
Gc32_217 0 n64 ns217 0 -0.00154092056118
Gc32_218 0 n64 ns218 0 0.000996214365687
Gc32_219 0 n64 ns219 0 0.000110136203766
Gc32_220 0 n64 ns220 0 -0.0010827077233
Gc32_221 0 n64 ns221 0 0.000232110069151
Gc32_222 0 n64 ns222 0 -0.00238601430134
Gc32_223 0 n64 ns223 0 0.00055560157154
Gc32_224 0 n64 ns224 0 -0.00168150331691
Gc32_225 0 n64 ns225 0 -0.000788198999452
Gc32_226 0 n64 ns226 0 -1.19766628888e-05
Gc32_227 0 n64 ns227 0 6.06370450579e-05
Gc32_228 0 n64 ns228 0 3.30440708909e-06
Gc32_229 0 n64 ns229 0 -0.000769129281636
Gc32_230 0 n64 ns230 0 -4.60920771183e-05
Gc32_231 0 n64 ns231 0 -0.00247357442691
Gc32_232 0 n64 ns232 0 0.00145848740532
Gc32_233 0 n64 ns233 0 -0.000419624771416
Gc32_234 0 n64 ns234 0 0.000649085301188
Gc32_235 0 n64 ns235 0 0.000245040413546
Gc32_236 0 n64 ns236 0 -0.000390743367568
Gc32_237 0 n64 ns237 0 -0.000658534567308
Gc32_238 0 n64 ns238 0 0.000705496138644
Gc32_239 0 n64 ns239 0 -9.4106978529e-05
Gc32_240 0 n64 ns240 0 -3.97102179028e-05
Gc32_241 0 n64 ns241 0 0.000961350725005
Gc32_242 0 n64 ns242 0 -0.000645411595684
Gc32_243 0 n64 ns243 0 -0.000650616121175
Gc32_244 0 n64 ns244 0 -0.000146674084675
Gc32_245 0 n64 ns245 0 0.000758373358625
Gc32_246 0 n64 ns246 0 0.000196873579983
Gc32_247 0 n64 ns247 0 0.00037205636397
Gc32_248 0 n64 ns248 0 -9.57353980199e-05
Gc32_249 0 n64 ns249 0 -0.00147226704664
Gc32_250 0 n64 ns250 0 0.0010853169719
Gc32_251 0 n64 ns251 0 0.000592363463342
Gc32_252 0 n64 ns252 0 -0.00193181977923
Gc32_253 0 n64 ns253 0 0.000675738797335
Gc32_254 0 n64 ns254 0 -0.00268655341359
Gc32_255 0 n64 ns255 0 -0.00016904262263
Gc32_256 0 n64 ns256 0 -0.000702648493426
Gc32_257 0 n64 ns257 0 0.00089701021676
Gc32_258 0 n64 ns258 0 -0.00120577319011
Gc32_259 0 n64 ns259 0 0.000851041303455
Gc32_260 0 n64 ns260 0 -0.00183891007407
Gc32_261 0 n64 ns261 0 0.00198437967156
Gc32_262 0 n64 ns262 0 -0.00255178904876
Gc32_263 0 n64 ns263 0 -0.00202021163444
Gc32_264 0 n64 ns264 0 -2.58732082239e-05
Gc32_265 0 n64 ns265 0 0.000115406604782
Gc32_266 0 n64 ns266 0 -1.22620867563e-05
Gc32_267 0 n64 ns267 0 0.000941894544189
Gc32_268 0 n64 ns268 0 -0.00215546996652
Gc32_269 0 n64 ns269 0 0.00136726297728
Gc32_270 0 n64 ns270 0 -0.00438640424188
Gc32_271 0 n64 ns271 0 -0.00242258121757
Gc32_272 0 n64 ns272 0 -0.00129736574692
Gc32_273 0 n64 ns273 0 0.00100958490366
Gc32_274 0 n64 ns274 0 0.000435130437503
Gc32_275 0 n64 ns275 0 -0.00078734271642
Gc32_276 0 n64 ns276 0 -0.000482789040058
Gc32_277 0 n64 ns277 0 -0.000134096756868
Gc32_278 0 n64 ns278 0 -8.73305840392e-05
Gc32_279 0 n64 ns279 0 0.0003474343528
Gc32_280 0 n64 ns280 0 0.000123714102364
Gc32_281 0 n64 ns281 0 0.00072215265005
Gc32_282 0 n64 ns282 0 -0.0008545733244
Gc32_283 0 n64 ns283 0 0.000652816974302
Gc32_284 0 n64 ns284 0 0.000479712688906
Gc32_285 0 n64 ns285 0 0.000351794008707
Gc32_286 0 n64 ns286 0 0.0001996524604
Gc32_287 0 n64 ns287 0 -0.00119745930462
Gc32_288 0 n64 ns288 0 -0.00190539042018
Gc32_289 0 n64 ns289 0 -0.00145084052772
Gc32_290 0 n64 ns290 0 -0.000857782494609
Gc32_291 0 n64 ns291 0 -0.00041170161878
Gc32_292 0 n64 ns292 0 -0.00154414953891
Gc32_293 0 n64 ns293 0 0.00461639112028
Gc32_294 0 n64 ns294 0 0.00201081246576
Gc32_295 0 n64 ns295 0 0.00139254050718
Gc32_296 0 n64 ns296 0 -0.000647655426349
Gc32_297 0 n64 ns297 0 -0.00207258487288
Gc32_298 0 n64 ns298 0 -0.00148237315145
Gc32_299 0 n64 ns299 0 0.00261039050835
Gc32_300 0 n64 ns300 0 0.00292504747723
Gc32_301 0 n64 ns301 0 -0.00354824109736
Gc32_302 0 n64 ns302 0 -9.96457743814e-06
Gc32_303 0 n64 ns303 0 0.000290836653501
Gc32_304 0 n64 ns304 0 -0.000151789214462
Gc32_305 0 n64 ns305 0 0.00244113477071
Gc32_306 0 n64 ns306 0 -0.00366290097358
Gc32_307 0 n64 ns307 0 0.00481019153089
Gc32_308 0 n64 ns308 0 -0.00873260248307
Gc32_309 0 n64 ns309 0 -0.00380763546981
Gc32_310 0 n64 ns310 0 -0.00259723042697
Gc32_311 0 n64 ns311 0 0.00129374037894
Gc32_312 0 n64 ns312 0 0.000976407267916
Gc32_313 0 n64 ns313 0 -0.00036855074735
Gc32_314 0 n64 ns314 0 -0.00086664852503
Gc32_315 0 n64 ns315 0 -0.000111061996369
Gc32_316 0 n64 ns316 0 -0.000104710206001
Gc32_317 0 n64 ns317 0 -0.000968855498895
Gc32_318 0 n64 ns318 0 5.98176976051e-05
Gc32_319 0 n64 ns319 0 0.0016807538209
Gc32_320 0 n64 ns320 0 -3.24630562538e-05
Gc32_321 0 n64 ns321 0 0.000574177926889
Gc32_322 0 n64 ns322 0 0.00082156101075
Gc32_323 0 n64 ns323 0 0.000430739847878
Gc32_324 0 n64 ns324 0 0.00117310171286
Gc32_325 0 n64 ns325 0 0.000954386792675
Gc32_326 0 n64 ns326 0 -0.00413595217588
Gc32_327 0 n64 ns327 0 -0.000462541014749
Gc32_328 0 n64 ns328 0 -0.00484071103169
Gc32_329 0 n64 ns329 0 0.000331578433525
Gc32_330 0 n64 ns330 0 -0.00428864490767
Gc32_331 0 n64 ns331 0 0.00671820989509
Gc32_332 0 n64 ns332 0 0.00738952641214
Gc32_333 0 n64 ns333 0 0.000892093052766
Gc32_334 0 n64 ns334 0 -0.000279065376326
Gc32_335 0 n64 ns335 0 -0.00547798498507
Gc32_336 0 n64 ns336 0 -0.00358152318248
Gc32_337 0 n64 ns337 0 0.00104995477409
Gc32_338 0 n64 ns338 0 0.00889943252329
Gc32_339 0 n64 ns339 0 -0.00349950979429
Gc32_340 0 n64 ns340 0 7.35745324585e-06
Gc32_341 0 n64 ns341 0 0.000474271362617
Gc32_342 0 n64 ns342 0 -0.000314587222805
Gc32_343 0 n64 ns343 0 0.000114325379201
Gc32_344 0 n64 ns344 0 0.000196968296069
Gc32_345 0 n64 ns345 0 0.000418220673912
Gc32_346 0 n64 ns346 0 0.000117957697745
Gc32_347 0 n64 ns347 0 4.78927163566e-05
Gc32_348 0 n64 ns348 0 4.24073285058e-06
Gc32_349 0 n64 ns349 0 -5.99296148981e-05
Gc32_350 0 n64 ns350 0 1.90928172974e-07
Gc32_351 0 n64 ns351 0 -0.000128892162508
Gc32_352 0 n64 ns352 0 0.000165217420433
Gc32_353 0 n64 ns353 0 9.8828292539e-05
Gc32_354 0 n64 ns354 0 -4.47380239901e-05
Gc32_355 0 n64 ns355 0 -5.85437658343e-05
Gc32_356 0 n64 ns356 0 -0.00040821140024
Gc32_357 0 n64 ns357 0 -0.000327516506357
Gc32_358 0 n64 ns358 0 -0.00021467194344
Gc32_359 0 n64 ns359 0 -0.000290862808165
Gc32_360 0 n64 ns360 0 4.70220243925e-05
Gc32_361 0 n64 ns361 0 -0.000295970872021
Gc32_362 0 n64 ns362 0 9.45501700457e-05
Gc32_363 0 n64 ns363 0 -0.000291962494636
Gc32_364 0 n64 ns364 0 0.000239154216658
Gc32_365 0 n64 ns365 0 -0.00130720469379
Gc32_366 0 n64 ns366 0 0.00207899747248
Gc32_367 0 n64 ns367 0 -0.00111086059903
Gc32_368 0 n64 ns368 0 0.00181264480054
Gc32_369 0 n64 ns369 0 0.000736095488435
Gc32_370 0 n64 ns370 0 0.000524904184412
Gc32_371 0 n64 ns371 0 -0.000187738838165
Gc32_372 0 n64 ns372 0 -9.55672751553e-05
Gc32_373 0 n64 ns373 0 -0.000807058501997
Gc32_374 0 n64 ns374 0 -0.000425793560232
Gc32_375 0 n64 ns375 0 -0.000143230164548
Gc32_376 0 n64 ns376 0 -0.000561805827808
Gc32_377 0 n64 ns377 0 -0.000165305547628
Gc32_378 0 n64 ns378 0 -1.11062837408e-05
Gc32_379 0 n64 ns379 0 7.35631313792e-06
Gc32_380 0 n64 ns380 0 3.47961905577e-06
Gc32_381 0 n64 ns381 0 -0.000240758922083
Gc32_382 0 n64 ns382 0 0.000663102997669
Gc32_383 0 n64 ns383 0 -0.000551990427036
Gc32_384 0 n64 ns384 0 0.00105708301971
Gc32_385 0 n64 ns385 0 -1.27134057529e-05
Gc32_386 0 n64 ns386 0 0.000364920389027
Gc32_387 0 n64 ns387 0 1.91811339716e-05
Gc32_388 0 n64 ns388 0 -0.000256224719336
Gc32_389 0 n64 ns389 0 -0.000153405699166
Gc32_390 0 n64 ns390 0 -0.00014599693005
Gc32_391 0 n64 ns391 0 0.000102065638887
Gc32_392 0 n64 ns392 0 9.5894645018e-05
Gc32_393 0 n64 ns393 0 0.00042613864415
Gc32_394 0 n64 ns394 0 -0.000287823125329
Gc32_395 0 n64 ns395 0 9.90263662884e-05
Gc32_396 0 n64 ns396 0 -0.000653273524882
Gc32_397 0 n64 ns397 0 -0.000318188686914
Gc32_398 0 n64 ns398 0 -0.000371503417368
Gc32_399 0 n64 ns399 0 -0.000345361426177
Gc32_400 0 n64 ns400 0 -0.00031786679318
Gc32_401 0 n64 ns401 0 -0.000508099006784
Gc32_402 0 n64 ns402 0 -0.000105972586442
Gc32_403 0 n64 ns403 0 -0.00386460337158
Gc32_404 0 n64 ns404 0 0.00102468075124
Gc32_405 0 n64 ns405 0 -0.00336572443043
Gc32_406 0 n64 ns406 0 0.000952645199833
Gc32_407 0 n64 ns407 0 0.00065993340776
Gc32_408 0 n64 ns408 0 0.00122887822048
Gc32_409 0 n64 ns409 0 -0.000284716709222
Gc32_410 0 n64 ns410 0 -0.000250218082207
Gc32_411 0 n64 ns411 0 -0.00104855736838
Gc32_412 0 n64 ns412 0 -0.000967356085278
Gc32_413 0 n64 ns413 0 -0.000165725771711
Gc32_414 0 n64 ns414 0 -0.000749454088817
Gc32_415 0 n64 ns415 0 -0.000217741923883
Gc32_416 0 n64 ns416 0 4.91942286921e-08
Gc32_417 0 n64 ns417 0 1.68002322136e-05
Gc32_418 0 n64 ns418 0 2.57712066921e-05
Gc32_419 0 n64 ns419 0 -0.000173937300248
Gc32_420 0 n64 ns420 0 0.000156445049801
Gc32_421 0 n64 ns421 0 -0.000201723269589
Gc32_422 0 n64 ns422 0 0.000571523153808
Gc32_423 0 n64 ns423 0 -9.44832342987e-05
Gc32_424 0 n64 ns424 0 0.000267769892945
Gc32_425 0 n64 ns425 0 0.000149277475496
Gc32_426 0 n64 ns426 0 -0.000121114489156
Gc32_427 0 n64 ns427 0 0.000372201099439
Gc32_428 0 n64 ns428 0 -0.000365761006693
Gc32_429 0 n64 ns429 0 -8.219693062e-05
Gc32_430 0 n64 ns430 0 0.000155702769052
Gc32_431 0 n64 ns431 0 0.000129554054782
Gc32_432 0 n64 ns432 0 0.000349790251448
Gc32_433 0 n64 ns433 0 0.000824229241085
Gc32_434 0 n64 ns434 0 -0.000339639328575
Gc32_435 0 n64 ns435 0 0.000137552709358
Gc32_436 0 n64 ns436 0 -0.000755805248724
Gc32_437 0 n64 ns437 0 5.87665564047e-05
Gc32_438 0 n64 ns438 0 -0.000726981649411
Gc32_439 0 n64 ns439 0 -8.72858726057e-05
Gc32_440 0 n64 ns440 0 -0.000491663443279
Gc32_441 0 n64 ns441 0 -0.005188630668
Gc32_442 0 n64 ns442 0 -0.002564346101
Gc32_443 0 n64 ns443 0 -0.00468948418164
Gc32_444 0 n64 ns444 0 -0.00217980908062
Gc32_445 0 n64 ns445 0 0.000170871908082
Gc32_446 0 n64 ns446 0 0.00186352643875
Gc32_447 0 n64 ns447 0 -0.000326117818137
Gc32_448 0 n64 ns448 0 -0.000539274647899
Gc32_449 0 n64 ns449 0 -0.00109184720216
Gc32_450 0 n64 ns450 0 -0.00177947509202
Gc32_451 0 n64 ns451 0 -0.000134441778797
Gc32_452 0 n64 ns452 0 -0.00123786164757
Gc32_453 0 n64 ns453 0 -0.000374295339572
Gc32_454 0 n64 ns454 0 6.34423391228e-07
Gc32_455 0 n64 ns455 0 5.07954646214e-05
Gc32_456 0 n64 ns456 0 1.17536063959e-05
Gc32_457 0 n64 ns457 0 -7.43272328653e-05
Gc32_458 0 n64 ns458 0 -0.000575872611736
Gc32_459 0 n64 ns459 0 -0.000184249983865
Gc32_460 0 n64 ns460 0 0.000321322358389
Gc32_461 0 n64 ns461 0 -0.000239248922059
Gc32_462 0 n64 ns462 0 -3.06262382093e-05
Gc32_463 0 n64 ns463 0 5.19881000628e-05
Gc32_464 0 n64 ns464 0 9.04711985509e-05
Gc32_465 0 n64 ns465 0 0.00048689790135
Gc32_466 0 n64 ns466 0 0.000343483784104
Gc32_467 0 n64 ns467 0 -0.000164427364793
Gc32_468 0 n64 ns468 0 6.27176263202e-05
Gc32_469 0 n64 ns469 0 -0.000232418809711
Gc32_470 0 n64 ns470 0 -2.98770509658e-05
Gc32_471 0 n64 ns471 0 0.000644943832997
Gc32_472 0 n64 ns472 0 0.000847201440439
Gc32_473 0 n64 ns473 0 0.000766744777289
Gc32_474 0 n64 ns474 0 -0.000330638361792
Gc32_475 0 n64 ns475 0 0.000542833422594
Gc32_476 0 n64 ns476 0 -0.00018616724575
Gc32_477 0 n64 ns477 0 0.000324423219349
Gc32_478 0 n64 ns478 0 -2.46652368619e-05
Gc32_479 0 n64 ns479 0 -0.00264506619272
Gc32_480 0 n64 ns480 0 -0.0062331518889
Gc32_481 0 n64 ns481 0 -0.00265645458285
Gc32_482 0 n64 ns482 0 -0.00565276864553
Gc32_483 0 n64 ns483 0 -0.00114130186808
Gc32_484 0 n64 ns484 0 0.00157917497405
Gc32_485 0 n64 ns485 0 -9.05820888048e-05
Gc32_486 0 n64 ns486 0 -0.000944311184024
Gc32_487 0 n64 ns487 0 -0.000264833581511
Gc32_488 0 n64 ns488 0 -0.00239594816352
Gc32_489 0 n64 ns489 0 0.000259455461008
Gc32_490 0 n64 ns490 0 -0.00155782885469
Gc32_491 0 n64 ns491 0 -0.000614746790019
Gc32_492 0 n64 ns492 0 -1.42893470758e-05
Gc32_493 0 n64 ns493 0 6.72051046943e-05
Gc32_494 0 n64 ns494 0 -3.54052242987e-06
Gc32_495 0 n64 ns495 0 -0.00040949187764
Gc32_496 0 n64 ns496 0 -4.23014235309e-05
Gc32_497 0 n64 ns497 0 -0.00112117415836
Gc32_498 0 n64 ns498 0 0.00188751105228
Gc32_499 0 n64 ns499 0 -9.41632135784e-05
Gc32_500 0 n64 ns500 0 0.000268848937437
Gc32_501 0 n64 ns501 0 2.33103198794e-05
Gc32_502 0 n64 ns502 0 -0.000214661449148
Gc32_503 0 n64 ns503 0 -0.000254992771762
Gc32_504 0 n64 ns504 0 0.00083407942055
Gc32_505 0 n64 ns505 0 -0.000112583762221
Gc32_506 0 n64 ns506 0 -3.39644572109e-05
Gc32_507 0 n64 ns507 0 0.000531748276713
Gc32_508 0 n64 ns508 0 -0.000777070761597
Gc32_509 0 n64 ns509 0 -0.000546676075857
Gc32_510 0 n64 ns510 0 0.000392409147769
Gc32_511 0 n64 ns511 0 0.00076189963775
Gc32_512 0 n64 ns512 0 7.66104711231e-05
Gc32_513 0 n64 ns513 0 0.000335577482842
Gc32_514 0 n64 ns514 0 -7.40877982081e-05
Gc32_515 0 n64 ns515 0 -0.000670444806137
Gc32_516 0 n64 ns516 0 0.00122654141638
Gc32_517 0 n64 ns517 0 0.000993524625467
Gc32_518 0 n64 ns518 0 -0.00335402373257
Gc32_519 0 n64 ns519 0 0.000756251930114
Gc32_520 0 n64 ns520 0 -0.00375880826454
Gc32_521 0 n64 ns521 0 -0.00112480918854
Gc32_522 0 n64 ns522 0 -0.000211302555909
Gc32_523 0 n64 ns523 0 0.000588004805696
Gc32_524 0 n64 ns524 0 -0.00123877726292
Gc32_525 0 n64 ns525 0 0.000849324546024
Gc32_526 0 n64 ns526 0 -0.00222721906382
Gc32_527 0 n64 ns527 0 0.00132968473911
Gc32_528 0 n64 ns528 0 -0.00256908700459
Gc32_529 0 n64 ns529 0 -0.0014736036174
Gc32_530 0 n64 ns530 0 -2.10347294143e-05
Gc32_531 0 n64 ns531 0 9.07680594614e-05
Gc32_532 0 n64 ns532 0 8.26852547583e-07
Gc32_533 0 n64 ns533 0 -0.00109939547847
Gc32_534 0 n64 ns534 0 -0.000468007030174
Gc32_535 0 n64 ns535 0 -0.00428135435877
Gc32_536 0 n64 ns536 0 -0.00163373770714
Gc32_537 0 n64 ns537 0 -0.00204046678407
Gc32_538 0 n64 ns538 0 0.000993460747626
Gc32_539 0 n64 ns539 0 0.000961347253016
Gc32_540 0 n64 ns540 0 -0.000486012724243
Gc32_541 0 n64 ns541 0 -0.000811438467995
Gc32_542 0 n64 ns542 0 0.000219490940542
Gc32_543 0 n64 ns543 0 -0.000113364071516
Gc32_544 0 n64 ns544 0 -5.69724917253e-05
Gc32_545 0 n64 ns545 0 0.000960756081762
Gc32_546 0 n64 ns546 0 4.11214907405e-07
Gc32_547 0 n64 ns547 0 0.000258976189355
Gc32_548 0 n64 ns548 0 -0.00090608160346
Gc32_549 0 n64 ns549 0 0.000886416442108
Gc32_550 0 n64 ns550 0 0.0002772913095
Gc32_551 0 n64 ns551 0 0.000774192501363
Gc32_552 0 n64 ns552 0 -7.09771018983e-05
Gc32_553 0 n64 ns553 0 -0.0023406597044
Gc32_554 0 n64 ns554 0 -0.000463894659815
Gc32_555 0 n64 ns555 0 -0.00164539032756
Gc32_556 0 n64 ns556 0 -0.00070501376255
Gc32_557 0 n64 ns557 0 -0.000730793901504
Gc32_558 0 n64 ns558 0 -0.00152798098976
Gc32_559 0 n64 ns559 0 0.00300941103874
Gc32_560 0 n64 ns560 0 0.000154065008648
Gc32_561 0 n64 ns561 0 0.00132094196624
Gc32_562 0 n64 ns562 0 -0.000893809484509
Gc32_563 0 n64 ns563 0 -0.000740700307459
Gc32_564 0 n64 ns564 0 -0.00159040705503
Gc32_565 0 n64 ns565 0 0.00293749636145
Gc32_566 0 n64 ns566 0 0.000240536663536
Gc32_567 0 n64 ns567 0 -0.00313626719007
Gc32_568 0 n64 ns568 0 -2.91905519869e-05
Gc32_569 0 n64 ns569 0 0.000392161023619
Gc32_570 0 n64 ns570 0 -0.000226722258322
Gc32_571 0 n64 ns571 0 -0.000421669961321
Gc32_572 0 n64 ns572 0 -0.000251232931382
Gc32_573 0 n64 ns573 0 0.000162416485778
Gc32_574 0 n64 ns574 0 0.00200453782377
Gc32_575 0 n64 ns575 0 0.001391704151
Gc32_576 0 n64 ns576 0 -0.000969486055261
Gc32_577 0 n64 ns577 0 -0.00031274544934
Gc32_578 0 n64 ns578 0 0.000199448050019
Gc32_579 0 n64 ns579 0 5.19978142127e-05
Gc32_580 0 n64 ns580 0 -0.000161760277734
Gc32_581 0 n64 ns581 0 -3.1681338319e-05
Gc32_582 0 n64 ns582 0 -8.57134132795e-05
Gc32_583 0 n64 ns583 0 0.00177515592619
Gc32_584 0 n64 ns584 0 -0.000341394450903
Gc32_585 0 n64 ns585 0 -0.000263654071044
Gc32_586 0 n64 ns586 0 0.000911863533661
Gc32_587 0 n64 ns587 0 -0.000610996861926
Gc32_588 0 n64 ns588 0 0.000394877287309
Gc32_589 0 n64 ns589 0 -0.00180343625989
Gc32_590 0 n64 ns590 0 -0.000968206107144
Gc32_591 0 n64 ns591 0 0.00259669725421
Gc32_592 0 n64 ns592 0 0.00298964855909
Gc32_593 0 n64 ns593 0 -0.00888711409423
Gc32_594 0 n64 ns594 0 0.00319566817068
Gc32_595 0 n64 ns595 0 -0.00623938305373
Gc32_596 0 n64 ns596 0 0.00182887410986
Gc32_597 0 n64 ns597 0 -0.00948448013715
Gc32_598 0 n64 ns598 0 -0.00169177922447
Gc32_599 0 n64 ns599 0 0.001692949115
Gc32_600 0 n64 ns600 0 0.00082507180989
Gc32_601 0 n64 ns601 0 -0.00346080473441
Gc32_602 0 n64 ns602 0 0.0109020041672
Gc32_603 0 n64 ns603 0 -0.0141493088344
Gc32_604 0 n64 ns604 0 -0.00130543662471
Gc32_605 0 n64 ns605 0 -0.00572777897073
Gc32_606 0 n64 ns606 0 -4.93872397333e-05
Gc32_607 0 n64 ns607 0 -0.000404269112106
Gc32_608 0 n64 ns608 0 0.000578016722893
Gc32_609 0 n64 ns609 0 0.000183459280817
Gc32_610 0 n64 ns610 0 0.000102967685475
Gc32_611 0 n64 ns611 0 0.000620689677548
Gc32_612 0 n64 ns612 0 -0.00011576873138
Gc32_613 0 n64 ns613 0 7.55385757452e-05
Gc32_614 0 n64 ns614 0 3.20767597823e-05
Gc32_615 0 n64 ns615 0 -8.00623812692e-06
Gc32_616 0 n64 ns616 0 -6.08452265246e-05
Gc32_617 0 n64 ns617 0 7.9968496414e-05
Gc32_618 0 n64 ns618 0 -0.000126253694872
Gc32_619 0 n64 ns619 0 -1.82712760824e-05
Gc32_620 0 n64 ns620 0 1.47472580299e-05
Gc32_621 0 n64 ns621 0 -0.000132316464762
Gc32_622 0 n64 ns622 0 5.08326311367e-05
Gc32_623 0 n64 ns623 0 -0.000148909206143
Gc32_624 0 n64 ns624 0 2.30291795616e-05
Gc32_625 0 n64 ns625 0 -5.01487728128e-05
Gc32_626 0 n64 ns626 0 6.57234877579e-05
Gc32_627 0 n64 ns627 0 -3.78162976172e-05
Gc32_628 0 n64 ns628 0 3.8467154062e-05
Gc32_629 0 n64 ns629 0 7.6736422747e-05
Gc32_630 0 n64 ns630 0 -1.9007030231e-05
Gc32_631 0 n64 ns631 0 -0.000182431253694
Gc32_632 0 n64 ns632 0 -0.000572746551265
Gc32_633 0 n64 ns633 0 -0.000165906837951
Gc32_634 0 n64 ns634 0 -0.00052013053037
Gc32_635 0 n64 ns635 0 0.000235618465069
Gc32_636 0 n64 ns636 0 0.000462824689435
Gc32_637 0 n64 ns637 0 -8.21712892688e-05
Gc32_638 0 n64 ns638 0 -9.55141215211e-05
Gc32_639 0 n64 ns639 0 -0.000369640326002
Gc32_640 0 n64 ns640 0 -0.000444320638031
Gc32_641 0 n64 ns641 0 -0.000186160608488
Gc32_642 0 n64 ns642 0 -0.000413657220988
Gc32_643 0 n64 ns643 0 -3.77965322338e-05
Gc32_644 0 n64 ns644 0 1.48868617366e-05
Gc32_645 0 n64 ns645 0 -4.68859321307e-05
Gc32_646 0 n64 ns646 0 2.04616296509e-05
Gc32_647 0 n64 ns647 0 6.77484954933e-05
Gc32_648 0 n64 ns648 0 0.000231727496304
Gc32_649 0 n64 ns649 0 0.000389034970365
Gc32_650 0 n64 ns650 0 -0.000105746530962
Gc32_651 0 n64 ns651 0 3.44916556853e-05
Gc32_652 0 n64 ns652 0 5.48040541291e-05
Gc32_653 0 n64 ns653 0 2.14710138472e-05
Gc32_654 0 n64 ns654 0 -5.57724828076e-05
Gc32_655 0 n64 ns655 0 0.000115278868688
Gc32_656 0 n64 ns656 0 -0.000103040760527
Gc32_657 0 n64 ns657 0 -2.49275774128e-05
Gc32_658 0 n64 ns658 0 1.49254483543e-05
Gc32_659 0 n64 ns659 0 -0.000136205215651
Gc32_660 0 n64 ns660 0 3.37979896903e-05
Gc32_661 0 n64 ns661 0 -0.000216024191936
Gc32_662 0 n64 ns662 0 2.44312846863e-05
Gc32_663 0 n64 ns663 0 -0.000113436740441
Gc32_664 0 n64 ns664 0 0.000108630571825
Gc32_665 0 n64 ns665 0 -0.000111194785091
Gc32_666 0 n64 ns666 0 0.000105940340693
Gc32_667 0 n64 ns667 0 6.45900896473e-05
Gc32_668 0 n64 ns668 0 -6.96097748539e-05
Gc32_669 0 n64 ns669 0 -0.000164062010572
Gc32_670 0 n64 ns670 0 -0.000853179251669
Gc32_671 0 n64 ns671 0 -0.000148014106958
Gc32_672 0 n64 ns672 0 -0.000765173887983
Gc32_673 0 n64 ns673 0 0.000217408602507
Gc32_674 0 n64 ns674 0 0.000431404449905
Gc32_675 0 n64 ns675 0 -9.96400026991e-05
Gc32_676 0 n64 ns676 0 -8.61787817463e-05
Gc32_677 0 n64 ns677 0 -0.000388364759694
Gc32_678 0 n64 ns678 0 -0.000353040281247
Gc32_679 0 n64 ns679 0 -0.000170214915425
Gc32_680 0 n64 ns680 0 -0.000264396957238
Gc32_681 0 n64 ns681 0 -6.24386576386e-06
Gc32_682 0 n64 ns682 0 8.4660738713e-06
Gc32_683 0 n64 ns683 0 -3.13957792615e-05
Gc32_684 0 n64 ns684 0 4.17921296571e-06
Gc32_685 0 n64 ns685 0 0.000158772229955
Gc32_686 0 n64 ns686 0 0.000354582846443
Gc32_687 0 n64 ns687 0 0.000718094479959
Gc32_688 0 n64 ns688 0 -0.000112320880942
Gc32_689 0 n64 ns689 0 2.12681731247e-05
Gc32_690 0 n64 ns690 0 6.69726209694e-05
Gc32_691 0 n64 ns691 0 2.56073791253e-05
Gc32_692 0 n64 ns692 0 -1.21581159243e-06
Gc32_693 0 n64 ns693 0 0.000278497371737
Gc32_694 0 n64 ns694 0 6.5444487034e-05
Gc32_695 0 n64 ns695 0 -6.20701346855e-05
Gc32_696 0 n64 ns696 0 -3.72194252186e-05
Gc32_697 0 n64 ns697 0 -0.000295985407719
Gc32_698 0 n64 ns698 0 -0.000121762660318
Gc32_699 0 n64 ns699 0 -0.000404597522742
Gc32_700 0 n64 ns700 0 -0.000388888427918
Gc32_701 0 n64 ns701 0 -0.000402950069761
Gc32_702 0 n64 ns702 0 -0.000127613258335
Gc32_703 0 n64 ns703 0 -0.000446187256412
Gc32_704 0 n64 ns704 0 -0.000203625610097
Gc32_705 0 n64 ns705 0 0.000467683698986
Gc32_706 0 n64 ns706 0 -4.70341794156e-05
Gc32_707 0 n64 ns707 0 0.00159208107541
Gc32_708 0 n64 ns708 0 -0.00138335846079
Gc32_709 0 n64 ns709 0 0.00136499694918
Gc32_710 0 n64 ns710 0 -0.00126159541836
Gc32_711 0 n64 ns711 0 0.000322704494591
Gc32_712 0 n64 ns712 0 0.000267924325561
Gc32_713 0 n64 ns713 0 -0.00016808560545
Gc32_714 0 n64 ns714 0 -8.89360747227e-05
Gc32_715 0 n64 ns715 0 -0.000639146768864
Gc32_716 0 n64 ns716 0 -0.000173325562359
Gc32_717 0 n64 ns717 0 -0.00024889732027
Gc32_718 0 n64 ns718 0 6.00976317476e-05
Gc32_719 0 n64 ns719 0 8.93294425555e-05
Gc32_720 0 n64 ns720 0 8.67611112108e-06
Gc32_721 0 n64 ns721 0 -2.54788574914e-05
Gc32_722 0 n64 ns722 0 -8.01797344654e-06
Gc32_723 0 n64 ns723 0 0.000113872138248
Gc32_724 0 n64 ns724 0 0.000318629722202
Gc32_725 0 n64 ns725 0 0.000570180390335
Gc32_726 0 n64 ns726 0 0.000676912616769
Gc32_727 0 n64 ns727 0 -3.14384669643e-05
Gc32_728 0 n64 ns728 0 2.57875337524e-05
Gc32_729 0 n64 ns729 0 -3.30387849848e-05
Gc32_730 0 n64 ns730 0 5.0405676167e-05
Gc32_731 0 n64 ns731 0 4.94464656933e-05
Gc32_732 0 n64 ns732 0 0.000491145227484
Gc32_733 0 n64 ns733 0 1.21649511561e-06
Gc32_734 0 n64 ns734 0 -0.000143079262525
Gc32_735 0 n64 ns735 0 -6.93712556797e-05
Gc32_736 0 n64 ns736 0 -0.000462916796441
Gc32_737 0 n64 ns737 0 0.000340047655481
Gc32_738 0 n64 ns738 0 -0.000942342866468
Gc32_739 0 n64 ns739 0 -0.000151962690471
Gc32_740 0 n64 ns740 0 -0.000747549213584
Gc32_741 0 n64 ns741 0 -3.87472283108e-05
Gc32_742 0 n64 ns742 0 -0.000852391170235
Gc32_743 0 n64 ns743 0 0.000609092829124
Gc32_744 0 n64 ns744 0 0.000813921357023
Gc32_745 0 n64 ns745 0 0.00411499573298
Gc32_746 0 n64 ns746 0 0.0010352251573
Gc32_747 0 n64 ns747 0 0.00365382341512
Gc32_748 0 n64 ns748 0 0.000744550689298
Gc32_749 0 n64 ns749 0 0.000680187419184
Gc32_750 0 n64 ns750 0 0.000723813375474
Gc32_751 0 n64 ns751 0 -0.000289662328985
Gc32_752 0 n64 ns752 0 -0.000262866457612
Gc32_753 0 n64 ns753 0 -0.00119926147426
Gc32_754 0 n64 ns754 0 -0.000765146082849
Gc32_755 0 n64 ns755 0 -0.000505655237328
Gc32_756 0 n64 ns756 0 -0.00044022434279
Gc32_757 0 n64 ns757 0 3.23449533848e-05
Gc32_758 0 n64 ns758 0 1.21361607861e-05
Gc32_759 0 n64 ns759 0 -3.74852889017e-05
Gc32_760 0 n64 ns760 0 -5.08700473699e-06
Gc32_761 0 n64 ns761 0 -0.000108992277373
Gc32_762 0 n64 ns762 0 -0.000149312888102
Gc32_763 0 n64 ns763 0 -0.00026021539805
Gc32_764 0 n64 ns764 0 0.000687512608378
Gc32_765 0 n64 ns765 0 4.19452343772e-05
Gc32_766 0 n64 ns766 0 -1.91489062662e-05
Gc32_767 0 n64 ns767 0 -5.48322995141e-05
Gc32_768 0 n64 ns768 0 -8.71998225176e-05
Gc32_769 0 n64 ns769 0 -0.000513810674844
Gc32_770 0 n64 ns770 0 0.000170294872124
Gc32_771 0 n64 ns771 0 0.000123576431753
Gc32_772 0 n64 ns772 0 -0.000134262990729
Gc32_773 0 n64 ns773 0 0.000170600695871
Gc32_774 0 n64 ns774 0 -0.000111392018136
Gc32_775 0 n64 ns775 0 0.00113952066073
Gc32_776 0 n64 ns776 0 7.59192493609e-05
Gc32_777 0 n64 ns777 0 0.000522236786562
Gc32_778 0 n64 ns778 0 -0.000670304817972
Gc32_779 0 n64 ns779 0 0.000481317984948
Gc32_780 0 n64 ns780 0 -0.000483078603982
Gc32_781 0 n64 ns781 0 -0.00053021865338
Gc32_782 0 n64 ns782 0 0.000857068094441
Gc32_783 0 n64 ns783 0 0.00325211341537
Gc32_784 0 n64 ns784 0 0.00437283809394
Gc32_785 0 n64 ns785 0 0.00317221873847
Gc32_786 0 n64 ns786 0 0.00378280572977
Gc32_787 0 n64 ns787 0 -9.83361311305e-05
Gc32_788 0 n64 ns788 0 0.0012173598073
Gc32_789 0 n64 ns789 0 -0.000275896095478
Gc32_790 0 n64 ns790 0 -0.000582265169982
Gc32_791 0 n64 ns791 0 -0.0010028088176
Gc32_792 0 n64 ns792 0 -0.00146108929002
Gc32_793 0 n64 ns793 0 -0.00058894472193
Gc32_794 0 n64 ns794 0 -0.000148505294568
Gc32_795 0 n64 ns795 0 0.000195604684448
Gc32_796 0 n64 ns796 0 1.78017285438e-06
Gc32_797 0 n64 ns797 0 -6.79032012416e-05
Gc32_798 0 n64 ns798 0 -1.33945180337e-05
Gc32_799 0 n64 ns799 0 -0.000166894231394
Gc32_800 0 n64 ns800 0 -0.000635559165772
Gc32_801 0 n64 ns801 0 -0.000570627260938
Gc32_802 0 n64 ns802 0 -0.000327692144857
Gc32_803 0 n64 ns803 0 8.53203521254e-05
Gc32_804 0 n64 ns804 0 -0.000104079865218
Gc32_805 0 n64 ns805 0 3.5811313102e-05
Gc32_806 0 n64 ns806 0 0.000102318384608
Gc32_807 0 n64 ns807 0 -0.000371091173166
Gc32_808 0 n64 ns808 0 -0.000568221655924
Gc32_809 0 n64 ns809 0 0.000205229518247
Gc32_810 0 n64 ns810 0 -5.99784708775e-06
Gc32_811 0 n64 ns811 0 7.62929110695e-05
Gc32_812 0 n64 ns812 0 0.000169477395837
Gc32_813 0 n64 ns813 0 -9.72059973782e-05
Gc32_814 0 n64 ns814 0 0.00138927282811
Gc32_815 0 n64 ns815 0 0.000586936913661
Gc32_816 0 n64 ns816 0 5.29140812349e-05
Gc32_817 0 n64 ns817 0 -7.03379275081e-05
Gc32_818 0 n64 ns818 0 0.000178778519004
Gc32_819 0 n64 ns819 0 -0.000900527588558
Gc32_820 0 n64 ns820 0 -0.00117329119673
Gc32_821 0 n64 ns821 0 -0.000235680466285
Gc32_822 0 n64 ns822 0 0.00382382182057
Gc32_823 0 n64 ns823 0 0.000206568832285
Gc32_824 0 n64 ns824 0 0.00388814757906
Gc32_825 0 n64 ns825 0 -0.00247088206153
Gc32_826 0 n64 ns826 0 -0.000168520907339
Gc32_827 0 n64 ns827 0 0.000208433820182
Gc32_828 0 n64 ns828 0 -0.000925294404893
Gc32_829 0 n64 ns829 0 0.000761694540007
Gc32_830 0 n64 ns830 0 -0.00109111544424
Gc32_831 0 n64 ns831 0 -0.000497859198162
Gc32_832 0 n64 ns832 0 0.0020204944781
Gc32_833 0 n64 ns833 0 0.000920166981729
Gc32_834 0 n64 ns834 0 -7.44233005741e-06
Gc32_835 0 n64 ns835 0 -0.000137205134958
Gc32_836 0 n64 ns836 0 4.44233167196e-06
Gc32_837 0 n64 ns837 0 0.000744581182076
Gc32_838 0 n64 ns838 0 -0.00221373281138
Gc32_839 0 n64 ns839 0 0.00187182967166
Gc32_840 0 n64 ns840 0 -0.00167112205946
Gc32_841 0 n64 ns841 0 -0.000409688746928
Gc32_842 0 n64 ns842 0 -9.05711537312e-05
Gc32_843 0 n64 ns843 0 5.79696000807e-05
Gc32_844 0 n64 ns844 0 3.66301553249e-05
Gc32_845 0 n64 ns845 0 0.000541456294176
Gc32_846 0 n64 ns846 0 -0.000354322604043
Gc32_847 0 n64 ns847 0 0.000173993123908
Gc32_848 0 n64 ns848 0 7.9367502792e-05
Gc32_849 0 n64 ns849 0 -0.000106886936327
Gc32_850 0 n64 ns850 0 0.000222434138133
Gc32_851 0 n64 ns851 0 -0.00129437755601
Gc32_852 0 n64 ns852 0 -0.00023049263413
Gc32_853 0 n64 ns853 0 0.000375981881227
Gc32_854 0 n64 ns854 0 9.11628063389e-06
Gc32_855 0 n64 ns855 0 -0.000246746151309
Gc32_856 0 n64 ns856 0 -0.000595323098445
Gc32_857 0 n64 ns857 0 0.00159086782313
Gc32_858 0 n64 ns858 0 -0.000939469666243
Gc32_859 0 n64 ns859 0 -0.000788496091765
Gc32_860 0 n64 ns860 0 0.00208616088681
Gc32_861 0 n64 ns861 0 -0.000840148072129
Gc32_862 0 n64 ns862 0 0.00280050435304
Gc32_863 0 n64 ns863 0 -0.000981948615948
Gc32_864 0 n64 ns864 0 -0.00261352581782
Gc32_865 0 n64 ns865 0 0.000985921070484
Gc32_866 0 n64 ns866 0 -0.000994482640961
Gc32_867 0 n64 ns867 0 0.00115771501951
Gc32_868 0 n64 ns868 0 -0.000179593307602
Gc32_869 0 n64 ns869 0 -0.00193769427003
Gc32_870 0 n64 ns870 0 0.00271601877524
Gc32_871 0 n64 ns871 0 0.00208037752924
Gc32_872 0 n64 ns872 0 1.97700994179e-05
Gc32_873 0 n64 ns873 0 -0.000259014591043
Gc32_874 0 n64 ns874 0 9.63753994553e-05
Gc32_875 0 n64 ns875 0 0.00144155500547
Gc32_876 0 n64 ns876 0 -0.00476403778
Gc32_877 0 n64 ns877 0 0.00176123608583
Gc32_878 0 n64 ns878 0 -0.00379156923501
Gc32_879 0 n64 ns879 0 -0.00135026870432
Gc32_880 0 n64 ns880 0 -0.000815093865111
Gc32_881 0 n64 ns881 0 0.000577341893451
Gc32_882 0 n64 ns882 0 1.1239348316e-05
Gc32_883 0 n64 ns883 0 0.000362881879705
Gc32_884 0 n64 ns884 0 0.000582601906106
Gc32_885 0 n64 ns885 0 0.000142530931029
Gc32_886 0 n64 ns886 0 0.000120211545168
Gc32_887 0 n64 ns887 0 -0.000237085418241
Gc32_888 0 n64 ns888 0 0.000474444765639
Gc32_889 0 n64 ns889 0 9.47770787142e-05
Gc32_890 0 n64 ns890 0 -0.00124139094516
Gc32_891 0 n64 ns891 0 0.000449491140316
Gc32_892 0 n64 ns892 0 7.65243686107e-06
Gc32_893 0 n64 ns893 0 0.000215243134626
Gc32_894 0 n64 ns894 0 -0.000827663152453
Gc32_895 0 n64 ns895 0 0.00159301346702
Gc32_896 0 n64 ns896 0 0.0016008678523
Gc32_897 0 n64 ns897 0 0.00260440455416
Gc32_898 0 n64 ns898 0 0.00311336562841
Gc32_899 0 n64 ns899 0 0.00128520524293
Gc32_900 0 n64 ns900 0 0.0034120062629
Gc32_901 0 n64 ns901 0 0.00340131823222
Gc32_902 0 n64 ns902 0 0.000680379479344
Gc32_903 0 n64 ns903 0 0.0012935672752
Gc32_904 0 n64 ns904 0 -0.000539692933933
Gc32_905 0 n64 ns905 0 -0.00344647443452
Gc32_906 0 n64 ns906 0 -9.50811839e-05
Gc32_907 0 n64 ns907 0 -0.000573384924402
Gc32_908 0 n64 ns908 0 -0.00226254497379
Gc32_909 0 n64 ns909 0 0.00385450855258
Gc32_910 0 n64 ns910 0 1.57689091872e-05
Gc32_911 0 n64 ns911 0 -0.000142746548517
Gc32_912 0 n64 ns912 0 3.26739117353e-05
Gc32_913 0 n64 ns913 0 0.0020773504726
Gc32_914 0 n64 ns914 0 -0.00582770256282
Gc32_915 0 n64 ns915 0 0.00185309009289
Gc32_916 0 n64 ns916 0 -0.00446361381183
Gc32_917 0 n64 ns917 0 -0.000809796206581
Gc32_918 0 n64 ns918 0 -0.00105071363275
Gc32_919 0 n64 ns919 0 0.000597522936699
Gc32_920 0 n64 ns920 0 0.00018407819349
Gc32_921 0 n64 ns921 0 -0.000143004066275
Gc32_922 0 n64 ns922 0 0.00039865724337
Gc32_923 0 n64 ns923 0 3.75170515013e-05
Gc32_924 0 n64 ns924 0 8.6289013706e-05
Gc32_925 0 n64 ns925 0 -0.000884161902498
Gc32_926 0 n64 ns926 0 0.000339848938519
Gc32_927 0 n64 ns927 0 0.000433883547029
Gc32_928 0 n64 ns928 0 6.71028875543e-06
Gc32_929 0 n64 ns929 0 -6.97766719426e-05
Gc32_930 0 n64 ns930 0 0.000189852434409
Gc32_931 0 n64 ns931 0 -0.00049630208626
Gc32_932 0 n64 ns932 0 -0.000619315513795
Gc32_933 0 n64 ns933 0 -0.000517637248323
Gc32_934 0 n64 ns934 0 0.00107313702378
Gc32_935 0 n64 ns935 0 0.00604095946178
Gc32_936 0 n64 ns936 0 0.00356431809338
Gc32_937 0 n64 ns937 0 0.00408282093763
Gc32_938 0 n64 ns938 0 0.00335446240884
Gc32_939 0 n64 ns939 0 0.0033449750315
Gc32_940 0 n64 ns940 0 0.00622558379442
Gc32_941 0 n64 ns941 0 0.000736722901254
Gc32_942 0 n64 ns942 0 -0.000154205471214
Gc32_943 0 n64 ns943 0 -0.00745694837236
Gc32_944 0 n64 ns944 0 -0.000942434331612
Gc32_945 0 n64 ns945 0 0.00386838502575
Gc32_946 0 n64 ns946 0 -0.00785298042948
Gc32_947 0 n64 ns947 0 0.00391539562994
Gc32_948 0 n64 ns948 0 1.11321767431e-05
Gc32_949 0 n64 ns949 0 -0.000111946158197
Gc32_950 0 n64 ns950 0 4.97857161708e-06
Gc32_951 0 n64 ns951 0 0.000104983897382
Gc32_952 0 n64 ns952 0 0.000270742966883
Gc32_953 0 n64 ns953 0 0.00049235367425
Gc32_954 0 n64 ns954 0 -0.000403794965372
Gc32_955 0 n64 ns955 0 -4.87390415099e-05
Gc32_956 0 n64 ns956 0 1.47665353333e-05
Gc32_957 0 n64 ns957 0 8.17285645769e-05
Gc32_958 0 n64 ns958 0 -9.82393525306e-06
Gc32_959 0 n64 ns959 0 0.000209892551744
Gc32_960 0 n64 ns960 0 -3.64571461343e-05
Gc32_961 0 n64 ns961 0 -4.96280455482e-05
Gc32_962 0 n64 ns962 0 -3.23269378013e-06
Gc32_963 0 n64 ns963 0 -0.000222475164798
Gc32_964 0 n64 ns964 0 -6.26443392586e-06
Gc32_965 0 n64 ns965 0 -0.000383655161165
Gc32_966 0 n64 ns966 0 -0.000137889152139
Gc32_967 0 n64 ns967 0 -0.00030498400658
Gc32_968 0 n64 ns968 0 3.80177901863e-05
Gc32_969 0 n64 ns969 0 -0.000353305743684
Gc32_970 0 n64 ns970 0 8.43946342459e-06
Gc32_971 0 n64 ns971 0 0.000273747634955
Gc32_972 0 n64 ns972 0 -0.00015298097558
Gc32_973 0 n64 ns973 0 0.000712732752812
Gc32_974 0 n64 ns974 0 -0.00141817003585
Gc32_975 0 n64 ns975 0 0.000602482556811
Gc32_976 0 n64 ns976 0 -0.0012655394473
Gc32_977 0 n64 ns977 0 0.000200939545145
Gc32_978 0 n64 ns978 0 0.000289846897945
Gc32_979 0 n64 ns979 0 -0.000129000285134
Gc32_980 0 n64 ns980 0 -8.03931476511e-05
Gc32_981 0 n64 ns981 0 -0.000470790626426
Gc32_982 0 n64 ns982 0 -0.000195873969745
Gc32_983 0 n64 ns983 0 -0.000188699607516
Gc32_984 0 n64 ns984 0 1.20366516266e-06
Gc32_985 0 n64 ns985 0 6.12733673329e-05
Gc32_986 0 n64 ns986 0 6.06898392138e-06
Gc32_987 0 n64 ns987 0 1.05739235922e-05
Gc32_988 0 n64 ns988 0 -2.53491949326e-05
Gc32_989 0 n64 ns989 0 0.000162563983443
Gc32_990 0 n64 ns990 0 0.000370404791561
Gc32_991 0 n64 ns991 0 0.000741724140145
Gc32_992 0 n64 ns992 0 0.000409017862858
Gc32_993 0 n64 ns993 0 -2.28090497816e-05
Gc32_994 0 n64 ns994 0 0.000112136063171
Gc32_995 0 n64 ns995 0 8.24423141864e-07
Gc32_996 0 n64 ns996 0 2.80084774721e-07
Gc32_997 0 n64 ns997 0 0.000227371823105
Gc32_998 0 n64 ns998 0 0.00031608974223
Gc32_999 0 n64 ns999 0 -3.97215206436e-05
Gc32_1000 0 n64 ns1000 0 -9.37796233291e-05
Gc32_1001 0 n64 ns1001 0 -0.000194728878235
Gc32_1002 0 n64 ns1002 0 -0.00036507991605
Gc32_1003 0 n64 ns1003 0 -4.91837940129e-05
Gc32_1004 0 n64 ns1004 0 -0.000821541789934
Gc32_1005 0 n64 ns1005 0 -0.00031221445451
Gc32_1006 0 n64 ns1006 0 -0.000516429086025
Gc32_1007 0 n64 ns1007 0 -0.000250924009495
Gc32_1008 0 n64 ns1008 0 -0.000648286967196
Gc32_1009 0 n64 ns1009 0 0.000659090865641
Gc32_1010 0 n64 ns1010 0 0.000474260649654
Gc32_1011 0 n64 ns1011 0 0.00318100169223
Gc32_1012 0 n64 ns1012 0 -0.000101809609329
Gc32_1013 0 n64 ns1013 0 0.00278293855863
Gc32_1014 0 n64 ns1014 0 -0.000214928034586
Gc32_1015 0 n64 ns1015 0 0.000625744305492
Gc32_1016 0 n64 ns1016 0 0.000526119022689
Gc32_1017 0 n64 ns1017 0 -0.000245578471646
Gc32_1018 0 n64 ns1018 0 -0.000180330968408
Gc32_1019 0 n64 ns1019 0 -0.0010223335399
Gc32_1020 0 n64 ns1020 0 -0.000522737945253
Gc32_1021 0 n64 ns1021 0 -0.000416431677574
Gc32_1022 0 n64 ns1022 0 -0.000314550903215
Gc32_1023 0 n64 ns1023 0 3.19889931143e-05
Gc32_1024 0 n64 ns1024 0 8.97066092068e-06
Gc32_1025 0 n64 ns1025 0 -2.16791273206e-05
Gc32_1026 0 n64 ns1026 0 -4.31746813997e-06
Gc32_1027 0 n64 ns1027 0 -2.148264973e-05
Gc32_1028 0 n64 ns1028 0 0.000204888842794
Gc32_1029 0 n64 ns1029 0 0.000135176879218
Gc32_1030 0 n64 ns1030 0 0.00129304273128
Gc32_1031 0 n64 ns1031 0 3.87322289055e-05
Gc32_1032 0 n64 ns1032 0 0.000215443394711
Gc32_1033 0 n64 ns1033 0 -9.89724146215e-05
Gc32_1034 0 n64 ns1034 0 -0.000169398739992
Gc32_1035 0 n64 ns1035 0 -0.00021955807884
Gc32_1036 0 n64 ns1036 0 0.000404097824779
Gc32_1037 0 n64 ns1037 0 6.80505521618e-05
Gc32_1038 0 n64 ns1038 0 -0.000167273636491
Gc32_1039 0 n64 ns1039 0 3.32250658405e-05
Gc32_1040 0 n64 ns1040 0 -0.000380559029546
Gc32_1041 0 n64 ns1041 0 0.000965729536334
Gc32_1042 0 n64 ns1042 0 -0.00058021368593
Gc32_1043 0 n64 ns1043 0 0.000286502083465
Gc32_1044 0 n64 ns1044 0 -0.00084868243709
Gc32_1045 0 n64 ns1045 0 0.000404829024195
Gc32_1046 0 n64 ns1046 0 -0.000818399697282
Gc32_1047 0 n64 ns1047 0 2.88323214899e-05
Gc32_1048 0 n64 ns1048 0 0.00116423445232
Gc32_1049 0 n64 ns1049 0 0.00402716665406
Gc32_1050 0 n64 ns1050 0 0.0035627740891
Gc32_1051 0 n64 ns1051 0 0.00373086228852
Gc32_1052 0 n64 ns1052 0 0.00296636710785
Gc32_1053 0 n64 ns1053 0 0.000529417418265
Gc32_1054 0 n64 ns1054 0 0.00122312424668
Gc32_1055 0 n64 ns1055 0 -0.000328718320953
Gc32_1056 0 n64 ns1056 0 -0.000467009928082
Gc32_1057 0 n64 ns1057 0 -0.00133712790742
Gc32_1058 0 n64 ns1058 0 -0.00138107517546
Gc32_1059 0 n64 ns1059 0 -0.000637048001644
Gc32_1060 0 n64 ns1060 0 -0.000627781597465
Gc32_1061 0 n64 ns1061 0 4.44114670629e-05
Gc32_1062 0 n64 ns1062 0 1.37225341404e-05
Gc32_1063 0 n64 ns1063 0 -7.08908346315e-05
Gc32_1064 0 n64 ns1064 0 1.21140897407e-06
Gc32_1065 0 n64 ns1065 0 -0.000185477249936
Gc32_1066 0 n64 ns1066 0 -0.000391083483349
Gc32_1067 0 n64 ns1067 0 -0.000519924711094
Gc32_1068 0 n64 ns1068 0 0.000294949407438
Gc32_1069 0 n64 ns1069 0 0.00013033019914
Gc32_1070 0 n64 ns1070 0 -5.04637420896e-05
Gc32_1071 0 n64 ns1071 0 1.84509267383e-05
Gc32_1072 0 n64 ns1072 0 -2.06090013375e-05
Gc32_1073 0 n64 ns1073 0 -0.000501118167304
Gc32_1074 0 n64 ns1074 0 -0.000297232751722
Gc32_1075 0 n64 ns1075 0 0.000171296123491
Gc32_1076 0 n64 ns1076 0 -7.48742422468e-05
Gc32_1077 0 n64 ns1077 0 2.95345150008e-05
Gc32_1078 0 n64 ns1078 0 7.53797600292e-05
Gc32_1079 0 n64 ns1079 0 0.000539485123172
Gc32_1080 0 n64 ns1080 0 0.00105779039824
Gc32_1081 0 n64 ns1081 0 0.000607614215317
Gc32_1082 0 n64 ns1082 0 -0.000211365796092
Gc32_1083 0 n64 ns1083 0 0.000181408682662
Gc32_1084 0 n64 ns1084 0 2.26314464879e-06
Gc32_1085 0 n64 ns1085 0 -0.00103460728547
Gc32_1086 0 n64 ns1086 0 -0.000352004628017
Gc32_1087 0 n64 ns1087 0 0.00102157566549
Gc32_1088 0 n64 ns1088 0 0.00440947586326
Gc32_1089 0 n64 ns1089 0 0.0013215398777
Gc32_1090 0 n64 ns1090 0 0.00414519320941
Gc32_1091 0 n64 ns1091 0 -0.00164872840988
Gc32_1092 0 n64 ns1092 0 0.000672090201472
Gc32_1093 0 n64 ns1093 0 -2.36534859992e-05
Gc32_1094 0 n64 ns1094 0 -0.000823355370352
Gc32_1095 0 n64 ns1095 0 3.84721138065e-05
Gc32_1096 0 n64 ns1096 0 -0.00145441922663
Gc32_1097 0 n64 ns1097 0 -0.000496373272079
Gc32_1098 0 n64 ns1098 0 0.00101294193305
Gc32_1099 0 n64 ns1099 0 0.000566501833182
Gc32_1100 0 n64 ns1100 0 -7.60903939429e-06
Gc32_1101 0 n64 ns1101 0 -0.000116036325086
Gc32_1102 0 n64 ns1102 0 -1.40399434134e-06
Gc32_1103 0 n64 ns1103 0 0.000419174386398
Gc32_1104 0 n64 ns1104 0 -0.00145279542036
Gc32_1105 0 n64 ns1105 0 0.00103960623306
Gc32_1106 0 n64 ns1106 0 -0.000867071893931
Gc32_1107 0 n64 ns1107 0 -0.000104117172782
Gc32_1108 0 n64 ns1108 0 9.8117003345e-05
Gc32_1109 0 n64 ns1109 0 -2.88151562204e-05
Gc32_1110 0 n64 ns1110 0 7.35392633471e-06
Gc32_1111 0 n64 ns1111 0 0.000252582853074
Gc32_1112 0 n64 ns1112 0 -0.000629186891705
Gc32_1113 0 n64 ns1113 0 0.000180291793195
Gc32_1114 0 n64 ns1114 0 5.02758155508e-05
Gc32_1115 0 n64 ns1115 0 -5.13288930953e-06
Gc32_1116 0 n64 ns1116 0 0.000138029500121
Gc32_1117 0 n64 ns1117 0 -0.0011156259657
Gc32_1118 0 n64 ns1118 0 0.000515761267969
Gc32_1119 0 n64 ns1119 0 0.000411553878249
Gc32_1120 0 n64 ns1120 0 2.57737283843e-05
Gc32_1121 0 n64 ns1121 0 -0.000252645994836
Gc32_1122 0 n64 ns1122 0 -0.000334577771085
Gc32_1123 0 n64 ns1123 0 0.000687824097281
Gc32_1124 0 n64 ns1124 0 -0.00148483105477
Gc32_1125 0 n64 ns1125 0 -0.00108260302826
Gc32_1126 0 n64 ns1126 0 0.00275793817168
Gc32_1127 0 n64 ns1127 0 -0.000848295317761
Gc32_1128 0 n64 ns1128 0 0.00325970378395
Gc32_1129 0 n64 ns1129 0 -0.0021887627255
Gc32_1130 0 n64 ns1130 0 -0.00198465697763
Gc32_1131 0 n64 ns1131 0 0.00068889511864
Gc32_1132 0 n64 ns1132 0 -0.00102995716242
Gc32_1133 0 n64 ns1133 0 0.00127638522655
Gc32_1134 0 n64 ns1134 0 -0.000493898820401
Gc32_1135 0 n64 ns1135 0 -0.0012003065294
Gc32_1136 0 n64 ns1136 0 0.00298873603548
Gc32_1137 0 n64 ns1137 0 0.00160029740392
Gc32_1138 0 n64 ns1138 0 2.06809371306e-05
Gc32_1139 0 n64 ns1139 0 -0.000285128820678
Gc32_1140 0 n64 ns1140 0 0.00010820710746
Gc32_1141 0 n64 ns1141 0 0.000419948207305
Gc32_1142 0 n64 ns1142 0 -0.00225843045305
Gc32_1143 0 n64 ns1143 0 0.000530826615647
Gc32_1144 0 n64 ns1144 0 -0.000864843614672
Gc32_1145 0 n64 ns1145 0 -0.000960593813232
Gc32_1146 0 n64 ns1146 0 0.000206283803749
Gc32_1147 0 n64 ns1147 0 0.000331624742366
Gc32_1148 0 n64 ns1148 0 -0.000337494919846
Gc32_1149 0 n64 ns1149 0 0.000548621465917
Gc32_1150 0 n64 ns1150 0 0.000293419137167
Gc32_1151 0 n64 ns1151 0 0.000187561031018
Gc32_1152 0 n64 ns1152 0 0.000116541235833
Gc32_1153 0 n64 ns1153 0 -0.000112801961841
Gc32_1154 0 n64 ns1154 0 0.00010819739686
Gc32_1155 0 n64 ns1155 0 2.9326882914e-05
Gc32_1156 0 n64 ns1156 0 -0.000994837171467
Gc32_1157 0 n64 ns1157 0 0.000713966180214
Gc32_1158 0 n64 ns1158 0 0.000104799880675
Gc32_1159 0 n64 ns1159 0 0.000455982425134
Gc32_1160 0 n64 ns1160 0 -0.000508328564873
Gc32_1161 0 n64 ns1161 0 0.00124762134152
Gc32_1162 0 n64 ns1162 0 0.00160100981689
Gc32_1163 0 n64 ns1163 0 -0.000763818521689
Gc32_1164 0 n64 ns1164 0 0.00236811859951
Gc32_1165 0 n64 ns1165 0 -0.00123057320054
Gc32_1166 0 n64 ns1166 0 0.00293678244557
Gc32_1167 0 n64 ns1167 0 0.00341433676127
Gc32_1168 0 n64 ns1168 0 -0.000759454265448
Gc32_1169 0 n64 ns1169 0 0.00128567962411
Gc32_1170 0 n64 ns1170 0 -0.000744063733609
Gc32_1171 0 n64 ns1171 0 -0.000838131294682
Gc32_1172 0 n64 ns1172 0 -0.000458219958729
Gc32_1173 0 n64 ns1173 0 -0.00371424419675
Gc32_1174 0 n64 ns1174 0 0.000106623617353
Gc32_1175 0 n64 ns1175 0 0.00320689595157
Gc32_1176 0 n64 ns1176 0 5.12918251303e-05
Gc32_1177 0 n64 ns1177 0 -0.000225258284291
Gc32_1178 0 n64 ns1178 0 6.96869847454e-05
Gc32_1179 0 n64 ns1179 0 0.00099458008094
Gc32_1180 0 n64 ns1180 0 -0.00323562743484
Gc32_1181 0 n64 ns1181 0 -0.000522950956084
Gc32_1182 0 n64 ns1182 0 -0.00212701098621
Gc32_1183 0 n64 ns1183 0 -0.000850161073966
Gc32_1184 0 n64 ns1184 0 -0.000747131002397
Gc32_1185 0 n64 ns1185 0 0.000531888595023
Gc32_1186 0 n64 ns1186 0 5.23578838471e-05
Gc32_1187 0 n64 ns1187 0 -0.000103351872996
Gc32_1188 0 n64 ns1188 0 0.000513545190449
Gc32_1189 0 n64 ns1189 0 0.000101608265374
Gc32_1190 0 n64 ns1190 0 0.000151773295442
Gc32_1191 0 n64 ns1191 0 -0.000503541451153
Gc32_1192 0 n64 ns1192 0 0.000327082473651
Gc32_1193 0 n64 ns1193 0 0.000706402550462
Gc32_1194 0 n64 ns1194 0 -1.24777465157e-05
Gc32_1195 0 n64 ns1195 0 0.000176007414981
Gc32_1196 0 n64 ns1196 0 0.000418176492172
Gc32_1197 0 n64 ns1197 0 -0.000271811129082
Gc32_1198 0 n64 ns1198 0 -0.000249390149756
Gc32_1199 0 n64 ns1199 0 -0.000710312985413
Gc32_1200 0 n64 ns1200 0 0.00116367750755
Gc32_1201 0 n64 ns1201 0 0.00475447916644
Gc32_1202 0 n64 ns1202 0 0.002233195959
Gc32_1203 0 n64 ns1203 0 0.00296134873907
Gc32_1204 0 n64 ns1204 0 0.00241025413094
Gc32_1205 0 n64 ns1205 0 0.00316189313271
Gc32_1206 0 n64 ns1206 0 0.00518674269945
Gc32_1207 0 n64 ns1207 0 0.00109766224504
Gc32_1208 0 n64 ns1208 0 -0.000137262197103
Gc32_1209 0 n64 ns1209 0 -0.00617460967957
Gc32_1210 0 n64 ns1210 0 -0.000287056448217
Gc32_1211 0 n64 ns1211 0 0.00286921440502
Gc32_1212 0 n64 ns1212 0 -0.00567529096655
Gc32_1213 0 n64 ns1213 0 0.00453280367406
Gc32_1214 0 n64 ns1214 0 -9.67839493195e-06
Gc32_1215 0 n64 ns1215 0 0.000115579810686
Gc32_1216 0 n64 ns1216 0 -0.000156676168462
Gd32_1 0 n64 ni1 0 0.000213955331378
Gd32_2 0 n64 ni2 0 -0.000124870914163
Gd32_3 0 n64 ni3 0 6.0033263806e-06
Gd32_4 0 n64 ni4 0 0.000821141729653
Gd32_5 0 n64 ni5 0 0.000212178251915
Gd32_6 0 n64 ni6 0 -0.000438678443679
Gd32_7 0 n64 ni7 0 0.000509679937985
Gd32_8 0 n64 ni8 0 -0.00175881817268
Gd32_9 0 n64 ni9 0 -0.00359116918061
Gd32_10 0 n64 ni10 0 -2.0527572713e-05
Gd32_11 0 n64 ni11 0 0.000623772039886
Gd32_12 0 n64 ni12 0 0.000230753840034
Gd32_13 0 n64 ni13 0 -0.00020405249456
Gd32_14 0 n64 ni14 0 0.000451812416695
Gd32_15 0 n64 ni15 0 8.38789221679e-05
Gd32_16 0 n64 ni16 0 0.000283507819366
Gd32_17 0 n64 ni17 0 -8.24592611977e-05
Gd32_18 0 n64 ni18 0 5.54773077576e-05
Gd32_19 0 n64 ni19 0 -1.13120123133e-06
Gd32_20 0 n64 ni20 0 9.59638400112e-05
Gd32_21 0 n64 ni21 0 0.000195562082789
Gd32_22 0 n64 ni22 0 9.58364785106e-05
Gd32_23 0 n64 ni23 0 -0.00182253168813
Gd32_24 0 n64 ni24 0 -0.0033940984806
Gd32_25 0 n64 ni25 0 -0.00320137755985
Gd32_26 0 n64 ni26 0 -3.35258003569e-05
Gd32_27 0 n64 ni27 0 2.76520588347e-05
Gd32_28 0 n64 ni28 0 0.000284070228066
Gd32_29 0 n64 ni29 0 0.000247420182363
Gd32_30 0 n64 ni30 0 -0.000911857665668
Gd32_31 0 n64 ni31 0 -0.00177845464123
Gd32_32 0 n64 ni32 0 -0.000260871680941
.ends m16lines_HFSS_fws
