* BEGIN ANSOFT HEADER
* node 1    trace_p_0_T1
* node 2    trace_n_0_T1
* node 3    trace_p_1_T1
* node 4    trace_n_1_T1
* node 5    trace_p_2_T1
* node 6    trace_n_2_T1
* node 7    trace_p_3_T1
* node 8    trace_n_3_T1
* node 9    trace_p_4_T1
* node 10   trace_n_4_T1
* node 11   trace_p_5_T1
* node 12   trace_n_5_T1
* node 13   trace_p_6_T1
* node 14   trace_n_6_T1
* node 15   trace_p_7_T1
* node 16   trace_n_7_T1
* node 17   trace_p_0_T2
* node 18   trace_n_0_T2
* node 19   trace_p_1_T2
* node 20   trace_n_1_T2
* node 21   trace_p_2_T2
* node 22   trace_n_2_T2
* node 23   trace_p_3_T2
* node 24   trace_n_3_T2
* node 25   trace_p_4_T2
* node 26   trace_n_4_T2
* node 27   trace_p_5_T2
* node 28   trace_n_5_T2
* node 29   trace_p_6_T2
* node 30   trace_n_6_T2
* node 31   trace_p_7_T2
* node 32   trace_n_7_T2
*   Format: HSPICE
*   Topckt: m16lines_HFSS_fws
*     Date: Sat Jun 06 13:22:46 2020
*    Notes: Frequency range: 1e+08 to 7e+10 Hz, 700 points
*         : Maximum number of poles: 10000
*         : S-Matrix fitting error tolerance: 0.001
*         : Causality check tolerance: auto
*         : Passivity enforcement: on (by iterated fitting)
*         : Causality enforcement: off
*         : Fitting method: FastFit
*         : Matrix fitting: By entire matrix (required by FastFit)
*         : Ensure Z-parameter accuracy: on
*         : Relative error control: off
*         : Common ground option: on
*         : Final fitting error: 0.00438288
*         : Final model order: 1216
* END ANSOFT HEADER

.subckt m16lines_HFSS_fws 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32
Vam1 1 n2 dc 0
Rport1 n2 0 50 noise=0
Vam2 2 n4 dc 0
Rport2 n4 0 50 noise=0
Vam3 3 n6 dc 0
Rport3 n6 0 50 noise=0
Vam4 4 n8 dc 0
Rport4 n8 0 50 noise=0
Vam5 5 n10 dc 0
Rport5 n10 0 50 noise=0
Vam6 6 n12 dc 0
Rport6 n12 0 50 noise=0
Vam7 7 n14 dc 0
Rport7 n14 0 50 noise=0
Vam8 8 n16 dc 0
Rport8 n16 0 50 noise=0
Vam9 9 n18 dc 0
Rport9 n18 0 50 noise=0
Vam10 10 n20 dc 0
Rport10 n20 0 50 noise=0
Vam11 11 n22 dc 0
Rport11 n22 0 50 noise=0
Vam12 12 n24 dc 0
Rport12 n24 0 50 noise=0
Vam13 13 n26 dc 0
Rport13 n26 0 50 noise=0
Vam14 14 n28 dc 0
Rport14 n28 0 50 noise=0
Vam15 15 n30 dc 0
Rport15 n30 0 50 noise=0
Vam16 16 n32 dc 0
Rport16 n32 0 50 noise=0
Vam17 17 n34 dc 0
Rport17 n34 0 50 noise=0
Vam18 18 n36 dc 0
Rport18 n36 0 50 noise=0
Vam19 19 n38 dc 0
Rport19 n38 0 50 noise=0
Vam20 20 n40 dc 0
Rport20 n40 0 50 noise=0
Vam21 21 n42 dc 0
Rport21 n42 0 50 noise=0
Vam22 22 n44 dc 0
Rport22 n44 0 50 noise=0
Vam23 23 n46 dc 0
Rport23 n46 0 50 noise=0
Vam24 24 n48 dc 0
Rport24 n48 0 50 noise=0
Vam25 25 n50 dc 0
Rport25 n50 0 50 noise=0
Vam26 26 n52 dc 0
Rport26 n52 0 50 noise=0
Vam27 27 n54 dc 0
Rport27 n54 0 50 noise=0
Vam28 28 n56 dc 0
Rport28 n56 0 50 noise=0
Vam29 29 n58 dc 0
Rport29 n58 0 50 noise=0
Vam30 30 n60 dc 0
Rport30 n60 0 50 noise=0
Vam31 31 n62 dc 0
Rport31 n62 0 50 noise=0
Vam32 32 n64 dc 0
Rport32 n64 0 50 noise=0

Fi1 0 ni1 Vam1 50
Gi1 0 ni1 1 0 1
Rt1 ni1 0 1 noise=0
Fi2 0 ni2 Vam2 50
Gi2 0 ni2 2 0 1
Rt2 ni2 0 1 noise=0
Fi3 0 ni3 Vam3 50
Gi3 0 ni3 3 0 1
Rt3 ni3 0 1 noise=0
Fi4 0 ni4 Vam4 50
Gi4 0 ni4 4 0 1
Rt4 ni4 0 1 noise=0
Fi5 0 ni5 Vam5 50
Gi5 0 ni5 5 0 1
Rt5 ni5 0 1 noise=0
Fi6 0 ni6 Vam6 50
Gi6 0 ni6 6 0 1
Rt6 ni6 0 1 noise=0
Fi7 0 ni7 Vam7 50
Gi7 0 ni7 7 0 1
Rt7 ni7 0 1 noise=0
Fi8 0 ni8 Vam8 50
Gi8 0 ni8 8 0 1
Rt8 ni8 0 1 noise=0
Fi9 0 ni9 Vam9 50
Gi9 0 ni9 9 0 1
Rt9 ni9 0 1 noise=0
Fi10 0 ni10 Vam10 50
Gi10 0 ni10 10 0 1
Rt10 ni10 0 1 noise=0
Fi11 0 ni11 Vam11 50
Gi11 0 ni11 11 0 1
Rt11 ni11 0 1 noise=0
Fi12 0 ni12 Vam12 50
Gi12 0 ni12 12 0 1
Rt12 ni12 0 1 noise=0
Fi13 0 ni13 Vam13 50
Gi13 0 ni13 13 0 1
Rt13 ni13 0 1 noise=0
Fi14 0 ni14 Vam14 50
Gi14 0 ni14 14 0 1
Rt14 ni14 0 1 noise=0
Fi15 0 ni15 Vam15 50
Gi15 0 ni15 15 0 1
Rt15 ni15 0 1 noise=0
Fi16 0 ni16 Vam16 50
Gi16 0 ni16 16 0 1
Rt16 ni16 0 1 noise=0
Fi17 0 ni17 Vam17 50
Gi17 0 ni17 17 0 1
Rt17 ni17 0 1 noise=0
Fi18 0 ni18 Vam18 50
Gi18 0 ni18 18 0 1
Rt18 ni18 0 1 noise=0
Fi19 0 ni19 Vam19 50
Gi19 0 ni19 19 0 1
Rt19 ni19 0 1 noise=0
Fi20 0 ni20 Vam20 50
Gi20 0 ni20 20 0 1
Rt20 ni20 0 1 noise=0
Fi21 0 ni21 Vam21 50
Gi21 0 ni21 21 0 1
Rt21 ni21 0 1 noise=0
Fi22 0 ni22 Vam22 50
Gi22 0 ni22 22 0 1
Rt22 ni22 0 1 noise=0
Fi23 0 ni23 Vam23 50
Gi23 0 ni23 23 0 1
Rt23 ni23 0 1 noise=0
Fi24 0 ni24 Vam24 50
Gi24 0 ni24 24 0 1
Rt24 ni24 0 1 noise=0
Fi25 0 ni25 Vam25 50
Gi25 0 ni25 25 0 1
Rt25 ni25 0 1 noise=0
Fi26 0 ni26 Vam26 50
Gi26 0 ni26 26 0 1
Rt26 ni26 0 1 noise=0
Fi27 0 ni27 Vam27 50
Gi27 0 ni27 27 0 1
Rt27 ni27 0 1 noise=0
Fi28 0 ni28 Vam28 50
Gi28 0 ni28 28 0 1
Rt28 ni28 0 1 noise=0
Fi29 0 ni29 Vam29 50
Gi29 0 ni29 29 0 1
Rt29 ni29 0 1 noise=0
Fi30 0 ni30 Vam30 50
Gi30 0 ni30 30 0 1
Rt30 ni30 0 1 noise=0
Fi31 0 ni31 Vam31 50
Gi31 0 ni31 31 0 1
Rt31 ni31 0 1 noise=0
Fi32 0 ni32 Vam32 50
Gi32 0 ni32 32 0 1
Rt32 ni32 0 1 noise=0

Ca1 ns1 0 1e-12
Ra1 ns1 0 0.622941609725 noise=0
Ca2 ns2 0 1e-12
Ra2 ns2 0 0.902892370164 noise=0
Ca3 ns3 0 1e-12
Ra3 ns3 0 2.25277197156 noise=0
Ca4 ns4 0 1e-12
Ca5 ns5 0 1e-12
Ra4 ns4 0 12.2584735833 noise=0
Ra5 ns5 0 12.2584735833 noise=0
Ga4 ns4 0 ns5 0 -0.470827691571
Ga5 ns5 0 ns4 0 0.470827691571
Ca6 ns6 0 1e-12
Ca7 ns7 0 1e-12
Ra6 ns6 0 25.6181403896 noise=0
Ra7 ns7 0 25.6181403896 noise=0
Ga6 ns6 0 ns7 0 -0.448026841046
Ga7 ns7 0 ns6 0 0.448026841046
Ca8 ns8 0 1e-12
Ca9 ns9 0 1e-12
Ra8 ns8 0 43.6974661765 noise=0
Ra9 ns9 0 43.6974661765 noise=0
Ga8 ns8 0 ns9 0 -0.43948250501
Ga9 ns9 0 ns8 0 0.43948250501
Ca10 ns10 0 1e-12
Ca11 ns11 0 1e-12
Ra10 ns10 0 18.0397111928 noise=0
Ra11 ns11 0 18.0397111928 noise=0
Ga10 ns10 0 ns11 0 -0.387833034432
Ga11 ns11 0 ns10 0 0.387833034432
Ca12 ns12 0 1e-12
Ca13 ns13 0 1e-12
Ra12 ns12 0 30.8418520482 noise=0
Ra13 ns13 0 30.8418520482 noise=0
Ga12 ns12 0 ns13 0 -0.396001611468
Ga13 ns13 0 ns12 0 0.396001611468
Ca14 ns14 0 1e-12
Ca15 ns15 0 1e-12
Ra14 ns14 0 41.0163217329 noise=0
Ra15 ns15 0 41.0163217329 noise=0
Ga14 ns14 0 ns15 0 -0.381592451289
Ga15 ns15 0 ns14 0 0.381592451289
Ca16 ns16 0 1e-12
Ca17 ns17 0 1e-12
Ra16 ns16 0 21.7602201341 noise=0
Ra17 ns17 0 21.7602201341 noise=0
Ga16 ns16 0 ns17 0 -0.308783855582
Ga17 ns17 0 ns16 0 0.308783855582
Ca18 ns18 0 1e-12
Ca19 ns19 0 1e-12
Ra18 ns18 0 31.7954014875 noise=0
Ra19 ns19 0 31.7954014875 noise=0
Ga18 ns18 0 ns19 0 -0.296374987646
Ga19 ns19 0 ns18 0 0.296374987646
Ca20 ns20 0 1e-12
Ca21 ns21 0 1e-12
Ra20 ns20 0 40.7548915023 noise=0
Ra21 ns21 0 40.7548915023 noise=0
Ga20 ns20 0 ns21 0 -0.280074006701
Ga21 ns21 0 ns20 0 0.280074006701
Ca22 ns22 0 1e-12
Ca23 ns23 0 1e-12
Ra22 ns22 0 16.2605473069 noise=0
Ra23 ns23 0 16.2605473069 noise=0
Ga22 ns22 0 ns23 0 -0.221944572364
Ga23 ns23 0 ns22 0 0.221944572364
Ca24 ns24 0 1e-12
Ca25 ns25 0 1e-12
Ra24 ns24 0 32.2071815157 noise=0
Ra25 ns25 0 32.2071815157 noise=0
Ga24 ns24 0 ns25 0 -0.202528261009
Ga25 ns25 0 ns24 0 0.202528261009
Ca26 ns26 0 1e-12
Ca27 ns27 0 1e-12
Ra26 ns26 0 37.0147768903 noise=0
Ra27 ns27 0 37.0147768903 noise=0
Ga26 ns26 0 ns27 0 -0.196192248457
Ga27 ns27 0 ns26 0 0.196192248457
Ca28 ns28 0 1e-12
Ca29 ns29 0 1e-12
Ra28 ns28 0 14.7020480531 noise=0
Ra29 ns29 0 14.7020480531 noise=0
Ga28 ns28 0 ns29 0 -0.120312309686
Ga29 ns29 0 ns28 0 0.120312309686
Ca30 ns30 0 1e-12
Ca31 ns31 0 1e-12
Ra30 ns30 0 26.4544905299 noise=0
Ra31 ns31 0 26.4544905299 noise=0
Ga30 ns30 0 ns31 0 -0.109680355063
Ga31 ns31 0 ns30 0 0.109680355063
Ca32 ns32 0 1e-12
Ca33 ns33 0 1e-12
Ra32 ns32 0 34.6142502796 noise=0
Ra33 ns33 0 34.6142502796 noise=0
Ga32 ns32 0 ns33 0 -0.0959452774828
Ga33 ns33 0 ns32 0 0.0959452774828
Ca34 ns34 0 1e-12
Ra34 ns34 0 13.7459165429 noise=0
Ca35 ns35 0 1e-12
Ra35 ns35 0 15.4643816792 noise=0
Ca36 ns36 0 1e-12
Ra36 ns36 0 31.0524450378 noise=0
Ca37 ns37 0 1e-12
Ra37 ns37 0 3165.2849616 noise=0
Ca38 ns38 0 1e-12
Ra38 ns38 0 0.000128571428571 noise=0
Ca39 ns39 0 1e-12
Ra39 ns39 0 0.622941609725 noise=0
Ca40 ns40 0 1e-12
Ra40 ns40 0 0.902892370164 noise=0
Ca41 ns41 0 1e-12
Ra41 ns41 0 2.25277197156 noise=0
Ca42 ns42 0 1e-12
Ca43 ns43 0 1e-12
Ra42 ns42 0 12.2584735833 noise=0
Ra43 ns43 0 12.2584735833 noise=0
Ga42 ns42 0 ns43 0 -0.470827691571
Ga43 ns43 0 ns42 0 0.470827691571
Ca44 ns44 0 1e-12
Ca45 ns45 0 1e-12
Ra44 ns44 0 25.6181403896 noise=0
Ra45 ns45 0 25.6181403896 noise=0
Ga44 ns44 0 ns45 0 -0.448026841046
Ga45 ns45 0 ns44 0 0.448026841046
Ca46 ns46 0 1e-12
Ca47 ns47 0 1e-12
Ra46 ns46 0 43.6974661765 noise=0
Ra47 ns47 0 43.6974661765 noise=0
Ga46 ns46 0 ns47 0 -0.43948250501
Ga47 ns47 0 ns46 0 0.43948250501
Ca48 ns48 0 1e-12
Ca49 ns49 0 1e-12
Ra48 ns48 0 18.0397111928 noise=0
Ra49 ns49 0 18.0397111928 noise=0
Ga48 ns48 0 ns49 0 -0.387833034432
Ga49 ns49 0 ns48 0 0.387833034432
Ca50 ns50 0 1e-12
Ca51 ns51 0 1e-12
Ra50 ns50 0 30.8418520482 noise=0
Ra51 ns51 0 30.8418520482 noise=0
Ga50 ns50 0 ns51 0 -0.396001611468
Ga51 ns51 0 ns50 0 0.396001611468
Ca52 ns52 0 1e-12
Ca53 ns53 0 1e-12
Ra52 ns52 0 41.0163217329 noise=0
Ra53 ns53 0 41.0163217329 noise=0
Ga52 ns52 0 ns53 0 -0.381592451289
Ga53 ns53 0 ns52 0 0.381592451289
Ca54 ns54 0 1e-12
Ca55 ns55 0 1e-12
Ra54 ns54 0 21.7602201341 noise=0
Ra55 ns55 0 21.7602201341 noise=0
Ga54 ns54 0 ns55 0 -0.308783855582
Ga55 ns55 0 ns54 0 0.308783855582
Ca56 ns56 0 1e-12
Ca57 ns57 0 1e-12
Ra56 ns56 0 31.7954014875 noise=0
Ra57 ns57 0 31.7954014875 noise=0
Ga56 ns56 0 ns57 0 -0.296374987646
Ga57 ns57 0 ns56 0 0.296374987646
Ca58 ns58 0 1e-12
Ca59 ns59 0 1e-12
Ra58 ns58 0 40.7548915023 noise=0
Ra59 ns59 0 40.7548915023 noise=0
Ga58 ns58 0 ns59 0 -0.280074006701
Ga59 ns59 0 ns58 0 0.280074006701
Ca60 ns60 0 1e-12
Ca61 ns61 0 1e-12
Ra60 ns60 0 16.2605473069 noise=0
Ra61 ns61 0 16.2605473069 noise=0
Ga60 ns60 0 ns61 0 -0.221944572364
Ga61 ns61 0 ns60 0 0.221944572364
Ca62 ns62 0 1e-12
Ca63 ns63 0 1e-12
Ra62 ns62 0 32.2071815157 noise=0
Ra63 ns63 0 32.2071815157 noise=0
Ga62 ns62 0 ns63 0 -0.202528261009
Ga63 ns63 0 ns62 0 0.202528261009
Ca64 ns64 0 1e-12
Ca65 ns65 0 1e-12
Ra64 ns64 0 37.0147768903 noise=0
Ra65 ns65 0 37.0147768903 noise=0
Ga64 ns64 0 ns65 0 -0.196192248457
Ga65 ns65 0 ns64 0 0.196192248457
Ca66 ns66 0 1e-12
Ca67 ns67 0 1e-12
Ra66 ns66 0 14.7020480531 noise=0
Ra67 ns67 0 14.7020480531 noise=0
Ga66 ns66 0 ns67 0 -0.120312309686
Ga67 ns67 0 ns66 0 0.120312309686
Ca68 ns68 0 1e-12
Ca69 ns69 0 1e-12
Ra68 ns68 0 26.4544905299 noise=0
Ra69 ns69 0 26.4544905299 noise=0
Ga68 ns68 0 ns69 0 -0.109680355063
Ga69 ns69 0 ns68 0 0.109680355063
Ca70 ns70 0 1e-12
Ca71 ns71 0 1e-12
Ra70 ns70 0 34.6142502796 noise=0
Ra71 ns71 0 34.6142502796 noise=0
Ga70 ns70 0 ns71 0 -0.0959452774828
Ga71 ns71 0 ns70 0 0.0959452774828
Ca72 ns72 0 1e-12
Ra72 ns72 0 13.7459165429 noise=0
Ca73 ns73 0 1e-12
Ra73 ns73 0 15.4643816792 noise=0
Ca74 ns74 0 1e-12
Ra74 ns74 0 31.0524450378 noise=0
Ca75 ns75 0 1e-12
Ra75 ns75 0 3165.2849616 noise=0
Ca76 ns76 0 1e-12
Ra76 ns76 0 0.000128571428571 noise=0
Ca77 ns77 0 1e-12
Ra77 ns77 0 0.622941609725 noise=0
Ca78 ns78 0 1e-12
Ra78 ns78 0 0.902892370164 noise=0
Ca79 ns79 0 1e-12
Ra79 ns79 0 2.25277197156 noise=0
Ca80 ns80 0 1e-12
Ca81 ns81 0 1e-12
Ra80 ns80 0 12.2584735833 noise=0
Ra81 ns81 0 12.2584735833 noise=0
Ga80 ns80 0 ns81 0 -0.470827691571
Ga81 ns81 0 ns80 0 0.470827691571
Ca82 ns82 0 1e-12
Ca83 ns83 0 1e-12
Ra82 ns82 0 25.6181403896 noise=0
Ra83 ns83 0 25.6181403896 noise=0
Ga82 ns82 0 ns83 0 -0.448026841046
Ga83 ns83 0 ns82 0 0.448026841046
Ca84 ns84 0 1e-12
Ca85 ns85 0 1e-12
Ra84 ns84 0 43.6974661765 noise=0
Ra85 ns85 0 43.6974661765 noise=0
Ga84 ns84 0 ns85 0 -0.43948250501
Ga85 ns85 0 ns84 0 0.43948250501
Ca86 ns86 0 1e-12
Ca87 ns87 0 1e-12
Ra86 ns86 0 18.0397111928 noise=0
Ra87 ns87 0 18.0397111928 noise=0
Ga86 ns86 0 ns87 0 -0.387833034432
Ga87 ns87 0 ns86 0 0.387833034432
Ca88 ns88 0 1e-12
Ca89 ns89 0 1e-12
Ra88 ns88 0 30.8418520482 noise=0
Ra89 ns89 0 30.8418520482 noise=0
Ga88 ns88 0 ns89 0 -0.396001611468
Ga89 ns89 0 ns88 0 0.396001611468
Ca90 ns90 0 1e-12
Ca91 ns91 0 1e-12
Ra90 ns90 0 41.0163217329 noise=0
Ra91 ns91 0 41.0163217329 noise=0
Ga90 ns90 0 ns91 0 -0.381592451289
Ga91 ns91 0 ns90 0 0.381592451289
Ca92 ns92 0 1e-12
Ca93 ns93 0 1e-12
Ra92 ns92 0 21.7602201341 noise=0
Ra93 ns93 0 21.7602201341 noise=0
Ga92 ns92 0 ns93 0 -0.308783855582
Ga93 ns93 0 ns92 0 0.308783855582
Ca94 ns94 0 1e-12
Ca95 ns95 0 1e-12
Ra94 ns94 0 31.7954014875 noise=0
Ra95 ns95 0 31.7954014875 noise=0
Ga94 ns94 0 ns95 0 -0.296374987646
Ga95 ns95 0 ns94 0 0.296374987646
Ca96 ns96 0 1e-12
Ca97 ns97 0 1e-12
Ra96 ns96 0 40.7548915023 noise=0
Ra97 ns97 0 40.7548915023 noise=0
Ga96 ns96 0 ns97 0 -0.280074006701
Ga97 ns97 0 ns96 0 0.280074006701
Ca98 ns98 0 1e-12
Ca99 ns99 0 1e-12
Ra98 ns98 0 16.2605473069 noise=0
Ra99 ns99 0 16.2605473069 noise=0
Ga98 ns98 0 ns99 0 -0.221944572364
Ga99 ns99 0 ns98 0 0.221944572364
Ca100 ns100 0 1e-12
Ca101 ns101 0 1e-12
Ra100 ns100 0 32.2071815157 noise=0
Ra101 ns101 0 32.2071815157 noise=0
Ga100 ns100 0 ns101 0 -0.202528261009
Ga101 ns101 0 ns100 0 0.202528261009
Ca102 ns102 0 1e-12
Ca103 ns103 0 1e-12
Ra102 ns102 0 37.0147768903 noise=0
Ra103 ns103 0 37.0147768903 noise=0
Ga102 ns102 0 ns103 0 -0.196192248457
Ga103 ns103 0 ns102 0 0.196192248457
Ca104 ns104 0 1e-12
Ca105 ns105 0 1e-12
Ra104 ns104 0 14.7020480531 noise=0
Ra105 ns105 0 14.7020480531 noise=0
Ga104 ns104 0 ns105 0 -0.120312309686
Ga105 ns105 0 ns104 0 0.120312309686
Ca106 ns106 0 1e-12
Ca107 ns107 0 1e-12
Ra106 ns106 0 26.4544905299 noise=0
Ra107 ns107 0 26.4544905299 noise=0
Ga106 ns106 0 ns107 0 -0.109680355063
Ga107 ns107 0 ns106 0 0.109680355063
Ca108 ns108 0 1e-12
Ca109 ns109 0 1e-12
Ra108 ns108 0 34.6142502796 noise=0
Ra109 ns109 0 34.6142502796 noise=0
Ga108 ns108 0 ns109 0 -0.0959452774828
Ga109 ns109 0 ns108 0 0.0959452774828
Ca110 ns110 0 1e-12
Ra110 ns110 0 13.7459165429 noise=0
Ca111 ns111 0 1e-12
Ra111 ns111 0 15.4643816792 noise=0
Ca112 ns112 0 1e-12
Ra112 ns112 0 31.0524450378 noise=0
Ca113 ns113 0 1e-12
Ra113 ns113 0 3165.2849616 noise=0
Ca114 ns114 0 1e-12
Ra114 ns114 0 0.000128571428571 noise=0
Ca115 ns115 0 1e-12
Ra115 ns115 0 0.622941609725 noise=0
Ca116 ns116 0 1e-12
Ra116 ns116 0 0.902892370164 noise=0
Ca117 ns117 0 1e-12
Ra117 ns117 0 2.25277197156 noise=0
Ca118 ns118 0 1e-12
Ca119 ns119 0 1e-12
Ra118 ns118 0 12.2584735833 noise=0
Ra119 ns119 0 12.2584735833 noise=0
Ga118 ns118 0 ns119 0 -0.470827691571
Ga119 ns119 0 ns118 0 0.470827691571
Ca120 ns120 0 1e-12
Ca121 ns121 0 1e-12
Ra120 ns120 0 25.6181403896 noise=0
Ra121 ns121 0 25.6181403896 noise=0
Ga120 ns120 0 ns121 0 -0.448026841046
Ga121 ns121 0 ns120 0 0.448026841046
Ca122 ns122 0 1e-12
Ca123 ns123 0 1e-12
Ra122 ns122 0 43.6974661765 noise=0
Ra123 ns123 0 43.6974661765 noise=0
Ga122 ns122 0 ns123 0 -0.43948250501
Ga123 ns123 0 ns122 0 0.43948250501
Ca124 ns124 0 1e-12
Ca125 ns125 0 1e-12
Ra124 ns124 0 18.0397111928 noise=0
Ra125 ns125 0 18.0397111928 noise=0
Ga124 ns124 0 ns125 0 -0.387833034432
Ga125 ns125 0 ns124 0 0.387833034432
Ca126 ns126 0 1e-12
Ca127 ns127 0 1e-12
Ra126 ns126 0 30.8418520482 noise=0
Ra127 ns127 0 30.8418520482 noise=0
Ga126 ns126 0 ns127 0 -0.396001611468
Ga127 ns127 0 ns126 0 0.396001611468
Ca128 ns128 0 1e-12
Ca129 ns129 0 1e-12
Ra128 ns128 0 41.0163217329 noise=0
Ra129 ns129 0 41.0163217329 noise=0
Ga128 ns128 0 ns129 0 -0.381592451289
Ga129 ns129 0 ns128 0 0.381592451289
Ca130 ns130 0 1e-12
Ca131 ns131 0 1e-12
Ra130 ns130 0 21.7602201341 noise=0
Ra131 ns131 0 21.7602201341 noise=0
Ga130 ns130 0 ns131 0 -0.308783855582
Ga131 ns131 0 ns130 0 0.308783855582
Ca132 ns132 0 1e-12
Ca133 ns133 0 1e-12
Ra132 ns132 0 31.7954014875 noise=0
Ra133 ns133 0 31.7954014875 noise=0
Ga132 ns132 0 ns133 0 -0.296374987646
Ga133 ns133 0 ns132 0 0.296374987646
Ca134 ns134 0 1e-12
Ca135 ns135 0 1e-12
Ra134 ns134 0 40.7548915023 noise=0
Ra135 ns135 0 40.7548915023 noise=0
Ga134 ns134 0 ns135 0 -0.280074006701
Ga135 ns135 0 ns134 0 0.280074006701
Ca136 ns136 0 1e-12
Ca137 ns137 0 1e-12
Ra136 ns136 0 16.2605473069 noise=0
Ra137 ns137 0 16.2605473069 noise=0
Ga136 ns136 0 ns137 0 -0.221944572364
Ga137 ns137 0 ns136 0 0.221944572364
Ca138 ns138 0 1e-12
Ca139 ns139 0 1e-12
Ra138 ns138 0 32.2071815157 noise=0
Ra139 ns139 0 32.2071815157 noise=0
Ga138 ns138 0 ns139 0 -0.202528261009
Ga139 ns139 0 ns138 0 0.202528261009
Ca140 ns140 0 1e-12
Ca141 ns141 0 1e-12
Ra140 ns140 0 37.0147768903 noise=0
Ra141 ns141 0 37.0147768903 noise=0
Ga140 ns140 0 ns141 0 -0.196192248457
Ga141 ns141 0 ns140 0 0.196192248457
Ca142 ns142 0 1e-12
Ca143 ns143 0 1e-12
Ra142 ns142 0 14.7020480531 noise=0
Ra143 ns143 0 14.7020480531 noise=0
Ga142 ns142 0 ns143 0 -0.120312309686
Ga143 ns143 0 ns142 0 0.120312309686
Ca144 ns144 0 1e-12
Ca145 ns145 0 1e-12
Ra144 ns144 0 26.4544905299 noise=0
Ra145 ns145 0 26.4544905299 noise=0
Ga144 ns144 0 ns145 0 -0.109680355063
Ga145 ns145 0 ns144 0 0.109680355063
Ca146 ns146 0 1e-12
Ca147 ns147 0 1e-12
Ra146 ns146 0 34.6142502796 noise=0
Ra147 ns147 0 34.6142502796 noise=0
Ga146 ns146 0 ns147 0 -0.0959452774828
Ga147 ns147 0 ns146 0 0.0959452774828
Ca148 ns148 0 1e-12
Ra148 ns148 0 13.7459165429 noise=0
Ca149 ns149 0 1e-12
Ra149 ns149 0 15.4643816792 noise=0
Ca150 ns150 0 1e-12
Ra150 ns150 0 31.0524450378 noise=0
Ca151 ns151 0 1e-12
Ra151 ns151 0 3165.2849616 noise=0
Ca152 ns152 0 1e-12
Ra152 ns152 0 0.000128571428571 noise=0
Ca153 ns153 0 1e-12
Ra153 ns153 0 0.622941609725 noise=0
Ca154 ns154 0 1e-12
Ra154 ns154 0 0.902892370164 noise=0
Ca155 ns155 0 1e-12
Ra155 ns155 0 2.25277197156 noise=0
Ca156 ns156 0 1e-12
Ca157 ns157 0 1e-12
Ra156 ns156 0 12.2584735833 noise=0
Ra157 ns157 0 12.2584735833 noise=0
Ga156 ns156 0 ns157 0 -0.470827691571
Ga157 ns157 0 ns156 0 0.470827691571
Ca158 ns158 0 1e-12
Ca159 ns159 0 1e-12
Ra158 ns158 0 25.6181403896 noise=0
Ra159 ns159 0 25.6181403896 noise=0
Ga158 ns158 0 ns159 0 -0.448026841046
Ga159 ns159 0 ns158 0 0.448026841046
Ca160 ns160 0 1e-12
Ca161 ns161 0 1e-12
Ra160 ns160 0 43.6974661765 noise=0
Ra161 ns161 0 43.6974661765 noise=0
Ga160 ns160 0 ns161 0 -0.43948250501
Ga161 ns161 0 ns160 0 0.43948250501
Ca162 ns162 0 1e-12
Ca163 ns163 0 1e-12
Ra162 ns162 0 18.0397111928 noise=0
Ra163 ns163 0 18.0397111928 noise=0
Ga162 ns162 0 ns163 0 -0.387833034432
Ga163 ns163 0 ns162 0 0.387833034432
Ca164 ns164 0 1e-12
Ca165 ns165 0 1e-12
Ra164 ns164 0 30.8418520482 noise=0
Ra165 ns165 0 30.8418520482 noise=0
Ga164 ns164 0 ns165 0 -0.396001611468
Ga165 ns165 0 ns164 0 0.396001611468
Ca166 ns166 0 1e-12
Ca167 ns167 0 1e-12
Ra166 ns166 0 41.0163217329 noise=0
Ra167 ns167 0 41.0163217329 noise=0
Ga166 ns166 0 ns167 0 -0.381592451289
Ga167 ns167 0 ns166 0 0.381592451289
Ca168 ns168 0 1e-12
Ca169 ns169 0 1e-12
Ra168 ns168 0 21.7602201341 noise=0
Ra169 ns169 0 21.7602201341 noise=0
Ga168 ns168 0 ns169 0 -0.308783855582
Ga169 ns169 0 ns168 0 0.308783855582
Ca170 ns170 0 1e-12
Ca171 ns171 0 1e-12
Ra170 ns170 0 31.7954014875 noise=0
Ra171 ns171 0 31.7954014875 noise=0
Ga170 ns170 0 ns171 0 -0.296374987646
Ga171 ns171 0 ns170 0 0.296374987646
Ca172 ns172 0 1e-12
Ca173 ns173 0 1e-12
Ra172 ns172 0 40.7548915023 noise=0
Ra173 ns173 0 40.7548915023 noise=0
Ga172 ns172 0 ns173 0 -0.280074006701
Ga173 ns173 0 ns172 0 0.280074006701
Ca174 ns174 0 1e-12
Ca175 ns175 0 1e-12
Ra174 ns174 0 16.2605473069 noise=0
Ra175 ns175 0 16.2605473069 noise=0
Ga174 ns174 0 ns175 0 -0.221944572364
Ga175 ns175 0 ns174 0 0.221944572364
Ca176 ns176 0 1e-12
Ca177 ns177 0 1e-12
Ra176 ns176 0 32.2071815157 noise=0
Ra177 ns177 0 32.2071815157 noise=0
Ga176 ns176 0 ns177 0 -0.202528261009
Ga177 ns177 0 ns176 0 0.202528261009
Ca178 ns178 0 1e-12
Ca179 ns179 0 1e-12
Ra178 ns178 0 37.0147768903 noise=0
Ra179 ns179 0 37.0147768903 noise=0
Ga178 ns178 0 ns179 0 -0.196192248457
Ga179 ns179 0 ns178 0 0.196192248457
Ca180 ns180 0 1e-12
Ca181 ns181 0 1e-12
Ra180 ns180 0 14.7020480531 noise=0
Ra181 ns181 0 14.7020480531 noise=0
Ga180 ns180 0 ns181 0 -0.120312309686
Ga181 ns181 0 ns180 0 0.120312309686
Ca182 ns182 0 1e-12
Ca183 ns183 0 1e-12
Ra182 ns182 0 26.4544905299 noise=0
Ra183 ns183 0 26.4544905299 noise=0
Ga182 ns182 0 ns183 0 -0.109680355063
Ga183 ns183 0 ns182 0 0.109680355063
Ca184 ns184 0 1e-12
Ca185 ns185 0 1e-12
Ra184 ns184 0 34.6142502796 noise=0
Ra185 ns185 0 34.6142502796 noise=0
Ga184 ns184 0 ns185 0 -0.0959452774828
Ga185 ns185 0 ns184 0 0.0959452774828
Ca186 ns186 0 1e-12
Ra186 ns186 0 13.7459165429 noise=0
Ca187 ns187 0 1e-12
Ra187 ns187 0 15.4643816792 noise=0
Ca188 ns188 0 1e-12
Ra188 ns188 0 31.0524450378 noise=0
Ca189 ns189 0 1e-12
Ra189 ns189 0 3165.2849616 noise=0
Ca190 ns190 0 1e-12
Ra190 ns190 0 0.000128571428571 noise=0
Ca191 ns191 0 1e-12
Ra191 ns191 0 0.622941609725 noise=0
Ca192 ns192 0 1e-12
Ra192 ns192 0 0.902892370164 noise=0
Ca193 ns193 0 1e-12
Ra193 ns193 0 2.25277197156 noise=0
Ca194 ns194 0 1e-12
Ca195 ns195 0 1e-12
Ra194 ns194 0 12.2584735833 noise=0
Ra195 ns195 0 12.2584735833 noise=0
Ga194 ns194 0 ns195 0 -0.470827691571
Ga195 ns195 0 ns194 0 0.470827691571
Ca196 ns196 0 1e-12
Ca197 ns197 0 1e-12
Ra196 ns196 0 25.6181403896 noise=0
Ra197 ns197 0 25.6181403896 noise=0
Ga196 ns196 0 ns197 0 -0.448026841046
Ga197 ns197 0 ns196 0 0.448026841046
Ca198 ns198 0 1e-12
Ca199 ns199 0 1e-12
Ra198 ns198 0 43.6974661765 noise=0
Ra199 ns199 0 43.6974661765 noise=0
Ga198 ns198 0 ns199 0 -0.43948250501
Ga199 ns199 0 ns198 0 0.43948250501
Ca200 ns200 0 1e-12
Ca201 ns201 0 1e-12
Ra200 ns200 0 18.0397111928 noise=0
Ra201 ns201 0 18.0397111928 noise=0
Ga200 ns200 0 ns201 0 -0.387833034432
Ga201 ns201 0 ns200 0 0.387833034432
Ca202 ns202 0 1e-12
Ca203 ns203 0 1e-12
Ra202 ns202 0 30.8418520482 noise=0
Ra203 ns203 0 30.8418520482 noise=0
Ga202 ns202 0 ns203 0 -0.396001611468
Ga203 ns203 0 ns202 0 0.396001611468
Ca204 ns204 0 1e-12
Ca205 ns205 0 1e-12
Ra204 ns204 0 41.0163217329 noise=0
Ra205 ns205 0 41.0163217329 noise=0
Ga204 ns204 0 ns205 0 -0.381592451289
Ga205 ns205 0 ns204 0 0.381592451289
Ca206 ns206 0 1e-12
Ca207 ns207 0 1e-12
Ra206 ns206 0 21.7602201341 noise=0
Ra207 ns207 0 21.7602201341 noise=0
Ga206 ns206 0 ns207 0 -0.308783855582
Ga207 ns207 0 ns206 0 0.308783855582
Ca208 ns208 0 1e-12
Ca209 ns209 0 1e-12
Ra208 ns208 0 31.7954014875 noise=0
Ra209 ns209 0 31.7954014875 noise=0
Ga208 ns208 0 ns209 0 -0.296374987646
Ga209 ns209 0 ns208 0 0.296374987646
Ca210 ns210 0 1e-12
Ca211 ns211 0 1e-12
Ra210 ns210 0 40.7548915023 noise=0
Ra211 ns211 0 40.7548915023 noise=0
Ga210 ns210 0 ns211 0 -0.280074006701
Ga211 ns211 0 ns210 0 0.280074006701
Ca212 ns212 0 1e-12
Ca213 ns213 0 1e-12
Ra212 ns212 0 16.2605473069 noise=0
Ra213 ns213 0 16.2605473069 noise=0
Ga212 ns212 0 ns213 0 -0.221944572364
Ga213 ns213 0 ns212 0 0.221944572364
Ca214 ns214 0 1e-12
Ca215 ns215 0 1e-12
Ra214 ns214 0 32.2071815157 noise=0
Ra215 ns215 0 32.2071815157 noise=0
Ga214 ns214 0 ns215 0 -0.202528261009
Ga215 ns215 0 ns214 0 0.202528261009
Ca216 ns216 0 1e-12
Ca217 ns217 0 1e-12
Ra216 ns216 0 37.0147768903 noise=0
Ra217 ns217 0 37.0147768903 noise=0
Ga216 ns216 0 ns217 0 -0.196192248457
Ga217 ns217 0 ns216 0 0.196192248457
Ca218 ns218 0 1e-12
Ca219 ns219 0 1e-12
Ra218 ns218 0 14.7020480531 noise=0
Ra219 ns219 0 14.7020480531 noise=0
Ga218 ns218 0 ns219 0 -0.120312309686
Ga219 ns219 0 ns218 0 0.120312309686
Ca220 ns220 0 1e-12
Ca221 ns221 0 1e-12
Ra220 ns220 0 26.4544905299 noise=0
Ra221 ns221 0 26.4544905299 noise=0
Ga220 ns220 0 ns221 0 -0.109680355063
Ga221 ns221 0 ns220 0 0.109680355063
Ca222 ns222 0 1e-12
Ca223 ns223 0 1e-12
Ra222 ns222 0 34.6142502796 noise=0
Ra223 ns223 0 34.6142502796 noise=0
Ga222 ns222 0 ns223 0 -0.0959452774828
Ga223 ns223 0 ns222 0 0.0959452774828
Ca224 ns224 0 1e-12
Ra224 ns224 0 13.7459165429 noise=0
Ca225 ns225 0 1e-12
Ra225 ns225 0 15.4643816792 noise=0
Ca226 ns226 0 1e-12
Ra226 ns226 0 31.0524450378 noise=0
Ca227 ns227 0 1e-12
Ra227 ns227 0 3165.2849616 noise=0
Ca228 ns228 0 1e-12
Ra228 ns228 0 0.000128571428571 noise=0
Ca229 ns229 0 1e-12
Ra229 ns229 0 0.622941609725 noise=0
Ca230 ns230 0 1e-12
Ra230 ns230 0 0.902892370164 noise=0
Ca231 ns231 0 1e-12
Ra231 ns231 0 2.25277197156 noise=0
Ca232 ns232 0 1e-12
Ca233 ns233 0 1e-12
Ra232 ns232 0 12.2584735833 noise=0
Ra233 ns233 0 12.2584735833 noise=0
Ga232 ns232 0 ns233 0 -0.470827691571
Ga233 ns233 0 ns232 0 0.470827691571
Ca234 ns234 0 1e-12
Ca235 ns235 0 1e-12
Ra234 ns234 0 25.6181403896 noise=0
Ra235 ns235 0 25.6181403896 noise=0
Ga234 ns234 0 ns235 0 -0.448026841046
Ga235 ns235 0 ns234 0 0.448026841046
Ca236 ns236 0 1e-12
Ca237 ns237 0 1e-12
Ra236 ns236 0 43.6974661765 noise=0
Ra237 ns237 0 43.6974661765 noise=0
Ga236 ns236 0 ns237 0 -0.43948250501
Ga237 ns237 0 ns236 0 0.43948250501
Ca238 ns238 0 1e-12
Ca239 ns239 0 1e-12
Ra238 ns238 0 18.0397111928 noise=0
Ra239 ns239 0 18.0397111928 noise=0
Ga238 ns238 0 ns239 0 -0.387833034432
Ga239 ns239 0 ns238 0 0.387833034432
Ca240 ns240 0 1e-12
Ca241 ns241 0 1e-12
Ra240 ns240 0 30.8418520482 noise=0
Ra241 ns241 0 30.8418520482 noise=0
Ga240 ns240 0 ns241 0 -0.396001611468
Ga241 ns241 0 ns240 0 0.396001611468
Ca242 ns242 0 1e-12
Ca243 ns243 0 1e-12
Ra242 ns242 0 41.0163217329 noise=0
Ra243 ns243 0 41.0163217329 noise=0
Ga242 ns242 0 ns243 0 -0.381592451289
Ga243 ns243 0 ns242 0 0.381592451289
Ca244 ns244 0 1e-12
Ca245 ns245 0 1e-12
Ra244 ns244 0 21.7602201341 noise=0
Ra245 ns245 0 21.7602201341 noise=0
Ga244 ns244 0 ns245 0 -0.308783855582
Ga245 ns245 0 ns244 0 0.308783855582
Ca246 ns246 0 1e-12
Ca247 ns247 0 1e-12
Ra246 ns246 0 31.7954014875 noise=0
Ra247 ns247 0 31.7954014875 noise=0
Ga246 ns246 0 ns247 0 -0.296374987646
Ga247 ns247 0 ns246 0 0.296374987646
Ca248 ns248 0 1e-12
Ca249 ns249 0 1e-12
Ra248 ns248 0 40.7548915023 noise=0
Ra249 ns249 0 40.7548915023 noise=0
Ga248 ns248 0 ns249 0 -0.280074006701
Ga249 ns249 0 ns248 0 0.280074006701
Ca250 ns250 0 1e-12
Ca251 ns251 0 1e-12
Ra250 ns250 0 16.2605473069 noise=0
Ra251 ns251 0 16.2605473069 noise=0
Ga250 ns250 0 ns251 0 -0.221944572364
Ga251 ns251 0 ns250 0 0.221944572364
Ca252 ns252 0 1e-12
Ca253 ns253 0 1e-12
Ra252 ns252 0 32.2071815157 noise=0
Ra253 ns253 0 32.2071815157 noise=0
Ga252 ns252 0 ns253 0 -0.202528261009
Ga253 ns253 0 ns252 0 0.202528261009
Ca254 ns254 0 1e-12
Ca255 ns255 0 1e-12
Ra254 ns254 0 37.0147768903 noise=0
Ra255 ns255 0 37.0147768903 noise=0
Ga254 ns254 0 ns255 0 -0.196192248457
Ga255 ns255 0 ns254 0 0.196192248457
Ca256 ns256 0 1e-12
Ca257 ns257 0 1e-12
Ra256 ns256 0 14.7020480531 noise=0
Ra257 ns257 0 14.7020480531 noise=0
Ga256 ns256 0 ns257 0 -0.120312309686
Ga257 ns257 0 ns256 0 0.120312309686
Ca258 ns258 0 1e-12
Ca259 ns259 0 1e-12
Ra258 ns258 0 26.4544905299 noise=0
Ra259 ns259 0 26.4544905299 noise=0
Ga258 ns258 0 ns259 0 -0.109680355063
Ga259 ns259 0 ns258 0 0.109680355063
Ca260 ns260 0 1e-12
Ca261 ns261 0 1e-12
Ra260 ns260 0 34.6142502796 noise=0
Ra261 ns261 0 34.6142502796 noise=0
Ga260 ns260 0 ns261 0 -0.0959452774828
Ga261 ns261 0 ns260 0 0.0959452774828
Ca262 ns262 0 1e-12
Ra262 ns262 0 13.7459165429 noise=0
Ca263 ns263 0 1e-12
Ra263 ns263 0 15.4643816792 noise=0
Ca264 ns264 0 1e-12
Ra264 ns264 0 31.0524450378 noise=0
Ca265 ns265 0 1e-12
Ra265 ns265 0 3165.2849616 noise=0
Ca266 ns266 0 1e-12
Ra266 ns266 0 0.000128571428571 noise=0
Ca267 ns267 0 1e-12
Ra267 ns267 0 0.622941609725 noise=0
Ca268 ns268 0 1e-12
Ra268 ns268 0 0.902892370164 noise=0
Ca269 ns269 0 1e-12
Ra269 ns269 0 2.25277197156 noise=0
Ca270 ns270 0 1e-12
Ca271 ns271 0 1e-12
Ra270 ns270 0 12.2584735833 noise=0
Ra271 ns271 0 12.2584735833 noise=0
Ga270 ns270 0 ns271 0 -0.470827691571
Ga271 ns271 0 ns270 0 0.470827691571
Ca272 ns272 0 1e-12
Ca273 ns273 0 1e-12
Ra272 ns272 0 25.6181403896 noise=0
Ra273 ns273 0 25.6181403896 noise=0
Ga272 ns272 0 ns273 0 -0.448026841046
Ga273 ns273 0 ns272 0 0.448026841046
Ca274 ns274 0 1e-12
Ca275 ns275 0 1e-12
Ra274 ns274 0 43.6974661765 noise=0
Ra275 ns275 0 43.6974661765 noise=0
Ga274 ns274 0 ns275 0 -0.43948250501
Ga275 ns275 0 ns274 0 0.43948250501
Ca276 ns276 0 1e-12
Ca277 ns277 0 1e-12
Ra276 ns276 0 18.0397111928 noise=0
Ra277 ns277 0 18.0397111928 noise=0
Ga276 ns276 0 ns277 0 -0.387833034432
Ga277 ns277 0 ns276 0 0.387833034432
Ca278 ns278 0 1e-12
Ca279 ns279 0 1e-12
Ra278 ns278 0 30.8418520482 noise=0
Ra279 ns279 0 30.8418520482 noise=0
Ga278 ns278 0 ns279 0 -0.396001611468
Ga279 ns279 0 ns278 0 0.396001611468
Ca280 ns280 0 1e-12
Ca281 ns281 0 1e-12
Ra280 ns280 0 41.0163217329 noise=0
Ra281 ns281 0 41.0163217329 noise=0
Ga280 ns280 0 ns281 0 -0.381592451289
Ga281 ns281 0 ns280 0 0.381592451289
Ca282 ns282 0 1e-12
Ca283 ns283 0 1e-12
Ra282 ns282 0 21.7602201341 noise=0
Ra283 ns283 0 21.7602201341 noise=0
Ga282 ns282 0 ns283 0 -0.308783855582
Ga283 ns283 0 ns282 0 0.308783855582
Ca284 ns284 0 1e-12
Ca285 ns285 0 1e-12
Ra284 ns284 0 31.7954014875 noise=0
Ra285 ns285 0 31.7954014875 noise=0
Ga284 ns284 0 ns285 0 -0.296374987646
Ga285 ns285 0 ns284 0 0.296374987646
Ca286 ns286 0 1e-12
Ca287 ns287 0 1e-12
Ra286 ns286 0 40.7548915023 noise=0
Ra287 ns287 0 40.7548915023 noise=0
Ga286 ns286 0 ns287 0 -0.280074006701
Ga287 ns287 0 ns286 0 0.280074006701
Ca288 ns288 0 1e-12
Ca289 ns289 0 1e-12
Ra288 ns288 0 16.2605473069 noise=0
Ra289 ns289 0 16.2605473069 noise=0
Ga288 ns288 0 ns289 0 -0.221944572364
Ga289 ns289 0 ns288 0 0.221944572364
Ca290 ns290 0 1e-12
Ca291 ns291 0 1e-12
Ra290 ns290 0 32.2071815157 noise=0
Ra291 ns291 0 32.2071815157 noise=0
Ga290 ns290 0 ns291 0 -0.202528261009
Ga291 ns291 0 ns290 0 0.202528261009
Ca292 ns292 0 1e-12
Ca293 ns293 0 1e-12
Ra292 ns292 0 37.0147768903 noise=0
Ra293 ns293 0 37.0147768903 noise=0
Ga292 ns292 0 ns293 0 -0.196192248457
Ga293 ns293 0 ns292 0 0.196192248457
Ca294 ns294 0 1e-12
Ca295 ns295 0 1e-12
Ra294 ns294 0 14.7020480531 noise=0
Ra295 ns295 0 14.7020480531 noise=0
Ga294 ns294 0 ns295 0 -0.120312309686
Ga295 ns295 0 ns294 0 0.120312309686
Ca296 ns296 0 1e-12
Ca297 ns297 0 1e-12
Ra296 ns296 0 26.4544905299 noise=0
Ra297 ns297 0 26.4544905299 noise=0
Ga296 ns296 0 ns297 0 -0.109680355063
Ga297 ns297 0 ns296 0 0.109680355063
Ca298 ns298 0 1e-12
Ca299 ns299 0 1e-12
Ra298 ns298 0 34.6142502796 noise=0
Ra299 ns299 0 34.6142502796 noise=0
Ga298 ns298 0 ns299 0 -0.0959452774828
Ga299 ns299 0 ns298 0 0.0959452774828
Ca300 ns300 0 1e-12
Ra300 ns300 0 13.7459165429 noise=0
Ca301 ns301 0 1e-12
Ra301 ns301 0 15.4643816792 noise=0
Ca302 ns302 0 1e-12
Ra302 ns302 0 31.0524450378 noise=0
Ca303 ns303 0 1e-12
Ra303 ns303 0 3165.2849616 noise=0
Ca304 ns304 0 1e-12
Ra304 ns304 0 0.000128571428571 noise=0
Ca305 ns305 0 1e-12
Ra305 ns305 0 0.622941609725 noise=0
Ca306 ns306 0 1e-12
Ra306 ns306 0 0.902892370164 noise=0
Ca307 ns307 0 1e-12
Ra307 ns307 0 2.25277197156 noise=0
Ca308 ns308 0 1e-12
Ca309 ns309 0 1e-12
Ra308 ns308 0 12.2584735833 noise=0
Ra309 ns309 0 12.2584735833 noise=0
Ga308 ns308 0 ns309 0 -0.470827691571
Ga309 ns309 0 ns308 0 0.470827691571
Ca310 ns310 0 1e-12
Ca311 ns311 0 1e-12
Ra310 ns310 0 25.6181403896 noise=0
Ra311 ns311 0 25.6181403896 noise=0
Ga310 ns310 0 ns311 0 -0.448026841046
Ga311 ns311 0 ns310 0 0.448026841046
Ca312 ns312 0 1e-12
Ca313 ns313 0 1e-12
Ra312 ns312 0 43.6974661765 noise=0
Ra313 ns313 0 43.6974661765 noise=0
Ga312 ns312 0 ns313 0 -0.43948250501
Ga313 ns313 0 ns312 0 0.43948250501
Ca314 ns314 0 1e-12
Ca315 ns315 0 1e-12
Ra314 ns314 0 18.0397111928 noise=0
Ra315 ns315 0 18.0397111928 noise=0
Ga314 ns314 0 ns315 0 -0.387833034432
Ga315 ns315 0 ns314 0 0.387833034432
Ca316 ns316 0 1e-12
Ca317 ns317 0 1e-12
Ra316 ns316 0 30.8418520482 noise=0
Ra317 ns317 0 30.8418520482 noise=0
Ga316 ns316 0 ns317 0 -0.396001611468
Ga317 ns317 0 ns316 0 0.396001611468
Ca318 ns318 0 1e-12
Ca319 ns319 0 1e-12
Ra318 ns318 0 41.0163217329 noise=0
Ra319 ns319 0 41.0163217329 noise=0
Ga318 ns318 0 ns319 0 -0.381592451289
Ga319 ns319 0 ns318 0 0.381592451289
Ca320 ns320 0 1e-12
Ca321 ns321 0 1e-12
Ra320 ns320 0 21.7602201341 noise=0
Ra321 ns321 0 21.7602201341 noise=0
Ga320 ns320 0 ns321 0 -0.308783855582
Ga321 ns321 0 ns320 0 0.308783855582
Ca322 ns322 0 1e-12
Ca323 ns323 0 1e-12
Ra322 ns322 0 31.7954014875 noise=0
Ra323 ns323 0 31.7954014875 noise=0
Ga322 ns322 0 ns323 0 -0.296374987646
Ga323 ns323 0 ns322 0 0.296374987646
Ca324 ns324 0 1e-12
Ca325 ns325 0 1e-12
Ra324 ns324 0 40.7548915023 noise=0
Ra325 ns325 0 40.7548915023 noise=0
Ga324 ns324 0 ns325 0 -0.280074006701
Ga325 ns325 0 ns324 0 0.280074006701
Ca326 ns326 0 1e-12
Ca327 ns327 0 1e-12
Ra326 ns326 0 16.2605473069 noise=0
Ra327 ns327 0 16.2605473069 noise=0
Ga326 ns326 0 ns327 0 -0.221944572364
Ga327 ns327 0 ns326 0 0.221944572364
Ca328 ns328 0 1e-12
Ca329 ns329 0 1e-12
Ra328 ns328 0 32.2071815157 noise=0
Ra329 ns329 0 32.2071815157 noise=0
Ga328 ns328 0 ns329 0 -0.202528261009
Ga329 ns329 0 ns328 0 0.202528261009
Ca330 ns330 0 1e-12
Ca331 ns331 0 1e-12
Ra330 ns330 0 37.0147768903 noise=0
Ra331 ns331 0 37.0147768903 noise=0
Ga330 ns330 0 ns331 0 -0.196192248457
Ga331 ns331 0 ns330 0 0.196192248457
Ca332 ns332 0 1e-12
Ca333 ns333 0 1e-12
Ra332 ns332 0 14.7020480531 noise=0
Ra333 ns333 0 14.7020480531 noise=0
Ga332 ns332 0 ns333 0 -0.120312309686
Ga333 ns333 0 ns332 0 0.120312309686
Ca334 ns334 0 1e-12
Ca335 ns335 0 1e-12
Ra334 ns334 0 26.4544905299 noise=0
Ra335 ns335 0 26.4544905299 noise=0
Ga334 ns334 0 ns335 0 -0.109680355063
Ga335 ns335 0 ns334 0 0.109680355063
Ca336 ns336 0 1e-12
Ca337 ns337 0 1e-12
Ra336 ns336 0 34.6142502796 noise=0
Ra337 ns337 0 34.6142502796 noise=0
Ga336 ns336 0 ns337 0 -0.0959452774828
Ga337 ns337 0 ns336 0 0.0959452774828
Ca338 ns338 0 1e-12
Ra338 ns338 0 13.7459165429 noise=0
Ca339 ns339 0 1e-12
Ra339 ns339 0 15.4643816792 noise=0
Ca340 ns340 0 1e-12
Ra340 ns340 0 31.0524450378 noise=0
Ca341 ns341 0 1e-12
Ra341 ns341 0 3165.2849616 noise=0
Ca342 ns342 0 1e-12
Ra342 ns342 0 0.000128571428571 noise=0
Ca343 ns343 0 1e-12
Ra343 ns343 0 0.622941609725 noise=0
Ca344 ns344 0 1e-12
Ra344 ns344 0 0.902892370164 noise=0
Ca345 ns345 0 1e-12
Ra345 ns345 0 2.25277197156 noise=0
Ca346 ns346 0 1e-12
Ca347 ns347 0 1e-12
Ra346 ns346 0 12.2584735833 noise=0
Ra347 ns347 0 12.2584735833 noise=0
Ga346 ns346 0 ns347 0 -0.470827691571
Ga347 ns347 0 ns346 0 0.470827691571
Ca348 ns348 0 1e-12
Ca349 ns349 0 1e-12
Ra348 ns348 0 25.6181403896 noise=0
Ra349 ns349 0 25.6181403896 noise=0
Ga348 ns348 0 ns349 0 -0.448026841046
Ga349 ns349 0 ns348 0 0.448026841046
Ca350 ns350 0 1e-12
Ca351 ns351 0 1e-12
Ra350 ns350 0 43.6974661765 noise=0
Ra351 ns351 0 43.6974661765 noise=0
Ga350 ns350 0 ns351 0 -0.43948250501
Ga351 ns351 0 ns350 0 0.43948250501
Ca352 ns352 0 1e-12
Ca353 ns353 0 1e-12
Ra352 ns352 0 18.0397111928 noise=0
Ra353 ns353 0 18.0397111928 noise=0
Ga352 ns352 0 ns353 0 -0.387833034432
Ga353 ns353 0 ns352 0 0.387833034432
Ca354 ns354 0 1e-12
Ca355 ns355 0 1e-12
Ra354 ns354 0 30.8418520482 noise=0
Ra355 ns355 0 30.8418520482 noise=0
Ga354 ns354 0 ns355 0 -0.396001611468
Ga355 ns355 0 ns354 0 0.396001611468
Ca356 ns356 0 1e-12
Ca357 ns357 0 1e-12
Ra356 ns356 0 41.0163217329 noise=0
Ra357 ns357 0 41.0163217329 noise=0
Ga356 ns356 0 ns357 0 -0.381592451289
Ga357 ns357 0 ns356 0 0.381592451289
Ca358 ns358 0 1e-12
Ca359 ns359 0 1e-12
Ra358 ns358 0 21.7602201341 noise=0
Ra359 ns359 0 21.7602201341 noise=0
Ga358 ns358 0 ns359 0 -0.308783855582
Ga359 ns359 0 ns358 0 0.308783855582
Ca360 ns360 0 1e-12
Ca361 ns361 0 1e-12
Ra360 ns360 0 31.7954014875 noise=0
Ra361 ns361 0 31.7954014875 noise=0
Ga360 ns360 0 ns361 0 -0.296374987646
Ga361 ns361 0 ns360 0 0.296374987646
Ca362 ns362 0 1e-12
Ca363 ns363 0 1e-12
Ra362 ns362 0 40.7548915023 noise=0
Ra363 ns363 0 40.7548915023 noise=0
Ga362 ns362 0 ns363 0 -0.280074006701
Ga363 ns363 0 ns362 0 0.280074006701
Ca364 ns364 0 1e-12
Ca365 ns365 0 1e-12
Ra364 ns364 0 16.2605473069 noise=0
Ra365 ns365 0 16.2605473069 noise=0
Ga364 ns364 0 ns365 0 -0.221944572364
Ga365 ns365 0 ns364 0 0.221944572364
Ca366 ns366 0 1e-12
Ca367 ns367 0 1e-12
Ra366 ns366 0 32.2071815157 noise=0
Ra367 ns367 0 32.2071815157 noise=0
Ga366 ns366 0 ns367 0 -0.202528261009
Ga367 ns367 0 ns366 0 0.202528261009
Ca368 ns368 0 1e-12
Ca369 ns369 0 1e-12
Ra368 ns368 0 37.0147768903 noise=0
Ra369 ns369 0 37.0147768903 noise=0
Ga368 ns368 0 ns369 0 -0.196192248457
Ga369 ns369 0 ns368 0 0.196192248457
Ca370 ns370 0 1e-12
Ca371 ns371 0 1e-12
Ra370 ns370 0 14.7020480531 noise=0
Ra371 ns371 0 14.7020480531 noise=0
Ga370 ns370 0 ns371 0 -0.120312309686
Ga371 ns371 0 ns370 0 0.120312309686
Ca372 ns372 0 1e-12
Ca373 ns373 0 1e-12
Ra372 ns372 0 26.4544905299 noise=0
Ra373 ns373 0 26.4544905299 noise=0
Ga372 ns372 0 ns373 0 -0.109680355063
Ga373 ns373 0 ns372 0 0.109680355063
Ca374 ns374 0 1e-12
Ca375 ns375 0 1e-12
Ra374 ns374 0 34.6142502796 noise=0
Ra375 ns375 0 34.6142502796 noise=0
Ga374 ns374 0 ns375 0 -0.0959452774828
Ga375 ns375 0 ns374 0 0.0959452774828
Ca376 ns376 0 1e-12
Ra376 ns376 0 13.7459165429 noise=0
Ca377 ns377 0 1e-12
Ra377 ns377 0 15.4643816792 noise=0
Ca378 ns378 0 1e-12
Ra378 ns378 0 31.0524450378 noise=0
Ca379 ns379 0 1e-12
Ra379 ns379 0 3165.2849616 noise=0
Ca380 ns380 0 1e-12
Ra380 ns380 0 0.000128571428571 noise=0
Ca381 ns381 0 1e-12
Ra381 ns381 0 0.622941609725 noise=0
Ca382 ns382 0 1e-12
Ra382 ns382 0 0.902892370164 noise=0
Ca383 ns383 0 1e-12
Ra383 ns383 0 2.25277197156 noise=0
Ca384 ns384 0 1e-12
Ca385 ns385 0 1e-12
Ra384 ns384 0 12.2584735833 noise=0
Ra385 ns385 0 12.2584735833 noise=0
Ga384 ns384 0 ns385 0 -0.470827691571
Ga385 ns385 0 ns384 0 0.470827691571
Ca386 ns386 0 1e-12
Ca387 ns387 0 1e-12
Ra386 ns386 0 25.6181403896 noise=0
Ra387 ns387 0 25.6181403896 noise=0
Ga386 ns386 0 ns387 0 -0.448026841046
Ga387 ns387 0 ns386 0 0.448026841046
Ca388 ns388 0 1e-12
Ca389 ns389 0 1e-12
Ra388 ns388 0 43.6974661765 noise=0
Ra389 ns389 0 43.6974661765 noise=0
Ga388 ns388 0 ns389 0 -0.43948250501
Ga389 ns389 0 ns388 0 0.43948250501
Ca390 ns390 0 1e-12
Ca391 ns391 0 1e-12
Ra390 ns390 0 18.0397111928 noise=0
Ra391 ns391 0 18.0397111928 noise=0
Ga390 ns390 0 ns391 0 -0.387833034432
Ga391 ns391 0 ns390 0 0.387833034432
Ca392 ns392 0 1e-12
Ca393 ns393 0 1e-12
Ra392 ns392 0 30.8418520482 noise=0
Ra393 ns393 0 30.8418520482 noise=0
Ga392 ns392 0 ns393 0 -0.396001611468
Ga393 ns393 0 ns392 0 0.396001611468
Ca394 ns394 0 1e-12
Ca395 ns395 0 1e-12
Ra394 ns394 0 41.0163217329 noise=0
Ra395 ns395 0 41.0163217329 noise=0
Ga394 ns394 0 ns395 0 -0.381592451289
Ga395 ns395 0 ns394 0 0.381592451289
Ca396 ns396 0 1e-12
Ca397 ns397 0 1e-12
Ra396 ns396 0 21.7602201341 noise=0
Ra397 ns397 0 21.7602201341 noise=0
Ga396 ns396 0 ns397 0 -0.308783855582
Ga397 ns397 0 ns396 0 0.308783855582
Ca398 ns398 0 1e-12
Ca399 ns399 0 1e-12
Ra398 ns398 0 31.7954014875 noise=0
Ra399 ns399 0 31.7954014875 noise=0
Ga398 ns398 0 ns399 0 -0.296374987646
Ga399 ns399 0 ns398 0 0.296374987646
Ca400 ns400 0 1e-12
Ca401 ns401 0 1e-12
Ra400 ns400 0 40.7548915023 noise=0
Ra401 ns401 0 40.7548915023 noise=0
Ga400 ns400 0 ns401 0 -0.280074006701
Ga401 ns401 0 ns400 0 0.280074006701
Ca402 ns402 0 1e-12
Ca403 ns403 0 1e-12
Ra402 ns402 0 16.2605473069 noise=0
Ra403 ns403 0 16.2605473069 noise=0
Ga402 ns402 0 ns403 0 -0.221944572364
Ga403 ns403 0 ns402 0 0.221944572364
Ca404 ns404 0 1e-12
Ca405 ns405 0 1e-12
Ra404 ns404 0 32.2071815157 noise=0
Ra405 ns405 0 32.2071815157 noise=0
Ga404 ns404 0 ns405 0 -0.202528261009
Ga405 ns405 0 ns404 0 0.202528261009
Ca406 ns406 0 1e-12
Ca407 ns407 0 1e-12
Ra406 ns406 0 37.0147768903 noise=0
Ra407 ns407 0 37.0147768903 noise=0
Ga406 ns406 0 ns407 0 -0.196192248457
Ga407 ns407 0 ns406 0 0.196192248457
Ca408 ns408 0 1e-12
Ca409 ns409 0 1e-12
Ra408 ns408 0 14.7020480531 noise=0
Ra409 ns409 0 14.7020480531 noise=0
Ga408 ns408 0 ns409 0 -0.120312309686
Ga409 ns409 0 ns408 0 0.120312309686
Ca410 ns410 0 1e-12
Ca411 ns411 0 1e-12
Ra410 ns410 0 26.4544905299 noise=0
Ra411 ns411 0 26.4544905299 noise=0
Ga410 ns410 0 ns411 0 -0.109680355063
Ga411 ns411 0 ns410 0 0.109680355063
Ca412 ns412 0 1e-12
Ca413 ns413 0 1e-12
Ra412 ns412 0 34.6142502796 noise=0
Ra413 ns413 0 34.6142502796 noise=0
Ga412 ns412 0 ns413 0 -0.0959452774828
Ga413 ns413 0 ns412 0 0.0959452774828
Ca414 ns414 0 1e-12
Ra414 ns414 0 13.7459165429 noise=0
Ca415 ns415 0 1e-12
Ra415 ns415 0 15.4643816792 noise=0
Ca416 ns416 0 1e-12
Ra416 ns416 0 31.0524450378 noise=0
Ca417 ns417 0 1e-12
Ra417 ns417 0 3165.2849616 noise=0
Ca418 ns418 0 1e-12
Ra418 ns418 0 0.000128571428571 noise=0
Ca419 ns419 0 1e-12
Ra419 ns419 0 0.622941609725 noise=0
Ca420 ns420 0 1e-12
Ra420 ns420 0 0.902892370164 noise=0
Ca421 ns421 0 1e-12
Ra421 ns421 0 2.25277197156 noise=0
Ca422 ns422 0 1e-12
Ca423 ns423 0 1e-12
Ra422 ns422 0 12.2584735833 noise=0
Ra423 ns423 0 12.2584735833 noise=0
Ga422 ns422 0 ns423 0 -0.470827691571
Ga423 ns423 0 ns422 0 0.470827691571
Ca424 ns424 0 1e-12
Ca425 ns425 0 1e-12
Ra424 ns424 0 25.6181403896 noise=0
Ra425 ns425 0 25.6181403896 noise=0
Ga424 ns424 0 ns425 0 -0.448026841046
Ga425 ns425 0 ns424 0 0.448026841046
Ca426 ns426 0 1e-12
Ca427 ns427 0 1e-12
Ra426 ns426 0 43.6974661765 noise=0
Ra427 ns427 0 43.6974661765 noise=0
Ga426 ns426 0 ns427 0 -0.43948250501
Ga427 ns427 0 ns426 0 0.43948250501
Ca428 ns428 0 1e-12
Ca429 ns429 0 1e-12
Ra428 ns428 0 18.0397111928 noise=0
Ra429 ns429 0 18.0397111928 noise=0
Ga428 ns428 0 ns429 0 -0.387833034432
Ga429 ns429 0 ns428 0 0.387833034432
Ca430 ns430 0 1e-12
Ca431 ns431 0 1e-12
Ra430 ns430 0 30.8418520482 noise=0
Ra431 ns431 0 30.8418520482 noise=0
Ga430 ns430 0 ns431 0 -0.396001611468
Ga431 ns431 0 ns430 0 0.396001611468
Ca432 ns432 0 1e-12
Ca433 ns433 0 1e-12
Ra432 ns432 0 41.0163217329 noise=0
Ra433 ns433 0 41.0163217329 noise=0
Ga432 ns432 0 ns433 0 -0.381592451289
Ga433 ns433 0 ns432 0 0.381592451289
Ca434 ns434 0 1e-12
Ca435 ns435 0 1e-12
Ra434 ns434 0 21.7602201341 noise=0
Ra435 ns435 0 21.7602201341 noise=0
Ga434 ns434 0 ns435 0 -0.308783855582
Ga435 ns435 0 ns434 0 0.308783855582
Ca436 ns436 0 1e-12
Ca437 ns437 0 1e-12
Ra436 ns436 0 31.7954014875 noise=0
Ra437 ns437 0 31.7954014875 noise=0
Ga436 ns436 0 ns437 0 -0.296374987646
Ga437 ns437 0 ns436 0 0.296374987646
Ca438 ns438 0 1e-12
Ca439 ns439 0 1e-12
Ra438 ns438 0 40.7548915023 noise=0
Ra439 ns439 0 40.7548915023 noise=0
Ga438 ns438 0 ns439 0 -0.280074006701
Ga439 ns439 0 ns438 0 0.280074006701
Ca440 ns440 0 1e-12
Ca441 ns441 0 1e-12
Ra440 ns440 0 16.2605473069 noise=0
Ra441 ns441 0 16.2605473069 noise=0
Ga440 ns440 0 ns441 0 -0.221944572364
Ga441 ns441 0 ns440 0 0.221944572364
Ca442 ns442 0 1e-12
Ca443 ns443 0 1e-12
Ra442 ns442 0 32.2071815157 noise=0
Ra443 ns443 0 32.2071815157 noise=0
Ga442 ns442 0 ns443 0 -0.202528261009
Ga443 ns443 0 ns442 0 0.202528261009
Ca444 ns444 0 1e-12
Ca445 ns445 0 1e-12
Ra444 ns444 0 37.0147768903 noise=0
Ra445 ns445 0 37.0147768903 noise=0
Ga444 ns444 0 ns445 0 -0.196192248457
Ga445 ns445 0 ns444 0 0.196192248457
Ca446 ns446 0 1e-12
Ca447 ns447 0 1e-12
Ra446 ns446 0 14.7020480531 noise=0
Ra447 ns447 0 14.7020480531 noise=0
Ga446 ns446 0 ns447 0 -0.120312309686
Ga447 ns447 0 ns446 0 0.120312309686
Ca448 ns448 0 1e-12
Ca449 ns449 0 1e-12
Ra448 ns448 0 26.4544905299 noise=0
Ra449 ns449 0 26.4544905299 noise=0
Ga448 ns448 0 ns449 0 -0.109680355063
Ga449 ns449 0 ns448 0 0.109680355063
Ca450 ns450 0 1e-12
Ca451 ns451 0 1e-12
Ra450 ns450 0 34.6142502796 noise=0
Ra451 ns451 0 34.6142502796 noise=0
Ga450 ns450 0 ns451 0 -0.0959452774828
Ga451 ns451 0 ns450 0 0.0959452774828
Ca452 ns452 0 1e-12
Ra452 ns452 0 13.7459165429 noise=0
Ca453 ns453 0 1e-12
Ra453 ns453 0 15.4643816792 noise=0
Ca454 ns454 0 1e-12
Ra454 ns454 0 31.0524450378 noise=0
Ca455 ns455 0 1e-12
Ra455 ns455 0 3165.2849616 noise=0
Ca456 ns456 0 1e-12
Ra456 ns456 0 0.000128571428571 noise=0
Ca457 ns457 0 1e-12
Ra457 ns457 0 0.622941609725 noise=0
Ca458 ns458 0 1e-12
Ra458 ns458 0 0.902892370164 noise=0
Ca459 ns459 0 1e-12
Ra459 ns459 0 2.25277197156 noise=0
Ca460 ns460 0 1e-12
Ca461 ns461 0 1e-12
Ra460 ns460 0 12.2584735833 noise=0
Ra461 ns461 0 12.2584735833 noise=0
Ga460 ns460 0 ns461 0 -0.470827691571
Ga461 ns461 0 ns460 0 0.470827691571
Ca462 ns462 0 1e-12
Ca463 ns463 0 1e-12
Ra462 ns462 0 25.6181403896 noise=0
Ra463 ns463 0 25.6181403896 noise=0
Ga462 ns462 0 ns463 0 -0.448026841046
Ga463 ns463 0 ns462 0 0.448026841046
Ca464 ns464 0 1e-12
Ca465 ns465 0 1e-12
Ra464 ns464 0 43.6974661765 noise=0
Ra465 ns465 0 43.6974661765 noise=0
Ga464 ns464 0 ns465 0 -0.43948250501
Ga465 ns465 0 ns464 0 0.43948250501
Ca466 ns466 0 1e-12
Ca467 ns467 0 1e-12
Ra466 ns466 0 18.0397111928 noise=0
Ra467 ns467 0 18.0397111928 noise=0
Ga466 ns466 0 ns467 0 -0.387833034432
Ga467 ns467 0 ns466 0 0.387833034432
Ca468 ns468 0 1e-12
Ca469 ns469 0 1e-12
Ra468 ns468 0 30.8418520482 noise=0
Ra469 ns469 0 30.8418520482 noise=0
Ga468 ns468 0 ns469 0 -0.396001611468
Ga469 ns469 0 ns468 0 0.396001611468
Ca470 ns470 0 1e-12
Ca471 ns471 0 1e-12
Ra470 ns470 0 41.0163217329 noise=0
Ra471 ns471 0 41.0163217329 noise=0
Ga470 ns470 0 ns471 0 -0.381592451289
Ga471 ns471 0 ns470 0 0.381592451289
Ca472 ns472 0 1e-12
Ca473 ns473 0 1e-12
Ra472 ns472 0 21.7602201341 noise=0
Ra473 ns473 0 21.7602201341 noise=0
Ga472 ns472 0 ns473 0 -0.308783855582
Ga473 ns473 0 ns472 0 0.308783855582
Ca474 ns474 0 1e-12
Ca475 ns475 0 1e-12
Ra474 ns474 0 31.7954014875 noise=0
Ra475 ns475 0 31.7954014875 noise=0
Ga474 ns474 0 ns475 0 -0.296374987646
Ga475 ns475 0 ns474 0 0.296374987646
Ca476 ns476 0 1e-12
Ca477 ns477 0 1e-12
Ra476 ns476 0 40.7548915023 noise=0
Ra477 ns477 0 40.7548915023 noise=0
Ga476 ns476 0 ns477 0 -0.280074006701
Ga477 ns477 0 ns476 0 0.280074006701
Ca478 ns478 0 1e-12
Ca479 ns479 0 1e-12
Ra478 ns478 0 16.2605473069 noise=0
Ra479 ns479 0 16.2605473069 noise=0
Ga478 ns478 0 ns479 0 -0.221944572364
Ga479 ns479 0 ns478 0 0.221944572364
Ca480 ns480 0 1e-12
Ca481 ns481 0 1e-12
Ra480 ns480 0 32.2071815157 noise=0
Ra481 ns481 0 32.2071815157 noise=0
Ga480 ns480 0 ns481 0 -0.202528261009
Ga481 ns481 0 ns480 0 0.202528261009
Ca482 ns482 0 1e-12
Ca483 ns483 0 1e-12
Ra482 ns482 0 37.0147768903 noise=0
Ra483 ns483 0 37.0147768903 noise=0
Ga482 ns482 0 ns483 0 -0.196192248457
Ga483 ns483 0 ns482 0 0.196192248457
Ca484 ns484 0 1e-12
Ca485 ns485 0 1e-12
Ra484 ns484 0 14.7020480531 noise=0
Ra485 ns485 0 14.7020480531 noise=0
Ga484 ns484 0 ns485 0 -0.120312309686
Ga485 ns485 0 ns484 0 0.120312309686
Ca486 ns486 0 1e-12
Ca487 ns487 0 1e-12
Ra486 ns486 0 26.4544905299 noise=0
Ra487 ns487 0 26.4544905299 noise=0
Ga486 ns486 0 ns487 0 -0.109680355063
Ga487 ns487 0 ns486 0 0.109680355063
Ca488 ns488 0 1e-12
Ca489 ns489 0 1e-12
Ra488 ns488 0 34.6142502796 noise=0
Ra489 ns489 0 34.6142502796 noise=0
Ga488 ns488 0 ns489 0 -0.0959452774828
Ga489 ns489 0 ns488 0 0.0959452774828
Ca490 ns490 0 1e-12
Ra490 ns490 0 13.7459165429 noise=0
Ca491 ns491 0 1e-12
Ra491 ns491 0 15.4643816792 noise=0
Ca492 ns492 0 1e-12
Ra492 ns492 0 31.0524450378 noise=0
Ca493 ns493 0 1e-12
Ra493 ns493 0 3165.2849616 noise=0
Ca494 ns494 0 1e-12
Ra494 ns494 0 0.000128571428571 noise=0
Ca495 ns495 0 1e-12
Ra495 ns495 0 0.622941609725 noise=0
Ca496 ns496 0 1e-12
Ra496 ns496 0 0.902892370164 noise=0
Ca497 ns497 0 1e-12
Ra497 ns497 0 2.25277197156 noise=0
Ca498 ns498 0 1e-12
Ca499 ns499 0 1e-12
Ra498 ns498 0 12.2584735833 noise=0
Ra499 ns499 0 12.2584735833 noise=0
Ga498 ns498 0 ns499 0 -0.470827691571
Ga499 ns499 0 ns498 0 0.470827691571
Ca500 ns500 0 1e-12
Ca501 ns501 0 1e-12
Ra500 ns500 0 25.6181403896 noise=0
Ra501 ns501 0 25.6181403896 noise=0
Ga500 ns500 0 ns501 0 -0.448026841046
Ga501 ns501 0 ns500 0 0.448026841046
Ca502 ns502 0 1e-12
Ca503 ns503 0 1e-12
Ra502 ns502 0 43.6974661765 noise=0
Ra503 ns503 0 43.6974661765 noise=0
Ga502 ns502 0 ns503 0 -0.43948250501
Ga503 ns503 0 ns502 0 0.43948250501
Ca504 ns504 0 1e-12
Ca505 ns505 0 1e-12
Ra504 ns504 0 18.0397111928 noise=0
Ra505 ns505 0 18.0397111928 noise=0
Ga504 ns504 0 ns505 0 -0.387833034432
Ga505 ns505 0 ns504 0 0.387833034432
Ca506 ns506 0 1e-12
Ca507 ns507 0 1e-12
Ra506 ns506 0 30.8418520482 noise=0
Ra507 ns507 0 30.8418520482 noise=0
Ga506 ns506 0 ns507 0 -0.396001611468
Ga507 ns507 0 ns506 0 0.396001611468
Ca508 ns508 0 1e-12
Ca509 ns509 0 1e-12
Ra508 ns508 0 41.0163217329 noise=0
Ra509 ns509 0 41.0163217329 noise=0
Ga508 ns508 0 ns509 0 -0.381592451289
Ga509 ns509 0 ns508 0 0.381592451289
Ca510 ns510 0 1e-12
Ca511 ns511 0 1e-12
Ra510 ns510 0 21.7602201341 noise=0
Ra511 ns511 0 21.7602201341 noise=0
Ga510 ns510 0 ns511 0 -0.308783855582
Ga511 ns511 0 ns510 0 0.308783855582
Ca512 ns512 0 1e-12
Ca513 ns513 0 1e-12
Ra512 ns512 0 31.7954014875 noise=0
Ra513 ns513 0 31.7954014875 noise=0
Ga512 ns512 0 ns513 0 -0.296374987646
Ga513 ns513 0 ns512 0 0.296374987646
Ca514 ns514 0 1e-12
Ca515 ns515 0 1e-12
Ra514 ns514 0 40.7548915023 noise=0
Ra515 ns515 0 40.7548915023 noise=0
Ga514 ns514 0 ns515 0 -0.280074006701
Ga515 ns515 0 ns514 0 0.280074006701
Ca516 ns516 0 1e-12
Ca517 ns517 0 1e-12
Ra516 ns516 0 16.2605473069 noise=0
Ra517 ns517 0 16.2605473069 noise=0
Ga516 ns516 0 ns517 0 -0.221944572364
Ga517 ns517 0 ns516 0 0.221944572364
Ca518 ns518 0 1e-12
Ca519 ns519 0 1e-12
Ra518 ns518 0 32.2071815157 noise=0
Ra519 ns519 0 32.2071815157 noise=0
Ga518 ns518 0 ns519 0 -0.202528261009
Ga519 ns519 0 ns518 0 0.202528261009
Ca520 ns520 0 1e-12
Ca521 ns521 0 1e-12
Ra520 ns520 0 37.0147768903 noise=0
Ra521 ns521 0 37.0147768903 noise=0
Ga520 ns520 0 ns521 0 -0.196192248457
Ga521 ns521 0 ns520 0 0.196192248457
Ca522 ns522 0 1e-12
Ca523 ns523 0 1e-12
Ra522 ns522 0 14.7020480531 noise=0
Ra523 ns523 0 14.7020480531 noise=0
Ga522 ns522 0 ns523 0 -0.120312309686
Ga523 ns523 0 ns522 0 0.120312309686
Ca524 ns524 0 1e-12
Ca525 ns525 0 1e-12
Ra524 ns524 0 26.4544905299 noise=0
Ra525 ns525 0 26.4544905299 noise=0
Ga524 ns524 0 ns525 0 -0.109680355063
Ga525 ns525 0 ns524 0 0.109680355063
Ca526 ns526 0 1e-12
Ca527 ns527 0 1e-12
Ra526 ns526 0 34.6142502796 noise=0
Ra527 ns527 0 34.6142502796 noise=0
Ga526 ns526 0 ns527 0 -0.0959452774828
Ga527 ns527 0 ns526 0 0.0959452774828
Ca528 ns528 0 1e-12
Ra528 ns528 0 13.7459165429 noise=0
Ca529 ns529 0 1e-12
Ra529 ns529 0 15.4643816792 noise=0
Ca530 ns530 0 1e-12
Ra530 ns530 0 31.0524450378 noise=0
Ca531 ns531 0 1e-12
Ra531 ns531 0 3165.2849616 noise=0
Ca532 ns532 0 1e-12
Ra532 ns532 0 0.000128571428571 noise=0
Ca533 ns533 0 1e-12
Ra533 ns533 0 0.622941609725 noise=0
Ca534 ns534 0 1e-12
Ra534 ns534 0 0.902892370164 noise=0
Ca535 ns535 0 1e-12
Ra535 ns535 0 2.25277197156 noise=0
Ca536 ns536 0 1e-12
Ca537 ns537 0 1e-12
Ra536 ns536 0 12.2584735833 noise=0
Ra537 ns537 0 12.2584735833 noise=0
Ga536 ns536 0 ns537 0 -0.470827691571
Ga537 ns537 0 ns536 0 0.470827691571
Ca538 ns538 0 1e-12
Ca539 ns539 0 1e-12
Ra538 ns538 0 25.6181403896 noise=0
Ra539 ns539 0 25.6181403896 noise=0
Ga538 ns538 0 ns539 0 -0.448026841046
Ga539 ns539 0 ns538 0 0.448026841046
Ca540 ns540 0 1e-12
Ca541 ns541 0 1e-12
Ra540 ns540 0 43.6974661765 noise=0
Ra541 ns541 0 43.6974661765 noise=0
Ga540 ns540 0 ns541 0 -0.43948250501
Ga541 ns541 0 ns540 0 0.43948250501
Ca542 ns542 0 1e-12
Ca543 ns543 0 1e-12
Ra542 ns542 0 18.0397111928 noise=0
Ra543 ns543 0 18.0397111928 noise=0
Ga542 ns542 0 ns543 0 -0.387833034432
Ga543 ns543 0 ns542 0 0.387833034432
Ca544 ns544 0 1e-12
Ca545 ns545 0 1e-12
Ra544 ns544 0 30.8418520482 noise=0
Ra545 ns545 0 30.8418520482 noise=0
Ga544 ns544 0 ns545 0 -0.396001611468
Ga545 ns545 0 ns544 0 0.396001611468
Ca546 ns546 0 1e-12
Ca547 ns547 0 1e-12
Ra546 ns546 0 41.0163217329 noise=0
Ra547 ns547 0 41.0163217329 noise=0
Ga546 ns546 0 ns547 0 -0.381592451289
Ga547 ns547 0 ns546 0 0.381592451289
Ca548 ns548 0 1e-12
Ca549 ns549 0 1e-12
Ra548 ns548 0 21.7602201341 noise=0
Ra549 ns549 0 21.7602201341 noise=0
Ga548 ns548 0 ns549 0 -0.308783855582
Ga549 ns549 0 ns548 0 0.308783855582
Ca550 ns550 0 1e-12
Ca551 ns551 0 1e-12
Ra550 ns550 0 31.7954014875 noise=0
Ra551 ns551 0 31.7954014875 noise=0
Ga550 ns550 0 ns551 0 -0.296374987646
Ga551 ns551 0 ns550 0 0.296374987646
Ca552 ns552 0 1e-12
Ca553 ns553 0 1e-12
Ra552 ns552 0 40.7548915023 noise=0
Ra553 ns553 0 40.7548915023 noise=0
Ga552 ns552 0 ns553 0 -0.280074006701
Ga553 ns553 0 ns552 0 0.280074006701
Ca554 ns554 0 1e-12
Ca555 ns555 0 1e-12
Ra554 ns554 0 16.2605473069 noise=0
Ra555 ns555 0 16.2605473069 noise=0
Ga554 ns554 0 ns555 0 -0.221944572364
Ga555 ns555 0 ns554 0 0.221944572364
Ca556 ns556 0 1e-12
Ca557 ns557 0 1e-12
Ra556 ns556 0 32.2071815157 noise=0
Ra557 ns557 0 32.2071815157 noise=0
Ga556 ns556 0 ns557 0 -0.202528261009
Ga557 ns557 0 ns556 0 0.202528261009
Ca558 ns558 0 1e-12
Ca559 ns559 0 1e-12
Ra558 ns558 0 37.0147768903 noise=0
Ra559 ns559 0 37.0147768903 noise=0
Ga558 ns558 0 ns559 0 -0.196192248457
Ga559 ns559 0 ns558 0 0.196192248457
Ca560 ns560 0 1e-12
Ca561 ns561 0 1e-12
Ra560 ns560 0 14.7020480531 noise=0
Ra561 ns561 0 14.7020480531 noise=0
Ga560 ns560 0 ns561 0 -0.120312309686
Ga561 ns561 0 ns560 0 0.120312309686
Ca562 ns562 0 1e-12
Ca563 ns563 0 1e-12
Ra562 ns562 0 26.4544905299 noise=0
Ra563 ns563 0 26.4544905299 noise=0
Ga562 ns562 0 ns563 0 -0.109680355063
Ga563 ns563 0 ns562 0 0.109680355063
Ca564 ns564 0 1e-12
Ca565 ns565 0 1e-12
Ra564 ns564 0 34.6142502796 noise=0
Ra565 ns565 0 34.6142502796 noise=0
Ga564 ns564 0 ns565 0 -0.0959452774828
Ga565 ns565 0 ns564 0 0.0959452774828
Ca566 ns566 0 1e-12
Ra566 ns566 0 13.7459165429 noise=0
Ca567 ns567 0 1e-12
Ra567 ns567 0 15.4643816792 noise=0
Ca568 ns568 0 1e-12
Ra568 ns568 0 31.0524450378 noise=0
Ca569 ns569 0 1e-12
Ra569 ns569 0 3165.2849616 noise=0
Ca570 ns570 0 1e-12
Ra570 ns570 0 0.000128571428571 noise=0
Ca571 ns571 0 1e-12
Ra571 ns571 0 0.622941609725 noise=0
Ca572 ns572 0 1e-12
Ra572 ns572 0 0.902892370164 noise=0
Ca573 ns573 0 1e-12
Ra573 ns573 0 2.25277197156 noise=0
Ca574 ns574 0 1e-12
Ca575 ns575 0 1e-12
Ra574 ns574 0 12.2584735833 noise=0
Ra575 ns575 0 12.2584735833 noise=0
Ga574 ns574 0 ns575 0 -0.470827691571
Ga575 ns575 0 ns574 0 0.470827691571
Ca576 ns576 0 1e-12
Ca577 ns577 0 1e-12
Ra576 ns576 0 25.6181403896 noise=0
Ra577 ns577 0 25.6181403896 noise=0
Ga576 ns576 0 ns577 0 -0.448026841046
Ga577 ns577 0 ns576 0 0.448026841046
Ca578 ns578 0 1e-12
Ca579 ns579 0 1e-12
Ra578 ns578 0 43.6974661765 noise=0
Ra579 ns579 0 43.6974661765 noise=0
Ga578 ns578 0 ns579 0 -0.43948250501
Ga579 ns579 0 ns578 0 0.43948250501
Ca580 ns580 0 1e-12
Ca581 ns581 0 1e-12
Ra580 ns580 0 18.0397111928 noise=0
Ra581 ns581 0 18.0397111928 noise=0
Ga580 ns580 0 ns581 0 -0.387833034432
Ga581 ns581 0 ns580 0 0.387833034432
Ca582 ns582 0 1e-12
Ca583 ns583 0 1e-12
Ra582 ns582 0 30.8418520482 noise=0
Ra583 ns583 0 30.8418520482 noise=0
Ga582 ns582 0 ns583 0 -0.396001611468
Ga583 ns583 0 ns582 0 0.396001611468
Ca584 ns584 0 1e-12
Ca585 ns585 0 1e-12
Ra584 ns584 0 41.0163217329 noise=0
Ra585 ns585 0 41.0163217329 noise=0
Ga584 ns584 0 ns585 0 -0.381592451289
Ga585 ns585 0 ns584 0 0.381592451289
Ca586 ns586 0 1e-12
Ca587 ns587 0 1e-12
Ra586 ns586 0 21.7602201341 noise=0
Ra587 ns587 0 21.7602201341 noise=0
Ga586 ns586 0 ns587 0 -0.308783855582
Ga587 ns587 0 ns586 0 0.308783855582
Ca588 ns588 0 1e-12
Ca589 ns589 0 1e-12
Ra588 ns588 0 31.7954014875 noise=0
Ra589 ns589 0 31.7954014875 noise=0
Ga588 ns588 0 ns589 0 -0.296374987646
Ga589 ns589 0 ns588 0 0.296374987646
Ca590 ns590 0 1e-12
Ca591 ns591 0 1e-12
Ra590 ns590 0 40.7548915023 noise=0
Ra591 ns591 0 40.7548915023 noise=0
Ga590 ns590 0 ns591 0 -0.280074006701
Ga591 ns591 0 ns590 0 0.280074006701
Ca592 ns592 0 1e-12
Ca593 ns593 0 1e-12
Ra592 ns592 0 16.2605473069 noise=0
Ra593 ns593 0 16.2605473069 noise=0
Ga592 ns592 0 ns593 0 -0.221944572364
Ga593 ns593 0 ns592 0 0.221944572364
Ca594 ns594 0 1e-12
Ca595 ns595 0 1e-12
Ra594 ns594 0 32.2071815157 noise=0
Ra595 ns595 0 32.2071815157 noise=0
Ga594 ns594 0 ns595 0 -0.202528261009
Ga595 ns595 0 ns594 0 0.202528261009
Ca596 ns596 0 1e-12
Ca597 ns597 0 1e-12
Ra596 ns596 0 37.0147768903 noise=0
Ra597 ns597 0 37.0147768903 noise=0
Ga596 ns596 0 ns597 0 -0.196192248457
Ga597 ns597 0 ns596 0 0.196192248457
Ca598 ns598 0 1e-12
Ca599 ns599 0 1e-12
Ra598 ns598 0 14.7020480531 noise=0
Ra599 ns599 0 14.7020480531 noise=0
Ga598 ns598 0 ns599 0 -0.120312309686
Ga599 ns599 0 ns598 0 0.120312309686
Ca600 ns600 0 1e-12
Ca601 ns601 0 1e-12
Ra600 ns600 0 26.4544905299 noise=0
Ra601 ns601 0 26.4544905299 noise=0
Ga600 ns600 0 ns601 0 -0.109680355063
Ga601 ns601 0 ns600 0 0.109680355063
Ca602 ns602 0 1e-12
Ca603 ns603 0 1e-12
Ra602 ns602 0 34.6142502796 noise=0
Ra603 ns603 0 34.6142502796 noise=0
Ga602 ns602 0 ns603 0 -0.0959452774828
Ga603 ns603 0 ns602 0 0.0959452774828
Ca604 ns604 0 1e-12
Ra604 ns604 0 13.7459165429 noise=0
Ca605 ns605 0 1e-12
Ra605 ns605 0 15.4643816792 noise=0
Ca606 ns606 0 1e-12
Ra606 ns606 0 31.0524450378 noise=0
Ca607 ns607 0 1e-12
Ra607 ns607 0 3165.2849616 noise=0
Ca608 ns608 0 1e-12
Ra608 ns608 0 0.000128571428571 noise=0
Ca609 ns609 0 1e-12
Ra609 ns609 0 0.622941609725 noise=0
Ca610 ns610 0 1e-12
Ra610 ns610 0 0.902892370164 noise=0
Ca611 ns611 0 1e-12
Ra611 ns611 0 2.25277197156 noise=0
Ca612 ns612 0 1e-12
Ca613 ns613 0 1e-12
Ra612 ns612 0 12.2584735833 noise=0
Ra613 ns613 0 12.2584735833 noise=0
Ga612 ns612 0 ns613 0 -0.470827691571
Ga613 ns613 0 ns612 0 0.470827691571
Ca614 ns614 0 1e-12
Ca615 ns615 0 1e-12
Ra614 ns614 0 25.6181403896 noise=0
Ra615 ns615 0 25.6181403896 noise=0
Ga614 ns614 0 ns615 0 -0.448026841046
Ga615 ns615 0 ns614 0 0.448026841046
Ca616 ns616 0 1e-12
Ca617 ns617 0 1e-12
Ra616 ns616 0 43.6974661765 noise=0
Ra617 ns617 0 43.6974661765 noise=0
Ga616 ns616 0 ns617 0 -0.43948250501
Ga617 ns617 0 ns616 0 0.43948250501
Ca618 ns618 0 1e-12
Ca619 ns619 0 1e-12
Ra618 ns618 0 18.0397111928 noise=0
Ra619 ns619 0 18.0397111928 noise=0
Ga618 ns618 0 ns619 0 -0.387833034432
Ga619 ns619 0 ns618 0 0.387833034432
Ca620 ns620 0 1e-12
Ca621 ns621 0 1e-12
Ra620 ns620 0 30.8418520482 noise=0
Ra621 ns621 0 30.8418520482 noise=0
Ga620 ns620 0 ns621 0 -0.396001611468
Ga621 ns621 0 ns620 0 0.396001611468
Ca622 ns622 0 1e-12
Ca623 ns623 0 1e-12
Ra622 ns622 0 41.0163217329 noise=0
Ra623 ns623 0 41.0163217329 noise=0
Ga622 ns622 0 ns623 0 -0.381592451289
Ga623 ns623 0 ns622 0 0.381592451289
Ca624 ns624 0 1e-12
Ca625 ns625 0 1e-12
Ra624 ns624 0 21.7602201341 noise=0
Ra625 ns625 0 21.7602201341 noise=0
Ga624 ns624 0 ns625 0 -0.308783855582
Ga625 ns625 0 ns624 0 0.308783855582
Ca626 ns626 0 1e-12
Ca627 ns627 0 1e-12
Ra626 ns626 0 31.7954014875 noise=0
Ra627 ns627 0 31.7954014875 noise=0
Ga626 ns626 0 ns627 0 -0.296374987646
Ga627 ns627 0 ns626 0 0.296374987646
Ca628 ns628 0 1e-12
Ca629 ns629 0 1e-12
Ra628 ns628 0 40.7548915023 noise=0
Ra629 ns629 0 40.7548915023 noise=0
Ga628 ns628 0 ns629 0 -0.280074006701
Ga629 ns629 0 ns628 0 0.280074006701
Ca630 ns630 0 1e-12
Ca631 ns631 0 1e-12
Ra630 ns630 0 16.2605473069 noise=0
Ra631 ns631 0 16.2605473069 noise=0
Ga630 ns630 0 ns631 0 -0.221944572364
Ga631 ns631 0 ns630 0 0.221944572364
Ca632 ns632 0 1e-12
Ca633 ns633 0 1e-12
Ra632 ns632 0 32.2071815157 noise=0
Ra633 ns633 0 32.2071815157 noise=0
Ga632 ns632 0 ns633 0 -0.202528261009
Ga633 ns633 0 ns632 0 0.202528261009
Ca634 ns634 0 1e-12
Ca635 ns635 0 1e-12
Ra634 ns634 0 37.0147768903 noise=0
Ra635 ns635 0 37.0147768903 noise=0
Ga634 ns634 0 ns635 0 -0.196192248457
Ga635 ns635 0 ns634 0 0.196192248457
Ca636 ns636 0 1e-12
Ca637 ns637 0 1e-12
Ra636 ns636 0 14.7020480531 noise=0
Ra637 ns637 0 14.7020480531 noise=0
Ga636 ns636 0 ns637 0 -0.120312309686
Ga637 ns637 0 ns636 0 0.120312309686
Ca638 ns638 0 1e-12
Ca639 ns639 0 1e-12
Ra638 ns638 0 26.4544905299 noise=0
Ra639 ns639 0 26.4544905299 noise=0
Ga638 ns638 0 ns639 0 -0.109680355063
Ga639 ns639 0 ns638 0 0.109680355063
Ca640 ns640 0 1e-12
Ca641 ns641 0 1e-12
Ra640 ns640 0 34.6142502796 noise=0
Ra641 ns641 0 34.6142502796 noise=0
Ga640 ns640 0 ns641 0 -0.0959452774828
Ga641 ns641 0 ns640 0 0.0959452774828
Ca642 ns642 0 1e-12
Ra642 ns642 0 13.7459165429 noise=0
Ca643 ns643 0 1e-12
Ra643 ns643 0 15.4643816792 noise=0
Ca644 ns644 0 1e-12
Ra644 ns644 0 31.0524450378 noise=0
Ca645 ns645 0 1e-12
Ra645 ns645 0 3165.2849616 noise=0
Ca646 ns646 0 1e-12
Ra646 ns646 0 0.000128571428571 noise=0
Ca647 ns647 0 1e-12
Ra647 ns647 0 0.622941609725 noise=0
Ca648 ns648 0 1e-12
Ra648 ns648 0 0.902892370164 noise=0
Ca649 ns649 0 1e-12
Ra649 ns649 0 2.25277197156 noise=0
Ca650 ns650 0 1e-12
Ca651 ns651 0 1e-12
Ra650 ns650 0 12.2584735833 noise=0
Ra651 ns651 0 12.2584735833 noise=0
Ga650 ns650 0 ns651 0 -0.470827691571
Ga651 ns651 0 ns650 0 0.470827691571
Ca652 ns652 0 1e-12
Ca653 ns653 0 1e-12
Ra652 ns652 0 25.6181403896 noise=0
Ra653 ns653 0 25.6181403896 noise=0
Ga652 ns652 0 ns653 0 -0.448026841046
Ga653 ns653 0 ns652 0 0.448026841046
Ca654 ns654 0 1e-12
Ca655 ns655 0 1e-12
Ra654 ns654 0 43.6974661765 noise=0
Ra655 ns655 0 43.6974661765 noise=0
Ga654 ns654 0 ns655 0 -0.43948250501
Ga655 ns655 0 ns654 0 0.43948250501
Ca656 ns656 0 1e-12
Ca657 ns657 0 1e-12
Ra656 ns656 0 18.0397111928 noise=0
Ra657 ns657 0 18.0397111928 noise=0
Ga656 ns656 0 ns657 0 -0.387833034432
Ga657 ns657 0 ns656 0 0.387833034432
Ca658 ns658 0 1e-12
Ca659 ns659 0 1e-12
Ra658 ns658 0 30.8418520482 noise=0
Ra659 ns659 0 30.8418520482 noise=0
Ga658 ns658 0 ns659 0 -0.396001611468
Ga659 ns659 0 ns658 0 0.396001611468
Ca660 ns660 0 1e-12
Ca661 ns661 0 1e-12
Ra660 ns660 0 41.0163217329 noise=0
Ra661 ns661 0 41.0163217329 noise=0
Ga660 ns660 0 ns661 0 -0.381592451289
Ga661 ns661 0 ns660 0 0.381592451289
Ca662 ns662 0 1e-12
Ca663 ns663 0 1e-12
Ra662 ns662 0 21.7602201341 noise=0
Ra663 ns663 0 21.7602201341 noise=0
Ga662 ns662 0 ns663 0 -0.308783855582
Ga663 ns663 0 ns662 0 0.308783855582
Ca664 ns664 0 1e-12
Ca665 ns665 0 1e-12
Ra664 ns664 0 31.7954014875 noise=0
Ra665 ns665 0 31.7954014875 noise=0
Ga664 ns664 0 ns665 0 -0.296374987646
Ga665 ns665 0 ns664 0 0.296374987646
Ca666 ns666 0 1e-12
Ca667 ns667 0 1e-12
Ra666 ns666 0 40.7548915023 noise=0
Ra667 ns667 0 40.7548915023 noise=0
Ga666 ns666 0 ns667 0 -0.280074006701
Ga667 ns667 0 ns666 0 0.280074006701
Ca668 ns668 0 1e-12
Ca669 ns669 0 1e-12
Ra668 ns668 0 16.2605473069 noise=0
Ra669 ns669 0 16.2605473069 noise=0
Ga668 ns668 0 ns669 0 -0.221944572364
Ga669 ns669 0 ns668 0 0.221944572364
Ca670 ns670 0 1e-12
Ca671 ns671 0 1e-12
Ra670 ns670 0 32.2071815157 noise=0
Ra671 ns671 0 32.2071815157 noise=0
Ga670 ns670 0 ns671 0 -0.202528261009
Ga671 ns671 0 ns670 0 0.202528261009
Ca672 ns672 0 1e-12
Ca673 ns673 0 1e-12
Ra672 ns672 0 37.0147768903 noise=0
Ra673 ns673 0 37.0147768903 noise=0
Ga672 ns672 0 ns673 0 -0.196192248457
Ga673 ns673 0 ns672 0 0.196192248457
Ca674 ns674 0 1e-12
Ca675 ns675 0 1e-12
Ra674 ns674 0 14.7020480531 noise=0
Ra675 ns675 0 14.7020480531 noise=0
Ga674 ns674 0 ns675 0 -0.120312309686
Ga675 ns675 0 ns674 0 0.120312309686
Ca676 ns676 0 1e-12
Ca677 ns677 0 1e-12
Ra676 ns676 0 26.4544905299 noise=0
Ra677 ns677 0 26.4544905299 noise=0
Ga676 ns676 0 ns677 0 -0.109680355063
Ga677 ns677 0 ns676 0 0.109680355063
Ca678 ns678 0 1e-12
Ca679 ns679 0 1e-12
Ra678 ns678 0 34.6142502796 noise=0
Ra679 ns679 0 34.6142502796 noise=0
Ga678 ns678 0 ns679 0 -0.0959452774828
Ga679 ns679 0 ns678 0 0.0959452774828
Ca680 ns680 0 1e-12
Ra680 ns680 0 13.7459165429 noise=0
Ca681 ns681 0 1e-12
Ra681 ns681 0 15.4643816792 noise=0
Ca682 ns682 0 1e-12
Ra682 ns682 0 31.0524450378 noise=0
Ca683 ns683 0 1e-12
Ra683 ns683 0 3165.2849616 noise=0
Ca684 ns684 0 1e-12
Ra684 ns684 0 0.000128571428571 noise=0
Ca685 ns685 0 1e-12
Ra685 ns685 0 0.622941609725 noise=0
Ca686 ns686 0 1e-12
Ra686 ns686 0 0.902892370164 noise=0
Ca687 ns687 0 1e-12
Ra687 ns687 0 2.25277197156 noise=0
Ca688 ns688 0 1e-12
Ca689 ns689 0 1e-12
Ra688 ns688 0 12.2584735833 noise=0
Ra689 ns689 0 12.2584735833 noise=0
Ga688 ns688 0 ns689 0 -0.470827691571
Ga689 ns689 0 ns688 0 0.470827691571
Ca690 ns690 0 1e-12
Ca691 ns691 0 1e-12
Ra690 ns690 0 25.6181403896 noise=0
Ra691 ns691 0 25.6181403896 noise=0
Ga690 ns690 0 ns691 0 -0.448026841046
Ga691 ns691 0 ns690 0 0.448026841046
Ca692 ns692 0 1e-12
Ca693 ns693 0 1e-12
Ra692 ns692 0 43.6974661765 noise=0
Ra693 ns693 0 43.6974661765 noise=0
Ga692 ns692 0 ns693 0 -0.43948250501
Ga693 ns693 0 ns692 0 0.43948250501
Ca694 ns694 0 1e-12
Ca695 ns695 0 1e-12
Ra694 ns694 0 18.0397111928 noise=0
Ra695 ns695 0 18.0397111928 noise=0
Ga694 ns694 0 ns695 0 -0.387833034432
Ga695 ns695 0 ns694 0 0.387833034432
Ca696 ns696 0 1e-12
Ca697 ns697 0 1e-12
Ra696 ns696 0 30.8418520482 noise=0
Ra697 ns697 0 30.8418520482 noise=0
Ga696 ns696 0 ns697 0 -0.396001611468
Ga697 ns697 0 ns696 0 0.396001611468
Ca698 ns698 0 1e-12
Ca699 ns699 0 1e-12
Ra698 ns698 0 41.0163217329 noise=0
Ra699 ns699 0 41.0163217329 noise=0
Ga698 ns698 0 ns699 0 -0.381592451289
Ga699 ns699 0 ns698 0 0.381592451289
Ca700 ns700 0 1e-12
Ca701 ns701 0 1e-12
Ra700 ns700 0 21.7602201341 noise=0
Ra701 ns701 0 21.7602201341 noise=0
Ga700 ns700 0 ns701 0 -0.308783855582
Ga701 ns701 0 ns700 0 0.308783855582
Ca702 ns702 0 1e-12
Ca703 ns703 0 1e-12
Ra702 ns702 0 31.7954014875 noise=0
Ra703 ns703 0 31.7954014875 noise=0
Ga702 ns702 0 ns703 0 -0.296374987646
Ga703 ns703 0 ns702 0 0.296374987646
Ca704 ns704 0 1e-12
Ca705 ns705 0 1e-12
Ra704 ns704 0 40.7548915023 noise=0
Ra705 ns705 0 40.7548915023 noise=0
Ga704 ns704 0 ns705 0 -0.280074006701
Ga705 ns705 0 ns704 0 0.280074006701
Ca706 ns706 0 1e-12
Ca707 ns707 0 1e-12
Ra706 ns706 0 16.2605473069 noise=0
Ra707 ns707 0 16.2605473069 noise=0
Ga706 ns706 0 ns707 0 -0.221944572364
Ga707 ns707 0 ns706 0 0.221944572364
Ca708 ns708 0 1e-12
Ca709 ns709 0 1e-12
Ra708 ns708 0 32.2071815157 noise=0
Ra709 ns709 0 32.2071815157 noise=0
Ga708 ns708 0 ns709 0 -0.202528261009
Ga709 ns709 0 ns708 0 0.202528261009
Ca710 ns710 0 1e-12
Ca711 ns711 0 1e-12
Ra710 ns710 0 37.0147768903 noise=0
Ra711 ns711 0 37.0147768903 noise=0
Ga710 ns710 0 ns711 0 -0.196192248457
Ga711 ns711 0 ns710 0 0.196192248457
Ca712 ns712 0 1e-12
Ca713 ns713 0 1e-12
Ra712 ns712 0 14.7020480531 noise=0
Ra713 ns713 0 14.7020480531 noise=0
Ga712 ns712 0 ns713 0 -0.120312309686
Ga713 ns713 0 ns712 0 0.120312309686
Ca714 ns714 0 1e-12
Ca715 ns715 0 1e-12
Ra714 ns714 0 26.4544905299 noise=0
Ra715 ns715 0 26.4544905299 noise=0
Ga714 ns714 0 ns715 0 -0.109680355063
Ga715 ns715 0 ns714 0 0.109680355063
Ca716 ns716 0 1e-12
Ca717 ns717 0 1e-12
Ra716 ns716 0 34.6142502796 noise=0
Ra717 ns717 0 34.6142502796 noise=0
Ga716 ns716 0 ns717 0 -0.0959452774828
Ga717 ns717 0 ns716 0 0.0959452774828
Ca718 ns718 0 1e-12
Ra718 ns718 0 13.7459165429 noise=0
Ca719 ns719 0 1e-12
Ra719 ns719 0 15.4643816792 noise=0
Ca720 ns720 0 1e-12
Ra720 ns720 0 31.0524450378 noise=0
Ca721 ns721 0 1e-12
Ra721 ns721 0 3165.2849616 noise=0
Ca722 ns722 0 1e-12
Ra722 ns722 0 0.000128571428571 noise=0
Ca723 ns723 0 1e-12
Ra723 ns723 0 0.622941609725 noise=0
Ca724 ns724 0 1e-12
Ra724 ns724 0 0.902892370164 noise=0
Ca725 ns725 0 1e-12
Ra725 ns725 0 2.25277197156 noise=0
Ca726 ns726 0 1e-12
Ca727 ns727 0 1e-12
Ra726 ns726 0 12.2584735833 noise=0
Ra727 ns727 0 12.2584735833 noise=0
Ga726 ns726 0 ns727 0 -0.470827691571
Ga727 ns727 0 ns726 0 0.470827691571
Ca728 ns728 0 1e-12
Ca729 ns729 0 1e-12
Ra728 ns728 0 25.6181403896 noise=0
Ra729 ns729 0 25.6181403896 noise=0
Ga728 ns728 0 ns729 0 -0.448026841046
Ga729 ns729 0 ns728 0 0.448026841046
Ca730 ns730 0 1e-12
Ca731 ns731 0 1e-12
Ra730 ns730 0 43.6974661765 noise=0
Ra731 ns731 0 43.6974661765 noise=0
Ga730 ns730 0 ns731 0 -0.43948250501
Ga731 ns731 0 ns730 0 0.43948250501
Ca732 ns732 0 1e-12
Ca733 ns733 0 1e-12
Ra732 ns732 0 18.0397111928 noise=0
Ra733 ns733 0 18.0397111928 noise=0
Ga732 ns732 0 ns733 0 -0.387833034432
Ga733 ns733 0 ns732 0 0.387833034432
Ca734 ns734 0 1e-12
Ca735 ns735 0 1e-12
Ra734 ns734 0 30.8418520482 noise=0
Ra735 ns735 0 30.8418520482 noise=0
Ga734 ns734 0 ns735 0 -0.396001611468
Ga735 ns735 0 ns734 0 0.396001611468
Ca736 ns736 0 1e-12
Ca737 ns737 0 1e-12
Ra736 ns736 0 41.0163217329 noise=0
Ra737 ns737 0 41.0163217329 noise=0
Ga736 ns736 0 ns737 0 -0.381592451289
Ga737 ns737 0 ns736 0 0.381592451289
Ca738 ns738 0 1e-12
Ca739 ns739 0 1e-12
Ra738 ns738 0 21.7602201341 noise=0
Ra739 ns739 0 21.7602201341 noise=0
Ga738 ns738 0 ns739 0 -0.308783855582
Ga739 ns739 0 ns738 0 0.308783855582
Ca740 ns740 0 1e-12
Ca741 ns741 0 1e-12
Ra740 ns740 0 31.7954014875 noise=0
Ra741 ns741 0 31.7954014875 noise=0
Ga740 ns740 0 ns741 0 -0.296374987646
Ga741 ns741 0 ns740 0 0.296374987646
Ca742 ns742 0 1e-12
Ca743 ns743 0 1e-12
Ra742 ns742 0 40.7548915023 noise=0
Ra743 ns743 0 40.7548915023 noise=0
Ga742 ns742 0 ns743 0 -0.280074006701
Ga743 ns743 0 ns742 0 0.280074006701
Ca744 ns744 0 1e-12
Ca745 ns745 0 1e-12
Ra744 ns744 0 16.2605473069 noise=0
Ra745 ns745 0 16.2605473069 noise=0
Ga744 ns744 0 ns745 0 -0.221944572364
Ga745 ns745 0 ns744 0 0.221944572364
Ca746 ns746 0 1e-12
Ca747 ns747 0 1e-12
Ra746 ns746 0 32.2071815157 noise=0
Ra747 ns747 0 32.2071815157 noise=0
Ga746 ns746 0 ns747 0 -0.202528261009
Ga747 ns747 0 ns746 0 0.202528261009
Ca748 ns748 0 1e-12
Ca749 ns749 0 1e-12
Ra748 ns748 0 37.0147768903 noise=0
Ra749 ns749 0 37.0147768903 noise=0
Ga748 ns748 0 ns749 0 -0.196192248457
Ga749 ns749 0 ns748 0 0.196192248457
Ca750 ns750 0 1e-12
Ca751 ns751 0 1e-12
Ra750 ns750 0 14.7020480531 noise=0
Ra751 ns751 0 14.7020480531 noise=0
Ga750 ns750 0 ns751 0 -0.120312309686
Ga751 ns751 0 ns750 0 0.120312309686
Ca752 ns752 0 1e-12
Ca753 ns753 0 1e-12
Ra752 ns752 0 26.4544905299 noise=0
Ra753 ns753 0 26.4544905299 noise=0
Ga752 ns752 0 ns753 0 -0.109680355063
Ga753 ns753 0 ns752 0 0.109680355063
Ca754 ns754 0 1e-12
Ca755 ns755 0 1e-12
Ra754 ns754 0 34.6142502796 noise=0
Ra755 ns755 0 34.6142502796 noise=0
Ga754 ns754 0 ns755 0 -0.0959452774828
Ga755 ns755 0 ns754 0 0.0959452774828
Ca756 ns756 0 1e-12
Ra756 ns756 0 13.7459165429 noise=0
Ca757 ns757 0 1e-12
Ra757 ns757 0 15.4643816792 noise=0
Ca758 ns758 0 1e-12
Ra758 ns758 0 31.0524450378 noise=0
Ca759 ns759 0 1e-12
Ra759 ns759 0 3165.2849616 noise=0
Ca760 ns760 0 1e-12
Ra760 ns760 0 0.000128571428571 noise=0
Ca761 ns761 0 1e-12
Ra761 ns761 0 0.622941609725 noise=0
Ca762 ns762 0 1e-12
Ra762 ns762 0 0.902892370164 noise=0
Ca763 ns763 0 1e-12
Ra763 ns763 0 2.25277197156 noise=0
Ca764 ns764 0 1e-12
Ca765 ns765 0 1e-12
Ra764 ns764 0 12.2584735833 noise=0
Ra765 ns765 0 12.2584735833 noise=0
Ga764 ns764 0 ns765 0 -0.470827691571
Ga765 ns765 0 ns764 0 0.470827691571
Ca766 ns766 0 1e-12
Ca767 ns767 0 1e-12
Ra766 ns766 0 25.6181403896 noise=0
Ra767 ns767 0 25.6181403896 noise=0
Ga766 ns766 0 ns767 0 -0.448026841046
Ga767 ns767 0 ns766 0 0.448026841046
Ca768 ns768 0 1e-12
Ca769 ns769 0 1e-12
Ra768 ns768 0 43.6974661765 noise=0
Ra769 ns769 0 43.6974661765 noise=0
Ga768 ns768 0 ns769 0 -0.43948250501
Ga769 ns769 0 ns768 0 0.43948250501
Ca770 ns770 0 1e-12
Ca771 ns771 0 1e-12
Ra770 ns770 0 18.0397111928 noise=0
Ra771 ns771 0 18.0397111928 noise=0
Ga770 ns770 0 ns771 0 -0.387833034432
Ga771 ns771 0 ns770 0 0.387833034432
Ca772 ns772 0 1e-12
Ca773 ns773 0 1e-12
Ra772 ns772 0 30.8418520482 noise=0
Ra773 ns773 0 30.8418520482 noise=0
Ga772 ns772 0 ns773 0 -0.396001611468
Ga773 ns773 0 ns772 0 0.396001611468
Ca774 ns774 0 1e-12
Ca775 ns775 0 1e-12
Ra774 ns774 0 41.0163217329 noise=0
Ra775 ns775 0 41.0163217329 noise=0
Ga774 ns774 0 ns775 0 -0.381592451289
Ga775 ns775 0 ns774 0 0.381592451289
Ca776 ns776 0 1e-12
Ca777 ns777 0 1e-12
Ra776 ns776 0 21.7602201341 noise=0
Ra777 ns777 0 21.7602201341 noise=0
Ga776 ns776 0 ns777 0 -0.308783855582
Ga777 ns777 0 ns776 0 0.308783855582
Ca778 ns778 0 1e-12
Ca779 ns779 0 1e-12
Ra778 ns778 0 31.7954014875 noise=0
Ra779 ns779 0 31.7954014875 noise=0
Ga778 ns778 0 ns779 0 -0.296374987646
Ga779 ns779 0 ns778 0 0.296374987646
Ca780 ns780 0 1e-12
Ca781 ns781 0 1e-12
Ra780 ns780 0 40.7548915023 noise=0
Ra781 ns781 0 40.7548915023 noise=0
Ga780 ns780 0 ns781 0 -0.280074006701
Ga781 ns781 0 ns780 0 0.280074006701
Ca782 ns782 0 1e-12
Ca783 ns783 0 1e-12
Ra782 ns782 0 16.2605473069 noise=0
Ra783 ns783 0 16.2605473069 noise=0
Ga782 ns782 0 ns783 0 -0.221944572364
Ga783 ns783 0 ns782 0 0.221944572364
Ca784 ns784 0 1e-12
Ca785 ns785 0 1e-12
Ra784 ns784 0 32.2071815157 noise=0
Ra785 ns785 0 32.2071815157 noise=0
Ga784 ns784 0 ns785 0 -0.202528261009
Ga785 ns785 0 ns784 0 0.202528261009
Ca786 ns786 0 1e-12
Ca787 ns787 0 1e-12
Ra786 ns786 0 37.0147768903 noise=0
Ra787 ns787 0 37.0147768903 noise=0
Ga786 ns786 0 ns787 0 -0.196192248457
Ga787 ns787 0 ns786 0 0.196192248457
Ca788 ns788 0 1e-12
Ca789 ns789 0 1e-12
Ra788 ns788 0 14.7020480531 noise=0
Ra789 ns789 0 14.7020480531 noise=0
Ga788 ns788 0 ns789 0 -0.120312309686
Ga789 ns789 0 ns788 0 0.120312309686
Ca790 ns790 0 1e-12
Ca791 ns791 0 1e-12
Ra790 ns790 0 26.4544905299 noise=0
Ra791 ns791 0 26.4544905299 noise=0
Ga790 ns790 0 ns791 0 -0.109680355063
Ga791 ns791 0 ns790 0 0.109680355063
Ca792 ns792 0 1e-12
Ca793 ns793 0 1e-12
Ra792 ns792 0 34.6142502796 noise=0
Ra793 ns793 0 34.6142502796 noise=0
Ga792 ns792 0 ns793 0 -0.0959452774828
Ga793 ns793 0 ns792 0 0.0959452774828
Ca794 ns794 0 1e-12
Ra794 ns794 0 13.7459165429 noise=0
Ca795 ns795 0 1e-12
Ra795 ns795 0 15.4643816792 noise=0
Ca796 ns796 0 1e-12
Ra796 ns796 0 31.0524450378 noise=0
Ca797 ns797 0 1e-12
Ra797 ns797 0 3165.2849616 noise=0
Ca798 ns798 0 1e-12
Ra798 ns798 0 0.000128571428571 noise=0
Ca799 ns799 0 1e-12
Ra799 ns799 0 0.622941609725 noise=0
Ca800 ns800 0 1e-12
Ra800 ns800 0 0.902892370164 noise=0
Ca801 ns801 0 1e-12
Ra801 ns801 0 2.25277197156 noise=0
Ca802 ns802 0 1e-12
Ca803 ns803 0 1e-12
Ra802 ns802 0 12.2584735833 noise=0
Ra803 ns803 0 12.2584735833 noise=0
Ga802 ns802 0 ns803 0 -0.470827691571
Ga803 ns803 0 ns802 0 0.470827691571
Ca804 ns804 0 1e-12
Ca805 ns805 0 1e-12
Ra804 ns804 0 25.6181403896 noise=0
Ra805 ns805 0 25.6181403896 noise=0
Ga804 ns804 0 ns805 0 -0.448026841046
Ga805 ns805 0 ns804 0 0.448026841046
Ca806 ns806 0 1e-12
Ca807 ns807 0 1e-12
Ra806 ns806 0 43.6974661765 noise=0
Ra807 ns807 0 43.6974661765 noise=0
Ga806 ns806 0 ns807 0 -0.43948250501
Ga807 ns807 0 ns806 0 0.43948250501
Ca808 ns808 0 1e-12
Ca809 ns809 0 1e-12
Ra808 ns808 0 18.0397111928 noise=0
Ra809 ns809 0 18.0397111928 noise=0
Ga808 ns808 0 ns809 0 -0.387833034432
Ga809 ns809 0 ns808 0 0.387833034432
Ca810 ns810 0 1e-12
Ca811 ns811 0 1e-12
Ra810 ns810 0 30.8418520482 noise=0
Ra811 ns811 0 30.8418520482 noise=0
Ga810 ns810 0 ns811 0 -0.396001611468
Ga811 ns811 0 ns810 0 0.396001611468
Ca812 ns812 0 1e-12
Ca813 ns813 0 1e-12
Ra812 ns812 0 41.0163217329 noise=0
Ra813 ns813 0 41.0163217329 noise=0
Ga812 ns812 0 ns813 0 -0.381592451289
Ga813 ns813 0 ns812 0 0.381592451289
Ca814 ns814 0 1e-12
Ca815 ns815 0 1e-12
Ra814 ns814 0 21.7602201341 noise=0
Ra815 ns815 0 21.7602201341 noise=0
Ga814 ns814 0 ns815 0 -0.308783855582
Ga815 ns815 0 ns814 0 0.308783855582
Ca816 ns816 0 1e-12
Ca817 ns817 0 1e-12
Ra816 ns816 0 31.7954014875 noise=0
Ra817 ns817 0 31.7954014875 noise=0
Ga816 ns816 0 ns817 0 -0.296374987646
Ga817 ns817 0 ns816 0 0.296374987646
Ca818 ns818 0 1e-12
Ca819 ns819 0 1e-12
Ra818 ns818 0 40.7548915023 noise=0
Ra819 ns819 0 40.7548915023 noise=0
Ga818 ns818 0 ns819 0 -0.280074006701
Ga819 ns819 0 ns818 0 0.280074006701
Ca820 ns820 0 1e-12
Ca821 ns821 0 1e-12
Ra820 ns820 0 16.2605473069 noise=0
Ra821 ns821 0 16.2605473069 noise=0
Ga820 ns820 0 ns821 0 -0.221944572364
Ga821 ns821 0 ns820 0 0.221944572364
Ca822 ns822 0 1e-12
Ca823 ns823 0 1e-12
Ra822 ns822 0 32.2071815157 noise=0
Ra823 ns823 0 32.2071815157 noise=0
Ga822 ns822 0 ns823 0 -0.202528261009
Ga823 ns823 0 ns822 0 0.202528261009
Ca824 ns824 0 1e-12
Ca825 ns825 0 1e-12
Ra824 ns824 0 37.0147768903 noise=0
Ra825 ns825 0 37.0147768903 noise=0
Ga824 ns824 0 ns825 0 -0.196192248457
Ga825 ns825 0 ns824 0 0.196192248457
Ca826 ns826 0 1e-12
Ca827 ns827 0 1e-12
Ra826 ns826 0 14.7020480531 noise=0
Ra827 ns827 0 14.7020480531 noise=0
Ga826 ns826 0 ns827 0 -0.120312309686
Ga827 ns827 0 ns826 0 0.120312309686
Ca828 ns828 0 1e-12
Ca829 ns829 0 1e-12
Ra828 ns828 0 26.4544905299 noise=0
Ra829 ns829 0 26.4544905299 noise=0
Ga828 ns828 0 ns829 0 -0.109680355063
Ga829 ns829 0 ns828 0 0.109680355063
Ca830 ns830 0 1e-12
Ca831 ns831 0 1e-12
Ra830 ns830 0 34.6142502796 noise=0
Ra831 ns831 0 34.6142502796 noise=0
Ga830 ns830 0 ns831 0 -0.0959452774828
Ga831 ns831 0 ns830 0 0.0959452774828
Ca832 ns832 0 1e-12
Ra832 ns832 0 13.7459165429 noise=0
Ca833 ns833 0 1e-12
Ra833 ns833 0 15.4643816792 noise=0
Ca834 ns834 0 1e-12
Ra834 ns834 0 31.0524450378 noise=0
Ca835 ns835 0 1e-12
Ra835 ns835 0 3165.2849616 noise=0
Ca836 ns836 0 1e-12
Ra836 ns836 0 0.000128571428571 noise=0
Ca837 ns837 0 1e-12
Ra837 ns837 0 0.622941609725 noise=0
Ca838 ns838 0 1e-12
Ra838 ns838 0 0.902892370164 noise=0
Ca839 ns839 0 1e-12
Ra839 ns839 0 2.25277197156 noise=0
Ca840 ns840 0 1e-12
Ca841 ns841 0 1e-12
Ra840 ns840 0 12.2584735833 noise=0
Ra841 ns841 0 12.2584735833 noise=0
Ga840 ns840 0 ns841 0 -0.470827691571
Ga841 ns841 0 ns840 0 0.470827691571
Ca842 ns842 0 1e-12
Ca843 ns843 0 1e-12
Ra842 ns842 0 25.6181403896 noise=0
Ra843 ns843 0 25.6181403896 noise=0
Ga842 ns842 0 ns843 0 -0.448026841046
Ga843 ns843 0 ns842 0 0.448026841046
Ca844 ns844 0 1e-12
Ca845 ns845 0 1e-12
Ra844 ns844 0 43.6974661765 noise=0
Ra845 ns845 0 43.6974661765 noise=0
Ga844 ns844 0 ns845 0 -0.43948250501
Ga845 ns845 0 ns844 0 0.43948250501
Ca846 ns846 0 1e-12
Ca847 ns847 0 1e-12
Ra846 ns846 0 18.0397111928 noise=0
Ra847 ns847 0 18.0397111928 noise=0
Ga846 ns846 0 ns847 0 -0.387833034432
Ga847 ns847 0 ns846 0 0.387833034432
Ca848 ns848 0 1e-12
Ca849 ns849 0 1e-12
Ra848 ns848 0 30.8418520482 noise=0
Ra849 ns849 0 30.8418520482 noise=0
Ga848 ns848 0 ns849 0 -0.396001611468
Ga849 ns849 0 ns848 0 0.396001611468
Ca850 ns850 0 1e-12
Ca851 ns851 0 1e-12
Ra850 ns850 0 41.0163217329 noise=0
Ra851 ns851 0 41.0163217329 noise=0
Ga850 ns850 0 ns851 0 -0.381592451289
Ga851 ns851 0 ns850 0 0.381592451289
Ca852 ns852 0 1e-12
Ca853 ns853 0 1e-12
Ra852 ns852 0 21.7602201341 noise=0
Ra853 ns853 0 21.7602201341 noise=0
Ga852 ns852 0 ns853 0 -0.308783855582
Ga853 ns853 0 ns852 0 0.308783855582
Ca854 ns854 0 1e-12
Ca855 ns855 0 1e-12
Ra854 ns854 0 31.7954014875 noise=0
Ra855 ns855 0 31.7954014875 noise=0
Ga854 ns854 0 ns855 0 -0.296374987646
Ga855 ns855 0 ns854 0 0.296374987646
Ca856 ns856 0 1e-12
Ca857 ns857 0 1e-12
Ra856 ns856 0 40.7548915023 noise=0
Ra857 ns857 0 40.7548915023 noise=0
Ga856 ns856 0 ns857 0 -0.280074006701
Ga857 ns857 0 ns856 0 0.280074006701
Ca858 ns858 0 1e-12
Ca859 ns859 0 1e-12
Ra858 ns858 0 16.2605473069 noise=0
Ra859 ns859 0 16.2605473069 noise=0
Ga858 ns858 0 ns859 0 -0.221944572364
Ga859 ns859 0 ns858 0 0.221944572364
Ca860 ns860 0 1e-12
Ca861 ns861 0 1e-12
Ra860 ns860 0 32.2071815157 noise=0
Ra861 ns861 0 32.2071815157 noise=0
Ga860 ns860 0 ns861 0 -0.202528261009
Ga861 ns861 0 ns860 0 0.202528261009
Ca862 ns862 0 1e-12
Ca863 ns863 0 1e-12
Ra862 ns862 0 37.0147768903 noise=0
Ra863 ns863 0 37.0147768903 noise=0
Ga862 ns862 0 ns863 0 -0.196192248457
Ga863 ns863 0 ns862 0 0.196192248457
Ca864 ns864 0 1e-12
Ca865 ns865 0 1e-12
Ra864 ns864 0 14.7020480531 noise=0
Ra865 ns865 0 14.7020480531 noise=0
Ga864 ns864 0 ns865 0 -0.120312309686
Ga865 ns865 0 ns864 0 0.120312309686
Ca866 ns866 0 1e-12
Ca867 ns867 0 1e-12
Ra866 ns866 0 26.4544905299 noise=0
Ra867 ns867 0 26.4544905299 noise=0
Ga866 ns866 0 ns867 0 -0.109680355063
Ga867 ns867 0 ns866 0 0.109680355063
Ca868 ns868 0 1e-12
Ca869 ns869 0 1e-12
Ra868 ns868 0 34.6142502796 noise=0
Ra869 ns869 0 34.6142502796 noise=0
Ga868 ns868 0 ns869 0 -0.0959452774828
Ga869 ns869 0 ns868 0 0.0959452774828
Ca870 ns870 0 1e-12
Ra870 ns870 0 13.7459165429 noise=0
Ca871 ns871 0 1e-12
Ra871 ns871 0 15.4643816792 noise=0
Ca872 ns872 0 1e-12
Ra872 ns872 0 31.0524450378 noise=0
Ca873 ns873 0 1e-12
Ra873 ns873 0 3165.2849616 noise=0
Ca874 ns874 0 1e-12
Ra874 ns874 0 0.000128571428571 noise=0
Ca875 ns875 0 1e-12
Ra875 ns875 0 0.622941609725 noise=0
Ca876 ns876 0 1e-12
Ra876 ns876 0 0.902892370164 noise=0
Ca877 ns877 0 1e-12
Ra877 ns877 0 2.25277197156 noise=0
Ca878 ns878 0 1e-12
Ca879 ns879 0 1e-12
Ra878 ns878 0 12.2584735833 noise=0
Ra879 ns879 0 12.2584735833 noise=0
Ga878 ns878 0 ns879 0 -0.470827691571
Ga879 ns879 0 ns878 0 0.470827691571
Ca880 ns880 0 1e-12
Ca881 ns881 0 1e-12
Ra880 ns880 0 25.6181403896 noise=0
Ra881 ns881 0 25.6181403896 noise=0
Ga880 ns880 0 ns881 0 -0.448026841046
Ga881 ns881 0 ns880 0 0.448026841046
Ca882 ns882 0 1e-12
Ca883 ns883 0 1e-12
Ra882 ns882 0 43.6974661765 noise=0
Ra883 ns883 0 43.6974661765 noise=0
Ga882 ns882 0 ns883 0 -0.43948250501
Ga883 ns883 0 ns882 0 0.43948250501
Ca884 ns884 0 1e-12
Ca885 ns885 0 1e-12
Ra884 ns884 0 18.0397111928 noise=0
Ra885 ns885 0 18.0397111928 noise=0
Ga884 ns884 0 ns885 0 -0.387833034432
Ga885 ns885 0 ns884 0 0.387833034432
Ca886 ns886 0 1e-12
Ca887 ns887 0 1e-12
Ra886 ns886 0 30.8418520482 noise=0
Ra887 ns887 0 30.8418520482 noise=0
Ga886 ns886 0 ns887 0 -0.396001611468
Ga887 ns887 0 ns886 0 0.396001611468
Ca888 ns888 0 1e-12
Ca889 ns889 0 1e-12
Ra888 ns888 0 41.0163217329 noise=0
Ra889 ns889 0 41.0163217329 noise=0
Ga888 ns888 0 ns889 0 -0.381592451289
Ga889 ns889 0 ns888 0 0.381592451289
Ca890 ns890 0 1e-12
Ca891 ns891 0 1e-12
Ra890 ns890 0 21.7602201341 noise=0
Ra891 ns891 0 21.7602201341 noise=0
Ga890 ns890 0 ns891 0 -0.308783855582
Ga891 ns891 0 ns890 0 0.308783855582
Ca892 ns892 0 1e-12
Ca893 ns893 0 1e-12
Ra892 ns892 0 31.7954014875 noise=0
Ra893 ns893 0 31.7954014875 noise=0
Ga892 ns892 0 ns893 0 -0.296374987646
Ga893 ns893 0 ns892 0 0.296374987646
Ca894 ns894 0 1e-12
Ca895 ns895 0 1e-12
Ra894 ns894 0 40.7548915023 noise=0
Ra895 ns895 0 40.7548915023 noise=0
Ga894 ns894 0 ns895 0 -0.280074006701
Ga895 ns895 0 ns894 0 0.280074006701
Ca896 ns896 0 1e-12
Ca897 ns897 0 1e-12
Ra896 ns896 0 16.2605473069 noise=0
Ra897 ns897 0 16.2605473069 noise=0
Ga896 ns896 0 ns897 0 -0.221944572364
Ga897 ns897 0 ns896 0 0.221944572364
Ca898 ns898 0 1e-12
Ca899 ns899 0 1e-12
Ra898 ns898 0 32.2071815157 noise=0
Ra899 ns899 0 32.2071815157 noise=0
Ga898 ns898 0 ns899 0 -0.202528261009
Ga899 ns899 0 ns898 0 0.202528261009
Ca900 ns900 0 1e-12
Ca901 ns901 0 1e-12
Ra900 ns900 0 37.0147768903 noise=0
Ra901 ns901 0 37.0147768903 noise=0
Ga900 ns900 0 ns901 0 -0.196192248457
Ga901 ns901 0 ns900 0 0.196192248457
Ca902 ns902 0 1e-12
Ca903 ns903 0 1e-12
Ra902 ns902 0 14.7020480531 noise=0
Ra903 ns903 0 14.7020480531 noise=0
Ga902 ns902 0 ns903 0 -0.120312309686
Ga903 ns903 0 ns902 0 0.120312309686
Ca904 ns904 0 1e-12
Ca905 ns905 0 1e-12
Ra904 ns904 0 26.4544905299 noise=0
Ra905 ns905 0 26.4544905299 noise=0
Ga904 ns904 0 ns905 0 -0.109680355063
Ga905 ns905 0 ns904 0 0.109680355063
Ca906 ns906 0 1e-12
Ca907 ns907 0 1e-12
Ra906 ns906 0 34.6142502796 noise=0
Ra907 ns907 0 34.6142502796 noise=0
Ga906 ns906 0 ns907 0 -0.0959452774828
Ga907 ns907 0 ns906 0 0.0959452774828
Ca908 ns908 0 1e-12
Ra908 ns908 0 13.7459165429 noise=0
Ca909 ns909 0 1e-12
Ra909 ns909 0 15.4643816792 noise=0
Ca910 ns910 0 1e-12
Ra910 ns910 0 31.0524450378 noise=0
Ca911 ns911 0 1e-12
Ra911 ns911 0 3165.2849616 noise=0
Ca912 ns912 0 1e-12
Ra912 ns912 0 0.000128571428571 noise=0
Ca913 ns913 0 1e-12
Ra913 ns913 0 0.622941609725 noise=0
Ca914 ns914 0 1e-12
Ra914 ns914 0 0.902892370164 noise=0
Ca915 ns915 0 1e-12
Ra915 ns915 0 2.25277197156 noise=0
Ca916 ns916 0 1e-12
Ca917 ns917 0 1e-12
Ra916 ns916 0 12.2584735833 noise=0
Ra917 ns917 0 12.2584735833 noise=0
Ga916 ns916 0 ns917 0 -0.470827691571
Ga917 ns917 0 ns916 0 0.470827691571
Ca918 ns918 0 1e-12
Ca919 ns919 0 1e-12
Ra918 ns918 0 25.6181403896 noise=0
Ra919 ns919 0 25.6181403896 noise=0
Ga918 ns918 0 ns919 0 -0.448026841046
Ga919 ns919 0 ns918 0 0.448026841046
Ca920 ns920 0 1e-12
Ca921 ns921 0 1e-12
Ra920 ns920 0 43.6974661765 noise=0
Ra921 ns921 0 43.6974661765 noise=0
Ga920 ns920 0 ns921 0 -0.43948250501
Ga921 ns921 0 ns920 0 0.43948250501
Ca922 ns922 0 1e-12
Ca923 ns923 0 1e-12
Ra922 ns922 0 18.0397111928 noise=0
Ra923 ns923 0 18.0397111928 noise=0
Ga922 ns922 0 ns923 0 -0.387833034432
Ga923 ns923 0 ns922 0 0.387833034432
Ca924 ns924 0 1e-12
Ca925 ns925 0 1e-12
Ra924 ns924 0 30.8418520482 noise=0
Ra925 ns925 0 30.8418520482 noise=0
Ga924 ns924 0 ns925 0 -0.396001611468
Ga925 ns925 0 ns924 0 0.396001611468
Ca926 ns926 0 1e-12
Ca927 ns927 0 1e-12
Ra926 ns926 0 41.0163217329 noise=0
Ra927 ns927 0 41.0163217329 noise=0
Ga926 ns926 0 ns927 0 -0.381592451289
Ga927 ns927 0 ns926 0 0.381592451289
Ca928 ns928 0 1e-12
Ca929 ns929 0 1e-12
Ra928 ns928 0 21.7602201341 noise=0
Ra929 ns929 0 21.7602201341 noise=0
Ga928 ns928 0 ns929 0 -0.308783855582
Ga929 ns929 0 ns928 0 0.308783855582
Ca930 ns930 0 1e-12
Ca931 ns931 0 1e-12
Ra930 ns930 0 31.7954014875 noise=0
Ra931 ns931 0 31.7954014875 noise=0
Ga930 ns930 0 ns931 0 -0.296374987646
Ga931 ns931 0 ns930 0 0.296374987646
Ca932 ns932 0 1e-12
Ca933 ns933 0 1e-12
Ra932 ns932 0 40.7548915023 noise=0
Ra933 ns933 0 40.7548915023 noise=0
Ga932 ns932 0 ns933 0 -0.280074006701
Ga933 ns933 0 ns932 0 0.280074006701
Ca934 ns934 0 1e-12
Ca935 ns935 0 1e-12
Ra934 ns934 0 16.2605473069 noise=0
Ra935 ns935 0 16.2605473069 noise=0
Ga934 ns934 0 ns935 0 -0.221944572364
Ga935 ns935 0 ns934 0 0.221944572364
Ca936 ns936 0 1e-12
Ca937 ns937 0 1e-12
Ra936 ns936 0 32.2071815157 noise=0
Ra937 ns937 0 32.2071815157 noise=0
Ga936 ns936 0 ns937 0 -0.202528261009
Ga937 ns937 0 ns936 0 0.202528261009
Ca938 ns938 0 1e-12
Ca939 ns939 0 1e-12
Ra938 ns938 0 37.0147768903 noise=0
Ra939 ns939 0 37.0147768903 noise=0
Ga938 ns938 0 ns939 0 -0.196192248457
Ga939 ns939 0 ns938 0 0.196192248457
Ca940 ns940 0 1e-12
Ca941 ns941 0 1e-12
Ra940 ns940 0 14.7020480531 noise=0
Ra941 ns941 0 14.7020480531 noise=0
Ga940 ns940 0 ns941 0 -0.120312309686
Ga941 ns941 0 ns940 0 0.120312309686
Ca942 ns942 0 1e-12
Ca943 ns943 0 1e-12
Ra942 ns942 0 26.4544905299 noise=0
Ra943 ns943 0 26.4544905299 noise=0
Ga942 ns942 0 ns943 0 -0.109680355063
Ga943 ns943 0 ns942 0 0.109680355063
Ca944 ns944 0 1e-12
Ca945 ns945 0 1e-12
Ra944 ns944 0 34.6142502796 noise=0
Ra945 ns945 0 34.6142502796 noise=0
Ga944 ns944 0 ns945 0 -0.0959452774828
Ga945 ns945 0 ns944 0 0.0959452774828
Ca946 ns946 0 1e-12
Ra946 ns946 0 13.7459165429 noise=0
Ca947 ns947 0 1e-12
Ra947 ns947 0 15.4643816792 noise=0
Ca948 ns948 0 1e-12
Ra948 ns948 0 31.0524450378 noise=0
Ca949 ns949 0 1e-12
Ra949 ns949 0 3165.2849616 noise=0
Ca950 ns950 0 1e-12
Ra950 ns950 0 0.000128571428571 noise=0
Ca951 ns951 0 1e-12
Ra951 ns951 0 0.622941609725 noise=0
Ca952 ns952 0 1e-12
Ra952 ns952 0 0.902892370164 noise=0
Ca953 ns953 0 1e-12
Ra953 ns953 0 2.25277197156 noise=0
Ca954 ns954 0 1e-12
Ca955 ns955 0 1e-12
Ra954 ns954 0 12.2584735833 noise=0
Ra955 ns955 0 12.2584735833 noise=0
Ga954 ns954 0 ns955 0 -0.470827691571
Ga955 ns955 0 ns954 0 0.470827691571
Ca956 ns956 0 1e-12
Ca957 ns957 0 1e-12
Ra956 ns956 0 25.6181403896 noise=0
Ra957 ns957 0 25.6181403896 noise=0
Ga956 ns956 0 ns957 0 -0.448026841046
Ga957 ns957 0 ns956 0 0.448026841046
Ca958 ns958 0 1e-12
Ca959 ns959 0 1e-12
Ra958 ns958 0 43.6974661765 noise=0
Ra959 ns959 0 43.6974661765 noise=0
Ga958 ns958 0 ns959 0 -0.43948250501
Ga959 ns959 0 ns958 0 0.43948250501
Ca960 ns960 0 1e-12
Ca961 ns961 0 1e-12
Ra960 ns960 0 18.0397111928 noise=0
Ra961 ns961 0 18.0397111928 noise=0
Ga960 ns960 0 ns961 0 -0.387833034432
Ga961 ns961 0 ns960 0 0.387833034432
Ca962 ns962 0 1e-12
Ca963 ns963 0 1e-12
Ra962 ns962 0 30.8418520482 noise=0
Ra963 ns963 0 30.8418520482 noise=0
Ga962 ns962 0 ns963 0 -0.396001611468
Ga963 ns963 0 ns962 0 0.396001611468
Ca964 ns964 0 1e-12
Ca965 ns965 0 1e-12
Ra964 ns964 0 41.0163217329 noise=0
Ra965 ns965 0 41.0163217329 noise=0
Ga964 ns964 0 ns965 0 -0.381592451289
Ga965 ns965 0 ns964 0 0.381592451289
Ca966 ns966 0 1e-12
Ca967 ns967 0 1e-12
Ra966 ns966 0 21.7602201341 noise=0
Ra967 ns967 0 21.7602201341 noise=0
Ga966 ns966 0 ns967 0 -0.308783855582
Ga967 ns967 0 ns966 0 0.308783855582
Ca968 ns968 0 1e-12
Ca969 ns969 0 1e-12
Ra968 ns968 0 31.7954014875 noise=0
Ra969 ns969 0 31.7954014875 noise=0
Ga968 ns968 0 ns969 0 -0.296374987646
Ga969 ns969 0 ns968 0 0.296374987646
Ca970 ns970 0 1e-12
Ca971 ns971 0 1e-12
Ra970 ns970 0 40.7548915023 noise=0
Ra971 ns971 0 40.7548915023 noise=0
Ga970 ns970 0 ns971 0 -0.280074006701
Ga971 ns971 0 ns970 0 0.280074006701
Ca972 ns972 0 1e-12
Ca973 ns973 0 1e-12
Ra972 ns972 0 16.2605473069 noise=0
Ra973 ns973 0 16.2605473069 noise=0
Ga972 ns972 0 ns973 0 -0.221944572364
Ga973 ns973 0 ns972 0 0.221944572364
Ca974 ns974 0 1e-12
Ca975 ns975 0 1e-12
Ra974 ns974 0 32.2071815157 noise=0
Ra975 ns975 0 32.2071815157 noise=0
Ga974 ns974 0 ns975 0 -0.202528261009
Ga975 ns975 0 ns974 0 0.202528261009
Ca976 ns976 0 1e-12
Ca977 ns977 0 1e-12
Ra976 ns976 0 37.0147768903 noise=0
Ra977 ns977 0 37.0147768903 noise=0
Ga976 ns976 0 ns977 0 -0.196192248457
Ga977 ns977 0 ns976 0 0.196192248457
Ca978 ns978 0 1e-12
Ca979 ns979 0 1e-12
Ra978 ns978 0 14.7020480531 noise=0
Ra979 ns979 0 14.7020480531 noise=0
Ga978 ns978 0 ns979 0 -0.120312309686
Ga979 ns979 0 ns978 0 0.120312309686
Ca980 ns980 0 1e-12
Ca981 ns981 0 1e-12
Ra980 ns980 0 26.4544905299 noise=0
Ra981 ns981 0 26.4544905299 noise=0
Ga980 ns980 0 ns981 0 -0.109680355063
Ga981 ns981 0 ns980 0 0.109680355063
Ca982 ns982 0 1e-12
Ca983 ns983 0 1e-12
Ra982 ns982 0 34.6142502796 noise=0
Ra983 ns983 0 34.6142502796 noise=0
Ga982 ns982 0 ns983 0 -0.0959452774828
Ga983 ns983 0 ns982 0 0.0959452774828
Ca984 ns984 0 1e-12
Ra984 ns984 0 13.7459165429 noise=0
Ca985 ns985 0 1e-12
Ra985 ns985 0 15.4643816792 noise=0
Ca986 ns986 0 1e-12
Ra986 ns986 0 31.0524450378 noise=0
Ca987 ns987 0 1e-12
Ra987 ns987 0 3165.2849616 noise=0
Ca988 ns988 0 1e-12
Ra988 ns988 0 0.000128571428571 noise=0
Ca989 ns989 0 1e-12
Ra989 ns989 0 0.622941609725 noise=0
Ca990 ns990 0 1e-12
Ra990 ns990 0 0.902892370164 noise=0
Ca991 ns991 0 1e-12
Ra991 ns991 0 2.25277197156 noise=0
Ca992 ns992 0 1e-12
Ca993 ns993 0 1e-12
Ra992 ns992 0 12.2584735833 noise=0
Ra993 ns993 0 12.2584735833 noise=0
Ga992 ns992 0 ns993 0 -0.470827691571
Ga993 ns993 0 ns992 0 0.470827691571
Ca994 ns994 0 1e-12
Ca995 ns995 0 1e-12
Ra994 ns994 0 25.6181403896 noise=0
Ra995 ns995 0 25.6181403896 noise=0
Ga994 ns994 0 ns995 0 -0.448026841046
Ga995 ns995 0 ns994 0 0.448026841046
Ca996 ns996 0 1e-12
Ca997 ns997 0 1e-12
Ra996 ns996 0 43.6974661765 noise=0
Ra997 ns997 0 43.6974661765 noise=0
Ga996 ns996 0 ns997 0 -0.43948250501
Ga997 ns997 0 ns996 0 0.43948250501
Ca998 ns998 0 1e-12
Ca999 ns999 0 1e-12
Ra998 ns998 0 18.0397111928 noise=0
Ra999 ns999 0 18.0397111928 noise=0
Ga998 ns998 0 ns999 0 -0.387833034432
Ga999 ns999 0 ns998 0 0.387833034432
Ca1000 ns1000 0 1e-12
Ca1001 ns1001 0 1e-12
Ra1000 ns1000 0 30.8418520482 noise=0
Ra1001 ns1001 0 30.8418520482 noise=0
Ga1000 ns1000 0 ns1001 0 -0.396001611468
Ga1001 ns1001 0 ns1000 0 0.396001611468
Ca1002 ns1002 0 1e-12
Ca1003 ns1003 0 1e-12
Ra1002 ns1002 0 41.0163217329 noise=0
Ra1003 ns1003 0 41.0163217329 noise=0
Ga1002 ns1002 0 ns1003 0 -0.381592451289
Ga1003 ns1003 0 ns1002 0 0.381592451289
Ca1004 ns1004 0 1e-12
Ca1005 ns1005 0 1e-12
Ra1004 ns1004 0 21.7602201341 noise=0
Ra1005 ns1005 0 21.7602201341 noise=0
Ga1004 ns1004 0 ns1005 0 -0.308783855582
Ga1005 ns1005 0 ns1004 0 0.308783855582
Ca1006 ns1006 0 1e-12
Ca1007 ns1007 0 1e-12
Ra1006 ns1006 0 31.7954014875 noise=0
Ra1007 ns1007 0 31.7954014875 noise=0
Ga1006 ns1006 0 ns1007 0 -0.296374987646
Ga1007 ns1007 0 ns1006 0 0.296374987646
Ca1008 ns1008 0 1e-12
Ca1009 ns1009 0 1e-12
Ra1008 ns1008 0 40.7548915023 noise=0
Ra1009 ns1009 0 40.7548915023 noise=0
Ga1008 ns1008 0 ns1009 0 -0.280074006701
Ga1009 ns1009 0 ns1008 0 0.280074006701
Ca1010 ns1010 0 1e-12
Ca1011 ns1011 0 1e-12
Ra1010 ns1010 0 16.2605473069 noise=0
Ra1011 ns1011 0 16.2605473069 noise=0
Ga1010 ns1010 0 ns1011 0 -0.221944572364
Ga1011 ns1011 0 ns1010 0 0.221944572364
Ca1012 ns1012 0 1e-12
Ca1013 ns1013 0 1e-12
Ra1012 ns1012 0 32.2071815157 noise=0
Ra1013 ns1013 0 32.2071815157 noise=0
Ga1012 ns1012 0 ns1013 0 -0.202528261009
Ga1013 ns1013 0 ns1012 0 0.202528261009
Ca1014 ns1014 0 1e-12
Ca1015 ns1015 0 1e-12
Ra1014 ns1014 0 37.0147768903 noise=0
Ra1015 ns1015 0 37.0147768903 noise=0
Ga1014 ns1014 0 ns1015 0 -0.196192248457
Ga1015 ns1015 0 ns1014 0 0.196192248457
Ca1016 ns1016 0 1e-12
Ca1017 ns1017 0 1e-12
Ra1016 ns1016 0 14.7020480531 noise=0
Ra1017 ns1017 0 14.7020480531 noise=0
Ga1016 ns1016 0 ns1017 0 -0.120312309686
Ga1017 ns1017 0 ns1016 0 0.120312309686
Ca1018 ns1018 0 1e-12
Ca1019 ns1019 0 1e-12
Ra1018 ns1018 0 26.4544905299 noise=0
Ra1019 ns1019 0 26.4544905299 noise=0
Ga1018 ns1018 0 ns1019 0 -0.109680355063
Ga1019 ns1019 0 ns1018 0 0.109680355063
Ca1020 ns1020 0 1e-12
Ca1021 ns1021 0 1e-12
Ra1020 ns1020 0 34.6142502796 noise=0
Ra1021 ns1021 0 34.6142502796 noise=0
Ga1020 ns1020 0 ns1021 0 -0.0959452774828
Ga1021 ns1021 0 ns1020 0 0.0959452774828
Ca1022 ns1022 0 1e-12
Ra1022 ns1022 0 13.7459165429 noise=0
Ca1023 ns1023 0 1e-12
Ra1023 ns1023 0 15.4643816792 noise=0
Ca1024 ns1024 0 1e-12
Ra1024 ns1024 0 31.0524450378 noise=0
Ca1025 ns1025 0 1e-12
Ra1025 ns1025 0 3165.2849616 noise=0
Ca1026 ns1026 0 1e-12
Ra1026 ns1026 0 0.000128571428571 noise=0
Ca1027 ns1027 0 1e-12
Ra1027 ns1027 0 0.622941609725 noise=0
Ca1028 ns1028 0 1e-12
Ra1028 ns1028 0 0.902892370164 noise=0
Ca1029 ns1029 0 1e-12
Ra1029 ns1029 0 2.25277197156 noise=0
Ca1030 ns1030 0 1e-12
Ca1031 ns1031 0 1e-12
Ra1030 ns1030 0 12.2584735833 noise=0
Ra1031 ns1031 0 12.2584735833 noise=0
Ga1030 ns1030 0 ns1031 0 -0.470827691571
Ga1031 ns1031 0 ns1030 0 0.470827691571
Ca1032 ns1032 0 1e-12
Ca1033 ns1033 0 1e-12
Ra1032 ns1032 0 25.6181403896 noise=0
Ra1033 ns1033 0 25.6181403896 noise=0
Ga1032 ns1032 0 ns1033 0 -0.448026841046
Ga1033 ns1033 0 ns1032 0 0.448026841046
Ca1034 ns1034 0 1e-12
Ca1035 ns1035 0 1e-12
Ra1034 ns1034 0 43.6974661765 noise=0
Ra1035 ns1035 0 43.6974661765 noise=0
Ga1034 ns1034 0 ns1035 0 -0.43948250501
Ga1035 ns1035 0 ns1034 0 0.43948250501
Ca1036 ns1036 0 1e-12
Ca1037 ns1037 0 1e-12
Ra1036 ns1036 0 18.0397111928 noise=0
Ra1037 ns1037 0 18.0397111928 noise=0
Ga1036 ns1036 0 ns1037 0 -0.387833034432
Ga1037 ns1037 0 ns1036 0 0.387833034432
Ca1038 ns1038 0 1e-12
Ca1039 ns1039 0 1e-12
Ra1038 ns1038 0 30.8418520482 noise=0
Ra1039 ns1039 0 30.8418520482 noise=0
Ga1038 ns1038 0 ns1039 0 -0.396001611468
Ga1039 ns1039 0 ns1038 0 0.396001611468
Ca1040 ns1040 0 1e-12
Ca1041 ns1041 0 1e-12
Ra1040 ns1040 0 41.0163217329 noise=0
Ra1041 ns1041 0 41.0163217329 noise=0
Ga1040 ns1040 0 ns1041 0 -0.381592451289
Ga1041 ns1041 0 ns1040 0 0.381592451289
Ca1042 ns1042 0 1e-12
Ca1043 ns1043 0 1e-12
Ra1042 ns1042 0 21.7602201341 noise=0
Ra1043 ns1043 0 21.7602201341 noise=0
Ga1042 ns1042 0 ns1043 0 -0.308783855582
Ga1043 ns1043 0 ns1042 0 0.308783855582
Ca1044 ns1044 0 1e-12
Ca1045 ns1045 0 1e-12
Ra1044 ns1044 0 31.7954014875 noise=0
Ra1045 ns1045 0 31.7954014875 noise=0
Ga1044 ns1044 0 ns1045 0 -0.296374987646
Ga1045 ns1045 0 ns1044 0 0.296374987646
Ca1046 ns1046 0 1e-12
Ca1047 ns1047 0 1e-12
Ra1046 ns1046 0 40.7548915023 noise=0
Ra1047 ns1047 0 40.7548915023 noise=0
Ga1046 ns1046 0 ns1047 0 -0.280074006701
Ga1047 ns1047 0 ns1046 0 0.280074006701
Ca1048 ns1048 0 1e-12
Ca1049 ns1049 0 1e-12
Ra1048 ns1048 0 16.2605473069 noise=0
Ra1049 ns1049 0 16.2605473069 noise=0
Ga1048 ns1048 0 ns1049 0 -0.221944572364
Ga1049 ns1049 0 ns1048 0 0.221944572364
Ca1050 ns1050 0 1e-12
Ca1051 ns1051 0 1e-12
Ra1050 ns1050 0 32.2071815157 noise=0
Ra1051 ns1051 0 32.2071815157 noise=0
Ga1050 ns1050 0 ns1051 0 -0.202528261009
Ga1051 ns1051 0 ns1050 0 0.202528261009
Ca1052 ns1052 0 1e-12
Ca1053 ns1053 0 1e-12
Ra1052 ns1052 0 37.0147768903 noise=0
Ra1053 ns1053 0 37.0147768903 noise=0
Ga1052 ns1052 0 ns1053 0 -0.196192248457
Ga1053 ns1053 0 ns1052 0 0.196192248457
Ca1054 ns1054 0 1e-12
Ca1055 ns1055 0 1e-12
Ra1054 ns1054 0 14.7020480531 noise=0
Ra1055 ns1055 0 14.7020480531 noise=0
Ga1054 ns1054 0 ns1055 0 -0.120312309686
Ga1055 ns1055 0 ns1054 0 0.120312309686
Ca1056 ns1056 0 1e-12
Ca1057 ns1057 0 1e-12
Ra1056 ns1056 0 26.4544905299 noise=0
Ra1057 ns1057 0 26.4544905299 noise=0
Ga1056 ns1056 0 ns1057 0 -0.109680355063
Ga1057 ns1057 0 ns1056 0 0.109680355063
Ca1058 ns1058 0 1e-12
Ca1059 ns1059 0 1e-12
Ra1058 ns1058 0 34.6142502796 noise=0
Ra1059 ns1059 0 34.6142502796 noise=0
Ga1058 ns1058 0 ns1059 0 -0.0959452774828
Ga1059 ns1059 0 ns1058 0 0.0959452774828
Ca1060 ns1060 0 1e-12
Ra1060 ns1060 0 13.7459165429 noise=0
Ca1061 ns1061 0 1e-12
Ra1061 ns1061 0 15.4643816792 noise=0
Ca1062 ns1062 0 1e-12
Ra1062 ns1062 0 31.0524450378 noise=0
Ca1063 ns1063 0 1e-12
Ra1063 ns1063 0 3165.2849616 noise=0
Ca1064 ns1064 0 1e-12
Ra1064 ns1064 0 0.000128571428571 noise=0
Ca1065 ns1065 0 1e-12
Ra1065 ns1065 0 0.622941609725 noise=0
Ca1066 ns1066 0 1e-12
Ra1066 ns1066 0 0.902892370164 noise=0
Ca1067 ns1067 0 1e-12
Ra1067 ns1067 0 2.25277197156 noise=0
Ca1068 ns1068 0 1e-12
Ca1069 ns1069 0 1e-12
Ra1068 ns1068 0 12.2584735833 noise=0
Ra1069 ns1069 0 12.2584735833 noise=0
Ga1068 ns1068 0 ns1069 0 -0.470827691571
Ga1069 ns1069 0 ns1068 0 0.470827691571
Ca1070 ns1070 0 1e-12
Ca1071 ns1071 0 1e-12
Ra1070 ns1070 0 25.6181403896 noise=0
Ra1071 ns1071 0 25.6181403896 noise=0
Ga1070 ns1070 0 ns1071 0 -0.448026841046
Ga1071 ns1071 0 ns1070 0 0.448026841046
Ca1072 ns1072 0 1e-12
Ca1073 ns1073 0 1e-12
Ra1072 ns1072 0 43.6974661765 noise=0
Ra1073 ns1073 0 43.6974661765 noise=0
Ga1072 ns1072 0 ns1073 0 -0.43948250501
Ga1073 ns1073 0 ns1072 0 0.43948250501
Ca1074 ns1074 0 1e-12
Ca1075 ns1075 0 1e-12
Ra1074 ns1074 0 18.0397111928 noise=0
Ra1075 ns1075 0 18.0397111928 noise=0
Ga1074 ns1074 0 ns1075 0 -0.387833034432
Ga1075 ns1075 0 ns1074 0 0.387833034432
Ca1076 ns1076 0 1e-12
Ca1077 ns1077 0 1e-12
Ra1076 ns1076 0 30.8418520482 noise=0
Ra1077 ns1077 0 30.8418520482 noise=0
Ga1076 ns1076 0 ns1077 0 -0.396001611468
Ga1077 ns1077 0 ns1076 0 0.396001611468
Ca1078 ns1078 0 1e-12
Ca1079 ns1079 0 1e-12
Ra1078 ns1078 0 41.0163217329 noise=0
Ra1079 ns1079 0 41.0163217329 noise=0
Ga1078 ns1078 0 ns1079 0 -0.381592451289
Ga1079 ns1079 0 ns1078 0 0.381592451289
Ca1080 ns1080 0 1e-12
Ca1081 ns1081 0 1e-12
Ra1080 ns1080 0 21.7602201341 noise=0
Ra1081 ns1081 0 21.7602201341 noise=0
Ga1080 ns1080 0 ns1081 0 -0.308783855582
Ga1081 ns1081 0 ns1080 0 0.308783855582
Ca1082 ns1082 0 1e-12
Ca1083 ns1083 0 1e-12
Ra1082 ns1082 0 31.7954014875 noise=0
Ra1083 ns1083 0 31.7954014875 noise=0
Ga1082 ns1082 0 ns1083 0 -0.296374987646
Ga1083 ns1083 0 ns1082 0 0.296374987646
Ca1084 ns1084 0 1e-12
Ca1085 ns1085 0 1e-12
Ra1084 ns1084 0 40.7548915023 noise=0
Ra1085 ns1085 0 40.7548915023 noise=0
Ga1084 ns1084 0 ns1085 0 -0.280074006701
Ga1085 ns1085 0 ns1084 0 0.280074006701
Ca1086 ns1086 0 1e-12
Ca1087 ns1087 0 1e-12
Ra1086 ns1086 0 16.2605473069 noise=0
Ra1087 ns1087 0 16.2605473069 noise=0
Ga1086 ns1086 0 ns1087 0 -0.221944572364
Ga1087 ns1087 0 ns1086 0 0.221944572364
Ca1088 ns1088 0 1e-12
Ca1089 ns1089 0 1e-12
Ra1088 ns1088 0 32.2071815157 noise=0
Ra1089 ns1089 0 32.2071815157 noise=0
Ga1088 ns1088 0 ns1089 0 -0.202528261009
Ga1089 ns1089 0 ns1088 0 0.202528261009
Ca1090 ns1090 0 1e-12
Ca1091 ns1091 0 1e-12
Ra1090 ns1090 0 37.0147768903 noise=0
Ra1091 ns1091 0 37.0147768903 noise=0
Ga1090 ns1090 0 ns1091 0 -0.196192248457
Ga1091 ns1091 0 ns1090 0 0.196192248457
Ca1092 ns1092 0 1e-12
Ca1093 ns1093 0 1e-12
Ra1092 ns1092 0 14.7020480531 noise=0
Ra1093 ns1093 0 14.7020480531 noise=0
Ga1092 ns1092 0 ns1093 0 -0.120312309686
Ga1093 ns1093 0 ns1092 0 0.120312309686
Ca1094 ns1094 0 1e-12
Ca1095 ns1095 0 1e-12
Ra1094 ns1094 0 26.4544905299 noise=0
Ra1095 ns1095 0 26.4544905299 noise=0
Ga1094 ns1094 0 ns1095 0 -0.109680355063
Ga1095 ns1095 0 ns1094 0 0.109680355063
Ca1096 ns1096 0 1e-12
Ca1097 ns1097 0 1e-12
Ra1096 ns1096 0 34.6142502796 noise=0
Ra1097 ns1097 0 34.6142502796 noise=0
Ga1096 ns1096 0 ns1097 0 -0.0959452774828
Ga1097 ns1097 0 ns1096 0 0.0959452774828
Ca1098 ns1098 0 1e-12
Ra1098 ns1098 0 13.7459165429 noise=0
Ca1099 ns1099 0 1e-12
Ra1099 ns1099 0 15.4643816792 noise=0
Ca1100 ns1100 0 1e-12
Ra1100 ns1100 0 31.0524450378 noise=0
Ca1101 ns1101 0 1e-12
Ra1101 ns1101 0 3165.2849616 noise=0
Ca1102 ns1102 0 1e-12
Ra1102 ns1102 0 0.000128571428571 noise=0
Ca1103 ns1103 0 1e-12
Ra1103 ns1103 0 0.622941609725 noise=0
Ca1104 ns1104 0 1e-12
Ra1104 ns1104 0 0.902892370164 noise=0
Ca1105 ns1105 0 1e-12
Ra1105 ns1105 0 2.25277197156 noise=0
Ca1106 ns1106 0 1e-12
Ca1107 ns1107 0 1e-12
Ra1106 ns1106 0 12.2584735833 noise=0
Ra1107 ns1107 0 12.2584735833 noise=0
Ga1106 ns1106 0 ns1107 0 -0.470827691571
Ga1107 ns1107 0 ns1106 0 0.470827691571
Ca1108 ns1108 0 1e-12
Ca1109 ns1109 0 1e-12
Ra1108 ns1108 0 25.6181403896 noise=0
Ra1109 ns1109 0 25.6181403896 noise=0
Ga1108 ns1108 0 ns1109 0 -0.448026841046
Ga1109 ns1109 0 ns1108 0 0.448026841046
Ca1110 ns1110 0 1e-12
Ca1111 ns1111 0 1e-12
Ra1110 ns1110 0 43.6974661765 noise=0
Ra1111 ns1111 0 43.6974661765 noise=0
Ga1110 ns1110 0 ns1111 0 -0.43948250501
Ga1111 ns1111 0 ns1110 0 0.43948250501
Ca1112 ns1112 0 1e-12
Ca1113 ns1113 0 1e-12
Ra1112 ns1112 0 18.0397111928 noise=0
Ra1113 ns1113 0 18.0397111928 noise=0
Ga1112 ns1112 0 ns1113 0 -0.387833034432
Ga1113 ns1113 0 ns1112 0 0.387833034432
Ca1114 ns1114 0 1e-12
Ca1115 ns1115 0 1e-12
Ra1114 ns1114 0 30.8418520482 noise=0
Ra1115 ns1115 0 30.8418520482 noise=0
Ga1114 ns1114 0 ns1115 0 -0.396001611468
Ga1115 ns1115 0 ns1114 0 0.396001611468
Ca1116 ns1116 0 1e-12
Ca1117 ns1117 0 1e-12
Ra1116 ns1116 0 41.0163217329 noise=0
Ra1117 ns1117 0 41.0163217329 noise=0
Ga1116 ns1116 0 ns1117 0 -0.381592451289
Ga1117 ns1117 0 ns1116 0 0.381592451289
Ca1118 ns1118 0 1e-12
Ca1119 ns1119 0 1e-12
Ra1118 ns1118 0 21.7602201341 noise=0
Ra1119 ns1119 0 21.7602201341 noise=0
Ga1118 ns1118 0 ns1119 0 -0.308783855582
Ga1119 ns1119 0 ns1118 0 0.308783855582
Ca1120 ns1120 0 1e-12
Ca1121 ns1121 0 1e-12
Ra1120 ns1120 0 31.7954014875 noise=0
Ra1121 ns1121 0 31.7954014875 noise=0
Ga1120 ns1120 0 ns1121 0 -0.296374987646
Ga1121 ns1121 0 ns1120 0 0.296374987646
Ca1122 ns1122 0 1e-12
Ca1123 ns1123 0 1e-12
Ra1122 ns1122 0 40.7548915023 noise=0
Ra1123 ns1123 0 40.7548915023 noise=0
Ga1122 ns1122 0 ns1123 0 -0.280074006701
Ga1123 ns1123 0 ns1122 0 0.280074006701
Ca1124 ns1124 0 1e-12
Ca1125 ns1125 0 1e-12
Ra1124 ns1124 0 16.2605473069 noise=0
Ra1125 ns1125 0 16.2605473069 noise=0
Ga1124 ns1124 0 ns1125 0 -0.221944572364
Ga1125 ns1125 0 ns1124 0 0.221944572364
Ca1126 ns1126 0 1e-12
Ca1127 ns1127 0 1e-12
Ra1126 ns1126 0 32.2071815157 noise=0
Ra1127 ns1127 0 32.2071815157 noise=0
Ga1126 ns1126 0 ns1127 0 -0.202528261009
Ga1127 ns1127 0 ns1126 0 0.202528261009
Ca1128 ns1128 0 1e-12
Ca1129 ns1129 0 1e-12
Ra1128 ns1128 0 37.0147768903 noise=0
Ra1129 ns1129 0 37.0147768903 noise=0
Ga1128 ns1128 0 ns1129 0 -0.196192248457
Ga1129 ns1129 0 ns1128 0 0.196192248457
Ca1130 ns1130 0 1e-12
Ca1131 ns1131 0 1e-12
Ra1130 ns1130 0 14.7020480531 noise=0
Ra1131 ns1131 0 14.7020480531 noise=0
Ga1130 ns1130 0 ns1131 0 -0.120312309686
Ga1131 ns1131 0 ns1130 0 0.120312309686
Ca1132 ns1132 0 1e-12
Ca1133 ns1133 0 1e-12
Ra1132 ns1132 0 26.4544905299 noise=0
Ra1133 ns1133 0 26.4544905299 noise=0
Ga1132 ns1132 0 ns1133 0 -0.109680355063
Ga1133 ns1133 0 ns1132 0 0.109680355063
Ca1134 ns1134 0 1e-12
Ca1135 ns1135 0 1e-12
Ra1134 ns1134 0 34.6142502796 noise=0
Ra1135 ns1135 0 34.6142502796 noise=0
Ga1134 ns1134 0 ns1135 0 -0.0959452774828
Ga1135 ns1135 0 ns1134 0 0.0959452774828
Ca1136 ns1136 0 1e-12
Ra1136 ns1136 0 13.7459165429 noise=0
Ca1137 ns1137 0 1e-12
Ra1137 ns1137 0 15.4643816792 noise=0
Ca1138 ns1138 0 1e-12
Ra1138 ns1138 0 31.0524450378 noise=0
Ca1139 ns1139 0 1e-12
Ra1139 ns1139 0 3165.2849616 noise=0
Ca1140 ns1140 0 1e-12
Ra1140 ns1140 0 0.000128571428571 noise=0
Ca1141 ns1141 0 1e-12
Ra1141 ns1141 0 0.622941609725 noise=0
Ca1142 ns1142 0 1e-12
Ra1142 ns1142 0 0.902892370164 noise=0
Ca1143 ns1143 0 1e-12
Ra1143 ns1143 0 2.25277197156 noise=0
Ca1144 ns1144 0 1e-12
Ca1145 ns1145 0 1e-12
Ra1144 ns1144 0 12.2584735833 noise=0
Ra1145 ns1145 0 12.2584735833 noise=0
Ga1144 ns1144 0 ns1145 0 -0.470827691571
Ga1145 ns1145 0 ns1144 0 0.470827691571
Ca1146 ns1146 0 1e-12
Ca1147 ns1147 0 1e-12
Ra1146 ns1146 0 25.6181403896 noise=0
Ra1147 ns1147 0 25.6181403896 noise=0
Ga1146 ns1146 0 ns1147 0 -0.448026841046
Ga1147 ns1147 0 ns1146 0 0.448026841046
Ca1148 ns1148 0 1e-12
Ca1149 ns1149 0 1e-12
Ra1148 ns1148 0 43.6974661765 noise=0
Ra1149 ns1149 0 43.6974661765 noise=0
Ga1148 ns1148 0 ns1149 0 -0.43948250501
Ga1149 ns1149 0 ns1148 0 0.43948250501
Ca1150 ns1150 0 1e-12
Ca1151 ns1151 0 1e-12
Ra1150 ns1150 0 18.0397111928 noise=0
Ra1151 ns1151 0 18.0397111928 noise=0
Ga1150 ns1150 0 ns1151 0 -0.387833034432
Ga1151 ns1151 0 ns1150 0 0.387833034432
Ca1152 ns1152 0 1e-12
Ca1153 ns1153 0 1e-12
Ra1152 ns1152 0 30.8418520482 noise=0
Ra1153 ns1153 0 30.8418520482 noise=0
Ga1152 ns1152 0 ns1153 0 -0.396001611468
Ga1153 ns1153 0 ns1152 0 0.396001611468
Ca1154 ns1154 0 1e-12
Ca1155 ns1155 0 1e-12
Ra1154 ns1154 0 41.0163217329 noise=0
Ra1155 ns1155 0 41.0163217329 noise=0
Ga1154 ns1154 0 ns1155 0 -0.381592451289
Ga1155 ns1155 0 ns1154 0 0.381592451289
Ca1156 ns1156 0 1e-12
Ca1157 ns1157 0 1e-12
Ra1156 ns1156 0 21.7602201341 noise=0
Ra1157 ns1157 0 21.7602201341 noise=0
Ga1156 ns1156 0 ns1157 0 -0.308783855582
Ga1157 ns1157 0 ns1156 0 0.308783855582
Ca1158 ns1158 0 1e-12
Ca1159 ns1159 0 1e-12
Ra1158 ns1158 0 31.7954014875 noise=0
Ra1159 ns1159 0 31.7954014875 noise=0
Ga1158 ns1158 0 ns1159 0 -0.296374987646
Ga1159 ns1159 0 ns1158 0 0.296374987646
Ca1160 ns1160 0 1e-12
Ca1161 ns1161 0 1e-12
Ra1160 ns1160 0 40.7548915023 noise=0
Ra1161 ns1161 0 40.7548915023 noise=0
Ga1160 ns1160 0 ns1161 0 -0.280074006701
Ga1161 ns1161 0 ns1160 0 0.280074006701
Ca1162 ns1162 0 1e-12
Ca1163 ns1163 0 1e-12
Ra1162 ns1162 0 16.2605473069 noise=0
Ra1163 ns1163 0 16.2605473069 noise=0
Ga1162 ns1162 0 ns1163 0 -0.221944572364
Ga1163 ns1163 0 ns1162 0 0.221944572364
Ca1164 ns1164 0 1e-12
Ca1165 ns1165 0 1e-12
Ra1164 ns1164 0 32.2071815157 noise=0
Ra1165 ns1165 0 32.2071815157 noise=0
Ga1164 ns1164 0 ns1165 0 -0.202528261009
Ga1165 ns1165 0 ns1164 0 0.202528261009
Ca1166 ns1166 0 1e-12
Ca1167 ns1167 0 1e-12
Ra1166 ns1166 0 37.0147768903 noise=0
Ra1167 ns1167 0 37.0147768903 noise=0
Ga1166 ns1166 0 ns1167 0 -0.196192248457
Ga1167 ns1167 0 ns1166 0 0.196192248457
Ca1168 ns1168 0 1e-12
Ca1169 ns1169 0 1e-12
Ra1168 ns1168 0 14.7020480531 noise=0
Ra1169 ns1169 0 14.7020480531 noise=0
Ga1168 ns1168 0 ns1169 0 -0.120312309686
Ga1169 ns1169 0 ns1168 0 0.120312309686
Ca1170 ns1170 0 1e-12
Ca1171 ns1171 0 1e-12
Ra1170 ns1170 0 26.4544905299 noise=0
Ra1171 ns1171 0 26.4544905299 noise=0
Ga1170 ns1170 0 ns1171 0 -0.109680355063
Ga1171 ns1171 0 ns1170 0 0.109680355063
Ca1172 ns1172 0 1e-12
Ca1173 ns1173 0 1e-12
Ra1172 ns1172 0 34.6142502796 noise=0
Ra1173 ns1173 0 34.6142502796 noise=0
Ga1172 ns1172 0 ns1173 0 -0.0959452774828
Ga1173 ns1173 0 ns1172 0 0.0959452774828
Ca1174 ns1174 0 1e-12
Ra1174 ns1174 0 13.7459165429 noise=0
Ca1175 ns1175 0 1e-12
Ra1175 ns1175 0 15.4643816792 noise=0
Ca1176 ns1176 0 1e-12
Ra1176 ns1176 0 31.0524450378 noise=0
Ca1177 ns1177 0 1e-12
Ra1177 ns1177 0 3165.2849616 noise=0
Ca1178 ns1178 0 1e-12
Ra1178 ns1178 0 0.000128571428571 noise=0
Ca1179 ns1179 0 1e-12
Ra1179 ns1179 0 0.622941609725 noise=0
Ca1180 ns1180 0 1e-12
Ra1180 ns1180 0 0.902892370164 noise=0
Ca1181 ns1181 0 1e-12
Ra1181 ns1181 0 2.25277197156 noise=0
Ca1182 ns1182 0 1e-12
Ca1183 ns1183 0 1e-12
Ra1182 ns1182 0 12.2584735833 noise=0
Ra1183 ns1183 0 12.2584735833 noise=0
Ga1182 ns1182 0 ns1183 0 -0.470827691571
Ga1183 ns1183 0 ns1182 0 0.470827691571
Ca1184 ns1184 0 1e-12
Ca1185 ns1185 0 1e-12
Ra1184 ns1184 0 25.6181403896 noise=0
Ra1185 ns1185 0 25.6181403896 noise=0
Ga1184 ns1184 0 ns1185 0 -0.448026841046
Ga1185 ns1185 0 ns1184 0 0.448026841046
Ca1186 ns1186 0 1e-12
Ca1187 ns1187 0 1e-12
Ra1186 ns1186 0 43.6974661765 noise=0
Ra1187 ns1187 0 43.6974661765 noise=0
Ga1186 ns1186 0 ns1187 0 -0.43948250501
Ga1187 ns1187 0 ns1186 0 0.43948250501
Ca1188 ns1188 0 1e-12
Ca1189 ns1189 0 1e-12
Ra1188 ns1188 0 18.0397111928 noise=0
Ra1189 ns1189 0 18.0397111928 noise=0
Ga1188 ns1188 0 ns1189 0 -0.387833034432
Ga1189 ns1189 0 ns1188 0 0.387833034432
Ca1190 ns1190 0 1e-12
Ca1191 ns1191 0 1e-12
Ra1190 ns1190 0 30.8418520482 noise=0
Ra1191 ns1191 0 30.8418520482 noise=0
Ga1190 ns1190 0 ns1191 0 -0.396001611468
Ga1191 ns1191 0 ns1190 0 0.396001611468
Ca1192 ns1192 0 1e-12
Ca1193 ns1193 0 1e-12
Ra1192 ns1192 0 41.0163217329 noise=0
Ra1193 ns1193 0 41.0163217329 noise=0
Ga1192 ns1192 0 ns1193 0 -0.381592451289
Ga1193 ns1193 0 ns1192 0 0.381592451289
Ca1194 ns1194 0 1e-12
Ca1195 ns1195 0 1e-12
Ra1194 ns1194 0 21.7602201341 noise=0
Ra1195 ns1195 0 21.7602201341 noise=0
Ga1194 ns1194 0 ns1195 0 -0.308783855582
Ga1195 ns1195 0 ns1194 0 0.308783855582
Ca1196 ns1196 0 1e-12
Ca1197 ns1197 0 1e-12
Ra1196 ns1196 0 31.7954014875 noise=0
Ra1197 ns1197 0 31.7954014875 noise=0
Ga1196 ns1196 0 ns1197 0 -0.296374987646
Ga1197 ns1197 0 ns1196 0 0.296374987646
Ca1198 ns1198 0 1e-12
Ca1199 ns1199 0 1e-12
Ra1198 ns1198 0 40.7548915023 noise=0
Ra1199 ns1199 0 40.7548915023 noise=0
Ga1198 ns1198 0 ns1199 0 -0.280074006701
Ga1199 ns1199 0 ns1198 0 0.280074006701
Ca1200 ns1200 0 1e-12
Ca1201 ns1201 0 1e-12
Ra1200 ns1200 0 16.2605473069 noise=0
Ra1201 ns1201 0 16.2605473069 noise=0
Ga1200 ns1200 0 ns1201 0 -0.221944572364
Ga1201 ns1201 0 ns1200 0 0.221944572364
Ca1202 ns1202 0 1e-12
Ca1203 ns1203 0 1e-12
Ra1202 ns1202 0 32.2071815157 noise=0
Ra1203 ns1203 0 32.2071815157 noise=0
Ga1202 ns1202 0 ns1203 0 -0.202528261009
Ga1203 ns1203 0 ns1202 0 0.202528261009
Ca1204 ns1204 0 1e-12
Ca1205 ns1205 0 1e-12
Ra1204 ns1204 0 37.0147768903 noise=0
Ra1205 ns1205 0 37.0147768903 noise=0
Ga1204 ns1204 0 ns1205 0 -0.196192248457
Ga1205 ns1205 0 ns1204 0 0.196192248457
Ca1206 ns1206 0 1e-12
Ca1207 ns1207 0 1e-12
Ra1206 ns1206 0 14.7020480531 noise=0
Ra1207 ns1207 0 14.7020480531 noise=0
Ga1206 ns1206 0 ns1207 0 -0.120312309686
Ga1207 ns1207 0 ns1206 0 0.120312309686
Ca1208 ns1208 0 1e-12
Ca1209 ns1209 0 1e-12
Ra1208 ns1208 0 26.4544905299 noise=0
Ra1209 ns1209 0 26.4544905299 noise=0
Ga1208 ns1208 0 ns1209 0 -0.109680355063
Ga1209 ns1209 0 ns1208 0 0.109680355063
Ca1210 ns1210 0 1e-12
Ca1211 ns1211 0 1e-12
Ra1210 ns1210 0 34.6142502796 noise=0
Ra1211 ns1211 0 34.6142502796 noise=0
Ga1210 ns1210 0 ns1211 0 -0.0959452774828
Ga1211 ns1211 0 ns1210 0 0.0959452774828
Ca1212 ns1212 0 1e-12
Ra1212 ns1212 0 13.7459165429 noise=0
Ca1213 ns1213 0 1e-12
Ra1213 ns1213 0 15.4643816792 noise=0
Ca1214 ns1214 0 1e-12
Ra1214 ns1214 0 31.0524450378 noise=0
Ca1215 ns1215 0 1e-12
Ra1215 ns1215 0 3165.2849616 noise=0
Ca1216 ns1216 0 1e-12
Ra1216 ns1216 0 0.000128571428571 noise=0

Gb1_1 ns1 0 ni1 0 1.60528689108
Gb2_1 ns2 0 ni1 0 1.10755172271
Gb3_1 ns3 0 ni1 0 0.443897568251
Gb4_1 ns4 0 ni1 0 0.484961695613
Gb6_1 ns6 0 ni1 0 0.451427795096
Gb8_1 ns8 0 ni1 0 0.440674147276
Gb10_1 ns10 0 ni1 0 0.395756150918
Gb12_1 ns12 0 ni1 0 0.398656352411
Gb14_1 ns14 0 ni1 0 0.383150161989
Gb16_1 ns16 0 ni1 0 0.31562326883
Gb18_1 ns18 0 ni1 0 0.299712553354
Gb20_1 ns20 0 ni1 0 0.282223656493
Gb22_1 ns22 0 ni1 0 0.238985182975
Gb24_1 ns24 0 ni1 0 0.20728828262
Gb26_1 ns26 0 ni1 0 0.199912462121
Gb28_1 ns28 0 ni1 0 0.158765666691
Gb30_1 ns30 0 ni1 0 0.122708193017
Gb32_1 ns32 0 ni1 0 0.104644221536
Gb34_1 ns34 0 ni1 0 0.0727488775944
Gb35_1 ns35 0 ni1 0 0.0646647257385
Gb36_1 ns36 0 ni1 0 0.0322035832858
Gb37_1 ns37 0 ni1 0 0.000315927321594
Gb38_1 ns38 0 ni1 0 7777.77777778
Gb39_2 ns39 0 ni2 0 1.60528689108
Gb40_2 ns40 0 ni2 0 1.10755172271
Gb41_2 ns41 0 ni2 0 0.443897568251
Gb42_2 ns42 0 ni2 0 0.484961695613
Gb44_2 ns44 0 ni2 0 0.451427795096
Gb46_2 ns46 0 ni2 0 0.440674147276
Gb48_2 ns48 0 ni2 0 0.395756150918
Gb50_2 ns50 0 ni2 0 0.398656352411
Gb52_2 ns52 0 ni2 0 0.383150161989
Gb54_2 ns54 0 ni2 0 0.31562326883
Gb56_2 ns56 0 ni2 0 0.299712553354
Gb58_2 ns58 0 ni2 0 0.282223656493
Gb60_2 ns60 0 ni2 0 0.238985182975
Gb62_2 ns62 0 ni2 0 0.20728828262
Gb64_2 ns64 0 ni2 0 0.199912462121
Gb66_2 ns66 0 ni2 0 0.158765666691
Gb68_2 ns68 0 ni2 0 0.122708193017
Gb70_2 ns70 0 ni2 0 0.104644221536
Gb72_2 ns72 0 ni2 0 0.0727488775944
Gb73_2 ns73 0 ni2 0 0.0646647257385
Gb74_2 ns74 0 ni2 0 0.0322035832858
Gb75_2 ns75 0 ni2 0 0.000315927321594
Gb76_2 ns76 0 ni2 0 7777.77777778
Gb77_3 ns77 0 ni3 0 1.60528689108
Gb78_3 ns78 0 ni3 0 1.10755172271
Gb79_3 ns79 0 ni3 0 0.443897568251
Gb80_3 ns80 0 ni3 0 0.484961695613
Gb82_3 ns82 0 ni3 0 0.451427795096
Gb84_3 ns84 0 ni3 0 0.440674147276
Gb86_3 ns86 0 ni3 0 0.395756150918
Gb88_3 ns88 0 ni3 0 0.398656352411
Gb90_3 ns90 0 ni3 0 0.383150161989
Gb92_3 ns92 0 ni3 0 0.31562326883
Gb94_3 ns94 0 ni3 0 0.299712553354
Gb96_3 ns96 0 ni3 0 0.282223656493
Gb98_3 ns98 0 ni3 0 0.238985182975
Gb100_3 ns100 0 ni3 0 0.20728828262
Gb102_3 ns102 0 ni3 0 0.199912462121
Gb104_3 ns104 0 ni3 0 0.158765666691
Gb106_3 ns106 0 ni3 0 0.122708193017
Gb108_3 ns108 0 ni3 0 0.104644221536
Gb110_3 ns110 0 ni3 0 0.0727488775944
Gb111_3 ns111 0 ni3 0 0.0646647257385
Gb112_3 ns112 0 ni3 0 0.0322035832858
Gb113_3 ns113 0 ni3 0 0.000315927321594
Gb114_3 ns114 0 ni3 0 7777.77777778
Gb115_4 ns115 0 ni4 0 1.60528689108
Gb116_4 ns116 0 ni4 0 1.10755172271
Gb117_4 ns117 0 ni4 0 0.443897568251
Gb118_4 ns118 0 ni4 0 0.484961695613
Gb120_4 ns120 0 ni4 0 0.451427795096
Gb122_4 ns122 0 ni4 0 0.440674147276
Gb124_4 ns124 0 ni4 0 0.395756150918
Gb126_4 ns126 0 ni4 0 0.398656352411
Gb128_4 ns128 0 ni4 0 0.383150161989
Gb130_4 ns130 0 ni4 0 0.31562326883
Gb132_4 ns132 0 ni4 0 0.299712553354
Gb134_4 ns134 0 ni4 0 0.282223656493
Gb136_4 ns136 0 ni4 0 0.238985182975
Gb138_4 ns138 0 ni4 0 0.20728828262
Gb140_4 ns140 0 ni4 0 0.199912462121
Gb142_4 ns142 0 ni4 0 0.158765666691
Gb144_4 ns144 0 ni4 0 0.122708193017
Gb146_4 ns146 0 ni4 0 0.104644221536
Gb148_4 ns148 0 ni4 0 0.0727488775944
Gb149_4 ns149 0 ni4 0 0.0646647257385
Gb150_4 ns150 0 ni4 0 0.0322035832858
Gb151_4 ns151 0 ni4 0 0.000315927321594
Gb152_4 ns152 0 ni4 0 7777.77777778
Gb153_5 ns153 0 ni5 0 1.60528689108
Gb154_5 ns154 0 ni5 0 1.10755172271
Gb155_5 ns155 0 ni5 0 0.443897568251
Gb156_5 ns156 0 ni5 0 0.484961695613
Gb158_5 ns158 0 ni5 0 0.451427795096
Gb160_5 ns160 0 ni5 0 0.440674147276
Gb162_5 ns162 0 ni5 0 0.395756150918
Gb164_5 ns164 0 ni5 0 0.398656352411
Gb166_5 ns166 0 ni5 0 0.383150161989
Gb168_5 ns168 0 ni5 0 0.31562326883
Gb170_5 ns170 0 ni5 0 0.299712553354
Gb172_5 ns172 0 ni5 0 0.282223656493
Gb174_5 ns174 0 ni5 0 0.238985182975
Gb176_5 ns176 0 ni5 0 0.20728828262
Gb178_5 ns178 0 ni5 0 0.199912462121
Gb180_5 ns180 0 ni5 0 0.158765666691
Gb182_5 ns182 0 ni5 0 0.122708193017
Gb184_5 ns184 0 ni5 0 0.104644221536
Gb186_5 ns186 0 ni5 0 0.0727488775944
Gb187_5 ns187 0 ni5 0 0.0646647257385
Gb188_5 ns188 0 ni5 0 0.0322035832858
Gb189_5 ns189 0 ni5 0 0.000315927321594
Gb190_5 ns190 0 ni5 0 7777.77777778
Gb191_6 ns191 0 ni6 0 1.60528689108
Gb192_6 ns192 0 ni6 0 1.10755172271
Gb193_6 ns193 0 ni6 0 0.443897568251
Gb194_6 ns194 0 ni6 0 0.484961695613
Gb196_6 ns196 0 ni6 0 0.451427795096
Gb198_6 ns198 0 ni6 0 0.440674147276
Gb200_6 ns200 0 ni6 0 0.395756150918
Gb202_6 ns202 0 ni6 0 0.398656352411
Gb204_6 ns204 0 ni6 0 0.383150161989
Gb206_6 ns206 0 ni6 0 0.31562326883
Gb208_6 ns208 0 ni6 0 0.299712553354
Gb210_6 ns210 0 ni6 0 0.282223656493
Gb212_6 ns212 0 ni6 0 0.238985182975
Gb214_6 ns214 0 ni6 0 0.20728828262
Gb216_6 ns216 0 ni6 0 0.199912462121
Gb218_6 ns218 0 ni6 0 0.158765666691
Gb220_6 ns220 0 ni6 0 0.122708193017
Gb222_6 ns222 0 ni6 0 0.104644221536
Gb224_6 ns224 0 ni6 0 0.0727488775944
Gb225_6 ns225 0 ni6 0 0.0646647257385
Gb226_6 ns226 0 ni6 0 0.0322035832858
Gb227_6 ns227 0 ni6 0 0.000315927321594
Gb228_6 ns228 0 ni6 0 7777.77777778
Gb229_7 ns229 0 ni7 0 1.60528689108
Gb230_7 ns230 0 ni7 0 1.10755172271
Gb231_7 ns231 0 ni7 0 0.443897568251
Gb232_7 ns232 0 ni7 0 0.484961695613
Gb234_7 ns234 0 ni7 0 0.451427795096
Gb236_7 ns236 0 ni7 0 0.440674147276
Gb238_7 ns238 0 ni7 0 0.395756150918
Gb240_7 ns240 0 ni7 0 0.398656352411
Gb242_7 ns242 0 ni7 0 0.383150161989
Gb244_7 ns244 0 ni7 0 0.31562326883
Gb246_7 ns246 0 ni7 0 0.299712553354
Gb248_7 ns248 0 ni7 0 0.282223656493
Gb250_7 ns250 0 ni7 0 0.238985182975
Gb252_7 ns252 0 ni7 0 0.20728828262
Gb254_7 ns254 0 ni7 0 0.199912462121
Gb256_7 ns256 0 ni7 0 0.158765666691
Gb258_7 ns258 0 ni7 0 0.122708193017
Gb260_7 ns260 0 ni7 0 0.104644221536
Gb262_7 ns262 0 ni7 0 0.0727488775944
Gb263_7 ns263 0 ni7 0 0.0646647257385
Gb264_7 ns264 0 ni7 0 0.0322035832858
Gb265_7 ns265 0 ni7 0 0.000315927321594
Gb266_7 ns266 0 ni7 0 7777.77777778
Gb267_8 ns267 0 ni8 0 1.60528689108
Gb268_8 ns268 0 ni8 0 1.10755172271
Gb269_8 ns269 0 ni8 0 0.443897568251
Gb270_8 ns270 0 ni8 0 0.484961695613
Gb272_8 ns272 0 ni8 0 0.451427795096
Gb274_8 ns274 0 ni8 0 0.440674147276
Gb276_8 ns276 0 ni8 0 0.395756150918
Gb278_8 ns278 0 ni8 0 0.398656352411
Gb280_8 ns280 0 ni8 0 0.383150161989
Gb282_8 ns282 0 ni8 0 0.31562326883
Gb284_8 ns284 0 ni8 0 0.299712553354
Gb286_8 ns286 0 ni8 0 0.282223656493
Gb288_8 ns288 0 ni8 0 0.238985182975
Gb290_8 ns290 0 ni8 0 0.20728828262
Gb292_8 ns292 0 ni8 0 0.199912462121
Gb294_8 ns294 0 ni8 0 0.158765666691
Gb296_8 ns296 0 ni8 0 0.122708193017
Gb298_8 ns298 0 ni8 0 0.104644221536
Gb300_8 ns300 0 ni8 0 0.0727488775944
Gb301_8 ns301 0 ni8 0 0.0646647257385
Gb302_8 ns302 0 ni8 0 0.0322035832858
Gb303_8 ns303 0 ni8 0 0.000315927321594
Gb304_8 ns304 0 ni8 0 7777.77777778
Gb305_9 ns305 0 ni9 0 1.60528689108
Gb306_9 ns306 0 ni9 0 1.10755172271
Gb307_9 ns307 0 ni9 0 0.443897568251
Gb308_9 ns308 0 ni9 0 0.484961695613
Gb310_9 ns310 0 ni9 0 0.451427795096
Gb312_9 ns312 0 ni9 0 0.440674147276
Gb314_9 ns314 0 ni9 0 0.395756150918
Gb316_9 ns316 0 ni9 0 0.398656352411
Gb318_9 ns318 0 ni9 0 0.383150161989
Gb320_9 ns320 0 ni9 0 0.31562326883
Gb322_9 ns322 0 ni9 0 0.299712553354
Gb324_9 ns324 0 ni9 0 0.282223656493
Gb326_9 ns326 0 ni9 0 0.238985182975
Gb328_9 ns328 0 ni9 0 0.20728828262
Gb330_9 ns330 0 ni9 0 0.199912462121
Gb332_9 ns332 0 ni9 0 0.158765666691
Gb334_9 ns334 0 ni9 0 0.122708193017
Gb336_9 ns336 0 ni9 0 0.104644221536
Gb338_9 ns338 0 ni9 0 0.0727488775944
Gb339_9 ns339 0 ni9 0 0.0646647257385
Gb340_9 ns340 0 ni9 0 0.0322035832858
Gb341_9 ns341 0 ni9 0 0.000315927321594
Gb342_9 ns342 0 ni9 0 7777.77777778
Gb343_10 ns343 0 ni10 0 1.60528689108
Gb344_10 ns344 0 ni10 0 1.10755172271
Gb345_10 ns345 0 ni10 0 0.443897568251
Gb346_10 ns346 0 ni10 0 0.484961695613
Gb348_10 ns348 0 ni10 0 0.451427795096
Gb350_10 ns350 0 ni10 0 0.440674147276
Gb352_10 ns352 0 ni10 0 0.395756150918
Gb354_10 ns354 0 ni10 0 0.398656352411
Gb356_10 ns356 0 ni10 0 0.383150161989
Gb358_10 ns358 0 ni10 0 0.31562326883
Gb360_10 ns360 0 ni10 0 0.299712553354
Gb362_10 ns362 0 ni10 0 0.282223656493
Gb364_10 ns364 0 ni10 0 0.238985182975
Gb366_10 ns366 0 ni10 0 0.20728828262
Gb368_10 ns368 0 ni10 0 0.199912462121
Gb370_10 ns370 0 ni10 0 0.158765666691
Gb372_10 ns372 0 ni10 0 0.122708193017
Gb374_10 ns374 0 ni10 0 0.104644221536
Gb376_10 ns376 0 ni10 0 0.0727488775944
Gb377_10 ns377 0 ni10 0 0.0646647257385
Gb378_10 ns378 0 ni10 0 0.0322035832858
Gb379_10 ns379 0 ni10 0 0.000315927321594
Gb380_10 ns380 0 ni10 0 7777.77777778
Gb381_11 ns381 0 ni11 0 1.60528689108
Gb382_11 ns382 0 ni11 0 1.10755172271
Gb383_11 ns383 0 ni11 0 0.443897568251
Gb384_11 ns384 0 ni11 0 0.484961695613
Gb386_11 ns386 0 ni11 0 0.451427795096
Gb388_11 ns388 0 ni11 0 0.440674147276
Gb390_11 ns390 0 ni11 0 0.395756150918
Gb392_11 ns392 0 ni11 0 0.398656352411
Gb394_11 ns394 0 ni11 0 0.383150161989
Gb396_11 ns396 0 ni11 0 0.31562326883
Gb398_11 ns398 0 ni11 0 0.299712553354
Gb400_11 ns400 0 ni11 0 0.282223656493
Gb402_11 ns402 0 ni11 0 0.238985182975
Gb404_11 ns404 0 ni11 0 0.20728828262
Gb406_11 ns406 0 ni11 0 0.199912462121
Gb408_11 ns408 0 ni11 0 0.158765666691
Gb410_11 ns410 0 ni11 0 0.122708193017
Gb412_11 ns412 0 ni11 0 0.104644221536
Gb414_11 ns414 0 ni11 0 0.0727488775944
Gb415_11 ns415 0 ni11 0 0.0646647257385
Gb416_11 ns416 0 ni11 0 0.0322035832858
Gb417_11 ns417 0 ni11 0 0.000315927321594
Gb418_11 ns418 0 ni11 0 7777.77777778
Gb419_12 ns419 0 ni12 0 1.60528689108
Gb420_12 ns420 0 ni12 0 1.10755172271
Gb421_12 ns421 0 ni12 0 0.443897568251
Gb422_12 ns422 0 ni12 0 0.484961695613
Gb424_12 ns424 0 ni12 0 0.451427795096
Gb426_12 ns426 0 ni12 0 0.440674147276
Gb428_12 ns428 0 ni12 0 0.395756150918
Gb430_12 ns430 0 ni12 0 0.398656352411
Gb432_12 ns432 0 ni12 0 0.383150161989
Gb434_12 ns434 0 ni12 0 0.31562326883
Gb436_12 ns436 0 ni12 0 0.299712553354
Gb438_12 ns438 0 ni12 0 0.282223656493
Gb440_12 ns440 0 ni12 0 0.238985182975
Gb442_12 ns442 0 ni12 0 0.20728828262
Gb444_12 ns444 0 ni12 0 0.199912462121
Gb446_12 ns446 0 ni12 0 0.158765666691
Gb448_12 ns448 0 ni12 0 0.122708193017
Gb450_12 ns450 0 ni12 0 0.104644221536
Gb452_12 ns452 0 ni12 0 0.0727488775944
Gb453_12 ns453 0 ni12 0 0.0646647257385
Gb454_12 ns454 0 ni12 0 0.0322035832858
Gb455_12 ns455 0 ni12 0 0.000315927321594
Gb456_12 ns456 0 ni12 0 7777.77777778
Gb457_13 ns457 0 ni13 0 1.60528689108
Gb458_13 ns458 0 ni13 0 1.10755172271
Gb459_13 ns459 0 ni13 0 0.443897568251
Gb460_13 ns460 0 ni13 0 0.484961695613
Gb462_13 ns462 0 ni13 0 0.451427795096
Gb464_13 ns464 0 ni13 0 0.440674147276
Gb466_13 ns466 0 ni13 0 0.395756150918
Gb468_13 ns468 0 ni13 0 0.398656352411
Gb470_13 ns470 0 ni13 0 0.383150161989
Gb472_13 ns472 0 ni13 0 0.31562326883
Gb474_13 ns474 0 ni13 0 0.299712553354
Gb476_13 ns476 0 ni13 0 0.282223656493
Gb478_13 ns478 0 ni13 0 0.238985182975
Gb480_13 ns480 0 ni13 0 0.20728828262
Gb482_13 ns482 0 ni13 0 0.199912462121
Gb484_13 ns484 0 ni13 0 0.158765666691
Gb486_13 ns486 0 ni13 0 0.122708193017
Gb488_13 ns488 0 ni13 0 0.104644221536
Gb490_13 ns490 0 ni13 0 0.0727488775944
Gb491_13 ns491 0 ni13 0 0.0646647257385
Gb492_13 ns492 0 ni13 0 0.0322035832858
Gb493_13 ns493 0 ni13 0 0.000315927321594
Gb494_13 ns494 0 ni13 0 7777.77777778
Gb495_14 ns495 0 ni14 0 1.60528689108
Gb496_14 ns496 0 ni14 0 1.10755172271
Gb497_14 ns497 0 ni14 0 0.443897568251
Gb498_14 ns498 0 ni14 0 0.484961695613
Gb500_14 ns500 0 ni14 0 0.451427795096
Gb502_14 ns502 0 ni14 0 0.440674147276
Gb504_14 ns504 0 ni14 0 0.395756150918
Gb506_14 ns506 0 ni14 0 0.398656352411
Gb508_14 ns508 0 ni14 0 0.383150161989
Gb510_14 ns510 0 ni14 0 0.31562326883
Gb512_14 ns512 0 ni14 0 0.299712553354
Gb514_14 ns514 0 ni14 0 0.282223656493
Gb516_14 ns516 0 ni14 0 0.238985182975
Gb518_14 ns518 0 ni14 0 0.20728828262
Gb520_14 ns520 0 ni14 0 0.199912462121
Gb522_14 ns522 0 ni14 0 0.158765666691
Gb524_14 ns524 0 ni14 0 0.122708193017
Gb526_14 ns526 0 ni14 0 0.104644221536
Gb528_14 ns528 0 ni14 0 0.0727488775944
Gb529_14 ns529 0 ni14 0 0.0646647257385
Gb530_14 ns530 0 ni14 0 0.0322035832858
Gb531_14 ns531 0 ni14 0 0.000315927321594
Gb532_14 ns532 0 ni14 0 7777.77777778
Gb533_15 ns533 0 ni15 0 1.60528689108
Gb534_15 ns534 0 ni15 0 1.10755172271
Gb535_15 ns535 0 ni15 0 0.443897568251
Gb536_15 ns536 0 ni15 0 0.484961695613
Gb538_15 ns538 0 ni15 0 0.451427795096
Gb540_15 ns540 0 ni15 0 0.440674147276
Gb542_15 ns542 0 ni15 0 0.395756150918
Gb544_15 ns544 0 ni15 0 0.398656352411
Gb546_15 ns546 0 ni15 0 0.383150161989
Gb548_15 ns548 0 ni15 0 0.31562326883
Gb550_15 ns550 0 ni15 0 0.299712553354
Gb552_15 ns552 0 ni15 0 0.282223656493
Gb554_15 ns554 0 ni15 0 0.238985182975
Gb556_15 ns556 0 ni15 0 0.20728828262
Gb558_15 ns558 0 ni15 0 0.199912462121
Gb560_15 ns560 0 ni15 0 0.158765666691
Gb562_15 ns562 0 ni15 0 0.122708193017
Gb564_15 ns564 0 ni15 0 0.104644221536
Gb566_15 ns566 0 ni15 0 0.0727488775944
Gb567_15 ns567 0 ni15 0 0.0646647257385
Gb568_15 ns568 0 ni15 0 0.0322035832858
Gb569_15 ns569 0 ni15 0 0.000315927321594
Gb570_15 ns570 0 ni15 0 7777.77777778
Gb571_16 ns571 0 ni16 0 1.60528689108
Gb572_16 ns572 0 ni16 0 1.10755172271
Gb573_16 ns573 0 ni16 0 0.443897568251
Gb574_16 ns574 0 ni16 0 0.484961695613
Gb576_16 ns576 0 ni16 0 0.451427795096
Gb578_16 ns578 0 ni16 0 0.440674147276
Gb580_16 ns580 0 ni16 0 0.395756150918
Gb582_16 ns582 0 ni16 0 0.398656352411
Gb584_16 ns584 0 ni16 0 0.383150161989
Gb586_16 ns586 0 ni16 0 0.31562326883
Gb588_16 ns588 0 ni16 0 0.299712553354
Gb590_16 ns590 0 ni16 0 0.282223656493
Gb592_16 ns592 0 ni16 0 0.238985182975
Gb594_16 ns594 0 ni16 0 0.20728828262
Gb596_16 ns596 0 ni16 0 0.199912462121
Gb598_16 ns598 0 ni16 0 0.158765666691
Gb600_16 ns600 0 ni16 0 0.122708193017
Gb602_16 ns602 0 ni16 0 0.104644221536
Gb604_16 ns604 0 ni16 0 0.0727488775944
Gb605_16 ns605 0 ni16 0 0.0646647257385
Gb606_16 ns606 0 ni16 0 0.0322035832858
Gb607_16 ns607 0 ni16 0 0.000315927321594
Gb608_16 ns608 0 ni16 0 7777.77777778
Gb609_17 ns609 0 ni17 0 1.60528689108
Gb610_17 ns610 0 ni17 0 1.10755172271
Gb611_17 ns611 0 ni17 0 0.443897568251
Gb612_17 ns612 0 ni17 0 0.484961695613
Gb614_17 ns614 0 ni17 0 0.451427795096
Gb616_17 ns616 0 ni17 0 0.440674147276
Gb618_17 ns618 0 ni17 0 0.395756150918
Gb620_17 ns620 0 ni17 0 0.398656352411
Gb622_17 ns622 0 ni17 0 0.383150161989
Gb624_17 ns624 0 ni17 0 0.31562326883
Gb626_17 ns626 0 ni17 0 0.299712553354
Gb628_17 ns628 0 ni17 0 0.282223656493
Gb630_17 ns630 0 ni17 0 0.238985182975
Gb632_17 ns632 0 ni17 0 0.20728828262
Gb634_17 ns634 0 ni17 0 0.199912462121
Gb636_17 ns636 0 ni17 0 0.158765666691
Gb638_17 ns638 0 ni17 0 0.122708193017
Gb640_17 ns640 0 ni17 0 0.104644221536
Gb642_17 ns642 0 ni17 0 0.0727488775944
Gb643_17 ns643 0 ni17 0 0.0646647257385
Gb644_17 ns644 0 ni17 0 0.0322035832858
Gb645_17 ns645 0 ni17 0 0.000315927321594
Gb646_17 ns646 0 ni17 0 7777.77777778
Gb647_18 ns647 0 ni18 0 1.60528689108
Gb648_18 ns648 0 ni18 0 1.10755172271
Gb649_18 ns649 0 ni18 0 0.443897568251
Gb650_18 ns650 0 ni18 0 0.484961695613
Gb652_18 ns652 0 ni18 0 0.451427795096
Gb654_18 ns654 0 ni18 0 0.440674147276
Gb656_18 ns656 0 ni18 0 0.395756150918
Gb658_18 ns658 0 ni18 0 0.398656352411
Gb660_18 ns660 0 ni18 0 0.383150161989
Gb662_18 ns662 0 ni18 0 0.31562326883
Gb664_18 ns664 0 ni18 0 0.299712553354
Gb666_18 ns666 0 ni18 0 0.282223656493
Gb668_18 ns668 0 ni18 0 0.238985182975
Gb670_18 ns670 0 ni18 0 0.20728828262
Gb672_18 ns672 0 ni18 0 0.199912462121
Gb674_18 ns674 0 ni18 0 0.158765666691
Gb676_18 ns676 0 ni18 0 0.122708193017
Gb678_18 ns678 0 ni18 0 0.104644221536
Gb680_18 ns680 0 ni18 0 0.0727488775944
Gb681_18 ns681 0 ni18 0 0.0646647257385
Gb682_18 ns682 0 ni18 0 0.0322035832858
Gb683_18 ns683 0 ni18 0 0.000315927321594
Gb684_18 ns684 0 ni18 0 7777.77777778
Gb685_19 ns685 0 ni19 0 1.60528689108
Gb686_19 ns686 0 ni19 0 1.10755172271
Gb687_19 ns687 0 ni19 0 0.443897568251
Gb688_19 ns688 0 ni19 0 0.484961695613
Gb690_19 ns690 0 ni19 0 0.451427795096
Gb692_19 ns692 0 ni19 0 0.440674147276
Gb694_19 ns694 0 ni19 0 0.395756150918
Gb696_19 ns696 0 ni19 0 0.398656352411
Gb698_19 ns698 0 ni19 0 0.383150161989
Gb700_19 ns700 0 ni19 0 0.31562326883
Gb702_19 ns702 0 ni19 0 0.299712553354
Gb704_19 ns704 0 ni19 0 0.282223656493
Gb706_19 ns706 0 ni19 0 0.238985182975
Gb708_19 ns708 0 ni19 0 0.20728828262
Gb710_19 ns710 0 ni19 0 0.199912462121
Gb712_19 ns712 0 ni19 0 0.158765666691
Gb714_19 ns714 0 ni19 0 0.122708193017
Gb716_19 ns716 0 ni19 0 0.104644221536
Gb718_19 ns718 0 ni19 0 0.0727488775944
Gb719_19 ns719 0 ni19 0 0.0646647257385
Gb720_19 ns720 0 ni19 0 0.0322035832858
Gb721_19 ns721 0 ni19 0 0.000315927321594
Gb722_19 ns722 0 ni19 0 7777.77777778
Gb723_20 ns723 0 ni20 0 1.60528689108
Gb724_20 ns724 0 ni20 0 1.10755172271
Gb725_20 ns725 0 ni20 0 0.443897568251
Gb726_20 ns726 0 ni20 0 0.484961695613
Gb728_20 ns728 0 ni20 0 0.451427795096
Gb730_20 ns730 0 ni20 0 0.440674147276
Gb732_20 ns732 0 ni20 0 0.395756150918
Gb734_20 ns734 0 ni20 0 0.398656352411
Gb736_20 ns736 0 ni20 0 0.383150161989
Gb738_20 ns738 0 ni20 0 0.31562326883
Gb740_20 ns740 0 ni20 0 0.299712553354
Gb742_20 ns742 0 ni20 0 0.282223656493
Gb744_20 ns744 0 ni20 0 0.238985182975
Gb746_20 ns746 0 ni20 0 0.20728828262
Gb748_20 ns748 0 ni20 0 0.199912462121
Gb750_20 ns750 0 ni20 0 0.158765666691
Gb752_20 ns752 0 ni20 0 0.122708193017
Gb754_20 ns754 0 ni20 0 0.104644221536
Gb756_20 ns756 0 ni20 0 0.0727488775944
Gb757_20 ns757 0 ni20 0 0.0646647257385
Gb758_20 ns758 0 ni20 0 0.0322035832858
Gb759_20 ns759 0 ni20 0 0.000315927321594
Gb760_20 ns760 0 ni20 0 7777.77777778
Gb761_21 ns761 0 ni21 0 1.60528689108
Gb762_21 ns762 0 ni21 0 1.10755172271
Gb763_21 ns763 0 ni21 0 0.443897568251
Gb764_21 ns764 0 ni21 0 0.484961695613
Gb766_21 ns766 0 ni21 0 0.451427795096
Gb768_21 ns768 0 ni21 0 0.440674147276
Gb770_21 ns770 0 ni21 0 0.395756150918
Gb772_21 ns772 0 ni21 0 0.398656352411
Gb774_21 ns774 0 ni21 0 0.383150161989
Gb776_21 ns776 0 ni21 0 0.31562326883
Gb778_21 ns778 0 ni21 0 0.299712553354
Gb780_21 ns780 0 ni21 0 0.282223656493
Gb782_21 ns782 0 ni21 0 0.238985182975
Gb784_21 ns784 0 ni21 0 0.20728828262
Gb786_21 ns786 0 ni21 0 0.199912462121
Gb788_21 ns788 0 ni21 0 0.158765666691
Gb790_21 ns790 0 ni21 0 0.122708193017
Gb792_21 ns792 0 ni21 0 0.104644221536
Gb794_21 ns794 0 ni21 0 0.0727488775944
Gb795_21 ns795 0 ni21 0 0.0646647257385
Gb796_21 ns796 0 ni21 0 0.0322035832858
Gb797_21 ns797 0 ni21 0 0.000315927321594
Gb798_21 ns798 0 ni21 0 7777.77777778
Gb799_22 ns799 0 ni22 0 1.60528689108
Gb800_22 ns800 0 ni22 0 1.10755172271
Gb801_22 ns801 0 ni22 0 0.443897568251
Gb802_22 ns802 0 ni22 0 0.484961695613
Gb804_22 ns804 0 ni22 0 0.451427795096
Gb806_22 ns806 0 ni22 0 0.440674147276
Gb808_22 ns808 0 ni22 0 0.395756150918
Gb810_22 ns810 0 ni22 0 0.398656352411
Gb812_22 ns812 0 ni22 0 0.383150161989
Gb814_22 ns814 0 ni22 0 0.31562326883
Gb816_22 ns816 0 ni22 0 0.299712553354
Gb818_22 ns818 0 ni22 0 0.282223656493
Gb820_22 ns820 0 ni22 0 0.238985182975
Gb822_22 ns822 0 ni22 0 0.20728828262
Gb824_22 ns824 0 ni22 0 0.199912462121
Gb826_22 ns826 0 ni22 0 0.158765666691
Gb828_22 ns828 0 ni22 0 0.122708193017
Gb830_22 ns830 0 ni22 0 0.104644221536
Gb832_22 ns832 0 ni22 0 0.0727488775944
Gb833_22 ns833 0 ni22 0 0.0646647257385
Gb834_22 ns834 0 ni22 0 0.0322035832858
Gb835_22 ns835 0 ni22 0 0.000315927321594
Gb836_22 ns836 0 ni22 0 7777.77777778
Gb837_23 ns837 0 ni23 0 1.60528689108
Gb838_23 ns838 0 ni23 0 1.10755172271
Gb839_23 ns839 0 ni23 0 0.443897568251
Gb840_23 ns840 0 ni23 0 0.484961695613
Gb842_23 ns842 0 ni23 0 0.451427795096
Gb844_23 ns844 0 ni23 0 0.440674147276
Gb846_23 ns846 0 ni23 0 0.395756150918
Gb848_23 ns848 0 ni23 0 0.398656352411
Gb850_23 ns850 0 ni23 0 0.383150161989
Gb852_23 ns852 0 ni23 0 0.31562326883
Gb854_23 ns854 0 ni23 0 0.299712553354
Gb856_23 ns856 0 ni23 0 0.282223656493
Gb858_23 ns858 0 ni23 0 0.238985182975
Gb860_23 ns860 0 ni23 0 0.20728828262
Gb862_23 ns862 0 ni23 0 0.199912462121
Gb864_23 ns864 0 ni23 0 0.158765666691
Gb866_23 ns866 0 ni23 0 0.122708193017
Gb868_23 ns868 0 ni23 0 0.104644221536
Gb870_23 ns870 0 ni23 0 0.0727488775944
Gb871_23 ns871 0 ni23 0 0.0646647257385
Gb872_23 ns872 0 ni23 0 0.0322035832858
Gb873_23 ns873 0 ni23 0 0.000315927321594
Gb874_23 ns874 0 ni23 0 7777.77777778
Gb875_24 ns875 0 ni24 0 1.60528689108
Gb876_24 ns876 0 ni24 0 1.10755172271
Gb877_24 ns877 0 ni24 0 0.443897568251
Gb878_24 ns878 0 ni24 0 0.484961695613
Gb880_24 ns880 0 ni24 0 0.451427795096
Gb882_24 ns882 0 ni24 0 0.440674147276
Gb884_24 ns884 0 ni24 0 0.395756150918
Gb886_24 ns886 0 ni24 0 0.398656352411
Gb888_24 ns888 0 ni24 0 0.383150161989
Gb890_24 ns890 0 ni24 0 0.31562326883
Gb892_24 ns892 0 ni24 0 0.299712553354
Gb894_24 ns894 0 ni24 0 0.282223656493
Gb896_24 ns896 0 ni24 0 0.238985182975
Gb898_24 ns898 0 ni24 0 0.20728828262
Gb900_24 ns900 0 ni24 0 0.199912462121
Gb902_24 ns902 0 ni24 0 0.158765666691
Gb904_24 ns904 0 ni24 0 0.122708193017
Gb906_24 ns906 0 ni24 0 0.104644221536
Gb908_24 ns908 0 ni24 0 0.0727488775944
Gb909_24 ns909 0 ni24 0 0.0646647257385
Gb910_24 ns910 0 ni24 0 0.0322035832858
Gb911_24 ns911 0 ni24 0 0.000315927321594
Gb912_24 ns912 0 ni24 0 7777.77777778
Gb913_25 ns913 0 ni25 0 1.60528689108
Gb914_25 ns914 0 ni25 0 1.10755172271
Gb915_25 ns915 0 ni25 0 0.443897568251
Gb916_25 ns916 0 ni25 0 0.484961695613
Gb918_25 ns918 0 ni25 0 0.451427795096
Gb920_25 ns920 0 ni25 0 0.440674147276
Gb922_25 ns922 0 ni25 0 0.395756150918
Gb924_25 ns924 0 ni25 0 0.398656352411
Gb926_25 ns926 0 ni25 0 0.383150161989
Gb928_25 ns928 0 ni25 0 0.31562326883
Gb930_25 ns930 0 ni25 0 0.299712553354
Gb932_25 ns932 0 ni25 0 0.282223656493
Gb934_25 ns934 0 ni25 0 0.238985182975
Gb936_25 ns936 0 ni25 0 0.20728828262
Gb938_25 ns938 0 ni25 0 0.199912462121
Gb940_25 ns940 0 ni25 0 0.158765666691
Gb942_25 ns942 0 ni25 0 0.122708193017
Gb944_25 ns944 0 ni25 0 0.104644221536
Gb946_25 ns946 0 ni25 0 0.0727488775944
Gb947_25 ns947 0 ni25 0 0.0646647257385
Gb948_25 ns948 0 ni25 0 0.0322035832858
Gb949_25 ns949 0 ni25 0 0.000315927321594
Gb950_25 ns950 0 ni25 0 7777.77777778
Gb951_26 ns951 0 ni26 0 1.60528689108
Gb952_26 ns952 0 ni26 0 1.10755172271
Gb953_26 ns953 0 ni26 0 0.443897568251
Gb954_26 ns954 0 ni26 0 0.484961695613
Gb956_26 ns956 0 ni26 0 0.451427795096
Gb958_26 ns958 0 ni26 0 0.440674147276
Gb960_26 ns960 0 ni26 0 0.395756150918
Gb962_26 ns962 0 ni26 0 0.398656352411
Gb964_26 ns964 0 ni26 0 0.383150161989
Gb966_26 ns966 0 ni26 0 0.31562326883
Gb968_26 ns968 0 ni26 0 0.299712553354
Gb970_26 ns970 0 ni26 0 0.282223656493
Gb972_26 ns972 0 ni26 0 0.238985182975
Gb974_26 ns974 0 ni26 0 0.20728828262
Gb976_26 ns976 0 ni26 0 0.199912462121
Gb978_26 ns978 0 ni26 0 0.158765666691
Gb980_26 ns980 0 ni26 0 0.122708193017
Gb982_26 ns982 0 ni26 0 0.104644221536
Gb984_26 ns984 0 ni26 0 0.0727488775944
Gb985_26 ns985 0 ni26 0 0.0646647257385
Gb986_26 ns986 0 ni26 0 0.0322035832858
Gb987_26 ns987 0 ni26 0 0.000315927321594
Gb988_26 ns988 0 ni26 0 7777.77777778
Gb989_27 ns989 0 ni27 0 1.60528689108
Gb990_27 ns990 0 ni27 0 1.10755172271
Gb991_27 ns991 0 ni27 0 0.443897568251
Gb992_27 ns992 0 ni27 0 0.484961695613
Gb994_27 ns994 0 ni27 0 0.451427795096
Gb996_27 ns996 0 ni27 0 0.440674147276
Gb998_27 ns998 0 ni27 0 0.395756150918
Gb1000_27 ns1000 0 ni27 0 0.398656352411
Gb1002_27 ns1002 0 ni27 0 0.383150161989
Gb1004_27 ns1004 0 ni27 0 0.31562326883
Gb1006_27 ns1006 0 ni27 0 0.299712553354
Gb1008_27 ns1008 0 ni27 0 0.282223656493
Gb1010_27 ns1010 0 ni27 0 0.238985182975
Gb1012_27 ns1012 0 ni27 0 0.20728828262
Gb1014_27 ns1014 0 ni27 0 0.199912462121
Gb1016_27 ns1016 0 ni27 0 0.158765666691
Gb1018_27 ns1018 0 ni27 0 0.122708193017
Gb1020_27 ns1020 0 ni27 0 0.104644221536
Gb1022_27 ns1022 0 ni27 0 0.0727488775944
Gb1023_27 ns1023 0 ni27 0 0.0646647257385
Gb1024_27 ns1024 0 ni27 0 0.0322035832858
Gb1025_27 ns1025 0 ni27 0 0.000315927321594
Gb1026_27 ns1026 0 ni27 0 7777.77777778
Gb1027_28 ns1027 0 ni28 0 1.60528689108
Gb1028_28 ns1028 0 ni28 0 1.10755172271
Gb1029_28 ns1029 0 ni28 0 0.443897568251
Gb1030_28 ns1030 0 ni28 0 0.484961695613
Gb1032_28 ns1032 0 ni28 0 0.451427795096
Gb1034_28 ns1034 0 ni28 0 0.440674147276
Gb1036_28 ns1036 0 ni28 0 0.395756150918
Gb1038_28 ns1038 0 ni28 0 0.398656352411
Gb1040_28 ns1040 0 ni28 0 0.383150161989
Gb1042_28 ns1042 0 ni28 0 0.31562326883
Gb1044_28 ns1044 0 ni28 0 0.299712553354
Gb1046_28 ns1046 0 ni28 0 0.282223656493
Gb1048_28 ns1048 0 ni28 0 0.238985182975
Gb1050_28 ns1050 0 ni28 0 0.20728828262
Gb1052_28 ns1052 0 ni28 0 0.199912462121
Gb1054_28 ns1054 0 ni28 0 0.158765666691
Gb1056_28 ns1056 0 ni28 0 0.122708193017
Gb1058_28 ns1058 0 ni28 0 0.104644221536
Gb1060_28 ns1060 0 ni28 0 0.0727488775944
Gb1061_28 ns1061 0 ni28 0 0.0646647257385
Gb1062_28 ns1062 0 ni28 0 0.0322035832858
Gb1063_28 ns1063 0 ni28 0 0.000315927321594
Gb1064_28 ns1064 0 ni28 0 7777.77777778
Gb1065_29 ns1065 0 ni29 0 1.60528689108
Gb1066_29 ns1066 0 ni29 0 1.10755172271
Gb1067_29 ns1067 0 ni29 0 0.443897568251
Gb1068_29 ns1068 0 ni29 0 0.484961695613
Gb1070_29 ns1070 0 ni29 0 0.451427795096
Gb1072_29 ns1072 0 ni29 0 0.440674147276
Gb1074_29 ns1074 0 ni29 0 0.395756150918
Gb1076_29 ns1076 0 ni29 0 0.398656352411
Gb1078_29 ns1078 0 ni29 0 0.383150161989
Gb1080_29 ns1080 0 ni29 0 0.31562326883
Gb1082_29 ns1082 0 ni29 0 0.299712553354
Gb1084_29 ns1084 0 ni29 0 0.282223656493
Gb1086_29 ns1086 0 ni29 0 0.238985182975
Gb1088_29 ns1088 0 ni29 0 0.20728828262
Gb1090_29 ns1090 0 ni29 0 0.199912462121
Gb1092_29 ns1092 0 ni29 0 0.158765666691
Gb1094_29 ns1094 0 ni29 0 0.122708193017
Gb1096_29 ns1096 0 ni29 0 0.104644221536
Gb1098_29 ns1098 0 ni29 0 0.0727488775944
Gb1099_29 ns1099 0 ni29 0 0.0646647257385
Gb1100_29 ns1100 0 ni29 0 0.0322035832858
Gb1101_29 ns1101 0 ni29 0 0.000315927321594
Gb1102_29 ns1102 0 ni29 0 7777.77777778
Gb1103_30 ns1103 0 ni30 0 1.60528689108
Gb1104_30 ns1104 0 ni30 0 1.10755172271
Gb1105_30 ns1105 0 ni30 0 0.443897568251
Gb1106_30 ns1106 0 ni30 0 0.484961695613
Gb1108_30 ns1108 0 ni30 0 0.451427795096
Gb1110_30 ns1110 0 ni30 0 0.440674147276
Gb1112_30 ns1112 0 ni30 0 0.395756150918
Gb1114_30 ns1114 0 ni30 0 0.398656352411
Gb1116_30 ns1116 0 ni30 0 0.383150161989
Gb1118_30 ns1118 0 ni30 0 0.31562326883
Gb1120_30 ns1120 0 ni30 0 0.299712553354
Gb1122_30 ns1122 0 ni30 0 0.282223656493
Gb1124_30 ns1124 0 ni30 0 0.238985182975
Gb1126_30 ns1126 0 ni30 0 0.20728828262
Gb1128_30 ns1128 0 ni30 0 0.199912462121
Gb1130_30 ns1130 0 ni30 0 0.158765666691
Gb1132_30 ns1132 0 ni30 0 0.122708193017
Gb1134_30 ns1134 0 ni30 0 0.104644221536
Gb1136_30 ns1136 0 ni30 0 0.0727488775944
Gb1137_30 ns1137 0 ni30 0 0.0646647257385
Gb1138_30 ns1138 0 ni30 0 0.0322035832858
Gb1139_30 ns1139 0 ni30 0 0.000315927321594
Gb1140_30 ns1140 0 ni30 0 7777.77777778
Gb1141_31 ns1141 0 ni31 0 1.60528689108
Gb1142_31 ns1142 0 ni31 0 1.10755172271
Gb1143_31 ns1143 0 ni31 0 0.443897568251
Gb1144_31 ns1144 0 ni31 0 0.484961695613
Gb1146_31 ns1146 0 ni31 0 0.451427795096
Gb1148_31 ns1148 0 ni31 0 0.440674147276
Gb1150_31 ns1150 0 ni31 0 0.395756150918
Gb1152_31 ns1152 0 ni31 0 0.398656352411
Gb1154_31 ns1154 0 ni31 0 0.383150161989
Gb1156_31 ns1156 0 ni31 0 0.31562326883
Gb1158_31 ns1158 0 ni31 0 0.299712553354
Gb1160_31 ns1160 0 ni31 0 0.282223656493
Gb1162_31 ns1162 0 ni31 0 0.238985182975
Gb1164_31 ns1164 0 ni31 0 0.20728828262
Gb1166_31 ns1166 0 ni31 0 0.199912462121
Gb1168_31 ns1168 0 ni31 0 0.158765666691
Gb1170_31 ns1170 0 ni31 0 0.122708193017
Gb1172_31 ns1172 0 ni31 0 0.104644221536
Gb1174_31 ns1174 0 ni31 0 0.0727488775944
Gb1175_31 ns1175 0 ni31 0 0.0646647257385
Gb1176_31 ns1176 0 ni31 0 0.0322035832858
Gb1177_31 ns1177 0 ni31 0 0.000315927321594
Gb1178_31 ns1178 0 ni31 0 7777.77777778
Gb1179_32 ns1179 0 ni32 0 1.60528689108
Gb1180_32 ns1180 0 ni32 0 1.10755172271
Gb1181_32 ns1181 0 ni32 0 0.443897568251
Gb1182_32 ns1182 0 ni32 0 0.484961695613
Gb1184_32 ns1184 0 ni32 0 0.451427795096
Gb1186_32 ns1186 0 ni32 0 0.440674147276
Gb1188_32 ns1188 0 ni32 0 0.395756150918
Gb1190_32 ns1190 0 ni32 0 0.398656352411
Gb1192_32 ns1192 0 ni32 0 0.383150161989
Gb1194_32 ns1194 0 ni32 0 0.31562326883
Gb1196_32 ns1196 0 ni32 0 0.299712553354
Gb1198_32 ns1198 0 ni32 0 0.282223656493
Gb1200_32 ns1200 0 ni32 0 0.238985182975
Gb1202_32 ns1202 0 ni32 0 0.20728828262
Gb1204_32 ns1204 0 ni32 0 0.199912462121
Gb1206_32 ns1206 0 ni32 0 0.158765666691
Gb1208_32 ns1208 0 ni32 0 0.122708193017
Gb1210_32 ns1210 0 ni32 0 0.104644221536
Gb1212_32 ns1212 0 ni32 0 0.0727488775944
Gb1213_32 ns1213 0 ni32 0 0.0646647257385
Gb1214_32 ns1214 0 ni32 0 0.0322035832858
Gb1215_32 ns1215 0 ni32 0 0.000315927321594
Gb1216_32 ns1216 0 ni32 0 7777.77777778

Gc1_1 0 n2 ns1 0 -0.00568663865088
Gc1_2 0 n2 ns2 0 -0.0033392180086
Gc1_3 0 n2 ns3 0 -0.00329027974292
Gc1_4 0 n2 ns4 0 0.000366112627223
Gc1_5 0 n2 ns5 0 -0.000790496063028
Gc1_6 0 n2 ns6 0 -0.000240976577468
Gc1_7 0 n2 ns7 0 0.0001520109723
Gc1_8 0 n2 ns8 0 -0.000158472083965
Gc1_9 0 n2 ns9 0 -0.00013006242897
Gc1_10 0 n2 ns10 0 -0.00181448647179
Gc1_11 0 n2 ns11 0 0.00181816533795
Gc1_12 0 n2 ns12 0 0.000959406226074
Gc1_13 0 n2 ns13 0 9.99307212377e-05
Gc1_14 0 n2 ns14 0 0.000260018031078
Gc1_15 0 n2 ns15 0 -0.000146005248969
Gc1_16 0 n2 ns16 0 0.00183812299528
Gc1_17 0 n2 ns17 0 0.000780618280452
Gc1_18 0 n2 ns18 0 0.000517884296598
Gc1_19 0 n2 ns19 0 0.000157478625821
Gc1_20 0 n2 ns20 0 0.000176674314643
Gc1_21 0 n2 ns21 0 0.000181161784302
Gc1_22 0 n2 ns22 0 0.00131487131104
Gc1_23 0 n2 ns23 0 -0.00196260550661
Gc1_24 0 n2 ns24 0 0.00106382970921
Gc1_25 0 n2 ns25 0 0.00255617904475
Gc1_26 0 n2 ns26 0 0.0012855729873
Gc1_27 0 n2 ns27 0 -0.00124029378749
Gc1_28 0 n2 ns28 0 -0.000423575122545
Gc1_29 0 n2 ns29 0 -0.00344106999143
Gc1_30 0 n2 ns30 0 0.00381504974899
Gc1_31 0 n2 ns31 0 0.00073679454054
Gc1_32 0 n2 ns32 0 0.00221117735707
Gc1_33 0 n2 ns33 0 0.00021742320715
Gc1_34 0 n2 ns34 0 -0.0600689706777
Gc1_35 0 n2 ns35 0 0.0608289273391
Gc1_36 0 n2 ns36 0 0.00489853063987
Gc1_37 0 n2 ns37 0 6.39419253247e-06
Gc1_38 0 n2 ns38 0 2.60694714162e-05
Gc1_39 0 n2 ns39 0 -0.00558795442513
Gc1_40 0 n2 ns40 0 -0.00294305554973
Gc1_41 0 n2 ns41 0 -0.0044224513034
Gc1_42 0 n2 ns42 0 0.000177068807401
Gc1_43 0 n2 ns43 0 -0.00135878413752
Gc1_44 0 n2 ns44 0 -0.000665402475642
Gc1_45 0 n2 ns45 0 0.000819927383532
Gc1_46 0 n2 ns46 0 -2.83899899134e-05
Gc1_47 0 n2 ns47 0 -8.53487088261e-05
Gc1_48 0 n2 ns48 0 -0.00023144741564
Gc1_49 0 n2 ns49 0 0.00246721164373
Gc1_50 0 n2 ns50 0 0.00056720406431
Gc1_51 0 n2 ns51 0 -0.000200948121255
Gc1_52 0 n2 ns52 0 0.000205486803139
Gc1_53 0 n2 ns53 0 -9.28329880192e-05
Gc1_54 0 n2 ns54 0 0.00159869019883
Gc1_55 0 n2 ns55 0 0.00073777577721
Gc1_56 0 n2 ns56 0 0.000733162877503
Gc1_57 0 n2 ns57 0 -0.000110321094038
Gc1_58 0 n2 ns58 0 0.000172888076077
Gc1_59 0 n2 ns59 0 0.000133961216423
Gc1_60 0 n2 ns60 0 0.00132986364287
Gc1_61 0 n2 ns61 0 -0.00123175271717
Gc1_62 0 n2 ns62 0 0.00110289262335
Gc1_63 0 n2 ns63 0 0.00198604678826
Gc1_64 0 n2 ns64 0 0.00119388982277
Gc1_65 0 n2 ns65 0 -0.00110678366049
Gc1_66 0 n2 ns66 0 0.00094733425015
Gc1_67 0 n2 ns67 0 -0.00208083511551
Gc1_68 0 n2 ns68 0 0.00310290128278
Gc1_69 0 n2 ns69 0 -0.00012077145381
Gc1_70 0 n2 ns70 0 0.00218343006794
Gc1_71 0 n2 ns71 0 0.000430173552227
Gc1_72 0 n2 ns72 0 -0.041036076907
Gc1_73 0 n2 ns73 0 0.0423504129117
Gc1_74 0 n2 ns74 0 0.00598632459841
Gc1_75 0 n2 ns75 0 -5.03125211895e-06
Gc1_76 0 n2 ns76 0 2.45062395662e-05
Gc1_77 0 n2 ns77 0 -0.00152118985766
Gc1_78 0 n2 ns78 0 -0.00172839719973
Gc1_79 0 n2 ns79 0 0.00504141607979
Gc1_80 0 n2 ns80 0 0.00107027544893
Gc1_81 0 n2 ns81 0 -0.000453875017247
Gc1_82 0 n2 ns82 0 0.000823793944768
Gc1_83 0 n2 ns83 0 0.000492980941555
Gc1_84 0 n2 ns84 0 -0.000140347719607
Gc1_85 0 n2 ns85 0 -3.62439953978e-05
Gc1_86 0 n2 ns86 0 -0.00149715324448
Gc1_87 0 n2 ns87 0 -0.00198120043423
Gc1_88 0 n2 ns88 0 0.000843448169921
Gc1_89 0 n2 ns89 0 -0.000344591145565
Gc1_90 0 n2 ns90 0 0.000341245865247
Gc1_91 0 n2 ns91 0 -0.000230186338672
Gc1_92 0 n2 ns92 0 -0.00239547958519
Gc1_93 0 n2 ns93 0 -0.00232467194169
Gc1_94 0 n2 ns94 0 -3.08381080008e-05
Gc1_95 0 n2 ns95 0 0.000181850043055
Gc1_96 0 n2 ns96 0 0.000226745593636
Gc1_97 0 n2 ns97 0 0.000331474994393
Gc1_98 0 n2 ns98 0 -0.005084058372
Gc1_99 0 n2 ns99 0 0.00186324676527
Gc1_100 0 n2 ns100 0 0.000479625991746
Gc1_101 0 n2 ns101 0 0.000420498867505
Gc1_102 0 n2 ns102 0 0.000843313456978
Gc1_103 0 n2 ns103 0 -0.000821907483369
Gc1_104 0 n2 ns104 0 -0.00263438091041
Gc1_105 0 n2 ns105 0 0.0026779437636
Gc1_106 0 n2 ns106 0 -0.00186083153673
Gc1_107 0 n2 ns107 0 -0.000754845052083
Gc1_108 0 n2 ns108 0 0.001766087914
Gc1_109 0 n2 ns109 0 0.000527464475512
Gc1_110 0 n2 ns110 0 0.029638216441
Gc1_111 0 n2 ns111 0 -0.034407671105
Gc1_112 0 n2 ns112 0 0.00428746064332
Gc1_113 0 n2 ns113 0 2.7002382857e-06
Gc1_114 0 n2 ns114 0 2.84476377617e-05
Gc1_115 0 n2 ns115 0 -0.00120210590867
Gc1_116 0 n2 ns116 0 0.00260916294315
Gc1_117 0 n2 ns117 0 -0.00415380206219
Gc1_118 0 n2 ns118 0 0.00019040144208
Gc1_119 0 n2 ns119 0 -0.000475457007253
Gc1_120 0 n2 ns120 0 9.36842131259e-05
Gc1_121 0 n2 ns121 0 -0.000511448759472
Gc1_122 0 n2 ns122 0 -3.18870733288e-05
Gc1_123 0 n2 ns123 0 -1.38240394399e-05
Gc1_124 0 n2 ns124 0 -0.00153626935372
Gc1_125 0 n2 ns125 0 0.00163679763046
Gc1_126 0 n2 ns126 0 -0.000372579244679
Gc1_127 0 n2 ns127 0 -0.000425548229241
Gc1_128 0 n2 ns128 0 0.000154048727103
Gc1_129 0 n2 ns129 0 -0.000234261113736
Gc1_130 0 n2 ns130 0 -0.000133168693777
Gc1_131 0 n2 ns131 0 0.00267440505602
Gc1_132 0 n2 ns132 0 0.000125314198078
Gc1_133 0 n2 ns133 0 -0.000889441703354
Gc1_134 0 n2 ns134 0 0.000207293827742
Gc1_135 0 n2 ns135 0 1.08815104131e-05
Gc1_136 0 n2 ns136 0 0.00237825707977
Gc1_137 0 n2 ns137 0 0.0023265780096
Gc1_138 0 n2 ns138 0 -0.000518865371017
Gc1_139 0 n2 ns139 0 1.60726410024e-06
Gc1_140 0 n2 ns140 0 0.000464426670478
Gc1_141 0 n2 ns141 0 -0.000643105228091
Gc1_142 0 n2 ns142 0 0.00362093341251
Gc1_143 0 n2 ns143 0 0.000263815789359
Gc1_144 0 n2 ns144 0 -0.00189650119851
Gc1_145 0 n2 ns145 0 0.000664747466694
Gc1_146 0 n2 ns146 0 0.00113197591053
Gc1_147 0 n2 ns147 0 -0.000209694936462
Gc1_148 0 n2 ns148 0 0.0369014857282
Gc1_149 0 n2 ns149 0 -0.0337969452454
Gc1_150 0 n2 ns150 0 0.00190918706394
Gc1_151 0 n2 ns151 0 -6.34487957055e-06
Gc1_152 0 n2 ns152 0 1.85371677378e-05
Gc1_153 0 n2 ns153 0 -0.000854186734907
Gc1_154 0 n2 ns154 0 0.00176545974146
Gc1_155 0 n2 ns155 0 -0.00164633398721
Gc1_156 0 n2 ns156 0 -7.52874518886e-05
Gc1_157 0 n2 ns157 0 -0.000134294758958
Gc1_158 0 n2 ns158 0 -0.000322101454945
Gc1_159 0 n2 ns159 0 2.49763185951e-05
Gc1_160 0 n2 ns160 0 -4.362441785e-05
Gc1_161 0 n2 ns161 0 1.29666118793e-05
Gc1_162 0 n2 ns162 0 0.000578927798683
Gc1_163 0 n2 ns163 0 0.000656836536126
Gc1_164 0 n2 ns164 0 -7.97211064979e-05
Gc1_165 0 n2 ns165 0 0.000511092782493
Gc1_166 0 n2 ns166 0 4.42347656241e-05
Gc1_167 0 n2 ns167 0 -0.000285172185597
Gc1_168 0 n2 ns168 0 0.00168592653323
Gc1_169 0 n2 ns169 0 -0.000520049930166
Gc1_170 0 n2 ns170 0 -0.00107017850521
Gc1_171 0 n2 ns171 0 1.41097292542e-07
Gc1_172 0 n2 ns172 0 0.000159920232342
Gc1_173 0 n2 ns173 0 6.41305825318e-05
Gc1_174 0 n2 ns174 0 -3.08418392888e-05
Gc1_175 0 n2 ns175 0 -0.00110248372681
Gc1_176 0 n2 ns176 0 -0.000306272224883
Gc1_177 0 n2 ns177 0 0.00136787670317
Gc1_178 0 n2 ns178 0 0.000362556429268
Gc1_179 0 n2 ns179 0 -0.000923011484893
Gc1_180 0 n2 ns180 0 -0.00113094708963
Gc1_181 0 n2 ns181 0 -0.000979381886697
Gc1_182 0 n2 ns182 0 -9.21957854125e-05
Gc1_183 0 n2 ns183 0 0.00165246414624
Gc1_184 0 n2 ns184 0 0.000755585364728
Gc1_185 0 n2 ns185 0 -0.000587071179597
Gc1_186 0 n2 ns186 0 0.0116328600643
Gc1_187 0 n2 ns187 0 -0.0114202036871
Gc1_188 0 n2 ns188 0 0.000746902547576
Gc1_189 0 n2 ns189 0 -9.94682351492e-06
Gc1_190 0 n2 ns190 0 3.30810194166e-06
Gc1_191 0 n2 ns191 0 0.000242516518043
Gc1_192 0 n2 ns192 0 -0.000400365237181
Gc1_193 0 n2 ns193 0 0.00286148954849
Gc1_194 0 n2 ns194 0 0.000158911901249
Gc1_195 0 n2 ns195 0 0.000154937437161
Gc1_196 0 n2 ns196 0 0.00010103007316
Gc1_197 0 n2 ns197 0 4.37145226439e-05
Gc1_198 0 n2 ns198 0 2.47311736399e-05
Gc1_199 0 n2 ns199 0 2.38678258745e-05
Gc1_200 0 n2 ns200 0 -0.000761878234335
Gc1_201 0 n2 ns201 0 -0.00102520175073
Gc1_202 0 n2 ns202 0 0.000758315514992
Gc1_203 0 n2 ns203 0 0.000296644138022
Gc1_204 0 n2 ns204 0 -8.74787174766e-05
Gc1_205 0 n2 ns205 0 -0.000206091851258
Gc1_206 0 n2 ns206 0 -0.0008869962749
Gc1_207 0 n2 ns207 0 -0.00156969899226
Gc1_208 0 n2 ns208 0 -0.000313938033807
Gc1_209 0 n2 ns209 0 0.00109180330542
Gc1_210 0 n2 ns210 0 0.000221240555961
Gc1_211 0 n2 ns211 0 -5.72964461467e-06
Gc1_212 0 n2 ns212 0 -0.00186118575647
Gc1_213 0 n2 ns213 0 0.000387117967829
Gc1_214 0 n2 ns214 0 0.000813662835802
Gc1_215 0 n2 ns215 0 0.00108300587527
Gc1_216 0 n2 ns216 0 -0.000214441078521
Gc1_217 0 n2 ns217 0 -0.00081968522258
Gc1_218 0 n2 ns218 0 -0.00230082814611
Gc1_219 0 n2 ns219 0 0.000537506421816
Gc1_220 0 n2 ns220 0 0.000710604721232
Gc1_221 0 n2 ns221 0 0.00109898322497
Gc1_222 0 n2 ns222 0 0.000371184882281
Gc1_223 0 n2 ns223 0 -0.00057880621734
Gc1_224 0 n2 ns224 0 0.00335332528993
Gc1_225 0 n2 ns225 0 -0.00413818151257
Gc1_226 0 n2 ns226 0 0.00036267671555
Gc1_227 0 n2 ns227 0 -7.17473224699e-06
Gc1_228 0 n2 ns228 0 -1.79550215863e-05
Gc1_229 0 n2 ns229 0 0.000159226996395
Gc1_230 0 n2 ns230 0 -0.000745426946089
Gc1_231 0 n2 ns231 0 0.000393696011806
Gc1_232 0 n2 ns232 0 0.000109014714786
Gc1_233 0 n2 ns233 0 -0.000122269126296
Gc1_234 0 n2 ns234 0 8.40002685325e-05
Gc1_235 0 n2 ns235 0 -3.88671771692e-06
Gc1_236 0 n2 ns236 0 1.37974351443e-05
Gc1_237 0 n2 ns237 0 -5.45030144811e-05
Gc1_238 0 n2 ns238 0 -0.000941737143667
Gc1_239 0 n2 ns239 0 0.000487653136386
Gc1_240 0 n2 ns240 0 0.000399371884057
Gc1_241 0 n2 ns241 0 -0.00044465826765
Gc1_242 0 n2 ns242 0 -0.000144799958303
Gc1_243 0 n2 ns243 0 -4.07159237714e-05
Gc1_244 0 n2 ns244 0 -0.000933772419634
Gc1_245 0 n2 ns245 0 0.000462212009338
Gc1_246 0 n2 ns246 0 0.000595020417113
Gc1_247 0 n2 ns247 0 0.000326739977163
Gc1_248 0 n2 ns248 0 6.64185366582e-05
Gc1_249 0 n2 ns249 0 -0.000157126685357
Gc1_250 0 n2 ns250 0 0.000355818562951
Gc1_251 0 n2 ns251 0 0.00117374478211
Gc1_252 0 n2 ns252 0 0.000807079438992
Gc1_253 0 n2 ns253 0 -0.000239560838781
Gc1_254 0 n2 ns254 0 -0.000538049939049
Gc1_255 0 n2 ns255 0 -0.000144058205709
Gc1_256 0 n2 ns256 0 0.000475652020905
Gc1_257 0 n2 ns257 0 0.000724510878247
Gc1_258 0 n2 ns258 0 0.000302361387516
Gc1_259 0 n2 ns259 0 8.42138956734e-05
Gc1_260 0 n2 ns260 0 1.6314056763e-07
Gc1_261 0 n2 ns261 0 -0.000263452729862
Gc1_262 0 n2 ns262 0 0.00962526885533
Gc1_263 0 n2 ns263 0 -0.0084338083618
Gc1_264 0 n2 ns264 0 0.000335829846314
Gc1_265 0 n2 ns265 0 -7.2832359355e-06
Gc1_266 0 n2 ns266 0 -2.76480211542e-05
Gc1_267 0 n2 ns267 0 -0.000156108455878
Gc1_268 0 n2 ns268 0 0.000326827923644
Gc1_269 0 n2 ns269 0 -0.00265882792926
Gc1_270 0 n2 ns270 0 -0.000195133604654
Gc1_271 0 n2 ns271 0 -0.000133788164853
Gc1_272 0 n2 ns272 0 -0.000141676237276
Gc1_273 0 n2 ns273 0 2.4812606401e-05
Gc1_274 0 n2 ns274 0 -7.01267951844e-06
Gc1_275 0 n2 ns275 0 9.39959737719e-06
Gc1_276 0 n2 ns276 0 0.000676122327646
Gc1_277 0 n2 ns277 0 0.0010366779227
Gc1_278 0 n2 ns278 0 -0.000376226367018
Gc1_279 0 n2 ns279 0 -0.000344227154756
Gc1_280 0 n2 ns280 0 -8.31697765546e-05
Gc1_281 0 n2 ns281 0 0.000102014464215
Gc1_282 0 n2 ns282 0 0.000221503332632
Gc1_283 0 n2 ns283 0 0.000816533265677
Gc1_284 0 n2 ns284 0 0.000367685307867
Gc1_285 0 n2 ns285 0 -0.000306832762656
Gc1_286 0 n2 ns286 0 -6.44407263549e-05
Gc1_287 0 n2 ns287 0 -0.000102696280614
Gc1_288 0 n2 ns288 0 0.00118709129394
Gc1_289 0 n2 ns289 0 0.000480477182644
Gc1_290 0 n2 ns290 0 0.00029497089177
Gc1_291 0 n2 ns291 0 -0.000551302753224
Gc1_292 0 n2 ns292 0 -0.000347968275148
Gc1_293 0 n2 ns293 0 0.00016497403269
Gc1_294 0 n2 ns294 0 0.00138237506305
Gc1_295 0 n2 ns295 0 0.000674998413308
Gc1_296 0 n2 ns296 0 0.000178530559916
Gc1_297 0 n2 ns297 0 -0.000264200834062
Gc1_298 0 n2 ns298 0 -0.000116512550712
Gc1_299 0 n2 ns299 0 -0.00015478659301
Gc1_300 0 n2 ns300 0 0.0143687462091
Gc1_301 0 n2 ns301 0 -0.0121367321215
Gc1_302 0 n2 ns302 0 0.000416908396949
Gc1_303 0 n2 ns303 0 -7.39569551232e-06
Gc1_304 0 n2 ns304 0 -2.53088603434e-05
Gc1_305 0 n2 ns305 0 -0.000211842922544
Gc1_306 0 n2 ns306 0 0.0004079444018
Gc1_307 0 n2 ns307 0 -0.00206576324643
Gc1_308 0 n2 ns308 0 -0.000233791333043
Gc1_309 0 n2 ns309 0 -6.40724154288e-06
Gc1_310 0 n2 ns310 0 -0.000139354772477
Gc1_311 0 n2 ns311 0 0.000118083141127
Gc1_312 0 n2 ns312 0 2.04967878429e-05
Gc1_313 0 n2 ns313 0 2.97760538449e-05
Gc1_314 0 n2 ns314 0 0.00100308531815
Gc1_315 0 n2 ns315 0 0.000270019011636
Gc1_316 0 n2 ns316 0 -0.000393290538141
Gc1_317 0 n2 ns317 0 3.6145530735e-05
Gc1_318 0 n2 ns318 0 -1.3574236624e-06
Gc1_319 0 n2 ns319 0 9.08326901749e-05
Gc1_320 0 n2 ns320 0 0.000419714799079
Gc1_321 0 n2 ns321 0 0.00022983824336
Gc1_322 0 n2 ns322 0 1.71954323935e-05
Gc1_323 0 n2 ns323 0 -0.000238927763275
Gc1_324 0 n2 ns324 0 -5.52699550829e-05
Gc1_325 0 n2 ns325 0 -1.33417015457e-05
Gc1_326 0 n2 ns326 0 0.000620648508288
Gc1_327 0 n2 ns327 0 -1.48545725681e-05
Gc1_328 0 n2 ns328 0 1.56941399692e-05
Gc1_329 0 n2 ns329 0 -0.000285502449297
Gc1_330 0 n2 ns330 0 -0.000108777671082
Gc1_331 0 n2 ns331 0 0.000135029513274
Gc1_332 0 n2 ns332 0 0.000713663782294
Gc1_333 0 n2 ns333 0 0.000395070835883
Gc1_334 0 n2 ns334 0 0.000140793486286
Gc1_335 0 n2 ns335 0 -0.000169985563886
Gc1_336 0 n2 ns336 0 -7.53238226037e-05
Gc1_337 0 n2 ns337 0 -9.61256661794e-05
Gc1_338 0 n2 ns338 0 0.00824342153911
Gc1_339 0 n2 ns339 0 -0.00690728177956
Gc1_340 0 n2 ns340 0 0.000235779752223
Gc1_341 0 n2 ns341 0 -8.14565875874e-06
Gc1_342 0 n2 ns342 0 -1.99111034845e-05
Gc1_343 0 n2 ns343 0 -0.00182686197131
Gc1_344 0 n2 ns344 0 -0.00303491091983
Gc1_345 0 n2 ns345 0 0.00644549492309
Gc1_346 0 n2 ns346 0 0.000688183457113
Gc1_347 0 n2 ns347 0 -0.000296633788175
Gc1_348 0 n2 ns348 0 0.000686869742735
Gc1_349 0 n2 ns349 0 0.000776448779461
Gc1_350 0 n2 ns350 0 -0.00016495544319
Gc1_351 0 n2 ns351 0 -9.67337680538e-05
Gc1_352 0 n2 ns352 0 -0.000880823741447
Gc1_353 0 n2 ns353 0 -0.00194241944367
Gc1_354 0 n2 ns354 0 0.00116831480863
Gc1_355 0 n2 ns355 0 7.51689034181e-05
Gc1_356 0 n2 ns356 0 0.000421197520277
Gc1_357 0 n2 ns357 0 -0.000181821533307
Gc1_358 0 n2 ns358 0 -0.000750735259762
Gc1_359 0 n2 ns359 0 -0.00330121248675
Gc1_360 0 n2 ns360 0 -0.000110184881236
Gc1_361 0 n2 ns361 0 0.000196316227135
Gc1_362 0 n2 ns362 0 0.000165357540543
Gc1_363 0 n2 ns363 0 0.000373213808797
Gc1_364 0 n2 ns364 0 -0.00574595398256
Gc1_365 0 n2 ns365 0 -0.00140934265328
Gc1_366 0 n2 ns366 0 0.000665081414565
Gc1_367 0 n2 ns367 0 0.000862083277646
Gc1_368 0 n2 ns368 0 0.0010273307872
Gc1_369 0 n2 ns369 0 -0.000848209771116
Gc1_370 0 n2 ns370 0 -0.00663751518898
Gc1_371 0 n2 ns371 0 -0.000294757501165
Gc1_372 0 n2 ns372 0 -0.00100219424705
Gc1_373 0 n2 ns373 0 -0.000563252454159
Gc1_374 0 n2 ns374 0 0.00203926424446
Gc1_375 0 n2 ns375 0 0.000788088814596
Gc1_376 0 n2 ns376 0 0.00394068480668
Gc1_377 0 n2 ns377 0 -0.0138232810737
Gc1_378 0 n2 ns378 0 0.00513408166115
Gc1_379 0 n2 ns379 0 1.53303725016e-06
Gc1_380 0 n2 ns380 0 3.07530959342e-05
Gc1_381 0 n2 ns381 0 -0.00116211240099
Gc1_382 0 n2 ns382 0 0.00075920060623
Gc1_383 0 n2 ns383 0 -0.000956185080755
Gc1_384 0 n2 ns384 0 0.000731609716769
Gc1_385 0 n2 ns385 0 -0.000690629550848
Gc1_386 0 n2 ns386 0 0.000503144252651
Gc1_387 0 n2 ns387 0 -0.000378547011683
Gc1_388 0 n2 ns388 0 -5.58722020292e-05
Gc1_389 0 n2 ns389 0 -1.04081537497e-05
Gc1_390 0 n2 ns390 0 -0.0027711291437
Gc1_391 0 n2 ns391 0 0.000417758541822
Gc1_392 0 n2 ns392 0 0.000109846962057
Gc1_393 0 n2 ns393 0 -0.000669347165934
Gc1_394 0 n2 ns394 0 0.00025169836652
Gc1_395 0 n2 ns395 0 -0.000246921612112
Gc1_396 0 n2 ns396 0 -0.00207805155066
Gc1_397 0 n2 ns397 0 0.00205144584856
Gc1_398 0 n2 ns398 0 0.000518842929874
Gc1_399 0 n2 ns399 0 -0.000532886145538
Gc1_400 0 n2 ns400 0 0.000290748258334
Gc1_401 0 n2 ns401 0 8.88857796695e-05
Gc1_402 0 n2 ns402 0 0.00067555911043
Gc1_403 0 n2 ns403 0 0.00387971122578
Gc1_404 0 n2 ns404 0 -0.000101474792094
Gc1_405 0 n2 ns405 0 -0.000236146818615
Gc1_406 0 n2 ns406 0 0.000487849270645
Gc1_407 0 n2 ns407 0 -0.000677427502246
Gc1_408 0 n2 ns408 0 0.00317328644266
Gc1_409 0 n2 ns409 0 0.00188320725739
Gc1_410 0 n2 ns410 0 -0.00212898073054
Gc1_411 0 n2 ns411 0 4.74569160158e-05
Gc1_412 0 n2 ns412 0 0.0013170904132
Gc1_413 0 n2 ns413 0 -3.77621769136e-05
Gc1_414 0 n2 ns414 0 0.0412584948952
Gc1_415 0 n2 ns415 0 -0.0391450041802
Gc1_416 0 n2 ns416 0 0.00261067669195
Gc1_417 0 n2 ns417 0 -2.33051887185e-06
Gc1_418 0 n2 ns418 0 2.28855987331e-05
Gc1_419 0 n2 ns419 0 -0.00127929923011
Gc1_420 0 n2 ns420 0 0.00275528646749
Gc1_421 0 n2 ns421 0 -0.00445696469706
Gc1_422 0 n2 ns422 0 -0.000192773123415
Gc1_423 0 n2 ns423 0 -0.000355904937282
Gc1_424 0 n2 ns424 0 -0.000444088375818
Gc1_425 0 n2 ns425 0 -0.000118844143741
Gc1_426 0 n2 ns426 0 -3.02681022771e-05
Gc1_427 0 n2 ns427 0 3.85741642831e-07
Gc1_428 0 n2 ns428 0 0.000736511439173
Gc1_429 0 n2 ns429 0 0.00192447866217
Gc1_430 0 n2 ns430 0 -0.000586285732714
Gc1_431 0 n2 ns431 0 0.00016817876875
Gc1_432 0 n2 ns432 0 6.59075141124e-05
Gc1_433 0 n2 ns433 0 -0.000248625838464
Gc1_434 0 n2 ns434 0 0.0022086501273
Gc1_435 0 n2 ns435 0 0.00100132410812
Gc1_436 0 n2 ns436 0 -0.000874877443655
Gc1_437 0 n2 ns437 0 -0.000724943682142
Gc1_438 0 n2 ns438 0 0.000122053921226
Gc1_439 0 n2 ns439 0 2.73249204616e-05
Gc1_440 0 n2 ns440 0 0.00163133079758
Gc1_441 0 n2 ns441 0 -0.000704520859679
Gc1_442 0 n2 ns442 0 -0.000669809373987
Gc1_443 0 n2 ns443 0 0.000957368296199
Gc1_444 0 n2 ns444 0 0.00047423417505
Gc1_445 0 n2 ns445 0 -0.000817569746778
Gc1_446 0 n2 ns446 0 0.00089758292885
Gc1_447 0 n2 ns447 0 -0.00108519412487
Gc1_448 0 n2 ns448 0 -0.000721700617548
Gc1_449 0 n2 ns449 0 0.00145077526121
Gc1_450 0 n2 ns450 0 0.000870509938838
Gc1_451 0 n2 ns451 0 -0.000506887505127
Gc1_452 0 n2 ns452 0 0.022548592365
Gc1_453 0 n2 ns453 0 -0.0206770266601
Gc1_454 0 n2 ns454 0 0.00113013758099
Gc1_455 0 n2 ns455 0 -9.77522497398e-06
Gc1_456 0 n2 ns456 0 1.40354467596e-05
Gc1_457 0 n2 ns457 0 -0.000145387078163
Gc1_458 0 n2 ns458 0 -0.000258004175628
Gc1_459 0 n2 ns459 0 0.00257068907394
Gc1_460 0 n2 ns460 0 8.22566985568e-05
Gc1_461 0 n2 ns461 0 2.10083444514e-05
Gc1_462 0 n2 ns462 0 -7.95479437349e-05
Gc1_463 0 n2 ns463 0 0.00017798502762
Gc1_464 0 n2 ns464 0 1.75360179801e-05
Gc1_465 0 n2 ns465 0 3.30118779097e-05
Gc1_466 0 n2 ns466 0 -0.00012207197163
Gc1_467 0 n2 ns467 0 -0.00104704835682
Gc1_468 0 n2 ns468 0 0.000540753762692
Gc1_469 0 n2 ns469 0 0.000668003593102
Gc1_470 0 n2 ns470 0 -1.63036466534e-07
Gc1_471 0 n2 ns471 0 -0.000258213309571
Gc1_472 0 n2 ns472 0 -0.00011361581159
Gc1_473 0 n2 ns473 0 -0.00184832404841
Gc1_474 0 n2 ns474 0 -0.000778714833712
Gc1_475 0 n2 ns475 0 0.000994887144271
Gc1_476 0 n2 ns476 0 0.000243042854055
Gc1_477 0 n2 ns477 0 5.86782542359e-05
Gc1_478 0 n2 ns478 0 -0.00181085943896
Gc1_479 0 n2 ns479 0 -0.00020685021996
Gc1_480 0 n2 ns480 0 0.00053731862133
Gc1_481 0 n2 ns481 0 0.00136831026195
Gc1_482 0 n2 ns482 0 -3.22391828132e-05
Gc1_483 0 n2 ns483 0 -0.000945039992691
Gc1_484 0 n2 ns484 0 -0.00247678480573
Gc1_485 0 n2 ns485 0 -0.000118141414087
Gc1_486 0 n2 ns486 0 0.000486673016062
Gc1_487 0 n2 ns487 0 0.00136577303588
Gc1_488 0 n2 ns488 0 0.000501561934335
Gc1_489 0 n2 ns489 0 -0.000564842290616
Gc1_490 0 n2 ns490 0 0.00125497535386
Gc1_491 0 n2 ns491 0 -0.00247216858048
Gc1_492 0 n2 ns492 0 0.000355003446625
Gc1_493 0 n2 ns493 0 -7.56702914854e-06
Gc1_494 0 n2 ns494 0 -7.62303297581e-06
Gc1_495 0 n2 ns495 0 0.000388591306608
Gc1_496 0 n2 ns496 0 -0.00124104376851
Gc1_497 0 n2 ns497 0 0.0021904046197
Gc1_498 0 n2 ns498 0 0.000197089058777
Gc1_499 0 n2 ns499 0 -0.000132743108579
Gc1_500 0 n2 ns500 0 0.000100173380749
Gc1_501 0 n2 ns501 0 1.62005470996e-05
Gc1_502 0 n2 ns502 0 3.42788373257e-05
Gc1_503 0 n2 ns503 0 -3.71341876206e-05
Gc1_504 0 n2 ns504 0 -0.00139027884195
Gc1_505 0 n2 ns505 0 -5.97099049435e-05
Gc1_506 0 n2 ns506 0 0.000721726433974
Gc1_507 0 n2 ns507 0 -0.000253349841662
Gc1_508 0 n2 ns508 0 -0.000139963795475
Gc1_509 0 n2 ns509 0 -0.000129245774048
Gc1_510 0 n2 ns510 0 -0.00135828236449
Gc1_511 0 n2 ns511 0 -0.000143977027493
Gc1_512 0 n2 ns512 0 0.000462016141988
Gc1_513 0 n2 ns513 0 0.000745554100621
Gc1_514 0 n2 ns514 0 0.000154862583968
Gc1_515 0 n2 ns515 0 -0.00013548006103
Gc1_516 0 n2 ns516 0 -0.000437465366655
Gc1_517 0 n2 ns517 0 0.00129875741441
Gc1_518 0 n2 ns518 0 0.000975987316144
Gc1_519 0 n2 ns519 0 0.000134000959566
Gc1_520 0 n2 ns520 0 -0.000525674657126
Gc1_521 0 n2 ns521 0 -0.00037733066236
Gc1_522 0 n2 ns522 0 -0.000422324690527
Gc1_523 0 n2 ns523 0 0.000821469069162
Gc1_524 0 n2 ns524 0 0.00045718284699
Gc1_525 0 n2 ns525 0 0.00035614201689
Gc1_526 0 n2 ns526 0 9.16336908796e-05
Gc1_527 0 n2 ns527 0 -0.000357192367258
Gc1_528 0 n2 ns528 0 0.00673467172457
Gc1_529 0 n2 ns529 0 -0.00633094803938
Gc1_530 0 n2 ns530 0 0.000319912291809
Gc1_531 0 n2 ns531 0 -7.18067631953e-06
Gc1_532 0 n2 ns532 0 -2.41496337981e-05
Gc1_533 0 n2 ns533 0 -1.62589689252e-05
Gc1_534 0 n2 ns534 0 -0.000147104877545
Gc1_535 0 n2 ns535 0 -0.00141205445599
Gc1_536 0 n2 ns536 0 -9.96408829562e-05
Gc1_537 0 n2 ns537 0 -0.000114632813315
Gc1_538 0 n2 ns538 0 -3.15269535248e-05
Gc1_539 0 n2 ns539 0 -3.52497801085e-05
Gc1_540 0 n2 ns540 0 -1.54046983597e-05
Gc1_541 0 n2 ns541 0 -2.00389190731e-05
Gc1_542 0 n2 ns542 0 4.44857126673e-05
Gc1_543 0 n2 ns543 0 0.0010722571723
Gc1_544 0 n2 ns544 0 -0.000116339163795
Gc1_545 0 n2 ns545 0 -0.000498592913684
Gc1_546 0 n2 ns546 0 -0.000127466901343
Gc1_547 0 n2 ns547 0 5.88972707522e-05
Gc1_548 0 n2 ns548 0 -0.000140004354562
Gc1_549 0 n2 ns549 0 0.000864920101167
Gc1_550 0 n2 ns550 0 0.000517031564892
Gc1_551 0 n2 ns551 0 -0.000165772534612
Gc1_552 0 n2 ns552 0 -3.79475249826e-05
Gc1_553 0 n2 ns553 0 -0.000140296813164
Gc1_554 0 n2 ns554 0 0.00104271291086
Gc1_555 0 n2 ns555 0 0.000659239804754
Gc1_556 0 n2 ns556 0 0.000433042441463
Gc1_557 0 n2 ns557 0 -0.00051977063026
Gc1_558 0 n2 ns558 0 -0.000421222367345
Gc1_559 0 n2 ns559 0 0.000109578495416
Gc1_560 0 n2 ns560 0 0.000996565982955
Gc1_561 0 n2 ns561 0 0.000492334140665
Gc1_562 0 n2 ns562 0 0.000187706286012
Gc1_563 0 n2 ns563 0 -7.35012446705e-05
Gc1_564 0 n2 ns564 0 -5.32693597033e-05
Gc1_565 0 n2 ns565 0 -0.000183241272427
Gc1_566 0 n2 ns566 0 0.0118303382737
Gc1_567 0 n2 ns567 0 -0.0100973020265
Gc1_568 0 n2 ns568 0 0.000365048814215
Gc1_569 0 n2 ns569 0 -7.69676599304e-06
Gc1_570 0 n2 ns570 0 -2.77515509276e-05
Gc1_571 0 n2 ns571 0 -0.00018479303955
Gc1_572 0 n2 ns572 0 0.000784297320609
Gc1_573 0 n2 ns573 0 -0.00342627766061
Gc1_574 0 n2 ns574 0 -0.000320074842777
Gc1_575 0 n2 ns575 0 -0.000100277632423
Gc1_576 0 n2 ns576 0 -0.000213455908606
Gc1_577 0 n2 ns577 0 0.000115621434758
Gc1_578 0 n2 ns578 0 1.66216521863e-05
Gc1_579 0 n2 ns579 0 3.81250332662e-05
Gc1_580 0 n2 ns580 0 0.0011963870842
Gc1_581 0 n2 ns581 0 0.000731393617759
Gc1_582 0 n2 ns582 0 -0.000527558898288
Gc1_583 0 n2 ns583 0 -0.00010655369662
Gc1_584 0 n2 ns584 0 -3.24656322854e-05
Gc1_585 0 n2 ns585 0 0.000122954727921
Gc1_586 0 n2 ns586 0 0.000450811998566
Gc1_587 0 n2 ns587 0 0.000563557208859
Gc1_588 0 n2 ns588 0 0.000166874472906
Gc1_589 0 n2 ns589 0 -0.000324464389711
Gc1_590 0 n2 ns590 0 -6.50879558848e-05
Gc1_591 0 n2 ns591 0 -5.12877720013e-05
Gc1_592 0 n2 ns592 0 0.00110386646316
Gc1_593 0 n2 ns593 0 0.000315234441941
Gc1_594 0 n2 ns594 0 0.000170639791779
Gc1_595 0 n2 ns595 0 -0.000496836016267
Gc1_596 0 n2 ns596 0 -0.000253132230739
Gc1_597 0 n2 ns597 0 0.000177270770389
Gc1_598 0 n2 ns598 0 0.00150428320629
Gc1_599 0 n2 ns599 0 0.000779261880382
Gc1_600 0 n2 ns600 0 0.000157132237445
Gc1_601 0 n2 ns601 0 -0.000380094905216
Gc1_602 0 n2 ns602 0 -0.000147060226121
Gc1_603 0 n2 ns603 0 -0.000116286423695
Gc1_604 0 n2 ns604 0 0.0152423432573
Gc1_605 0 n2 ns605 0 -0.0128703971533
Gc1_606 0 n2 ns606 0 0.000447789066889
Gc1_607 0 n2 ns607 0 -8.14280552524e-06
Gc1_608 0 n2 ns608 0 -2.24330716995e-05
Gc1_609 0 n2 ns609 0 -0.0180265580163
Gc1_610 0 n2 ns610 0 -0.00349072231366
Gc1_611 0 n2 ns611 0 0.0153250825253
Gc1_612 0 n2 ns612 0 0.00896009738304
Gc1_613 0 n2 ns613 0 0.0084776235365
Gc1_614 0 n2 ns614 0 -0.000534323718799
Gc1_615 0 n2 ns615 0 -0.00314493922703
Gc1_616 0 n2 ns616 0 -0.000261234580909
Gc1_617 0 n2 ns617 0 0.000225006801374
Gc1_618 0 n2 ns618 0 -0.00378565075058
Gc1_619 0 n2 ns619 0 -0.00900278855543
Gc1_620 0 n2 ns620 0 0.00114627468121
Gc1_621 0 n2 ns621 0 0.000327282459073
Gc1_622 0 n2 ns622 0 4.49589847891e-05
Gc1_623 0 n2 ns623 0 -0.00015684806093
Gc1_624 0 n2 ns624 0 0.0018765400682
Gc1_625 0 n2 ns625 0 0.0018733591159
Gc1_626 0 n2 ns626 0 0.000722765181866
Gc1_627 0 n2 ns627 0 0.000237381230471
Gc1_628 0 n2 ns628 0 0.000218351945881
Gc1_629 0 n2 ns629 0 0.000209203526475
Gc1_630 0 n2 ns630 0 -0.0097701785065
Gc1_631 0 n2 ns631 0 -0.00163485888535
Gc1_632 0 n2 ns632 0 -0.00204987944861
Gc1_633 0 n2 ns633 0 -0.00126423301061
Gc1_634 0 n2 ns634 0 -0.00050169258309
Gc1_635 0 n2 ns635 0 0.00115838868004
Gc1_636 0 n2 ns636 0 0.0165156809902
Gc1_637 0 n2 ns637 0 -0.000453536907902
Gc1_638 0 n2 ns638 0 0.00345497917984
Gc1_639 0 n2 ns639 0 -0.00181899098233
Gc1_640 0 n2 ns640 0 0.00154026757444
Gc1_641 0 n2 ns641 0 0.000125427972628
Gc1_642 0 n2 ns642 0 -0.036094543293
Gc1_643 0 n2 ns643 0 0.0065998762421
Gc1_644 0 n2 ns644 0 -0.00617619211375
Gc1_645 0 n2 ns645 0 -5.07330061741e-06
Gc1_646 0 n2 ns646 0 1.64671005439e-05
Gc1_647 0 n2 ns647 0 -0.00530706947167
Gc1_648 0 n2 ns648 0 -0.00333619431298
Gc1_649 0 n2 ns649 0 -0.00261596929007
Gc1_650 0 n2 ns650 0 0.00204028687946
Gc1_651 0 n2 ns651 0 -0.00349286677932
Gc1_652 0 n2 ns652 0 0.000354319164772
Gc1_653 0 n2 ns653 0 0.00329543518742
Gc1_654 0 n2 ns654 0 0.000134235803506
Gc1_655 0 n2 ns655 0 -0.000308458754037
Gc1_656 0 n2 ns656 0 -0.001164208219
Gc1_657 0 n2 ns657 0 0.002896643218
Gc1_658 0 n2 ns658 0 -0.000965050640889
Gc1_659 0 n2 ns659 0 -0.00027342008985
Gc1_660 0 n2 ns660 0 -0.000276763827937
Gc1_661 0 n2 ns661 0 6.0375934999e-05
Gc1_662 0 n2 ns662 0 0.00345291648484
Gc1_663 0 n2 ns663 0 -0.00169584272566
Gc1_664 0 n2 ns664 0 -8.57637886705e-06
Gc1_665 0 n2 ns665 0 -0.000799784744456
Gc1_666 0 n2 ns666 0 -9.25118383279e-05
Gc1_667 0 n2 ns667 0 9.23403771453e-05
Gc1_668 0 n2 ns668 0 0.00534950046013
Gc1_669 0 n2 ns669 0 0.00561418459241
Gc1_670 0 n2 ns670 0 -4.26810200204e-05
Gc1_671 0 n2 ns671 0 -0.00240103773767
Gc1_672 0 n2 ns672 0 -0.00165296020468
Gc1_673 0 n2 ns673 0 0.000799362217402
Gc1_674 0 n2 ns674 0 -0.00706696301084
Gc1_675 0 n2 ns675 0 0.000734788525824
Gc1_676 0 n2 ns676 0 0.00355024022712
Gc1_677 0 n2 ns677 0 -0.000168145294993
Gc1_678 0 n2 ns678 0 0.00212974836304
Gc1_679 0 n2 ns679 0 0.0004047433961
Gc1_680 0 n2 ns680 0 0.0849863960317
Gc1_681 0 n2 ns681 0 -0.0659016340308
Gc1_682 0 n2 ns682 0 -0.00596267470493
Gc1_683 0 n2 ns683 0 -6.45115290794e-06
Gc1_684 0 n2 ns684 0 2.4058873172e-05
Gc1_685 0 n2 ns685 0 0.000238164966968
Gc1_686 0 n2 ns686 0 -0.000306058177975
Gc1_687 0 n2 ns687 0 0.00744982398141
Gc1_688 0 n2 ns688 0 -9.85835891715e-05
Gc1_689 0 n2 ns689 0 -6.77607298049e-05
Gc1_690 0 n2 ns690 0 0.000257048210048
Gc1_691 0 n2 ns691 0 -0.000756561529783
Gc1_692 0 n2 ns692 0 -0.000134401544335
Gc1_693 0 n2 ns693 0 1.61122720537e-05
Gc1_694 0 n2 ns694 0 0.00186912274241
Gc1_695 0 n2 ns695 0 -0.00170423561524
Gc1_696 0 n2 ns696 0 -0.000449139785362
Gc1_697 0 n2 ns697 0 0.000757395548231
Gc1_698 0 n2 ns698 0 -0.000259230763417
Gc1_699 0 n2 ns699 0 0.000210606291351
Gc1_700 0 n2 ns700 0 -0.00224146443393
Gc1_701 0 n2 ns701 0 -0.00175399593162
Gc1_702 0 n2 ns702 0 0.000123162431979
Gc1_703 0 n2 ns703 0 0.000152705424009
Gc1_704 0 n2 ns704 0 0.000249763588129
Gc1_705 0 n2 ns705 0 0.000320189428869
Gc1_706 0 n2 ns706 0 -0.000286076495174
Gc1_707 0 n2 ns707 0 -0.00556459495878
Gc1_708 0 n2 ns708 0 -0.00204990641236
Gc1_709 0 n2 ns709 0 0.000798504874023
Gc1_710 0 n2 ns710 0 0.000214292778759
Gc1_711 0 n2 ns711 0 0.000994372096457
Gc1_712 0 n2 ns712 0 -0.00777587844577
Gc1_713 0 n2 ns713 0 -0.00317454079459
Gc1_714 0 n2 ns714 0 -0.0021856677628
Gc1_715 0 n2 ns715 0 0.000912786113284
Gc1_716 0 n2 ns716 0 0.00223372783824
Gc1_717 0 n2 ns717 0 0.000665559292174
Gc1_718 0 n2 ns718 0 -0.0776557581053
Gc1_719 0 n2 ns719 0 0.0720926719855
Gc1_720 0 n2 ns720 0 -0.00506663173833
Gc1_721 0 n2 ns721 0 -6.68404319144e-06
Gc1_722 0 n2 ns722 0 2.33535343803e-05
Gc1_723 0 n2 ns723 0 0.000363916227904
Gc1_724 0 n2 ns724 0 -0.00123676237825
Gc1_725 0 n2 ns725 0 0.00845544188799
Gc1_726 0 n2 ns726 0 0.000501759540324
Gc1_727 0 n2 ns727 0 -0.000156569972188
Gc1_728 0 n2 ns728 0 -9.84943351859e-05
Gc1_729 0 n2 ns729 0 0.000171715317802
Gc1_730 0 n2 ns730 0 -1.00906922758e-05
Gc1_731 0 n2 ns731 0 4.93546296831e-05
Gc1_732 0 n2 ns732 0 -0.00136670342082
Gc1_733 0 n2 ns733 0 -0.00283695821202
Gc1_734 0 n2 ns734 0 0.000836728827495
Gc1_735 0 n2 ns735 0 0.000700080286394
Gc1_736 0 n2 ns736 0 1.97187589134e-05
Gc1_737 0 n2 ns737 0 0.000214884769774
Gc1_738 0 n2 ns738 0 0.000227720401963
Gc1_739 0 n2 ns739 0 0.000809025595879
Gc1_740 0 n2 ns740 0 -0.00057071176762
Gc1_741 0 n2 ns741 0 -0.000960060717786
Gc1_742 0 n2 ns742 0 6.62209764942e-05
Gc1_743 0 n2 ns743 0 0.000111387822716
Gc1_744 0 n2 ns744 0 -0.00247178253293
Gc1_745 0 n2 ns745 0 -0.00298107035381
Gc1_746 0 n2 ns746 0 9.85771703762e-05
Gc1_747 0 n2 ns747 0 -1.55764664478e-05
Gc1_748 0 n2 ns748 0 -0.000279418851707
Gc1_749 0 n2 ns749 0 0.000823625092065
Gc1_750 0 n2 ns750 0 -0.00568300686701
Gc1_751 0 n2 ns751 0 -0.00472887526539
Gc1_752 0 n2 ns752 0 -0.00189543514258
Gc1_753 0 n2 ns753 0 0.00314118792164
Gc1_754 0 n2 ns754 0 0.00190874251753
Gc1_755 0 n2 ns755 0 -0.000105783741928
Gc1_756 0 n2 ns756 0 -0.0526768183237
Gc1_757 0 n2 ns757 0 0.0456758025983
Gc1_758 0 n2 ns758 0 -0.00207812608758
Gc1_759 0 n2 ns759 0 -7.3717364688e-06
Gc1_760 0 n2 ns760 0 1.64494205561e-05
Gc1_761 0 n2 ns761 0 -2.71986337571e-05
Gc1_762 0 n2 ns762 0 0.000227550246466
Gc1_763 0 n2 ns763 0 0.00410305792037
Gc1_764 0 n2 ns764 0 -7.13559662843e-05
Gc1_765 0 n2 ns765 0 0.000297431898097
Gc1_766 0 n2 ns766 0 0.000423961375044
Gc1_767 0 n2 ns767 0 -1.26930636961e-05
Gc1_768 0 n2 ns768 0 3.36355321085e-05
Gc1_769 0 n2 ns769 0 -4.25299907397e-05
Gc1_770 0 n2 ns770 0 -0.000485318872929
Gc1_771 0 n2 ns771 0 -0.00010234608775
Gc1_772 0 n2 ns772 0 0.000224357135517
Gc1_773 0 n2 ns773 0 -0.00062101621579
Gc1_774 0 n2 ns774 0 -4.91820377405e-05
Gc1_775 0 n2 ns775 0 0.000205064563604
Gc1_776 0 n2 ns776 0 0.00146395136684
Gc1_777 0 n2 ns777 0 -0.00145471632619
Gc1_778 0 n2 ns778 0 -0.00148609344155
Gc1_779 0 n2 ns779 0 0.000155962208688
Gc1_780 0 n2 ns780 0 0.000114605239563
Gc1_781 0 n2 ns781 0 0.000192702773166
Gc1_782 0 n2 ns782 0 -0.000842565584372
Gc1_783 0 n2 ns783 0 -0.00137838478688
Gc1_784 0 n2 ns784 0 -0.000584034960699
Gc1_785 0 n2 ns785 0 -0.00131394527406
Gc1_786 0 n2 ns786 0 3.66331506063e-06
Gc1_787 0 n2 ns787 0 0.0012676226793
Gc1_788 0 n2 ns788 0 -0.00514453692879
Gc1_789 0 n2 ns789 0 -0.00356667947376
Gc1_790 0 n2 ns790 0 -0.000171285104385
Gc1_791 0 n2 ns791 0 0.00289548507898
Gc1_792 0 n2 ns792 0 0.00115439566456
Gc1_793 0 n2 ns793 0 -0.00053546473801
Gc1_794 0 n2 ns794 0 -0.0257972956328
Gc1_795 0 n2 ns795 0 0.0214797784825
Gc1_796 0 n2 ns796 0 -0.000820797591125
Gc1_797 0 n2 ns797 0 -1.28331740739e-06
Gc1_798 0 n2 ns798 0 3.29738754613e-06
Gc1_799 0 n2 ns799 0 0.000200438139131
Gc1_800 0 n2 ns800 0 -0.000757732624146
Gc1_801 0 n2 ns801 0 0.00393265963222
Gc1_802 0 n2 ns802 0 0.000210099959161
Gc1_803 0 n2 ns803 0 0.000166374015887
Gc1_804 0 n2 ns804 0 0.000124571205066
Gc1_805 0 n2 ns805 0 -0.000184132702434
Gc1_806 0 n2 ns806 0 -5.34143589946e-05
Gc1_807 0 n2 ns807 0 -4.42911409875e-05
Gc1_808 0 n2 ns808 0 0.000838584411166
Gc1_809 0 n2 ns809 0 -0.000824352427934
Gc1_810 0 n2 ns810 0 -0.000765168770082
Gc1_811 0 n2 ns811 0 3.975073105e-05
Gc1_812 0 n2 ns812 0 0.000145851666766
Gc1_813 0 n2 ns813 0 0.000282381542014
Gc1_814 0 n2 ns814 0 -0.000690888325572
Gc1_815 0 n2 ns815 0 -0.00170433415358
Gc1_816 0 n2 ns816 0 -0.00036461707034
Gc1_817 0 n2 ns817 0 0.00105371253092
Gc1_818 0 n2 ns818 0 0.000218178970689
Gc1_819 0 n2 ns819 0 -2.72165187139e-06
Gc1_820 0 n2 ns820 0 -0.000400773610257
Gc1_821 0 n2 ns821 0 -0.00108979795265
Gc1_822 0 n2 ns822 0 -0.00126246593794
Gc1_823 0 n2 ns823 0 -0.000626908906676
Gc1_824 0 n2 ns824 0 0.000572091754971
Gc1_825 0 n2 ns825 0 0.000855620198901
Gc1_826 0 n2 ns826 0 -0.0044591620955
Gc1_827 0 n2 ns827 0 -0.00124602934808
Gc1_828 0 n2 ns828 0 0.000686161230864
Gc1_829 0 n2 ns829 0 0.00180702155359
Gc1_830 0 n2 ns830 0 0.000586299403634
Gc1_831 0 n2 ns831 0 -0.000558004649855
Gc1_832 0 n2 ns832 0 -0.0129491270033
Gc1_833 0 n2 ns833 0 0.0102382339243
Gc1_834 0 n2 ns834 0 -0.00034004248357
Gc1_835 0 n2 ns835 0 6.48164647754e-06
Gc1_836 0 n2 ns836 0 -1.53887093845e-05
Gc1_837 0 n2 ns837 0 4.83624580698e-05
Gc1_838 0 n2 ns838 0 -0.00042064270467
Gc1_839 0 n2 ns839 0 0.000853666382236
Gc1_840 0 n2 ns840 0 -0.000128023029667
Gc1_841 0 n2 ns841 0 0.00016946924113
Gc1_842 0 n2 ns842 0 7.1326159824e-06
Gc1_843 0 n2 ns843 0 0.000128118457473
Gc1_844 0 n2 ns844 0 5.86351804058e-06
Gc1_845 0 n2 ns845 0 1.60241632952e-05
Gc1_846 0 n2 ns846 0 0.000434511643892
Gc1_847 0 n2 ns847 0 -0.00144655752405
Gc1_848 0 n2 ns848 0 -0.000283832432225
Gc1_849 0 n2 ns849 0 0.000800036532437
Gc1_850 0 n2 ns850 0 0.000272261726803
Gc1_851 0 n2 ns851 0 6.00295798915e-05
Gc1_852 0 n2 ns852 0 -0.000767024371255
Gc1_853 0 n2 ns853 0 9.99267553694e-05
Gc1_854 0 n2 ns854 0 0.000505903151179
Gc1_855 0 n2 ns855 0 0.000283730601734
Gc1_856 0 n2 ns856 0 3.56562401116e-05
Gc1_857 0 n2 ns857 0 -0.000170847419193
Gc1_858 0 n2 ns858 0 0.000256238309056
Gc1_859 0 n2 ns859 0 -0.000779769298499
Gc1_860 0 n2 ns860 0 -0.000874555380112
Gc1_861 0 n2 ns861 0 -4.72735640975e-05
Gc1_862 0 n2 ns862 0 0.000482381249919
Gc1_863 0 n2 ns863 0 0.000295220469277
Gc1_864 0 n2 ns864 0 -0.0014162856686
Gc1_865 0 n2 ns865 0 0.00016293961451
Gc1_866 0 n2 ns866 0 0.000496620773836
Gc1_867 0 n2 ns867 0 0.000510103291007
Gc1_868 0 n2 ns868 0 0.000125415733803
Gc1_869 0 n2 ns869 0 -0.000316933507918
Gc1_870 0 n2 ns870 0 0.000298484977994
Gc1_871 0 n2 ns871 0 -0.00042027257305
Gc1_872 0 n2 ns872 0 -3.71072447984e-05
Gc1_873 0 n2 ns873 0 7.43656465997e-06
Gc1_874 0 n2 ns874 0 -2.56256188981e-05
Gc1_875 0 n2 ns875 0 -3.72960112869e-05
Gc1_876 0 n2 ns876 0 -0.000100302567538
Gc1_877 0 n2 ns877 0 -0.00105602807218
Gc1_878 0 n2 ns878 0 -0.000181926992196
Gc1_879 0 n2 ns879 0 8.12786634995e-05
Gc1_880 0 n2 ns880 0 4.60607081542e-05
Gc1_881 0 n2 ns881 0 0.000164531337302
Gc1_882 0 n2 ns882 0 3.85439773847e-05
Gc1_883 0 n2 ns883 0 -1.80476350396e-05
Gc1_884 0 n2 ns884 0 -0.00040420080965
Gc1_885 0 n2 ns885 0 -9.91009737585e-05
Gc1_886 0 n2 ns886 0 0.000316878720132
Gc1_887 0 n2 ns887 0 0.000209703010596
Gc1_888 0 n2 ns888 0 5.25464408033e-05
Gc1_889 0 n2 ns889 0 -0.000132631482903
Gc1_890 0 n2 ns890 0 4.79181596586e-05
Gc1_891 0 n2 ns891 0 0.000780047386264
Gc1_892 0 n2 ns892 0 0.00039339833363
Gc1_893 0 n2 ns893 0 -0.000287378471222
Gc1_894 0 n2 ns894 0 -7.45674308908e-05
Gc1_895 0 n2 ns895 0 -0.000114695410796
Gc1_896 0 n2 ns896 0 0.000403974650953
Gc1_897 0 n2 ns897 0 -0.00013534005346
Gc1_898 0 n2 ns898 0 -0.000215302464038
Gc1_899 0 n2 ns899 0 9.19843914991e-05
Gc1_900 0 n2 ns900 0 0.000158399689932
Gc1_901 0 n2 ns901 0 -1.7169471099e-05
Gc1_902 0 n2 ns902 0 0.000517477112601
Gc1_903 0 n2 ns903 0 0.00101317930725
Gc1_904 0 n2 ns904 0 0.000328755547398
Gc1_905 0 n2 ns905 0 -0.000188424229864
Gc1_906 0 n2 ns906 0 -9.00224478641e-05
Gc1_907 0 n2 ns907 0 -0.000190837067344
Gc1_908 0 n2 ns908 0 0.0101784710494
Gc1_909 0 n2 ns909 0 -0.0085931427806
Gc1_910 0 n2 ns910 0 0.000227211724528
Gc1_911 0 n2 ns911 0 5.52056226271e-06
Gc1_912 0 n2 ns912 0 -2.74750922198e-05
Gc1_913 0 n2 ns913 0 1.20572549388e-05
Gc1_914 0 n2 ns914 0 -0.000583665296615
Gc1_915 0 n2 ns915 0 -0.00034991586854
Gc1_916 0 n2 ns916 0 7.36256912526e-05
Gc1_917 0 n2 ns917 0 -0.00026398098563
Gc1_918 0 n2 ns918 0 -0.000174277043256
Gc1_919 0 n2 ns919 0 3.93374363132e-06
Gc1_920 0 n2 ns920 0 2.66623294721e-05
Gc1_921 0 n2 ns921 0 6.14130860949e-06
Gc1_922 0 n2 ns922 0 -0.000242720140228
Gc1_923 0 n2 ns923 0 0.000927433344808
Gc1_924 0 n2 ns924 0 0.000132157877207
Gc1_925 0 n2 ns925 0 -0.000312482299327
Gc1_926 0 n2 ns926 0 -0.000101116077774
Gc1_927 0 n2 ns927 0 -7.51427442636e-05
Gc1_928 0 n2 ns928 0 0.000288861214491
Gc1_929 0 n2 ns929 0 0.000476858146411
Gc1_930 0 n2 ns930 0 0.000108054359119
Gc1_931 0 n2 ns931 0 -0.0002577879308
Gc1_932 0 n2 ns932 0 -5.73589308066e-05
Gc1_933 0 n2 ns933 0 -2.82854219693e-05
Gc1_934 0 n2 ns934 0 0.00018153963861
Gc1_935 0 n2 ns935 0 0.000156643712673
Gc1_936 0 n2 ns936 0 6.03496001358e-05
Gc1_937 0 n2 ns937 0 7.51819494988e-05
Gc1_938 0 n2 ns938 0 3.80333677881e-06
Gc1_939 0 n2 ns939 0 -7.96014331366e-05
Gc1_940 0 n2 ns940 0 0.000629693865621
Gc1_941 0 n2 ns941 0 0.000837977552265
Gc1_942 0 n2 ns942 0 0.000180313916352
Gc1_943 0 n2 ns943 0 -0.000241889334158
Gc1_944 0 n2 ns944 0 -9.12018903104e-05
Gc1_945 0 n2 ns945 0 -0.00010066717747
Gc1_946 0 n2 ns946 0 0.00736322056135
Gc1_947 0 n2 ns947 0 -0.00612378773661
Gc1_948 0 n2 ns948 0 0.000136436873234
Gc1_949 0 n2 ns949 0 7.75428186231e-06
Gc1_950 0 n2 ns950 0 -2.45786121726e-05
Gc1_951 0 n2 ns951 0 -0.000510052168009
Gc1_952 0 n2 ns952 0 0.000610103585071
Gc1_953 0 n2 ns953 0 0.00191981765122
Gc1_954 0 n2 ns954 0 -0.00119146723393
Gc1_955 0 n2 ns955 0 -0.000825370459661
Gc1_956 0 n2 ns956 0 0.00159872702005
Gc1_957 0 n2 ns957 0 0.000206726226286
Gc1_958 0 n2 ns958 0 -0.000189183047443
Gc1_959 0 n2 ns959 0 -0.000189560914587
Gc1_960 0 n2 ns960 0 0.00240856057205
Gc1_961 0 n2 ns961 0 -0.000439048604939
Gc1_962 0 n2 ns962 0 -0.000885240267838
Gc1_963 0 n2 ns963 0 0.000642009281255
Gc1_964 0 n2 ns964 0 -0.000275417088238
Gc1_965 0 n2 ns965 0 0.000168722387361
Gc1_966 0 n2 ns966 0 -0.0012335922242
Gc1_967 0 n2 ns967 0 -0.00317996955883
Gc1_968 0 n2 ns968 0 -7.08923717423e-05
Gc1_969 0 n2 ns969 0 0.000296388543985
Gc1_970 0 n2 ns970 0 0.000177576517218
Gc1_971 0 n2 ns971 0 0.000386270518387
Gc1_972 0 n2 ns972 0 0.00192813716021
Gc1_973 0 n2 ns973 0 -0.00390790921804
Gc1_974 0 n2 ns974 0 -0.00222687320643
Gc1_975 0 n2 ns975 0 5.30194020952e-05
Gc1_976 0 n2 ns976 0 -9.44980866976e-05
Gc1_977 0 n2 ns977 0 0.00110097673615
Gc1_978 0 n2 ns978 0 -0.00847033515301
Gc1_979 0 n2 ns979 0 -0.00226853829839
Gc1_980 0 n2 ns980 0 -0.000863864862055
Gc1_981 0 n2 ns981 0 0.000348004834581
Gc1_982 0 n2 ns982 0 0.00231172502023
Gc1_983 0 n2 ns983 0 0.000770442668941
Gc1_984 0 n2 ns984 0 -0.0446997515813
Gc1_985 0 n2 ns985 0 0.0455628224256
Gc1_986 0 n2 ns986 0 -0.00596936419062
Gc1_987 0 n2 ns987 0 -5.60892777655e-06
Gc1_988 0 n2 ns988 0 2.89574669795e-05
Gc1_989 0 n2 ns989 0 0.000655910732636
Gc1_990 0 n2 ns990 0 -0.00058990306727
Gc1_991 0 n2 ns991 0 0.00933447614681
Gc1_992 0 n2 ns992 0 0.000321397062183
Gc1_993 0 n2 ns993 0 0.000221876262854
Gc1_994 0 n2 ns994 0 5.34618942947e-05
Gc1_995 0 n2 ns995 0 -0.000185151499379
Gc1_996 0 n2 ns996 0 -0.000115440088917
Gc1_997 0 n2 ns997 0 3.40676067498e-05
Gc1_998 0 n2 ns998 0 -0.000610581821866
Gc1_999 0 n2 ns999 0 -0.00374187720929
Gc1_1000 0 n2 ns1000 0 0.000612744247598
Gc1_1001 0 n2 ns1001 0 0.00117588279017
Gc1_1002 0 n2 ns1002 0 -1.83297038888e-05
Gc1_1003 0 n2 ns1003 0 0.000219487589042
Gc1_1004 0 n2 ns1004 0 -0.00119397839861
Gc1_1005 0 n2 ns1005 0 0.000561400033906
Gc1_1006 0 n2 ns1006 0 -6.95606154595e-05
Gc1_1007 0 n2 ns1007 0 -0.000769647685281
Gc1_1008 0 n2 ns1008 0 0.000149665500735
Gc1_1009 0 n2 ns1009 0 0.000146148878148
Gc1_1010 0 n2 ns1010 0 -0.00266048669789
Gc1_1011 0 n2 ns1011 0 -0.00410630772157
Gc1_1012 0 n2 ns1012 0 -0.000316677456263
Gc1_1013 0 n2 ns1013 0 0.000698752204456
Gc1_1014 0 n2 ns1014 0 -0.000121211198649
Gc1_1015 0 n2 ns1015 0 0.000699398530676
Gc1_1016 0 n2 ns1016 0 -0.00654969552332
Gc1_1017 0 n2 ns1017 0 -0.00455563797337
Gc1_1018 0 n2 ns1018 0 -0.0023111922948
Gc1_1019 0 n2 ns1019 0 0.00276571152643
Gc1_1020 0 n2 ns1020 0 0.00214430244477
Gc1_1021 0 n2 ns1021 0 0.000121938945674
Gc1_1022 0 n2 ns1022 0 -0.0656767813026
Gc1_1023 0 n2 ns1023 0 0.0578654681541
Gc1_1024 0 n2 ns1024 0 -0.00292574468234
Gc1_1025 0 n2 ns1025 0 -7.37927316647e-06
Gc1_1026 0 n2 ns1026 0 2.02710246179e-05
Gc1_1027 0 n2 ns1027 0 -5.15869973574e-06
Gc1_1028 0 n2 ns1028 0 4.28397220979e-05
Gc1_1029 0 n2 ns1029 0 0.00514215050581
Gc1_1030 0 n2 ns1030 0 9.62455897171e-05
Gc1_1031 0 n2 ns1031 0 0.000164564972237
Gc1_1032 0 n2 ns1032 0 0.000373186725309
Gc1_1033 0 n2 ns1033 0 0.000129295599093
Gc1_1034 0 n2 ns1034 0 3.66578594316e-05
Gc1_1035 0 n2 ns1035 0 -7.06692446338e-06
Gc1_1036 0 n2 ns1036 0 -0.00139159676946
Gc1_1037 0 n2 ns1037 0 -0.000919662077835
Gc1_1038 0 n2 ns1038 0 0.000798876200266
Gc1_1039 0 n2 ns1039 0 -0.000299213964218
Gc1_1040 0 n2 ns1040 0 -3.93495458552e-05
Gc1_1041 0 n2 ns1041 0 0.000158507918679
Gc1_1042 0 n2 ns1042 0 0.00169812723242
Gc1_1043 0 n2 ns1043 0 -0.0006082618588
Gc1_1044 0 n2 ns1044 0 -0.00149878526861
Gc1_1045 0 n2 ns1045 0 -0.000438657827677
Gc1_1046 0 n2 ns1046 0 5.93689569548e-05
Gc1_1047 0 n2 ns1047 0 0.00020719043195
Gc1_1048 0 n2 ns1048 0 -0.00143973531372
Gc1_1049 0 n2 ns1049 0 -0.00177427791712
Gc1_1050 0 n2 ns1050 0 -0.000212883666569
Gc1_1051 0 n2 ns1051 0 -0.00114196545588
Gc1_1052 0 n2 ns1052 0 -0.000196320763946
Gc1_1053 0 n2 ns1053 0 0.0012376049314
Gc1_1054 0 n2 ns1054 0 -0.00545118382634
Gc1_1055 0 n2 ns1055 0 -0.00419784672663
Gc1_1056 0 n2 ns1056 0 -0.000665853552087
Gc1_1057 0 n2 ns1057 0 0.00319507844794
Gc1_1058 0 n2 ns1058 0 0.00142896623169
Gc1_1059 0 n2 ns1059 0 -0.000467446941801
Gc1_1060 0 n2 ns1060 0 -0.0333452989406
Gc1_1061 0 n2 ns1061 0 0.0281380980079
Gc1_1062 0 n2 ns1062 0 -0.00113530865605
Gc1_1063 0 n2 ns1063 0 -4.61426435659e-06
Gc1_1064 0 n2 ns1064 0 1.20770613851e-05
Gc1_1065 0 n2 ns1065 0 0.000119701350384
Gc1_1066 0 n2 ns1066 0 -0.000583829193982
Gc1_1067 0 n2 ns1067 0 0.00436627488441
Gc1_1068 0 n2 ns1068 0 0.000196216531668
Gc1_1069 0 n2 ns1069 0 0.000166713552939
Gc1_1070 0 n2 ns1070 0 0.000210015918259
Gc1_1071 0 n2 ns1071 0 -0.000166842908655
Gc1_1072 0 n2 ns1072 0 -1.76778618549e-05
Gc1_1073 0 n2 ns1073 0 -7.05095910387e-05
Gc1_1074 0 n2 ns1074 0 0.00061954144989
Gc1_1075 0 n2 ns1075 0 -0.000245764669172
Gc1_1076 0 n2 ns1076 0 -0.000593044606016
Gc1_1077 0 n2 ns1077 0 -0.000434662115856
Gc1_1078 0 n2 ns1078 0 2.87570029448e-05
Gc1_1079 0 n2 ns1079 0 0.000305717880976
Gc1_1080 0 n2 ns1080 0 2.7492117012e-05
Gc1_1081 0 n2 ns1081 0 -0.00210552016936
Gc1_1082 0 n2 ns1082 0 -0.000919404169326
Gc1_1083 0 n2 ns1083 0 0.000990258865021
Gc1_1084 0 n2 ns1084 0 0.000229454248885
Gc1_1085 0 n2 ns1085 0 9.82616475041e-05
Gc1_1086 0 n2 ns1086 0 -0.000590585498231
Gc1_1087 0 n2 ns1087 0 -0.00114812772985
Gc1_1088 0 n2 ns1088 0 -0.00114756130702
Gc1_1089 0 n2 ns1089 0 -0.00093514924223
Gc1_1090 0 n2 ns1090 0 0.000440390778462
Gc1_1091 0 n2 ns1091 0 0.00106002289664
Gc1_1092 0 n2 ns1092 0 -0.00495391959691
Gc1_1093 0 n2 ns1093 0 -0.00215376493985
Gc1_1094 0 n2 ns1094 0 0.000443156141042
Gc1_1095 0 n2 ns1095 0 0.00223557349349
Gc1_1096 0 n2 ns1096 0 0.00077118810302
Gc1_1097 0 n2 ns1097 0 -0.000553252577896
Gc1_1098 0 n2 ns1098 0 -0.0189602137453
Gc1_1099 0 n2 ns1099 0 0.0153910468863
Gc1_1100 0 n2 ns1100 0 -0.000530494175546
Gc1_1101 0 n2 ns1101 0 3.58352914052e-06
Gc1_1102 0 n2 ns1102 0 -6.40187277656e-06
Gc1_1103 0 n2 ns1103 0 0.000110361364303
Gc1_1104 0 n2 ns1104 0 -0.000915544776717
Gc1_1105 0 n2 ns1105 0 0.00255322924539
Gc1_1106 0 n2 ns1106 0 0.00010729838438
Gc1_1107 0 n2 ns1107 0 8.92101358344e-05
Gc1_1108 0 n2 ns1108 0 -3.85975714054e-05
Gc1_1109 0 n2 ns1109 0 -1.78932412081e-05
Gc1_1110 0 n2 ns1110 0 -2.61399520587e-05
Gc1_1111 0 n2 ns1111 0 1.3487996764e-05
Gc1_1112 0 n2 ns1112 0 0.000705242146536
Gc1_1113 0 n2 ns1113 0 -0.00145934828356
Gc1_1114 0 n2 ns1114 0 -0.00060452061915
Gc1_1115 0 n2 ns1115 0 0.000671927094803
Gc1_1116 0 n2 ns1116 0 0.000279644514331
Gc1_1117 0 n2 ns1117 0 0.000175177123966
Gc1_1118 0 n2 ns1118 0 -0.00102509042627
Gc1_1119 0 n2 ns1119 0 -0.000543820334554
Gc1_1120 0 n2 ns1120 0 0.000334680215679
Gc1_1121 0 n2 ns1121 0 0.000657209756469
Gc1_1122 0 n2 ns1122 0 0.000115612513833
Gc1_1123 0 n2 ns1123 0 -0.000144794083372
Gc1_1124 0 n2 ns1124 0 -2.04910071887e-05
Gc1_1125 0 n2 ns1125 0 -0.000996150664029
Gc1_1126 0 n2 ns1126 0 -0.00114033152468
Gc1_1127 0 n2 ns1127 0 -0.000173843995471
Gc1_1128 0 n2 ns1128 0 0.000605219389695
Gc1_1129 0 n2 ns1129 0 0.000483932748668
Gc1_1130 0 n2 ns1130 0 -0.00274603905424
Gc1_1131 0 n2 ns1131 0 -0.00032811205751
Gc1_1132 0 n2 ns1132 0 0.000624823888588
Gc1_1133 0 n2 ns1133 0 0.000989563380807
Gc1_1134 0 n2 ns1134 0 0.000277608116998
Gc1_1135 0 n2 ns1135 0 -0.000408220590111
Gc1_1136 0 n2 ns1136 0 -0.00589799172053
Gc1_1137 0 n2 ns1137 0 0.00460401066103
Gc1_1138 0 n2 ns1138 0 -0.000184490968821
Gc1_1139 0 n2 ns1139 0 8.18809317644e-06
Gc1_1140 0 n2 ns1140 0 -2.17812798761e-05
Gc1_1141 0 n2 ns1141 0 -5.89884683948e-05
Gc1_1142 0 n2 ns1142 0 4.01171981489e-05
Gc1_1143 0 n2 ns1143 0 -0.000895810461324
Gc1_1144 0 n2 ns1144 0 -0.000234445188802
Gc1_1145 0 n2 ns1145 0 0.000174814597538
Gc1_1146 0 n2 ns1146 0 5.94687430606e-05
Gc1_1147 0 n2 ns1147 0 0.000203629315447
Gc1_1148 0 n2 ns1148 0 3.75902408916e-05
Gc1_1149 0 n2 ns1149 0 -5.86487360266e-06
Gc1_1150 0 n2 ns1150 0 -0.000167844765286
Gc1_1151 0 n2 ns1151 0 -0.000768517372294
Gc1_1152 0 n2 ns1152 0 0.000174815247081
Gc1_1153 0 n2 ns1153 0 0.000546507410779
Gc1_1154 0 n2 ns1154 0 0.000164118920504
Gc1_1155 0 n2 ns1155 0 -8.93479722551e-05
Gc1_1156 0 n2 ns1156 0 -0.000241264738401
Gc1_1157 0 n2 ns1157 0 0.000718531568315
Gc1_1158 0 n2 ns1158 0 0.000522169509226
Gc1_1159 0 n2 ns1159 0 -0.000157950043412
Gc1_1160 0 n2 ns1160 0 -5.31803678061e-05
Gc1_1161 0 n2 ns1161 0 -0.000158010226752
Gc1_1162 0 n2 ns1162 0 0.000454572804943
Gc1_1163 0 n2 ns1163 0 -0.000380615047309
Gc1_1164 0 n2 ns1164 0 -0.000449817594937
Gc1_1165 0 n2 ns1165 0 5.84124432969e-05
Gc1_1166 0 n2 ns1166 0 0.000274653919003
Gc1_1167 0 n2 ns1167 0 7.67410591125e-05
Gc1_1168 0 n2 ns1168 0 5.90610543245e-05
Gc1_1169 0 n2 ns1169 0 0.00082363328735
Gc1_1170 0 n2 ns1170 0 0.000384989813569
Gc1_1171 0 n2 ns1171 0 -1.95806114775e-05
Gc1_1172 0 n2 ns1172 0 -3.95162457172e-05
Gc1_1173 0 n2 ns1173 0 -0.000230667435521
Gc1_1174 0 n2 ns1174 0 0.00851741545797
Gc1_1175 0 n2 ns1175 0 -0.00725741123885
Gc1_1176 0 n2 ns1176 0 0.000190635323925
Gc1_1177 0 n2 ns1177 0 6.17193741091e-06
Gc1_1178 0 n2 ns1178 0 -2.7879566549e-05
Gc1_1179 0 n2 ns1179 0 6.44857767904e-05
Gc1_1180 0 n2 ns1180 0 -0.000423471843502
Gc1_1181 0 n2 ns1181 0 -0.000512170820532
Gc1_1182 0 n2 ns1182 0 -3.4913430049e-05
Gc1_1183 0 n2 ns1183 0 -0.000102306897071
Gc1_1184 0 n2 ns1184 0 -5.13893946676e-05
Gc1_1185 0 n2 ns1185 0 3.86544068053e-05
Gc1_1186 0 n2 ns1186 0 2.46979267578e-05
Gc1_1187 0 n2 ns1187 0 -1.02278144274e-05
Gc1_1188 0 n2 ns1188 0 -0.00043414276477
Gc1_1189 0 n2 ns1189 0 0.000698007990599
Gc1_1190 0 n2 ns1190 0 0.000278435649696
Gc1_1191 0 n2 ns1191 0 -0.000205288261621
Gc1_1192 0 n2 ns1192 0 -7.33694857336e-05
Gc1_1193 0 n2 ns1193 0 -0.000120745952976
Gc1_1194 0 n2 ns1194 0 0.000283895676917
Gc1_1195 0 n2 ns1195 0 0.000614981488583
Gc1_1196 0 n2 ns1196 0 0.000186738683268
Gc1_1197 0 n2 ns1197 0 -0.000318904339189
Gc1_1198 0 n2 ns1198 0 -7.78640751846e-05
Gc1_1199 0 n2 ns1199 0 -5.20886640602e-05
Gc1_1200 0 n2 ns1200 0 0.000173651334721
Gc1_1201 0 n2 ns1201 0 4.00637425468e-05
Gc1_1202 0 n2 ns1202 0 -2.25421008617e-05
Gc1_1203 0 n2 ns1203 0 0.000147433205494
Gc1_1204 0 n2 ns1204 0 7.12530328374e-05
Gc1_1205 0 n2 ns1205 0 -9.64590888668e-05
Gc1_1206 0 n2 ns1206 0 0.000551231877768
Gc1_1207 0 n2 ns1207 0 0.00100574712778
Gc1_1208 0 n2 ns1208 0 0.000276611346621
Gc1_1209 0 n2 ns1209 0 -0.000229896612828
Gc1_1210 0 n2 ns1210 0 -9.8586052346e-05
Gc1_1211 0 n2 ns1211 0 -0.000144730016565
Gc1_1212 0 n2 ns1212 0 0.00904530197227
Gc1_1213 0 n2 ns1213 0 -0.00764116716061
Gc1_1214 0 n2 ns1214 0 0.000198664812535
Gc1_1215 0 n2 ns1215 0 6.74978454704e-06
Gc1_1216 0 n2 ns1216 0 -2.65078321327e-05
Gd1_1 0 n2 ni1 0 -0.00294345935345
Gd1_2 0 n2 ni2 0 -0.00251381279531
Gd1_3 0 n2 ni3 0 -0.00122555721138
Gd1_4 0 n2 ni4 0 0.000306422817018
Gd1_5 0 n2 ni5 0 0.000210792961546
Gd1_6 0 n2 ni6 0 0.00023124678646
Gd1_7 0 n2 ni7 0 -0.000109735738534
Gd1_8 0 n2 ni8 0 -9.7547254189e-05
Gd1_9 0 n2 ni9 0 -8.51431867818e-05
Gd1_10 0 n2 ni10 0 -0.00203272525978
Gd1_11 0 n2 ni11 0 -0.000225403823452
Gd1_12 0 n2 ni12 0 0.000242229100262
Gd1_13 0 n2 ni13 0 5.54238837246e-05
Gd1_14 0 n2 ni14 0 -4.41212196738e-05
Gd1_15 0 n2 ni15 0 -9.8148698705e-05
Gd1_16 0 n2 ni16 0 -4.60532631683e-06
Gd1_17 0 n2 ni17 0 -0.00771641723375
Gd1_18 0 n2 ni18 0 -0.00313862175093
Gd1_19 0 n2 ni19 0 2.18744664497e-05
Gd1_20 0 n2 ni20 0 0.000195716763906
Gd1_21 0 n2 ni21 0 0.000266950459667
Gd1_22 0 n2 ni22 0 3.14711342756e-05
Gd1_23 0 n2 ni23 0 -8.32356111496e-05
Gd1_24 0 n2 ni24 0 -0.000102650164157
Gd1_25 0 n2 ni25 0 -0.000230971411602
Gd1_26 0 n2 ni26 0 -0.000446886949371
Gd1_27 0 n2 ni27 0 0.000566609511802
Gd1_28 0 n2 ni28 0 0.000268108751003
Gd1_29 0 n2 ni29 0 6.7318315178e-05
Gd1_30 0 n2 ni30 0 -0.000140775391328
Gd1_31 0 n2 ni31 0 -5.79881342694e-05
Gd1_32 0 n2 ni32 0 -0.000129133579831
Gc2_1 0 n4 ns1 0 -0.00558795382656
Gc2_2 0 n4 ns2 0 -0.00294305613063
Gc2_3 0 n4 ns3 0 -0.00442244746168
Gc2_4 0 n4 ns4 0 0.000177068872863
Gc2_5 0 n4 ns5 0 -0.00135878368131
Gc2_6 0 n4 ns6 0 -0.000665402147887
Gc2_7 0 n4 ns7 0 0.000819927167275
Gc2_8 0 n4 ns8 0 -2.83900346185e-05
Gc2_9 0 n4 ns9 0 -8.53487191726e-05
Gc2_10 0 n4 ns10 0 -0.000231447939988
Gc2_11 0 n4 ns11 0 0.00246721078957
Gc2_12 0 n4 ns12 0 0.000567204329343
Gc2_13 0 n4 ns13 0 -0.000200947981316
Gc2_14 0 n4 ns14 0 0.000205486836875
Gc2_15 0 n4 ns15 0 -9.28330287622e-05
Gc2_16 0 n4 ns16 0 0.00159869016038
Gc2_17 0 n4 ns17 0 0.00073777506939
Gc2_18 0 n4 ns18 0 0.000733162575908
Gc2_19 0 n4 ns19 0 -0.00011032096238
Gc2_20 0 n4 ns20 0 0.000172888073285
Gc2_21 0 n4 ns21 0 0.000133961286618
Gc2_22 0 n4 ns22 0 0.00132986257364
Gc2_23 0 n4 ns23 0 -0.00123175388735
Gc2_24 0 n4 ns24 0 0.00110289213724
Gc2_25 0 n4 ns25 0 0.0019860471667
Gc2_26 0 n4 ns26 0 0.00119389014938
Gc2_27 0 n4 ns27 0 -0.00110678364635
Gc2_28 0 n4 ns28 0 0.000947331229612
Gc2_29 0 n4 ns29 0 -0.00208083711302
Gc2_30 0 n4 ns30 0 0.00310290117263
Gc2_31 0 n4 ns31 0 -0.000120770315351
Gc2_32 0 n4 ns32 0 0.00218343046535
Gc2_33 0 n4 ns33 0 0.000430173578633
Gc2_34 0 n4 ns34 0 -0.0410360981301
Gc2_35 0 n4 ns35 0 0.0423504305023
Gc2_36 0 n4 ns36 0 0.00598632405938
Gc2_37 0 n4 ns37 0 -5.03124454373e-06
Gc2_38 0 n4 ns38 0 2.45062431213e-05
Gc2_39 0 n4 ns39 0 -0.00401097865046
Gc2_40 0 n4 ns40 0 -0.00230519473426
Gc2_41 0 n4 ns41 0 0.00161196108486
Gc2_42 0 n4 ns42 0 0.00109932228428
Gc2_43 0 n4 ns43 0 -0.00042717175232
Gc2_44 0 n4 ns44 0 0.000154918835314
Gc2_45 0 n4 ns45 0 0.000273284748789
Gc2_46 0 n4 ns46 0 -0.000210785289673
Gc2_47 0 n4 ns47 0 -0.00014710656195
Gc2_48 0 n4 ns48 0 -0.00290912611947
Gc2_49 0 n4 ns49 0 0.000537347130147
Gc2_50 0 n4 ns50 0 0.00152677357116
Gc2_51 0 n4 ns51 0 -8.44923982393e-05
Gc2_52 0 n4 ns52 0 0.000426704514513
Gc2_53 0 n4 ns53 0 -0.000288389341329
Gc2_54 0 n4 ns54 0 0.000400700449536
Gc2_55 0 n4 ns55 0 -0.000594176349377
Gc2_56 0 n4 ns56 0 0.000441589757561
Gc2_57 0 n4 ns57 0 0.000350460244329
Gc2_58 0 n4 ns58 0 0.000278567983257
Gc2_59 0 n4 ns59 0 0.000324220088521
Gc2_60 0 n4 ns60 0 -0.00170884940534
Gc2_61 0 n4 ns61 0 -0.00148583818306
Gc2_62 0 n4 ns62 0 0.0010946719059
Gc2_63 0 n4 ns63 0 0.00258574946034
Gc2_64 0 n4 ns64 0 0.00154735910207
Gc2_65 0 n4 ns65 0 -0.0014110041304
Gc2_66 0 n4 ns66 0 -0.00351371927352
Gc2_67 0 n4 ns67 0 -0.00266125584
Gc2_68 0 n4 ns68 0 0.00276578785405
Gc2_69 0 n4 ns69 0 0.000626628316192
Gc2_70 0 n4 ns70 0 0.00276691250611
Gc2_71 0 n4 ns71 0 0.000584441290178
Gc2_72 0 n4 ns72 0 -0.049229395599
Gc2_73 0 n4 ns73 0 0.0452181940178
Gc2_74 0 n4 ns74 0 0.00644822026293
Gc2_75 0 n4 ns75 0 9.68128027572e-06
Gc2_76 0 n4 ns76 0 2.6553432985e-05
Gc2_77 0 n4 ns77 0 -0.00172567657894
Gc2_78 0 n4 ns78 0 -0.00229265982696
Gc2_79 0 n4 ns79 0 0.00552751451022
Gc2_80 0 n4 ns80 0 0.00065546004191
Gc2_81 0 n4 ns81 0 -0.000440157060825
Gc2_82 0 n4 ns82 0 0.000757826227827
Gc2_83 0 n4 ns83 0 0.000355826944696
Gc2_84 0 n4 ns84 0 -0.000150087017991
Gc2_85 0 n4 ns85 0 -8.90840774546e-05
Gc2_86 0 n4 ns86 0 -0.00187362372587
Gc2_87 0 n4 ns87 0 -0.00105726316978
Gc2_88 0 n4 ns88 0 0.000888728409964
Gc2_89 0 n4 ns89 0 -0.000156193202746
Gc2_90 0 n4 ns90 0 0.000493016619884
Gc2_91 0 n4 ns91 0 -0.000283878811059
Gc2_92 0 n4 ns92 0 -0.000834992555257
Gc2_93 0 n4 ns93 0 -0.00160222734676
Gc2_94 0 n4 ns94 0 -6.73062347992e-06
Gc2_95 0 n4 ns95 0 -0.000250410191821
Gc2_96 0 n4 ns96 0 0.000245944209109
Gc2_97 0 n4 ns97 0 0.000343050273859
Gc2_98 0 n4 ns98 0 -0.00418791419274
Gc2_99 0 n4 ns99 0 -0.000456449721235
Gc2_100 0 n4 ns100 0 0.000257831793155
Gc2_101 0 n4 ns101 0 0.00076589765745
Gc2_102 0 n4 ns102 0 0.00117806295887
Gc2_103 0 n4 ns103 0 -0.000960707983699
Gc2_104 0 n4 ns104 0 -0.00503022938795
Gc2_105 0 n4 ns105 0 -0.000673535943952
Gc2_106 0 n4 ns106 0 -0.0017720340576
Gc2_107 0 n4 ns107 0 -9.45173397329e-05
Gc2_108 0 n4 ns108 0 0.00234339980903
Gc2_109 0 n4 ns109 0 0.000738470713953
Gc2_110 0 n4 ns110 0 0.0139852966641
Gc2_111 0 n4 ns111 0 -0.0226415923321
Gc2_112 0 n4 ns112 0 0.00537789807859
Gc2_113 0 n4 ns113 0 2.23515647979e-06
Gc2_114 0 n4 ns114 0 3.36199828907e-05
Gc2_115 0 n4 ns115 0 -0.0014689861084
Gc2_116 0 n4 ns116 0 0.00171330513535
Gc2_117 0 n4 ns117 0 -0.00278631307305
Gc2_118 0 n4 ns118 0 0.000454171477398
Gc2_119 0 n4 ns119 0 -0.000691035185512
Gc2_120 0 n4 ns120 0 0.000263623702885
Gc2_121 0 n4 ns121 0 -0.000236638768089
Gc2_122 0 n4 ns122 0 -6.28936914938e-05
Gc2_123 0 n4 ns123 0 -1.11637307974e-05
Gc2_124 0 n4 ns124 0 -0.00175144448495
Gc2_125 0 n4 ns125 0 0.000832600630644
Gc2_126 0 n4 ns126 0 -7.58648606733e-05
Gc2_127 0 n4 ns127 0 -0.000317674120762
Gc2_128 0 n4 ns128 0 0.000247645677071
Gc2_129 0 n4 ns129 0 -0.000357796133948
Gc2_130 0 n4 ns130 0 -0.000795566378979
Gc2_131 0 n4 ns131 0 0.00157649846884
Gc2_132 0 n4 ns132 0 -9.19994916252e-05
Gc2_133 0 n4 ns133 0 -0.000573316354641
Gc2_134 0 n4 ns134 0 0.000316127800354
Gc2_135 0 n4 ns135 0 0.000110447602479
Gc2_136 0 n4 ns136 0 0.000713050880757
Gc2_137 0 n4 ns137 0 0.00288609150722
Gc2_138 0 n4 ns138 0 -0.000244670680424
Gc2_139 0 n4 ns139 0 0.000368638736834
Gc2_140 0 n4 ns140 0 0.000613087956518
Gc2_141 0 n4 ns141 0 -0.000992368754393
Gc2_142 0 n4 ns142 0 0.00291574649321
Gc2_143 0 n4 ns143 0 0.00141527493202
Gc2_144 0 n4 ns144 0 -0.00203681142811
Gc2_145 0 n4 ns145 0 0.00052256175472
Gc2_146 0 n4 ns146 0 0.00143286060484
Gc2_147 0 n4 ns147 0 -0.000208257811427
Gc2_148 0 n4 ns148 0 0.045265611495
Gc2_149 0 n4 ns149 0 -0.0427346065085
Gc2_150 0 n4 ns150 0 0.00272857729585
Gc2_151 0 n4 ns151 0 -2.94754611328e-06
Gc2_152 0 n4 ns152 0 2.19549318259e-05
Gc2_153 0 n4 ns153 0 -0.000881861222857
Gc2_154 0 n4 ns154 0 0.00217779915551
Gc2_155 0 n4 ns155 0 -0.00245181843764
Gc2_156 0 n4 ns156 0 -0.00018025190051
Gc2_157 0 n4 ns157 0 -0.000144753722706
Gc2_158 0 n4 ns158 0 -0.000266054513684
Gc2_159 0 n4 ns159 0 -8.6701790443e-05
Gc2_160 0 n4 ns160 0 -1.9446185241e-05
Gc2_161 0 n4 ns161 0 1.61152651262e-05
Gc2_162 0 n4 ns162 0 0.000236579105483
Gc2_163 0 n4 ns163 0 0.000963334279617
Gc2_164 0 n4 ns164 0 -9.50515972721e-05
Gc2_165 0 n4 ns165 0 0.000408388127898
Gc2_166 0 n4 ns166 0 3.85614182174e-05
Gc2_167 0 n4 ns167 0 -0.0003461008111
Gc2_168 0 n4 ns168 0 0.00146937725851
Gc2_169 0 n4 ns169 0 5.97275284667e-05
Gc2_170 0 n4 ns170 0 -0.000961561592058
Gc2_171 0 n4 ns171 0 -8.0313009599e-05
Gc2_172 0 n4 ns172 0 0.000227824916271
Gc2_173 0 n4 ns173 0 3.65660321823e-05
Gc2_174 0 n4 ns174 0 0.000522339231384
Gc2_175 0 n4 ns175 0 -0.000399077022274
Gc2_176 0 n4 ns176 0 -0.000251986876942
Gc2_177 0 n4 ns177 0 0.0013410086703
Gc2_178 0 n4 ns178 0 0.000353628180823
Gc2_179 0 n4 ns179 0 -0.00108979318286
Gc2_180 0 n4 ns180 0 -0.000176741470671
Gc2_181 0 n4 ns181 0 -0.00084845170621
Gc2_182 0 n4 ns182 0 -0.000439444820682
Gc2_183 0 n4 ns183 0 0.00172107987013
Gc2_184 0 n4 ns184 0 0.000921327085998
Gc2_185 0 n4 ns185 0 -0.000629699343115
Gc2_186 0 n4 ns186 0 0.0194080844483
Gc2_187 0 n4 ns187 0 -0.0183751035562
Gc2_188 0 n4 ns188 0 0.00108771155779
Gc2_189 0 n4 ns189 0 -8.12059778766e-06
Gc2_190 0 n4 ns190 0 4.40984030677e-06
Gc2_191 0 n4 ns191 0 9.67548116314e-05
Gc2_192 0 n4 ns192 0 -0.000706193698182
Gc2_193 0 n4 ns193 0 0.00265716457534
Gc2_194 0 n4 ns194 0 0.000121722273471
Gc2_195 0 n4 ns195 0 1.78487465079e-05
Gc2_196 0 n4 ns196 0 8.99807574034e-06
Gc2_197 0 n4 ns197 0 9.02418599783e-05
Gc2_198 0 n4 ns198 0 1.4968931471e-05
Gc2_199 0 n4 ns199 0 1.14675146176e-05
Gc2_200 0 n4 ns200 0 -0.000707856145724
Gc2_201 0 n4 ns201 0 -0.000652066000182
Gc2_202 0 n4 ns202 0 0.00074777534662
Gc2_203 0 n4 ns203 0 0.000339102470526
Gc2_204 0 n4 ns204 0 -8.88347705575e-05
Gc2_205 0 n4 ns205 0 -0.000269221278351
Gc2_206 0 n4 ns206 0 -0.000575349244444
Gc2_207 0 n4 ns207 0 -0.00141733558665
Gc2_208 0 n4 ns208 0 -0.000405495276558
Gc2_209 0 n4 ns209 0 0.00106279517665
Gc2_210 0 n4 ns210 0 0.000257850258374
Gc2_211 0 n4 ns211 0 -2.57327890336e-05
Gc2_212 0 n4 ns212 0 -0.00143608062618
Gc2_213 0 n4 ns213 0 0.000369687249546
Gc2_214 0 n4 ns214 0 0.000828956134884
Gc2_215 0 n4 ns215 0 0.00111401161324
Gc2_216 0 n4 ns216 0 -0.000260118402968
Gc2_217 0 n4 ns217 0 -0.000909590197402
Gc2_218 0 n4 ns218 0 -0.00197625621577
Gc2_219 0 n4 ns219 0 0.000124838190706
Gc2_220 0 n4 ns220 0 0.000513378194263
Gc2_221 0 n4 ns221 0 0.00125851042551
Gc2_222 0 n4 ns222 0 0.000448955137999
Gc2_223 0 n4 ns223 0 -0.000589778259005
Gc2_224 0 n4 ns224 0 0.00459510664407
Gc2_225 0 n4 ns225 0 -0.00526967839999
Gc2_226 0 n4 ns226 0 0.000433144886945
Gc2_227 0 n4 ns227 0 -5.066361797e-06
Gc2_228 0 n4 ns228 0 -1.87287160991e-05
Gc2_229 0 n4 ns229 0 0.000331766338476
Gc2_230 0 n4 ns230 0 -0.000970512026494
Gc2_231 0 n4 ns231 0 0.000832688792043
Gc2_232 0 n4 ns232 0 8.89825476154e-05
Gc2_233 0 n4 ns233 0 -9.42712214486e-05
Gc2_234 0 n4 ns234 0 7.64336395704e-05
Gc2_235 0 n4 ns235 0 -4.18410455165e-05
Gc2_236 0 n4 ns236 0 1.33960663809e-05
Gc2_237 0 n4 ns237 0 -2.16921689738e-05
Gc2_238 0 n4 ns238 0 -0.00094822250726
Gc2_239 0 n4 ns239 0 0.000410734978393
Gc2_240 0 n4 ns240 0 0.000476683679486
Gc2_241 0 n4 ns241 0 -0.000415607946714
Gc2_242 0 n4 ns242 0 -0.000173190947691
Gc2_243 0 n4 ns243 0 -6.26986081253e-05
Gc2_244 0 n4 ns244 0 -0.00110271208023
Gc2_245 0 n4 ns245 0 0.000214141103816
Gc2_246 0 n4 ns246 0 0.00057282109689
Gc2_247 0 n4 ns247 0 0.000530691332582
Gc2_248 0 n4 ns248 0 0.000108822351892
Gc2_249 0 n4 ns249 0 -0.000169692952985
Gc2_250 0 n4 ns250 0 0.000159500452738
Gc2_251 0 n4 ns251 0 0.00128924835079
Gc2_252 0 n4 ns252 0 0.000975923602414
Gc2_253 0 n4 ns253 0 -0.000133123101819
Gc2_254 0 n4 ns254 0 -0.000619089929756
Gc2_255 0 n4 ns255 0 -0.000252944135631
Gc2_256 0 n4 ns256 0 0.00016518952858
Gc2_257 0 n4 ns257 0 0.000757171418434
Gc2_258 0 n4 ns258 0 0.000409176793701
Gc2_259 0 n4 ns259 0 0.000261619090944
Gc2_260 0 n4 ns260 0 4.9514853233e-05
Gc2_261 0 n4 ns261 0 -0.000352775846937
Gc2_262 0 n4 ns262 0 0.0104219390219
Gc2_263 0 n4 ns263 0 -0.00932046996215
Gc2_264 0 n4 ns264 0 0.000397319572933
Gc2_265 0 n4 ns265 0 -3.9274285015e-06
Gc2_266 0 n4 ns266 0 -3.05520326393e-05
Gc2_267 0 n4 ns267 0 -5.86239218191e-05
Gc2_268 0 n4 ns268 0 0.000223450542145
Gc2_269 0 n4 ns269 0 -0.00302063386943
Gc2_270 0 n4 ns270 0 -0.000234044824692
Gc2_271 0 n4 ns271 0 -0.000194958547194
Gc2_272 0 n4 ns272 0 -0.000173691620012
Gc2_273 0 n4 ns273 0 1.8492771349e-05
Gc2_274 0 n4 ns274 0 1.23956190738e-06
Gc2_275 0 n4 ns275 0 1.39685750726e-05
Gc2_276 0 n4 ns276 0 0.000640031030834
Gc2_277 0 n4 ns277 0 0.00131989446629
Gc2_278 0 n4 ns278 0 -0.000371593097957
Gc2_279 0 n4 ns279 0 -0.000480188742802
Gc2_280 0 n4 ns280 0 -0.000126521801108
Gc2_281 0 n4 ns281 0 0.000111486257895
Gc2_282 0 n4 ns282 0 6.62882053129e-05
Gc2_283 0 n4 ns283 0 0.00102433286271
Gc2_284 0 n4 ns284 0 0.00053703025259
Gc2_285 0 n4 ns285 0 -0.000276327541572
Gc2_286 0 n4 ns286 0 -5.46435091843e-05
Gc2_287 0 n4 ns287 0 -0.000148775969656
Gc2_288 0 n4 ns288 0 0.00146131076379
Gc2_289 0 n4 ns289 0 0.000803075735308
Gc2_290 0 n4 ns290 0 0.00049069282668
Gc2_291 0 n4 ns291 0 -0.000684032784819
Gc2_292 0 n4 ns292 0 -0.000498505922743
Gc2_293 0 n4 ns293 0 0.00016162740622
Gc2_294 0 n4 ns294 0 0.00181285578137
Gc2_295 0 n4 ns295 0 0.000862694796401
Gc2_296 0 n4 ns296 0 0.00019782479791
Gc2_297 0 n4 ns297 0 -0.000342210481589
Gc2_298 0 n4 ns298 0 -0.000151310899981
Gc2_299 0 n4 ns299 0 -0.00018748557041
Gc2_300 0 n4 ns300 0 0.0176875562086
Gc2_301 0 n4 ns301 0 -0.014923955661
Gc2_302 0 n4 ns302 0 0.000503922355848
Gc2_303 0 n4 ns303 0 -5.2281760196e-06
Gc2_304 0 n4 ns304 0 -2.80334177286e-05
Gc2_305 0 n4 ns305 0 -0.000188056724358
Gc2_306 0 n4 ns306 0 0.000758497364689
Gc2_307 0 n4 ns307 0 -0.00335642275197
Gc2_308 0 n4 ns308 0 -0.000315783592025
Gc2_309 0 n4 ns309 0 -9.57403026668e-05
Gc2_310 0 n4 ns310 0 -0.000208061649042
Gc2_311 0 n4 ns311 0 0.000115438646931
Gc2_312 0 n4 ns312 0 1.61934614917e-05
Gc2_313 0 n4 ns313 0 3.70396500386e-05
Gc2_314 0 n4 ns314 0 0.00118501799216
Gc2_315 0 n4 ns315 0 0.000713296319959
Gc2_316 0 n4 ns316 0 -0.000521553459201
Gc2_317 0 n4 ns317 0 -0.000102777766735
Gc2_318 0 n4 ns318 0 -3.14378074666e-05
Gc2_319 0 n4 ns319 0 0.000121987856187
Gc2_320 0 n4 ns320 0 0.000447926572031
Gc2_321 0 n4 ns321 0 0.00055328154842
Gc2_322 0 n4 ns322 0 0.000163277504373
Gc2_323 0 n4 ns323 0 -0.000321698823789
Gc2_324 0 n4 ns324 0 -6.4974093597e-05
Gc2_325 0 n4 ns325 0 -5.04250558408e-05
Gc2_326 0 n4 ns326 0 0.00108777578087
Gc2_327 0 n4 ns327 0 0.000300099960165
Gc2_328 0 n4 ns328 0 0.000164300757354
Gc2_329 0 n4 ns329 0 -0.000490906804867
Gc2_330 0 n4 ns330 0 -0.000248487219318
Gc2_331 0 n4 ns331 0 0.000176951911442
Gc2_332 0 n4 ns332 0 0.00146307667693
Gc2_333 0 n4 ns333 0 0.000751910719757
Gc2_334 0 n4 ns334 0 0.000155092454834
Gc2_335 0 n4 ns335 0 -0.000364638518105
Gc2_336 0 n4 ns336 0 -0.000141435286398
Gc2_337 0 n4 ns337 0 -0.000115753357458
Gc2_338 0 n4 ns338 0 0.0149234407017
Gc2_339 0 n4 ns339 0 -0.0126031849832
Gc2_340 0 n4 ns340 0 0.000439212277733
Gc2_341 0 n4 ns341 0 -8.18836569898e-06
Gc2_342 0 n4 ns342 0 -2.20314210502e-05
Gc2_343 0 n4 ns343 0 -0.00438905225454
Gc2_344 0 n4 ns344 0 -0.00231493651313
Gc2_345 0 n4 ns345 0 -0.00111674973433
Gc2_346 0 n4 ns346 0 0.000753936748125
Gc2_347 0 n4 ns347 0 -0.00132299153654
Gc2_348 0 n4 ns348 0 1.12555131837e-05
Gc2_349 0 n4 ns349 0 0.000928986107516
Gc2_350 0 n4 ns350 0 -9.6098634031e-05
Gc2_351 0 n4 ns351 0 -5.73418869047e-05
Gc2_352 0 n4 ns352 0 -0.000910487875303
Gc2_353 0 n4 ns353 0 0.000593628311429
Gc2_354 0 n4 ns354 0 0.000861456140636
Gc2_355 0 n4 ns355 0 -0.000551253727116
Gc2_356 0 n4 ns356 0 0.000339273284109
Gc2_357 0 n4 ns357 0 -0.00023390979603
Gc2_358 0 n4 ns358 0 -0.000820333221368
Gc2_359 0 n4 ns359 0 -0.00116900710995
Gc2_360 0 n4 ns360 0 0.000489169038095
Gc2_361 0 n4 ns361 0 -2.25612745997e-05
Gc2_362 0 n4 ns362 0 0.000272640259145
Gc2_363 0 n4 ns363 0 0.000290935919511
Gc2_364 0 n4 ns364 0 -0.00275715268155
Gc2_365 0 n4 ns365 0 0.00133526921355
Gc2_366 0 n4 ns366 0 0.0012140560688
Gc2_367 0 n4 ns367 0 0.00116371629345
Gc2_368 0 n4 ns368 0 0.00109083765392
Gc2_369 0 n4 ns369 0 -0.00124736643351
Gc2_370 0 n4 ns370 0 0.000340211314704
Gc2_371 0 n4 ns371 0 0.00203500643396
Gc2_372 0 n4 ns372 0 -2.51278773251e-05
Gc2_373 0 n4 ns373 0 -0.00125831178175
Gc2_374 0 n4 ns374 0 0.00224100722933
Gc2_375 0 n4 ns375 0 0.000647783294672
Gc2_376 0 n4 ns376 0 0.0162668946642
Gc2_377 0 n4 ns377 0 -0.0170420796151
Gc2_378 0 n4 ns378 0 0.00647698389469
Gc2_379 0 n4 ns379 0 -2.44623106398e-06
Gc2_380 0 n4 ns380 0 2.68476288228e-05
Gc2_381 0 n4 ns381 0 -0.00154256784447
Gc2_382 0 n4 ns382 0 0.000916459735058
Gc2_383 0 n4 ns383 0 -0.00141758672474
Gc2_384 0 n4 ns384 0 0.000685377739334
Gc2_385 0 n4 ns385 0 -0.000755716747501
Gc2_386 0 n4 ns386 0 0.000549103295156
Gc2_387 0 n4 ns387 0 -0.00013296766935
Gc2_388 0 n4 ns388 0 -0.000123082355558
Gc2_389 0 n4 ns389 0 -1.78452498185e-05
Gc2_390 0 n4 ns390 0 -0.00241677636075
Gc2_391 0 n4 ns391 0 0.000418659869536
Gc2_392 0 n4 ns392 0 0.000333862214603
Gc2_393 0 n4 ns393 0 -0.000587618792645
Gc2_394 0 n4 ns394 0 0.000338151532949
Gc2_395 0 n4 ns395 0 -0.00036935601416
Gc2_396 0 n4 ns396 0 -0.00164547335875
Gc2_397 0 n4 ns397 0 0.00102893615153
Gc2_398 0 n4 ns398 0 0.000246061432803
Gc2_399 0 n4 ns399 0 -0.000534503181994
Gc2_400 0 n4 ns400 0 0.000338925592445
Gc2_401 0 n4 ns401 0 0.000163970479635
Gc2_402 0 n4 ns402 0 -0.000567741794345
Gc2_403 0 n4 ns403 0 0.00322950000855
Gc2_404 0 n4 ns404 0 3.29412677238e-05
Gc2_405 0 n4 ns405 0 0.000117431675453
Gc2_406 0 n4 ns406 0 0.000693842447916
Gc2_407 0 n4 ns407 0 -0.000964239538116
Gc2_408 0 n4 ns408 0 0.00206332058918
Gc2_409 0 n4 ns409 0 0.00198381395749
Gc2_410 0 n4 ns410 0 -0.00230001076776
Gc2_411 0 n4 ns411 0 -5.2247905104e-05
Gc2_412 0 n4 ns412 0 0.0016671589711
Gc2_413 0 n4 ns413 0 6.2079836414e-05
Gc2_414 0 n4 ns414 0 0.0471047989946
Gc2_415 0 n4 ns415 0 -0.0462656073468
Gc2_416 0 n4 ns416 0 0.00365363676246
Gc2_417 0 n4 ns417 0 -4.32237346068e-07
Gc2_418 0 n4 ns418 0 2.78869879129e-05
Gc2_419 0 n4 ns419 0 -0.00129067348958
Gc2_420 0 n4 ns420 0 0.00261966293676
Gc2_421 0 n4 ns421 0 -0.00366617674911
Gc2_422 0 n4 ns422 0 -6.24775830905e-05
Gc2_423 0 n4 ns423 0 -0.000316834104243
Gc2_424 0 n4 ns424 0 -0.000160003595506
Gc2_425 0 n4 ns425 0 -0.000231236387845
Gc2_426 0 n4 ns426 0 -3.59517832017e-05
Gc2_427 0 n4 ns427 0 5.6412189123e-06
Gc2_428 0 n4 ns428 0 -0.000166801074366
Gc2_429 0 n4 ns429 0 0.00142466991296
Gc2_430 0 n4 ns430 0 -0.000348447317621
Gc2_431 0 n4 ns431 0 0.000161430753682
Gc2_432 0 n4 ns432 0 0.000124857924345
Gc2_433 0 n4 ns433 0 -0.000353090524905
Gc2_434 0 n4 ns434 0 0.00137547651736
Gc2_435 0 n4 ns435 0 0.00107988861043
Gc2_436 0 n4 ns436 0 -0.00080161153716
Gc2_437 0 n4 ns437 0 -0.000567072656531
Gc2_438 0 n4 ns438 0 0.000233222830476
Gc2_439 0 n4 ns439 0 5.09742815606e-05
Gc2_440 0 n4 ns440 0 0.00131565264208
Gc2_441 0 n4 ns441 0 0.000250252086436
Gc2_442 0 n4 ns442 0 -0.000545356203693
Gc2_443 0 n4 ns443 0 0.00105687043618
Gc2_444 0 n4 ns444 0 0.000530286021445
Gc2_445 0 n4 ns445 0 -0.00105526418766
Gc2_446 0 n4 ns446 0 0.00107038098844
Gc2_447 0 n4 ns447 0 -0.000682136109577
Gc2_448 0 n4 ns448 0 -0.00101932660334
Gc2_449 0 n4 ns449 0 0.00158156481609
Gc2_450 0 n4 ns450 0 0.00112132564357
Gc2_451 0 n4 ns451 0 -0.00055525058165
Gc2_452 0 n4 ns452 0 0.0278936175888
Gc2_453 0 n4 ns453 0 -0.0260309191846
Gc2_454 0 n4 ns454 0 0.00152500723083
Gc2_455 0 n4 ns455 0 -7.25206572838e-06
Gc2_456 0 n4 ns456 0 1.56125508899e-05
Gc2_457 0 n4 ns457 0 -0.000380841431971
Gc2_458 0 n4 ns458 0 0.000610494327279
Gc2_459 0 n4 ns459 0 0.00101772876114
Gc2_460 0 n4 ns460 0 -4.02307115078e-05
Gc2_461 0 n4 ns461 0 0.000122405033238
Gc2_462 0 n4 ns462 0 -4.83164944381e-05
Gc2_463 0 n4 ns463 0 0.000138125659151
Gc2_464 0 n4 ns464 0 -1.85659940879e-06
Gc2_465 0 n4 ns465 0 4.54962234609e-06
Gc2_466 0 n4 ns466 0 1.07717350724e-05
Gc2_467 0 n4 ns467 0 -0.000574713578435
Gc2_468 0 n4 ns468 0 0.000481844144398
Gc2_469 0 n4 ns469 0 0.000622531749505
Gc2_470 0 n4 ns470 0 -2.67312374019e-05
Gc2_471 0 n4 ns471 0 -0.000319136203513
Gc2_472 0 n4 ns472 0 0.000423825738868
Gc2_473 0 n4 ns473 0 -0.00153987299056
Gc2_474 0 n4 ns474 0 -0.000902539874672
Gc2_475 0 n4 ns475 0 0.000800019472185
Gc2_476 0 n4 ns476 0 0.000254290145589
Gc2_477 0 n4 ns477 0 3.26195110437e-05
Gc2_478 0 n4 ns478 0 -0.00126950619024
Gc2_479 0 n4 ns479 0 -0.000434056914246
Gc2_480 0 n4 ns480 0 0.000430843373117
Gc2_481 0 n4 ns481 0 0.00148534645632
Gc2_482 0 n4 ns482 0 5.18414680365e-06
Gc2_483 0 n4 ns483 0 -0.00107989219882
Gc2_484 0 n4 ns484 0 -0.00213145236092
Gc2_485 0 n4 ns485 0 -0.0005608524384
Gc2_486 0 n4 ns486 0 0.000308230906365
Gc2_487 0 n4 ns487 0 0.00165984471654
Gc2_488 0 n4 ns488 0 0.00065017423069
Gc2_489 0 n4 ns489 0 -0.000646512737979
Gc2_490 0 n4 ns490 0 0.00567891855841
Gc2_491 0 n4 ns491 0 -0.00641150321193
Gc2_492 0 n4 ns492 0 0.000547120029128
Gc2_493 0 n4 ns493 0 -6.39271565698e-06
Gc2_494 0 n4 ns494 0 -6.71479812092e-06
Gc2_495 0 n4 ns495 0 0.000358086907046
Gc2_496 0 n4 ns496 0 -0.000857644251726
Gc2_497 0 n4 ns497 0 0.00241650172541
Gc2_498 0 n4 ns498 0 6.57046277022e-05
Gc2_499 0 n4 ns499 0 0.000186749584257
Gc2_500 0 n4 ns500 0 0.000267590888801
Gc2_501 0 n4 ns501 0 6.87681879823e-06
Gc2_502 0 n4 ns502 0 5.9984180017e-06
Gc2_503 0 n4 ns503 0 -3.41803429321e-05
Gc2_504 0 n4 ns504 0 -0.00119170722066
Gc2_505 0 n4 ns505 0 -0.000487385168957
Gc2_506 0 n4 ns506 0 0.00080489061741
Gc2_507 0 n4 ns507 0 -8.37244772126e-05
Gc2_508 0 n4 ns508 0 -0.00014617357834
Gc2_509 0 n4 ns509 0 -0.000161285806333
Gc2_510 0 n4 ns510 0 -0.00125398988664
Gc2_511 0 n4 ns511 0 -0.000645677309378
Gc2_512 0 n4 ns512 0 0.000248761357359
Gc2_513 0 n4 ns513 0 0.000917093249223
Gc2_514 0 n4 ns514 0 0.000183939842398
Gc2_515 0 n4 ns515 0 -0.000119285145862
Gc2_516 0 n4 ns516 0 -0.000782673290066
Gc2_517 0 n4 ns517 0 0.00102334261442
Gc2_518 0 n4 ns518 0 0.00104644865124
Gc2_519 0 n4 ns519 0 0.000378355088088
Gc2_520 0 n4 ns520 0 -0.00053781893394
Gc2_521 0 n4 ns521 0 -0.000532937425829
Gc2_522 0 n4 ns522 0 -0.00101338646161
Gc2_523 0 n4 ns523 0 0.000193753208031
Gc2_524 0 n4 ns524 0 0.000366858468994
Gc2_525 0 n4 ns525 0 0.000747162565068
Gc2_526 0 n4 ns526 0 0.000241899108849
Gc2_527 0 n4 ns527 0 -0.000393803092502
Gc2_528 0 n4 ns528 0 0.00301835767364
Gc2_529 0 n4 ns529 0 -0.00333595184075
Gc2_530 0 n4 ns530 0 0.000257405784374
Gc2_531 0 n4 ns531 0 -3.84898698576e-06
Gc2_532 0 n4 ns532 0 -2.55272296198e-05
Gc2_533 0 n4 ns533 0 0.00010868491775
Gc2_534 0 n4 ns534 0 -0.000220156581582
Gc2_535 0 n4 ns535 0 -0.0015048662888
Gc2_536 0 n4 ns536 0 -0.000125720626378
Gc2_537 0 n4 ns537 0 -0.000100081408296
Gc2_538 0 n4 ns538 0 -1.29113198804e-05
Gc2_539 0 n4 ns539 0 -4.48738505374e-05
Gc2_540 0 n4 ns540 0 -9.36267628378e-06
Gc2_541 0 n4 ns541 0 -1.35988773966e-05
Gc2_542 0 n4 ns542 0 -6.58036680278e-05
Gc2_543 0 n4 ns543 0 0.00110863709962
Gc2_544 0 n4 ns544 0 -3.76750929197e-05
Gc2_545 0 n4 ns545 0 -0.000559505291035
Gc2_546 0 n4 ns546 0 -0.000162068527368
Gc2_547 0 n4 ns547 0 5.38060631682e-05
Gc2_548 0 n4 ns548 0 -0.000383208855125
Gc2_549 0 n4 ns549 0 0.000888669155716
Gc2_550 0 n4 ns550 0 0.000637968882245
Gc2_551 0 n4 ns551 0 -3.98960933847e-05
Gc2_552 0 n4 ns552 0 -1.16472326307e-05
Gc2_553 0 n4 ns553 0 -0.000176043773713
Gc2_554 0 n4 ns554 0 0.00111500950349
Gc2_555 0 n4 ns555 0 0.000963260995304
Gc2_556 0 n4 ns556 0 0.000648975788152
Gc2_557 0 n4 ns557 0 -0.00057214766946
Gc2_558 0 n4 ns558 0 -0.000561721282754
Gc2_559 0 n4 ns559 0 6.51058189734e-05
Gc2_560 0 n4 ns560 0 0.00118396154478
Gc2_561 0 n4 ns561 0 0.000667912386395
Gc2_562 0 n4 ns562 0 0.000243060955773
Gc2_563 0 n4 ns563 0 -8.67748591677e-05
Gc2_564 0 n4 ns564 0 -6.84459465082e-05
Gc2_565 0 n4 ns565 0 -0.000233001071268
Gc2_566 0 n4 ns566 0 0.0141600909323
Gc2_567 0 n4 ns567 0 -0.012111498936
Gc2_568 0 n4 ns568 0 0.000436501229095
Gc2_569 0 n4 ns569 0 -4.90120245827e-06
Gc2_570 0 n4 ns570 0 -3.06488565002e-05
Gc2_571 0 n4 ns571 0 -0.000122799478572
Gc2_572 0 n4 ns572 0 0.000693702517652
Gc2_573 0 n4 ns573 0 -0.00355064793315
Gc2_574 0 n4 ns574 0 -0.00032497684067
Gc2_575 0 n4 ns575 0 -0.000142705031429
Gc2_576 0 n4 ns576 0 -0.000236172584485
Gc2_577 0 n4 ns577 0 4.66749425776e-05
Gc2_578 0 n4 ns578 0 4.48095711614e-06
Gc2_579 0 n4 ns579 0 4.75508094629e-05
Gc2_580 0 n4 ns580 0 0.00117193716192
Gc2_581 0 n4 ns581 0 0.00109142057138
Gc2_582 0 n4 ns582 0 -0.000571117164044
Gc2_583 0 n4 ns583 0 -0.000267118472181
Gc2_584 0 n4 ns584 0 -6.95579434444e-05
Gc2_585 0 n4 ns585 0 0.000138740386704
Gc2_586 0 n4 ns586 0 0.000424847171222
Gc2_587 0 n4 ns587 0 0.000798405654962
Gc2_588 0 n4 ns588 0 0.000297794190305
Gc2_589 0 n4 ns589 0 -0.000376995258309
Gc2_590 0 n4 ns590 0 -7.61063097371e-05
Gc2_591 0 n4 ns591 0 -8.73498943937e-05
Gc2_592 0 n4 ns592 0 0.00135010765679
Gc2_593 0 n4 ns593 0 0.000420903368684
Gc2_594 0 n4 ns594 0 0.00023916756201
Gc2_595 0 n4 ns595 0 -0.000620439693462
Gc2_596 0 n4 ns596 0 -0.000336482447094
Gc2_597 0 n4 ns597 0 0.000215683455431
Gc2_598 0 n4 ns598 0 0.00166825258944
Gc2_599 0 n4 ns599 0 0.000792592990251
Gc2_600 0 n4 ns600 0 0.000178746163393
Gc2_601 0 n4 ns601 0 -0.000385440869048
Gc2_602 0 n4 ns602 0 -0.000160764184646
Gc2_603 0 n4 ns603 0 -0.000142131487414
Gc2_604 0 n4 ns604 0 0.0165572018739
Gc2_605 0 n4 ns605 0 -0.0139541632068
Gc2_606 0 n4 ns606 0 0.000477167216294
Gc2_607 0 n4 ns607 0 -6.08385179671e-06
Gc2_608 0 n4 ns608 0 -2.4951133418e-05
Gc2_609 0 n4 ns609 0 -0.00525547292262
Gc2_610 0 n4 ns610 0 -0.00341574616904
Gc2_611 0 n4 ns611 0 -0.00261160140383
Gc2_612 0 n4 ns612 0 0.00201658986029
Gc2_613 0 n4 ns613 0 -0.00353432789612
Gc2_614 0 n4 ns614 0 0.000312349131768
Gc2_615 0 n4 ns615 0 0.00329731686854
Gc2_616 0 n4 ns616 0 0.000139861998955
Gc2_617 0 n4 ns617 0 -0.000300418629542
Gc2_618 0 n4 ns618 0 -0.00110396195375
Gc2_619 0 n4 ns619 0 0.00300800818667
Gc2_620 0 n4 ns620 0 -0.000996552869484
Gc2_621 0 n4 ns621 0 -0.000298355945177
Gc2_622 0 n4 ns622 0 -0.000285511328859
Gc2_623 0 n4 ns623 0 6.49495460594e-05
Gc2_624 0 n4 ns624 0 0.00346711135841
Gc2_625 0 n4 ns625 0 -0.00165472796841
Gc2_626 0 n4 ns626 0 5.27705525104e-06
Gc2_627 0 n4 ns627 0 -0.000810228872092
Gc2_628 0 n4 ns628 0 -9.23246122906e-05
Gc2_629 0 n4 ns629 0 8.76692600848e-05
Gc2_630 0 n4 ns630 0 0.00539442996073
Gc2_631 0 n4 ns631 0 0.00565409080431
Gc2_632 0 n4 ns632 0 -2.74759303114e-05
Gc2_633 0 n4 ns633 0 -0.0024137215949
Gc2_634 0 n4 ns634 0 -0.0016628680751
Gc2_635 0 n4 ns635 0 0.000798460675326
Gc2_636 0 n4 ns636 0 -0.00697949223596
Gc2_637 0 n4 ns637 0 0.000771809353157
Gc2_638 0 n4 ns638 0 0.00354605090284
Gc2_639 0 n4 ns639 0 -0.000191161692246
Gc2_640 0 n4 ns640 0 0.00212147128758
Gc2_641 0 n4 ns641 0 0.000405403992437
Gc2_642 0 n4 ns642 0 0.0854908898521
Gc2_643 0 n4 ns643 0 -0.0663249952364
Gc2_644 0 n4 ns644 0 -0.00594892898262
Gc2_645 0 n4 ns645 0 -6.40689605666e-06
Gc2_646 0 n4 ns646 0 2.37876348646e-05
Gc2_647 0 n4 ns647 0 -0.0170291917855
Gc2_648 0 n4 ns648 0 0.00105468256596
Gc2_649 0 n4 ns649 0 0.012240433698
Gc2_650 0 n4 ns650 0 0.0058783020582
Gc2_651 0 n4 ns651 0 0.00976807946729
Gc2_652 0 n4 ns652 0 0.00128864903675
Gc2_653 0 n4 ns653 0 -0.00332431178748
Gc2_654 0 n4 ns654 0 -0.000455315063744
Gc2_655 0 n4 ns655 0 6.42357316525e-06
Gc2_656 0 n4 ns656 0 -0.000666396368891
Gc2_657 0 n4 ns657 0 -0.0117539429723
Gc2_658 0 n4 ns658 0 0.000918817221589
Gc2_659 0 n4 ns659 0 0.00149887583998
Gc2_660 0 n4 ns660 0 5.87279263193e-05
Gc2_661 0 n4 ns661 0 8.73057810252e-06
Gc2_662 0 n4 ns662 0 0.000186263063926
Gc2_663 0 n4 ns663 0 0.00048189109927
Gc2_664 0 n4 ns664 0 0.000547076643365
Gc2_665 0 n4 ns665 0 0.000539019676833
Gc2_666 0 n4 ns666 0 0.000326125077133
Gc2_667 0 n4 ns667 0 0.000411781808154
Gc2_668 0 n4 ns668 0 -0.00970743466533
Gc2_669 0 n4 ns669 0 -0.00569132623935
Gc2_670 0 n4 ns670 0 -0.00303133280498
Gc2_671 0 n4 ns671 0 -0.00079423662373
Gc2_672 0 n4 ns672 0 -0.000233081957995
Gc2_673 0 n4 ns673 0 0.00151794653701
Gc2_674 0 n4 ns674 0 0.0131856702948
Gc2_675 0 n4 ns675 0 -0.00135407591974
Gc2_676 0 n4 ns676 0 0.00245470443932
Gc2_677 0 n4 ns677 0 -0.00132822089252
Gc2_678 0 n4 ns678 0 0.0022614736541
Gc2_679 0 n4 ns679 0 0.000465767338589
Gc2_680 0 n4 ns680 0 -0.0699899614119
Gc2_681 0 n4 ns681 0 0.0388183991389
Gc2_682 0 n4 ns682 0 -0.00815749522379
Gc2_683 0 n4 ns683 0 -8.14419653597e-06
Gc2_684 0 n4 ns684 0 2.79499580598e-05
Gc2_685 0 n4 ns685 0 -0.000359366199416
Gc2_686 0 n4 ns686 0 -0.000473129370771
Gc2_687 0 n4 ns687 0 0.00564625880536
Gc2_688 0 n4 ns688 0 -0.000850670372513
Gc2_689 0 n4 ns689 0 -0.000926000815958
Gc2_690 0 n4 ns690 0 0.00140953359864
Gc2_691 0 n4 ns691 0 0.000414098741045
Gc2_692 0 n4 ns692 0 -0.000191180059905
Gc2_693 0 n4 ns693 0 -0.00014771991157
Gc2_694 0 n4 ns694 0 0.00155697902108
Gc2_695 0 n4 ns695 0 -0.00188110523653
Gc2_696 0 n4 ns696 0 -0.000388181308428
Gc2_697 0 n4 ns697 0 0.00101021765925
Gc2_698 0 n4 ns698 0 -0.000253615618049
Gc2_699 0 n4 ns699 0 0.000270837406774
Gc2_700 0 n4 ns700 0 -0.000988776453954
Gc2_701 0 n4 ns701 0 -0.00234366078998
Gc2_702 0 n4 ns702 0 -0.000275559122618
Gc2_703 0 n4 ns703 0 -0.000234015886875
Gc2_704 0 n4 ns704 0 0.000191475930425
Gc2_705 0 n4 ns705 0 0.000390407107788
Gc2_706 0 n4 ns706 0 0.000667943147573
Gc2_707 0 n4 ns707 0 -0.00465746814334
Gc2_708 0 n4 ns708 0 -0.00188520730915
Gc2_709 0 n4 ns709 0 7.97885712099e-05
Gc2_710 0 n4 ns710 0 -0.000227132420664
Gc2_711 0 n4 ns711 0 0.00126901082631
Gc2_712 0 n4 ns712 0 -0.00970285913337
Gc2_713 0 n4 ns713 0 -0.00419406566273
Gc2_714 0 n4 ns714 0 -0.00169565854631
Gc2_715 0 n4 ns715 0 0.00150526121905
Gc2_716 0 n4 ns716 0 0.00281779413851
Gc2_717 0 n4 ns717 0 0.000788684884075
Gc2_718 0 n4 ns718 0 -0.0651283661905
Gc2_719 0 n4 ns719 0 0.0629946048454
Gc2_720 0 n4 ns720 0 -0.00647870963762
Gc2_721 0 n4 ns721 0 -9.2147055172e-06
Gc2_722 0 n4 ns722 0 2.94633509554e-05
Gc2_723 0 n4 ns723 0 0.000425850989029
Gc2_724 0 n4 ns724 0 -0.000233297419861
Gc2_725 0 n4 ns725 0 0.00961855909028
Gc2_726 0 n4 ns726 0 0.000186568515721
Gc2_727 0 n4 ns727 0 0.000522748622382
Gc2_728 0 n4 ns728 0 0.000374134303065
Gc2_729 0 n4 ns729 0 -0.00021157863226
Gc2_730 0 n4 ns730 0 -9.21372761414e-05
Gc2_731 0 n4 ns731 0 1.80837338216e-05
Gc2_732 0 n4 ns732 0 -0.000863569211385
Gc2_733 0 n4 ns733 0 -0.00348386164351
Gc2_734 0 n4 ns734 0 0.000752892319999
Gc2_735 0 n4 ns735 0 0.000743798847468
Gc2_736 0 n4 ns736 0 -4.53329270177e-05
Gc2_737 0 n4 ns737 0 0.000297131046327
Gc2_738 0 n4 ns738 0 -0.000379161888728
Gc2_739 0 n4 ns739 0 -0.000106065825291
Gc2_740 0 n4 ns740 0 -0.000726219171744
Gc2_741 0 n4 ns741 0 -0.000630239896756
Gc2_742 0 n4 ns742 0 0.000194289876868
Gc2_743 0 n4 ns743 0 0.000216402692189
Gc2_744 0 n4 ns744 0 -0.00253542016906
Gc2_745 0 n4 ns745 0 -0.00421761162073
Gc2_746 0 n4 ns746 0 -0.000501452518903
Gc2_747 0 n4 ns747 0 -5.41441616847e-06
Gc2_748 0 n4 ns748 0 -0.00016256410274
Gc2_749 0 n4 ns749 0 0.00117591150021
Gc2_750 0 n4 ns750 0 -0.00764615442263
Gc2_751 0 n4 ns751 0 -0.00577542178241
Gc2_752 0 n4 ns752 0 -0.00226968525878
Gc2_753 0 n4 ns753 0 0.00356626358967
Gc2_754 0 n4 ns754 0 0.00235143510453
Gc2_755 0 n4 ns755 0 -2.77244430857e-05
Gc2_756 0 n4 ns756 0 -0.0713686176611
Gc2_757 0 n4 ns757 0 0.0625603053565
Gc2_758 0 n4 ns758 0 -0.00303380522448
Gc2_759 0 n4 ns759 0 -1.10283461294e-05
Gc2_760 0 n4 ns760 0 1.71173081384e-05
Gc2_761 0 n4 ns761 0 7.6187618522e-05
Gc2_762 0 n4 ns762 0 -0.000480493230518
Gc2_763 0 n4 ns763 0 0.00619605008988
Gc2_764 0 n4 ns764 0 0.000227945346844
Gc2_765 0 n4 ns765 0 0.00016693211185
Gc2_766 0 n4 ns766 0 0.000349134380421
Gc2_767 0 n4 ns767 0 5.51394175549e-06
Gc2_768 0 n4 ns768 0 5.87542926953e-06
Gc2_769 0 n4 ns769 0 -2.32391251709e-05
Gc2_770 0 n4 ns770 0 -0.00071589325846
Gc2_771 0 n4 ns771 0 -0.00100489827972
Gc2_772 0 n4 ns772 0 0.000259129198668
Gc2_773 0 n4 ns773 0 -0.000356480806478
Gc2_774 0 n4 ns774 0 9.94470254104e-06
Gc2_775 0 n4 ns775 0 0.000309679389912
Gc2_776 0 n4 ns776 0 0.00122485494592
Gc2_777 0 n4 ns777 0 -0.00128502552776
Gc2_778 0 n4 ns778 0 -0.00149134153137
Gc2_779 0 n4 ns779 0 8.17333219131e-05
Gc2_780 0 n4 ns780 0 0.000158715584224
Gc2_781 0 n4 ns781 0 0.000175927125049
Gc2_782 0 n4 ns782 0 -0.001360827563
Gc2_783 0 n4 ns783 0 -0.00201918827416
Gc2_784 0 n4 ns784 0 -0.000673846136636
Gc2_785 0 n4 ns785 0 -0.00129951786887
Gc2_786 0 n4 ns786 0 2.71584745125e-05
Gc2_787 0 n4 ns787 0 0.00145222459987
Gc2_788 0 n4 ns788 0 -0.00642763856534
Gc2_789 0 n4 ns789 0 -0.00452542474571
Gc2_790 0 n4 ns790 0 -0.000465470294328
Gc2_791 0 n4 ns791 0 0.00352786545779
Gc2_792 0 n4 ns792 0 0.00148727386204
Gc2_793 0 n4 ns793 0 -0.000564759716088
Gc2_794 0 n4 ns794 0 -0.0376522380524
Gc2_795 0 n4 ns795 0 0.0316940916855
Gc2_796 0 n4 ns796 0 -0.00123666292446
Gc2_797 0 n4 ns797 0 -5.80469820321e-06
Gc2_798 0 n4 ns798 0 1.99985491896e-06
Gc2_799 0 n4 ns799 0 0.000244593379896
Gc2_800 0 n4 ns800 0 -0.000681654079836
Gc2_801 0 n4 ns801 0 0.00413380904272
Gc2_802 0 n4 ns802 0 6.93993468027e-05
Gc2_803 0 n4 ns803 0 0.000222185192758
Gc2_804 0 n4 ns804 0 0.00017405847294
Gc2_805 0 n4 ns805 0 -0.000109914295111
Gc2_806 0 n4 ns806 0 -1.99302705875e-05
Gc2_807 0 n4 ns807 0 -4.16951997639e-05
Gc2_808 0 n4 ns808 0 0.000888860547112
Gc2_809 0 n4 ns809 0 -0.000846345324135
Gc2_810 0 n4 ns810 0 -0.000748935976196
Gc2_811 0 n4 ns811 0 -9.34407516914e-06
Gc2_812 0 n4 ns812 0 0.000162293112479
Gc2_813 0 n4 ns813 0 0.000322788970999
Gc2_814 0 n4 ns814 0 -0.000308052569749
Gc2_815 0 n4 ns815 0 -0.00180732500846
Gc2_816 0 n4 ns816 0 -0.000579064264187
Gc2_817 0 n4 ns817 0 0.00100746451361
Gc2_818 0 n4 ns818 0 0.000222370679004
Gc2_819 0 n4 ns819 0 1.51258329923e-06
Gc2_820 0 n4 ns820 0 -0.000353698114509
Gc2_821 0 n4 ns821 0 -0.00135369732419
Gc2_822 0 n4 ns822 0 -0.00137157955976
Gc2_823 0 n4 ns823 0 -0.000872414843883
Gc2_824 0 n4 ns824 0 0.000575821973055
Gc2_825 0 n4 ns825 0 0.00107056540675
Gc2_826 0 n4 ns826 0 -0.00487596650842
Gc2_827 0 n4 ns827 0 -0.00199162199556
Gc2_828 0 n4 ns828 0 0.000538001935279
Gc2_829 0 n4 ns829 0 0.00218092034498
Gc2_830 0 n4 ns830 0 0.000724024689149
Gc2_831 0 n4 ns831 0 -0.000591324846059
Gc2_832 0 n4 ns832 0 -0.0178760518234
Gc2_833 0 n4 ns833 0 0.0145547950962
Gc2_834 0 n4 ns834 0 -0.000515918874424
Gc2_835 0 n4 ns835 0 2.7341693164e-06
Gc2_836 0 n4 ns836 0 -1.66384326046e-05
Gc2_837 0 n4 ns837 0 0.000201780117193
Gc2_838 0 n4 ns838 0 -0.000607631501422
Gc2_839 0 n4 ns839 0 0.0014766182432
Gc2_840 0 n4 ns840 0 -0.000104132912095
Gc2_841 0 n4 ns841 0 0.000204835103636
Gc2_842 0 n4 ns842 0 4.13154535991e-05
Gc2_843 0 n4 ns843 0 9.78489498429e-05
Gc2_844 0 n4 ns844 0 -4.75200439255e-06
Gc2_845 0 n4 ns845 0 -2.91898871594e-06
Gc2_846 0 n4 ns846 0 0.000558188955477
Gc2_847 0 n4 ns847 0 -0.00147287106989
Gc2_848 0 n4 ns848 0 -0.000404193585865
Gc2_849 0 n4 ns849 0 0.000755871202236
Gc2_850 0 n4 ns850 0 0.000284752681378
Gc2_851 0 n4 ns851 0 9.70109433362e-05
Gc2_852 0 n4 ns852 0 -0.000856854398608
Gc2_853 0 n4 ns853 0 -0.000185125441103
Gc2_854 0 n4 ns854 0 0.000450868961929
Gc2_855 0 n4 ns855 0 0.000460161217825
Gc2_856 0 n4 ns856 0 6.82900637163e-05
Gc2_857 0 n4 ns857 0 -0.000178508237348
Gc2_858 0 n4 ns858 0 0.000160146522163
Gc2_859 0 n4 ns859 0 -0.000963144129436
Gc2_860 0 n4 ns860 0 -0.00109295357227
Gc2_861 0 n4 ns861 0 -0.000101998456966
Gc2_862 0 n4 ns862 0 0.000602563199933
Gc2_863 0 n4 ns863 0 0.000409754208439
Gc2_864 0 n4 ns864 0 -0.00206385780916
Gc2_865 0 n4 ns865 0 5.6506102961e-05
Gc2_866 0 n4 ns866 0 0.000631658185803
Gc2_867 0 n4 ns867 0 0.000750510417747
Gc2_868 0 n4 ns868 0 0.000190389145876
Gc2_869 0 n4 ns869 0 -0.000409148033057
Gc2_870 0 n4 ns870 0 -0.00155673585376
Gc2_871 0 n4 ns871 0 0.0010528378102
Gc2_872 0 n4 ns872 0 -8.2276100405e-05
Gc2_873 0 n4 ns873 0 6.1211541865e-06
Gc2_874 0 n4 ns874 0 -2.82664067703e-05
Gc2_875 0 n4 ns875 0 0.000148020660241
Gc2_876 0 n4 ns876 0 -0.000241504295973
Gc2_877 0 n4 ns877 0 -0.000607046942956
Gc2_878 0 n4 ns878 0 -0.000237174595273
Gc2_879 0 n4 ns879 0 0.000156585927779
Gc2_880 0 n4 ns880 0 8.15327169457e-05
Gc2_881 0 n4 ns881 0 0.000152450527024
Gc2_882 0 n4 ns882 0 2.94096337148e-05
Gc2_883 0 n4 ns883 0 -1.0489483948e-05
Gc2_884 0 n4 ns884 0 -0.000368233089279
Gc2_885 0 n4 ns885 0 -0.000366674293638
Gc2_886 0 n4 ns886 0 0.000285844044497
Gc2_887 0 n4 ns887 0 0.000352502798481
Gc2_888 0 n4 ns888 0 9.90477979468e-05
Gc2_889 0 n4 ns889 0 -0.000130689546787
Gc2_890 0 n4 ns890 0 -9.53437732677e-05
Gc2_891 0 n4 ns891 0 0.000772756823851
Gc2_892 0 n4 ns892 0 0.000479014417399
Gc2_893 0 n4 ns893 0 -0.000235719299681
Gc2_894 0 n4 ns894 0 -7.26478337311e-05
Gc2_895 0 n4 ns895 0 -0.00014442207697
Gc2_896 0 n4 ns896 0 0.000346906689452
Gc2_897 0 n4 ns897 0 -0.000340604272631
Gc2_898 0 n4 ns898 0 -0.000397534675732
Gc2_899 0 n4 ns899 0 0.00014864922304
Gc2_900 0 n4 ns900 0 0.000277835157213
Gc2_901 0 n4 ns901 0 1.10176208589e-05
Gc2_902 0 n4 ns902 0 0.000134868101811
Gc2_903 0 n4 ns903 0 0.000949157136008
Gc2_904 0 n4 ns904 0 0.000399968109537
Gc2_905 0 n4 ns905 0 -6.41528785542e-05
Gc2_906 0 n4 ns906 0 -5.88844436208e-05
Gc2_907 0 n4 ns907 0 -0.000234470830453
Gc2_908 0 n4 ns908 0 0.00859293262564
Gc2_909 0 n4 ns909 0 -0.00728480406722
Gc2_910 0 n4 ns910 0 0.000183152063979
Gc2_911 0 n4 ns911 0 4.92467035038e-06
Gc2_912 0 n4 ns912 0 -2.96254754491e-05
Gc2_913 0 n4 ns913 0 7.23904457063e-05
Gc2_914 0 n4 ns914 0 -0.000385301360829
Gc2_915 0 n4 ns915 0 -0.000638978227919
Gc2_916 0 n4 ns916 0 -6.00175203731e-05
Gc2_917 0 n4 ns917 0 -0.000110435017806
Gc2_918 0 n4 ns918 0 -6.18726087854e-05
Gc2_919 0 n4 ns919 0 4.68188208499e-05
Gc2_920 0 n4 ns920 0 2.74757127883e-05
Gc2_921 0 n4 ns921 0 -8.60752314213e-06
Gc2_922 0 n4 ns922 0 -0.000397336581181
Gc2_923 0 n4 ns923 0 0.00073360750562
Gc2_924 0 n4 ns924 0 0.00026424265607
Gc2_925 0 n4 ns925 0 -0.000209535682889
Gc2_926 0 n4 ns926 0 -7.5315400812e-05
Gc2_927 0 n4 ns927 0 -0.000118286627517
Gc2_928 0 n4 ns928 0 0.000288990370149
Gc2_929 0 n4 ns929 0 0.000640331600381
Gc2_930 0 n4 ns930 0 0.000197162789153
Gc2_931 0 n4 ns931 0 -0.000324266613312
Gc2_932 0 n4 ns932 0 -7.76402306928e-05
Gc2_933 0 n4 ns933 0 -5.49729428256e-05
Gc2_934 0 n4 ns934 0 0.000213746272611
Gc2_935 0 n4 ns935 0 7.56721486047e-05
Gc2_936 0 n4 ns936 0 -6.72903311966e-06
Gc2_937 0 n4 ns937 0 0.000135370820725
Gc2_938 0 n4 ns938 0 6.02629694075e-05
Gc2_939 0 n4 ns939 0 -9.77085209911e-05
Gc2_940 0 n4 ns940 0 0.000648062607951
Gc2_941 0 n4 ns941 0 0.00105474363851
Gc2_942 0 n4 ns942 0 0.000275263749344
Gc2_943 0 n4 ns943 0 -0.00026145456459
Gc2_944 0 n4 ns944 0 -0.0001090876769
Gc2_945 0 n4 ns945 0 -0.000144260109891
Gc2_946 0 n4 ns946 0 0.00966465320572
Gc2_947 0 n4 ns947 0 -0.00815231902058
Gc2_948 0 n4 ns948 0 0.000213801695304
Gc2_949 0 n4 ns949 0 6.62909850839e-06
Gc2_950 0 n4 ns950 0 -2.60632085423e-05
Gc2_951 0 n4 ns951 0 -0.00252796332152
Gc2_952 0 n4 ns952 0 -0.00229868511001
Gc2_953 0 n4 ns953 0 0.00516350501705
Gc2_954 0 n4 ns954 0 0.00115329841114
Gc2_955 0 n4 ns955 0 -0.0019060425801
Gc2_956 0 n4 ns956 0 0.000429072366749
Gc2_957 0 n4 ns957 0 0.00175082528589
Gc2_958 0 n4 ns958 0 -1.23360431728e-05
Gc2_959 0 n4 ns959 0 -0.000228283152163
Gc2_960 0 n4 ns960 0 0.0007171785161
Gc2_961 0 n4 ns961 0 -0.000489236120987
Gc2_962 0 n4 ns962 0 -0.000891476363258
Gc2_963 0 n4 ns963 0 0.000603275442219
Gc2_964 0 n4 ns964 0 -0.000330563516491
Gc2_965 0 n4 ns965 0 0.000222525588617
Gc2_966 0 n4 ns966 0 0.000464035845531
Gc2_967 0 n4 ns967 0 -0.00218403771071
Gc2_968 0 n4 ns968 0 0.000120095360157
Gc2_969 0 n4 ns969 0 -0.000397113875587
Gc2_970 0 n4 ns970 0 0.00014772867386
Gc2_971 0 n4 ns971 0 0.000291165775022
Gc2_972 0 n4 ns972 0 0.00222771389518
Gc2_973 0 n4 ns973 0 -0.00143808582826
Gc2_974 0 n4 ns974 0 -0.00176854870665
Gc2_975 0 n4 ns975 0 -0.000604261215509
Gc2_976 0 n4 ns976 0 -0.000621348424399
Gc2_977 0 n4 ns977 0 0.00125366396515
Gc2_978 0 n4 ns978 0 -0.00868307537328
Gc2_979 0 n4 ns979 0 -0.00277039610669
Gc2_980 0 n4 ns980 0 -0.000234125276733
Gc2_981 0 n4 ns981 0 0.000439536365483
Gc2_982 0 n4 ns982 0 0.00269262969869
Gc2_983 0 n4 ns983 0 0.000797474700809
Gc2_984 0 n4 ns984 0 -0.0269536982214
Gc2_985 0 n4 ns985 0 0.0310779786856
Gc2_986 0 n4 ns986 0 -0.00705822160121
Gc2_987 0 n4 ns987 0 -8.39159413282e-06
Gc2_988 0 n4 ns988 0 2.68036047487e-05
Gc2_989 0 n4 ns989 0 -7.32922969787e-05
Gc2_990 0 n4 ns990 0 -0.000825952066533
Gc2_991 0 n4 ns991 0 0.00944643292265
Gc2_992 0 n4 ns992 0 0.00011588722907
Gc2_993 0 n4 ns993 0 0.000170840420632
Gc2_994 0 n4 ns994 0 0.000398285845812
Gc2_995 0 n4 ns995 0 -0.000373819661409
Gc2_996 0 n4 ns996 0 -0.000140230844975
Gc2_997 0 n4 ns997 0 2.56545072717e-05
Gc2_998 0 n4 ns998 0 0.000108449900631
Gc2_999 0 n4 ns999 0 -0.00318305129396
Gc2_1000 0 n4 ns1000 0 0.00039540731043
Gc2_1001 0 n4 ns1001 0 0.000979379871628
Gc2_1002 0 n4 ns1002 0 -0.000154960903487
Gc2_1003 0 n4 ns1003 0 0.000291898277014
Gc2_1004 0 n4 ns1004 0 -0.00105250198814
Gc2_1005 0 n4 ns1005 0 -0.000293978695379
Gc2_1006 0 n4 ns1006 0 -0.000316829592643
Gc2_1007 0 n4 ns1007 0 -0.000681660890532
Gc2_1008 0 n4 ns1008 0 0.000208529861929
Gc2_1009 0 n4 ns1009 0 0.000245796559983
Gc2_1010 0 n4 ns1010 0 -0.00175748667534
Gc2_1011 0 n4 ns1011 0 -0.00494745413242
Gc2_1012 0 n4 ns1012 0 -0.000896283530824
Gc2_1013 0 n4 ns1013 0 0.000299041527313
Gc2_1014 0 n4 ns1014 0 -0.000183205211013
Gc2_1015 0 n4 ns1015 0 0.00117163915431
Gc2_1016 0 n4 ns1016 0 -0.00775482525985
Gc2_1017 0 n4 ns1017 0 -0.0053638767141
Gc2_1018 0 n4 ns1018 0 -0.00259188345244
Gc2_1019 0 n4 ns1019 0 0.00280356799998
Gc2_1020 0 n4 ns1020 0 0.00252697520161
Gc2_1021 0 n4 ns1021 0 0.000260501340252
Gc2_1022 0 n4 ns1022 0 -0.0779572331177
Gc2_1023 0 n4 ns1023 0 0.070087985905
Gc2_1024 0 n4 ns1024 0 -0.00408183386287
Gc2_1025 0 n4 ns1025 0 -1.02744932492e-05
Gc2_1026 0 n4 ns1026 0 2.29864032583e-05
Gc2_1027 0 n4 ns1027 0 0.000379461384208
Gc2_1028 0 n4 ns1028 0 -0.000891090999265
Gc2_1029 0 n4 ns1029 0 0.00746865101188
Gc2_1030 0 n4 ns1030 0 0.000285448202329
Gc2_1031 0 n4 ns1031 0 -0.000137442943244
Gc2_1032 0 n4 ns1032 0 9.67374087125e-05
Gc2_1033 0 n4 ns1033 0 6.69354214467e-05
Gc2_1034 0 n4 ns1034 0 1.86268578085e-05
Gc2_1035 0 n4 ns1035 0 2.60299588762e-05
Gc2_1036 0 n4 ns1036 0 -0.00115568708205
Gc2_1037 0 n4 ns1037 0 -0.00126712877038
Gc2_1038 0 n4 ns1038 0 0.000603850878673
Gc2_1039 0 n4 ns1039 0 -0.000195051826572
Gc2_1040 0 n4 ns1040 0 -6.77634428143e-05
Gc2_1041 0 n4 ns1041 0 0.000294871878375
Gc2_1042 0 n4 ns1042 0 0.00111585157545
Gc2_1043 0 n4 ns1043 0 -0.000431987658707
Gc2_1044 0 n4 ns1044 0 -0.00136658747502
Gc2_1045 0 n4 ns1045 0 -0.00040167271133
Gc2_1046 0 n4 ns1046 0 0.000157656675463
Gc2_1047 0 n4 ns1047 0 0.000190537644183
Gc2_1048 0 n4 ns1048 0 -0.00178658397221
Gc2_1049 0 n4 ns1049 0 -0.00227149079013
Gc2_1050 0 n4 ns1050 0 -0.000265312665669
Gc2_1051 0 n4 ns1051 0 -0.00108362718548
Gc2_1052 0 n4 ns1052 0 -0.000215101410087
Gc2_1053 0 n4 ns1053 0 0.00139942244009
Gc2_1054 0 n4 ns1054 0 -0.00642995777138
Gc2_1055 0 n4 ns1055 0 -0.00476849498179
Gc2_1056 0 n4 ns1056 0 -0.00102339000075
Gc2_1057 0 n4 ns1057 0 0.0036235044158
Gc2_1058 0 n4 ns1058 0 0.00176004378612
Gc2_1059 0 n4 ns1059 0 -0.000470891467627
Gc2_1060 0 n4 ns1060 0 -0.0440154019202
Gc2_1061 0 n4 ns1061 0 0.0375253532802
Gc2_1062 0 n4 ns1062 0 -0.00159130174681
Gc2_1063 0 n4 ns1063 0 -8.54823521441e-06
Gc2_1064 0 n4 ns1064 0 1.01111741304e-05
Gc2_1065 0 n4 ns1065 0 0.00022660548507
Gc2_1066 0 n4 ns1066 0 -0.000924168069984
Gc2_1067 0 n4 ns1067 0 0.00556662329909
Gc2_1068 0 n4 ns1068 0 0.000239451647882
Gc2_1069 0 n4 ns1069 0 0.000136629034562
Gc2_1070 0 n4 ns1070 0 0.000217262393773
Gc2_1071 0 n4 ns1071 0 -0.000141498929799
Gc2_1072 0 n4 ns1072 0 -3.02029376699e-06
Gc2_1073 0 n4 ns1073 0 -3.90134455728e-05
Gc2_1074 0 n4 ns1074 0 0.000367114334065
Gc2_1075 0 n4 ns1075 0 -0.000567342982387
Gc2_1076 0 n4 ns1076 0 -0.000486609789399
Gc2_1077 0 n4 ns1077 0 -0.000377303890558
Gc2_1078 0 n4 ns1078 0 7.30799105016e-05
Gc2_1079 0 n4 ns1079 0 0.000354690711941
Gc2_1080 0 n4 ns1080 0 0.000314420309861
Gc2_1081 0 n4 ns1081 0 -0.00208829324954
Gc2_1082 0 n4 ns1082 0 -0.00111890533286
Gc2_1083 0 n4 ns1083 0 0.000892042314252
Gc2_1084 0 n4 ns1084 0 0.000236937778358
Gc2_1085 0 n4 ns1085 0 9.80245434313e-05
Gc2_1086 0 n4 ns1086 0 -0.000812328107331
Gc2_1087 0 n4 ns1087 0 -0.00160816808716
Gc2_1088 0 n4 ns1088 0 -0.00129310294581
Gc2_1089 0 n4 ns1089 0 -0.0011371798454
Gc2_1090 0 n4 ns1090 0 0.000467153660596
Gc2_1091 0 n4 ns1091 0 0.00131617763151
Gc2_1092 0 n4 ns1092 0 -0.00603364230688
Gc2_1093 0 n4 ns1093 0 -0.00296127539438
Gc2_1094 0 n4 ns1094 0 0.000362629128261
Gc2_1095 0 n4 ns1095 0 0.00281691815096
Gc2_1096 0 n4 ns1096 0 0.00100436578943
Gc2_1097 0 n4 ns1097 0 -0.000641809667251
Gc2_1098 0 n4 ns1098 0 -0.0262327962166
Gc2_1099 0 n4 ns1099 0 0.0215641511107
Gc2_1100 0 n4 ns1100 0 -0.000761038140371
Gc2_1101 0 n4 ns1101 0 -4.86786794169e-08
Gc2_1102 0 n4 ns1102 0 -7.4698337021e-06
Gc2_1103 0 n4 ns1103 0 0.000239557989129
Gc2_1104 0 n4 ns1104 0 -0.00101199305338
Gc2_1105 0 n4 ns1105 0 0.0032496322258
Gc2_1106 0 n4 ns1106 0 6.51469971904e-05
Gc2_1107 0 n4 ns1107 0 0.000179912054251
Gc2_1108 0 n4 ns1108 0 4.21301079691e-05
Gc2_1109 0 n4 ns1109 0 -1.37159731804e-05
Gc2_1110 0 n4 ns1110 0 -2.06987514569e-05
Gc2_1111 0 n4 ns1111 0 -1.12169775437e-05
Gc2_1112 0 n4 ns1112 0 0.000858543855168
Gc2_1113 0 n4 ns1113 0 -0.00153792507662
Gc2_1114 0 n4 ns1114 0 -0.000699927542641
Gc2_1115 0 n4 ns1115 0 0.00060709163127
Gc2_1116 0 n4 ns1116 0 0.000291438668915
Gc2_1117 0 n4 ns1117 0 0.000223084636159
Gc2_1118 0 n4 ns1118 0 -0.000959654589231
Gc2_1119 0 n4 ns1119 0 -0.000947991047476
Gc2_1120 0 n4 ns1120 0 0.00015938494301
Gc2_1121 0 n4 ns1121 0 0.000829116847782
Gc2_1122 0 n4 ns1122 0 0.000150038091293
Gc2_1123 0 n4 ns1123 0 -0.000134646868922
Gc2_1124 0 n4 ns1124 0 -0.000120926301295
Gc2_1125 0 n4 ns1125 0 -0.00127697378434
Gc2_1126 0 n4 ns1126 0 -0.00138016401877
Gc2_1127 0 n4 ns1127 0 -0.000315182755392
Gc2_1128 0 n4 ns1128 0 0.000712001237978
Gc2_1129 0 n4 ns1129 0 0.000667429601937
Gc2_1130 0 n4 ns1130 0 -0.00349561230993
Gc2_1131 0 n4 ns1131 0 -0.00088447773771
Gc2_1132 0 n4 ns1132 0 0.000586359357606
Gc2_1133 0 n4 ns1133 0 0.00135467339834
Gc2_1134 0 n4 ns1134 0 0.000413378374833
Gc2_1135 0 n4 ns1135 0 -0.000452345850916
Gc2_1136 0 n4 ns1136 0 -0.010966933644
Gc2_1137 0 n4 ns1137 0 0.00886811459125
Gc2_1138 0 n4 ns1138 0 -0.000324257957501
Gc2_1139 0 n4 ns1139 0 6.34101787039e-06
Gc2_1140 0 n4 ns1140 0 -2.3796369925e-05
Gc2_1141 0 n4 ns1141 0 0.000179324291688
Gc2_1142 0 n4 ns1142 0 -0.000330521971417
Gc2_1143 0 n4 ns1143 0 -0.00012915352299
Gc2_1144 0 n4 ns1144 0 -0.000241058471632
Gc2_1145 0 n4 ns1145 0 0.000163560895228
Gc2_1146 0 n4 ns1146 0 3.21833997709e-05
Gc2_1147 0 n4 ns1147 0 0.000169381071236
Gc2_1148 0 n4 ns1148 0 2.82932049228e-05
Gc2_1149 0 n4 ns1149 0 5.1253824534e-06
Gc2_1150 0 n4 ns1150 0 -2.7882531513e-05
Gc2_1151 0 n4 ns1151 0 -0.000883154565314
Gc2_1152 0 n4 ns1152 0 4.85023517826e-05
Gc2_1153 0 n4 ns1153 0 0.000619962615726
Gc2_1154 0 n4 ns1154 0 0.000198940418612
Gc2_1155 0 n4 ns1155 0 -6.2535354434e-05
Gc2_1156 0 n4 ns1156 0 -0.000413122112141
Gc2_1157 0 n4 ns1157 0 0.000618387060611
Gc2_1158 0 n4 ns1158 0 0.00058252430702
Gc2_1159 0 n4 ns1159 0 -4.36414557279e-05
Gc2_1160 0 n4 ns1160 0 -3.69577200959e-05
Gc2_1161 0 n4 ns1161 0 -0.000185434729024
Gc2_1162 0 n4 ns1162 0 0.000367074892259
Gc2_1163 0 n4 ns1163 0 -0.000568538943415
Gc2_1164 0 n4 ns1164 0 -0.000656962138097
Gc2_1165 0 n4 ns1165 0 9.70116458978e-05
Gc2_1166 0 n4 ns1166 0 0.000409072357525
Gc2_1167 0 n4 ns1167 0 0.00012607616397
Gc2_1168 0 n4 ns1168 0 -0.000438894154567
Gc2_1169 0 n4 ns1169 0 0.000776745147199
Gc2_1170 0 n4 ns1170 0 0.00048678798152
Gc2_1171 0 n4 ns1171 0 0.000136659303441
Gc2_1172 0 n4 ns1172 0 -1.05281614163e-06
Gc2_1173 0 n4 ns1173 0 -0.000291563185165
Gc2_1174 0 n4 ns1174 0 0.00650375877272
Gc2_1175 0 n4 ns1175 0 -0.00559926534599
Gc2_1176 0 n4 ns1176 0 0.000132287258293
Gc2_1177 0 n4 ns1177 0 5.7218344512e-06
Gc2_1178 0 n4 ns1178 0 -3.05365250296e-05
Gc2_1179 0 n4 ns1179 0 8.43630460102e-05
Gc2_1180 0 n4 ns1180 0 -0.000396629734006
Gc2_1181 0 n4 ns1181 0 -0.000738121727809
Gc2_1182 0 n4 ns1182 0 -0.00012575811257
Gc2_1183 0 n4 ns1183 0 -2.66623697556e-05
Gc2_1184 0 n4 ns1184 0 -8.59191890356e-06
Gc2_1185 0 n4 ns1185 0 0.000106922624244
Gc2_1186 0 n4 ns1186 0 3.41138525805e-05
Gc2_1187 0 n4 ns1187 0 -1.63204640511e-05
Gc2_1188 0 n4 ns1188 0 -0.000425148944581
Gc2_1189 0 n4 ns1189 0 0.000445825340753
Gc2_1190 0 n4 ns1190 0 0.000323190307402
Gc2_1191 0 n4 ns1191 0 -5.51128831815e-05
Gc2_1192 0 n4 ns1192 0 -3.45249919179e-05
Gc2_1193 0 n4 ns1193 0 -0.000140746073359
Gc2_1194 0 n4 ns1194 0 0.000250628079028
Gc2_1195 0 n4 ns1195 0 0.000724306988185
Gc2_1196 0 n4 ns1196 0 0.000276792713314
Gc2_1197 0 n4 ns1197 0 -0.00034924003268
Gc2_1198 0 n4 ns1198 0 -9.00138090363e-05
Gc2_1199 0 n4 ns1199 0 -8.14472079416e-05
Gc2_1200 0 n4 ns1200 0 0.000252637287207
Gc2_1201 0 n4 ns1201 0 -6.51746948917e-05
Gc2_1202 0 n4 ns1202 0 -0.000109072577808
Gc2_1203 0 n4 ns1203 0 0.000172819608554
Gc2_1204 0 n4 ns1204 0 0.000126472756813
Gc2_1205 0 n4 ns1205 0 -9.07126271777e-05
Gc2_1206 0 n4 ns1206 0 0.000605444811157
Gc2_1207 0 n4 ns1207 0 0.00105798797278
Gc2_1208 0 n4 ns1208 0 0.000303786549067
Gc2_1209 0 n4 ns1209 0 -0.000240020873724
Gc2_1210 0 n4 ns1210 0 -0.000107928147705
Gc2_1211 0 n4 ns1211 0 -0.000167474560438
Gc2_1212 0 n4 ns1212 0 0.00965715637294
Gc2_1213 0 n4 ns1213 0 -0.00810892927854
Gc2_1214 0 n4 ns1214 0 0.000202943859372
Gc2_1215 0 n4 ns1215 0 5.00679906666e-06
Gc2_1216 0 n4 ns1216 0 -2.82276612864e-05
Gd2_1 0 n4 ni1 0 -0.00251381245837
Gd2_2 0 n4 ni2 0 -0.000639502383298
Gd2_3 0 n4 ni3 0 -0.00166544892166
Gd2_4 0 n4 ni4 0 -0.000195611265411
Gd2_5 0 n4 ni5 0 0.000342807618142
Gd2_6 0 n4 ni6 0 2.78533548012e-05
Gd2_7 0 n4 ni7 0 -7.13234328081e-05
Gd2_8 0 n4 ni8 0 -9.44311242852e-05
Gd2_9 0 n4 ni9 0 -1.18908622355e-05
Gd2_10 0 n4 ni10 0 -0.00274371433347
Gd2_11 0 n4 ni11 0 -0.000608834502553
Gd2_12 0 n4 ni12 0 0.000235838982831
Gd2_13 0 n4 ni13 0 0.000179374494281
Gd2_14 0 n4 ni14 0 0.000115549324896
Gd2_15 0 n4 ni15 0 -5.03631682056e-05
Gd2_16 0 n4 ni16 0 -1.57534796035e-06
Gd2_17 0 n4 ni17 0 -0.0031334844292
Gd2_18 0 n4 ni18 0 -0.00652419060837
Gd2_19 0 n4 ni19 0 -0.000511386688171
Gd2_20 0 n4 ni20 0 0.000562173881615
Gd2_21 0 n4 ni21 0 0.000145173209964
Gd2_22 0 n4 ni22 0 8.35683572414e-05
Gd2_23 0 n4 ni23 0 -2.28528779232e-05
Gd2_24 0 n4 ni24 0 -1.39307817745e-05
Gd2_25 0 n4 ni25 0 -0.000115100303537
Gd2_26 0 n4 ni26 0 -0.00150850695167
Gd2_27 0 n4 ni27 0 -5.90838757961e-05
Gd2_28 0 n4 ni28 0 0.000243277201855
Gd2_29 0 n4 ni29 0 5.05813026578e-05
Gd2_30 0 n4 ni30 0 -7.40675012699e-05
Gd2_31 0 n4 ni31 0 -7.57424492655e-06
Gd2_32 0 n4 ni32 0 -0.000119510773347
Gc3_1 0 n6 ns1 0 -0.00152119037225
Gc3_2 0 n6 ns2 0 -0.00172839677903
Gc3_3 0 n6 ns3 0 0.00504141311473
Gc3_4 0 n6 ns4 0 0.00107027547907
Gc3_5 0 n6 ns5 0 -0.000453875494713
Gc3_6 0 n6 ns6 0 0.000823793638638
Gc3_7 0 n6 ns7 0 0.000492981055064
Gc3_8 0 n6 ns8 0 -0.000140347689146
Gc3_9 0 n6 ns9 0 -3.62439744227e-05
Gc3_10 0 n6 ns10 0 -0.00149715309602
Gc3_11 0 n6 ns11 0 -0.00198119954333
Gc3_12 0 n6 ns12 0 0.000843448029925
Gc3_13 0 n6 ns13 0 -0.00034459132943
Gc3_14 0 n6 ns14 0 0.000341245827381
Gc3_15 0 n6 ns15 0 -0.000230186336595
Gc3_16 0 n6 ns16 0 -0.00239547962776
Gc3_17 0 n6 ns17 0 -0.00232467127405
Gc3_18 0 n6 ns18 0 -3.08378211824e-05
Gc3_19 0 n6 ns19 0 0.000181849943473
Gc3_20 0 n6 ns20 0 0.000226745600681
Gc3_21 0 n6 ns21 0 0.000331474931962
Gc3_22 0 n6 ns22 0 -0.00508405759267
Gc3_23 0 n6 ns23 0 0.00186324785219
Gc3_24 0 n6 ns24 0 0.000479626420805
Gc3_25 0 n6 ns25 0 0.000420498616484
Gc3_26 0 n6 ns26 0 0.000843313200273
Gc3_27 0 n6 ns27 0 -0.000821907533978
Gc3_28 0 n6 ns28 0 -0.00263437849103
Gc3_29 0 n6 ns29 0 0.00267794588471
Gc3_30 0 n6 ns30 0 -0.00186083127605
Gc3_31 0 n6 ns31 0 -0.000754846056568
Gc3_32 0 n6 ns32 0 0.00176608755818
Gc3_33 0 n6 ns33 0 0.000527464394264
Gc3_34 0 n6 ns34 0 0.0296382374799
Gc3_35 0 n6 ns35 0 -0.0344076889039
Gc3_36 0 n6 ns36 0 0.00428746127404
Gc3_37 0 n6 ns37 0 2.7002303433e-06
Gc3_38 0 n6 ns38 0 2.84476349026e-05
Gc3_39 0 n6 ns39 0 -0.00172567641475
Gc3_40 0 n6 ns40 0 -0.00229265995806
Gc3_41 0 n6 ns41 0 0.00552751492155
Gc3_42 0 n6 ns42 0 0.000655459920026
Gc3_43 0 n6 ns43 0 -0.000440157010926
Gc3_44 0 n6 ns44 0 0.000757826211245
Gc3_45 0 n6 ns45 0 0.000355826989833
Gc3_46 0 n6 ns46 0 -0.000150086999636
Gc3_47 0 n6 ns47 0 -8.90840750466e-05
Gc3_48 0 n6 ns48 0 -0.00187362344423
Gc3_49 0 n6 ns49 0 -0.00105726322831
Gc3_50 0 n6 ns50 0 0.000888728331732
Gc3_51 0 n6 ns51 0 -0.000156193168386
Gc3_52 0 n6 ns52 0 0.000493016615489
Gc3_53 0 n6 ns53 0 -0.000283878787534
Gc3_54 0 n6 ns54 0 -0.000834992448993
Gc3_55 0 n6 ns55 0 -0.00160222745758
Gc3_56 0 n6 ns56 0 -6.73068542265e-06
Gc3_57 0 n6 ns57 0 -0.000250410206618
Gc3_58 0 n6 ns58 0 0.000245944201581
Gc3_59 0 n6 ns59 0 0.000343050280625
Gc3_60 0 n6 ns60 0 -0.00418791424924
Gc3_61 0 n6 ns61 0 -0.00045644997215
Gc3_62 0 n6 ns62 0 0.000257831699324
Gc3_63 0 n6 ns63 0 0.000765897684746
Gc3_64 0 n6 ns64 0 0.00117806300434
Gc3_65 0 n6 ns65 0 -0.000960707961886
Gc3_66 0 n6 ns66 0 -0.00503022972295
Gc3_67 0 n6 ns67 0 -0.000673536384622
Gc3_68 0 n6 ns68 0 -0.00177203414836
Gc3_69 0 n6 ns69 0 -9.45171684439e-05
Gc3_70 0 n6 ns70 0 0.00234339987682
Gc3_71 0 n6 ns71 0 0.00073847074406
Gc3_72 0 n6 ns72 0 0.0139852930278
Gc3_73 0 n6 ns73 0 -0.0226415892113
Gc3_74 0 n6 ns74 0 0.00537789795395
Gc3_75 0 n6 ns75 0 2.23515727026e-06
Gc3_76 0 n6 ns76 0 3.36199844648e-05
Gc3_77 0 n6 ns77 0 -0.00369718387113
Gc3_78 0 n6 ns78 0 0.000289676214691
Gc3_79 0 n6 ns79 0 -0.00279438580911
Gc3_80 0 n6 ns80 0 0.000503679424343
Gc3_81 0 n6 ns81 0 -0.000537018400322
Gc3_82 0 n6 ns82 0 0.00020862388493
Gc3_83 0 n6 ns83 0 -0.000309291147648
Gc3_84 0 n6 ns84 0 -0.000234825983808
Gc3_85 0 n6 ns85 0 -8.95258049569e-05
Gc3_86 0 n6 ns86 0 -0.00377834729697
Gc3_87 0 n6 ns87 0 0.00230007054264
Gc3_88 0 n6 ns88 0 0.0010335927254
Gc3_89 0 n6 ns89 0 -0.000206507852106
Gc3_90 0 n6 ns90 0 0.000554999799817
Gc3_91 0 n6 ns91 0 -0.000539224631974
Gc3_92 0 n6 ns92 0 0.00080480632513
Gc3_93 0 n6 ns93 0 0.00194706709739
Gc3_94 0 n6 ns94 0 0.000341320368179
Gc3_95 0 n6 ns95 0 -0.000324785969109
Gc3_96 0 n6 ns96 0 0.000488175054516
Gc3_97 0 n6 ns97 0 0.000292018679436
Gc3_98 0 n6 ns98 0 0.00122430847481
Gc3_99 0 n6 ns99 0 0.000161836770132
Gc3_100 0 n6 ns100 0 0.000536000643089
Gc3_101 0 n6 ns101 0 0.00277149754015
Gc3_102 0 n6 ns102 0 0.00178750388606
Gc3_103 0 n6 ns103 0 -0.00195055167549
Gc3_104 0 n6 ns104 0 -5.04928013913e-05
Gc3_105 0 n6 ns105 0 -0.00308667007798
Gc3_106 0 n6 ns106 0 0.00164280872636
Gc3_107 0 n6 ns107 0 0.00167299478016
Gc3_108 0 n6 ns108 0 0.00329596719562
Gc3_109 0 n6 ns109 0 0.000229707223352
Gc3_110 0 n6 ns110 0 -0.0229612559899
Gc3_111 0 n6 ns111 0 0.0227143089739
Gc3_112 0 n6 ns112 0 0.00701462648008
Gc3_113 0 n6 ns113 0 1.00551469714e-05
Gc3_114 0 n6 ns114 0 3.53760890848e-05
Gc3_115 0 n6 ns115 0 -0.0019432760226
Gc3_116 0 n6 ns116 0 -0.0017951787229
Gc3_117 0 n6 ns117 0 0.00518590630265
Gc3_118 0 n6 ns118 0 0.000363081196373
Gc3_119 0 n6 ns119 0 -0.000380950599428
Gc3_120 0 n6 ns120 0 0.000525310445544
Gc3_121 0 n6 ns121 0 0.000424892893366
Gc3_122 0 n6 ns122 0 -0.000175791231066
Gc3_123 0 n6 ns123 0 -4.46540542286e-05
Gc3_124 0 n6 ns124 0 -0.0010887913319
Gc3_125 0 n6 ns125 0 -0.000709739521684
Gc3_126 0 n6 ns126 0 0.000990093093168
Gc3_127 0 n6 ns127 0 0.000367455852369
Gc3_128 0 n6 ns128 0 0.00046077314631
Gc3_129 0 n6 ns129 0 -0.000547825213162
Gc3_130 0 n6 ns130 0 0.000542393772781
Gc3_131 0 n6 ns131 0 -0.00267188257781
Gc3_132 0 n6 ns132 0 -0.000937465539773
Gc3_133 0 n6 ns133 0 9.49174716259e-05
Gc3_134 0 n6 ns134 0 0.000396043283354
Gc3_135 0 n6 ns135 0 0.000365194436134
Gc3_136 0 n6 ns136 0 -0.00465745443391
Gc3_137 0 n6 ns137 0 -0.00170743218347
Gc3_138 0 n6 ns138 0 0.00035919025604
Gc3_139 0 n6 ns139 0 0.00196977366947
Gc3_140 0 n6 ns140 0 0.00122977723849
Gc3_141 0 n6 ns141 0 -0.0016982404617
Gc3_142 0 n6 ns142 0 -0.0065908388874
Gc3_143 0 n6 ns143 0 -0.001532722174
Gc3_144 0 n6 ns144 0 -0.00122500007999
Gc3_145 0 n6 ns145 0 0.00110542172301
Gc3_146 0 n6 ns146 0 0.00256930139218
Gc3_147 0 n6 ns147 0 0.000259224230867
Gc3_148 0 n6 ns148 0 0.0147394391323
Gc3_149 0 n6 ns149 0 -0.0235624102653
Gc3_150 0 n6 ns150 0 0.0053704889499
Gc3_151 0 n6 ns151 0 2.29891511113e-06
Gc3_152 0 n6 ns152 0 2.69750982132e-05
Gc3_153 0 n6 ns153 0 -0.00110597521813
Gc3_154 0 n6 ns154 0 0.000392280661874
Gc3_155 0 n6 ns155 0 9.98611818517e-05
Gc3_156 0 n6 ns156 0 0.000572332697333
Gc3_157 0 n6 ns157 0 -0.000525090227169
Gc3_158 0 n6 ns158 0 0.000465856137598
Gc3_159 0 n6 ns159 0 -0.000208503866922
Gc3_160 0 n6 ns160 0 -4.33429192539e-05
Gc3_161 0 n6 ns161 0 -3.01151702269e-07
Gc3_162 0 n6 ns162 0 -0.00257343280058
Gc3_163 0 n6 ns163 0 7.54096075058e-06
Gc3_164 0 n6 ns164 0 0.000657315592636
Gc3_165 0 n6 ns165 0 -0.000245461776416
Gc3_166 0 n6 ns166 0 0.000118705337949
Gc3_167 0 n6 ns167 0 -0.000505170139322
Gc3_168 0 n6 ns168 0 -0.00195106747834
Gc3_169 0 n6 ns169 0 0.000466639896369
Gc3_170 0 n6 ns170 0 -4.07790633162e-05
Gc3_171 0 n6 ns171 0 0.000392487571543
Gc3_172 0 n6 ns172 0 0.000487226385509
Gc3_173 0 n6 ns173 0 5.25312557615e-05
Gc3_174 0 n6 ns174 0 -0.000519397137646
Gc3_175 0 n6 ns175 0 0.00364996414744
Gc3_176 0 n6 ns176 0 0.000684244765496
Gc3_177 0 n6 ns177 0 0.000783672573733
Gc3_178 0 n6 ns178 0 0.000184696250349
Gc3_179 0 n6 ns179 0 -0.00143351006048
Gc3_180 0 n6 ns180 0 0.00177166950136
Gc3_181 0 n6 ns181 0 0.00172410806131
Gc3_182 0 n6 ns182 0 -0.00156218232474
Gc3_183 0 n6 ns183 0 0.000893804880365
Gc3_184 0 n6 ns184 0 0.0014478812931
Gc3_185 0 n6 ns185 0 -0.000436184809245
Gc3_186 0 n6 ns186 0 0.0420271236097
Gc3_187 0 n6 ns187 0 -0.0402218054293
Gc3_188 0 n6 ns188 0 0.00263212653532
Gc3_189 0 n6 ns189 0 -2.0266378872e-06
Gc3_190 0 n6 ns190 0 3.23298366235e-07
Gc3_191 0 n6 ns191 0 -0.000788934502828
Gc3_192 0 n6 ns192 0 0.00175847384012
Gc3_193 0 n6 ns193 0 -0.00354985567505
Gc3_194 0 n6 ns194 0 -0.000253968433429
Gc3_195 0 n6 ns195 0 -0.00013629999449
Gc3_196 0 n6 ns196 0 -0.000181982800976
Gc3_197 0 n6 ns197 0 -0.000143641124421
Gc3_198 0 n6 ns198 0 -2.41508667001e-05
Gc3_199 0 n6 ns199 0 -1.44450583632e-05
Gc3_200 0 n6 ns200 0 -5.94442144283e-05
Gc3_201 0 n6 ns201 0 0.00183284900779
Gc3_202 0 n6 ns202 0 3.88693348654e-07
Gc3_203 0 n6 ns203 0 -0.000133360649192
Gc3_204 0 n6 ns204 0 -0.000123331969134
Gc3_205 0 n6 ns205 0 -0.000312723467589
Gc3_206 0 n6 ns206 0 0.00100199277614
Gc3_207 0 n6 ns207 0 0.000886998873538
Gc3_208 0 n6 ns208 0 -0.000333941173494
Gc3_209 0 n6 ns209 0 -9.51578865407e-05
Gc3_210 0 n6 ns210 0 0.000221816224288
Gc3_211 0 n6 ns211 0 -0.000127345722592
Gc3_212 0 n6 ns212 0 0.00156942004397
Gc3_213 0 n6 ns213 0 0.000515999335923
Gc3_214 0 n6 ns214 0 0.000301025849978
Gc3_215 0 n6 ns215 0 0.000754706190003
Gc3_216 0 n6 ns216 0 -0.000133805123206
Gc3_217 0 n6 ns217 0 -0.000978485491743
Gc3_218 0 n6 ns218 0 0.00120729251112
Gc3_219 0 n6 ns219 0 -0.000515089674993
Gc3_220 0 n6 ns220 0 -0.000422186464793
Gc3_221 0 n6 ns221 0 0.00143754543663
Gc3_222 0 n6 ns222 0 0.000779042567044
Gc3_223 0 n6 ns223 0 -0.000668171512725
Gc3_224 0 n6 ns224 0 0.027378792964
Gc3_225 0 n6 ns225 0 -0.0248012589563
Gc3_226 0 n6 ns226 0 0.0012303897499
Gc3_227 0 n6 ns227 0 -6.9945893536e-06
Gc3_228 0 n6 ns228 0 -1.94130962529e-05
Gc3_229 0 n6 ns229 0 -0.000169029182013
Gc3_230 0 n6 ns230 0 3.61879415147e-05
Gc3_231 0 n6 ns231 0 -0.00072882317597
Gc3_232 0 n6 ns232 0 -0.000154957965885
Gc3_233 0 n6 ns233 0 6.35531611658e-05
Gc3_234 0 n6 ns234 0 -9.24673777353e-05
Gc3_235 0 n6 ns235 0 0.000114260097569
Gc3_236 0 n6 ns236 0 3.76989135549e-06
Gc3_237 0 n6 ns237 0 3.69252002774e-05
Gc3_238 0 n6 ns238 0 0.000385203450222
Gc3_239 0 n6 ns239 0 0.000132368328525
Gc3_240 0 n6 ns240 0 0.000239608470624
Gc3_241 0 n6 ns241 0 0.00013278252761
Gc3_242 0 n6 ns242 0 -0.000138768462516
Gc3_243 0 n6 ns243 0 -0.000135311615259
Gc3_244 0 n6 ns244 0 -7.24425116667e-05
Gc3_245 0 n6 ns245 0 -0.000717213313696
Gc3_246 0 n6 ns246 0 -0.000171314462908
Gc3_247 0 n6 ns247 0 0.000657805781738
Gc3_248 0 n6 ns248 0 0.000171697758504
Gc3_249 0 n6 ns249 0 -0.0001008854615
Gc3_250 0 n6 ns250 0 -0.00014680116087
Gc3_251 0 n6 ns251 0 0.000487828031216
Gc3_252 0 n6 ns252 0 0.000902670398259
Gc3_253 0 n6 ns253 0 0.000539327938562
Gc3_254 0 n6 ns254 0 -0.000493803955364
Gc3_255 0 n6 ns255 0 -0.000665422090265
Gc3_256 0 n6 ns256 0 -0.000409666513809
Gc3_257 0 n6 ns257 0 0.000340902679239
Gc3_258 0 n6 ns258 0 0.00048322914579
Gc3_259 0 n6 ns259 0 0.000888286343746
Gc3_260 0 n6 ns260 0 0.00029233327366
Gc3_261 0 n6 ns261 0 -0.00059603646451
Gc3_262 0 n6 ns262 0 0.0149470420573
Gc3_263 0 n6 ns263 0 -0.0136517597862
Gc3_264 0 n6 ns264 0 0.000646907760239
Gc3_265 0 n6 ns265 0 -3.92580714357e-06
Gc3_266 0 n6 ns266 0 -3.35478396913e-05
Gc3_267 0 n6 ns267 0 0.000174180159652
Gc3_268 0 n6 ns268 0 -0.000409599014897
Gc3_269 0 n6 ns269 0 -0.0014827049356
Gc3_270 0 n6 ns270 0 -0.000109864080578
Gc3_271 0 n6 ns271 0 -0.000132953493262
Gc3_272 0 n6 ns272 0 -6.33283267416e-05
Gc3_273 0 n6 ns273 0 5.62021581382e-05
Gc3_274 0 n6 ns274 0 3.13272682561e-05
Gc3_275 0 n6 ns275 0 8.82303807531e-06
Gc3_276 0 n6 ns276 0 -9.82277186034e-05
Gc3_277 0 n6 ns277 0 0.000677139667569
Gc3_278 0 n6 ns278 0 0.000131529773738
Gc3_279 0 n6 ns279 0 -0.000383645929052
Gc3_280 0 n6 ns280 0 -0.000170770185477
Gc3_281 0 n6 ns281 0 1.55022903569e-05
Gc3_282 0 n6 ns282 0 -0.000780111243709
Gc3_283 0 n6 ns283 0 0.000458758038113
Gc3_284 0 n6 ns284 0 0.000614346093316
Gc3_285 0 n6 ns285 0 0.000345308507469
Gc3_286 0 n6 ns286 0 7.39074066583e-05
Gc3_287 0 n6 ns287 0 -0.000188167784254
Gc3_288 0 n6 ns288 0 0.000805576539757
Gc3_289 0 n6 ns289 0 0.00140719573608
Gc3_290 0 n6 ns290 0 0.00102947825912
Gc3_291 0 n6 ns291 0 -0.000403480866705
Gc3_292 0 n6 ns292 0 -0.000731582262485
Gc3_293 0 n6 ns293 0 -0.000148630759128
Gc3_294 0 n6 ns294 0 0.00124010388183
Gc3_295 0 n6 ns295 0 0.00113295098651
Gc3_296 0 n6 ns296 0 0.000417114379047
Gc3_297 0 n6 ns297 0 -6.52244151941e-05
Gc3_298 0 n6 ns298 0 -7.53337465569e-05
Gc3_299 0 n6 ns299 0 -0.000358775027216
Gc3_300 0 n6 ns300 0 0.017894502496
Gc3_301 0 n6 ns301 0 -0.0154119507713
Gc3_302 0 n6 ns302 0 0.000560094606291
Gc3_303 0 n6 ns303 0 -3.67045270698e-06
Gc3_304 0 n6 ns304 0 -3.37774869413e-05
Gc3_305 0 n6 ns305 0 -6.93839140583e-06
Gc3_306 0 n6 ns306 0 -0.000163940469054
Gc3_307 0 n6 ns307 0 -0.00138692108433
Gc3_308 0 n6 ns308 0 -9.733519934e-05
Gc3_309 0 n6 ns309 0 -0.000116210152115
Gc3_310 0 n6 ns310 0 -3.2020562745e-05
Gc3_311 0 n6 ns311 0 -3.59747776999e-05
Gc3_312 0 n6 ns312 0 -1.54088440174e-05
Gc3_313 0 n6 ns313 0 -1.99604777352e-05
Gc3_314 0 n6 ns314 0 3.87264732575e-05
Gc3_315 0 n6 ns315 0 0.00107137208566
Gc3_316 0 n6 ns316 0 -0.000114369969367
Gc3_317 0 n6 ns317 0 -0.000498542044164
Gc3_318 0 n6 ns318 0 -0.000127388534505
Gc3_319 0 n6 ns319 0 5.83199773767e-05
Gc3_320 0 n6 ns320 0 -0.000142613363859
Gc3_321 0 n6 ns321 0 0.000862827112364
Gc3_322 0 n6 ns322 0 0.000516456961083
Gc3_323 0 n6 ns323 0 -0.000164037957657
Gc3_324 0 n6 ns324 0 -3.75264523509e-05
Gc3_325 0 n6 ns325 0 -0.000140067932772
Gc3_326 0 n6 ns326 0 0.00103754958999
Gc3_327 0 n6 ns327 0 0.000659164909622
Gc3_328 0 n6 ns328 0 0.000432952619541
Gc3_329 0 n6 ns329 0 -0.000517688596484
Gc3_330 0 n6 ns330 0 -0.000420493892076
Gc3_331 0 n6 ns331 0 0.000108664103275
Gc3_332 0 n6 ns332 0 0.000988644090367
Gc3_333 0 n6 ns333 0 0.000488819746676
Gc3_334 0 n6 ns334 0 0.000186866433934
Gc3_335 0 n6 ns335 0 -7.13544275413e-05
Gc3_336 0 n6 ns336 0 -5.23183848803e-05
Gc3_337 0 n6 ns337 0 -0.000182618091796
Gc3_338 0 n6 ns338 0 0.011765241878
Gc3_339 0 n6 ns339 0 -0.0100451540743
Gc3_340 0 n6 ns340 0 0.000364024093232
Gc3_341 0 n6 ns341 0 -7.69081204897e-06
Gc3_342 0 n6 ns342 0 -2.73474556821e-05
Gc3_343 0 n6 ns343 0 -0.00465183363514
Gc3_344 0 n6 ns344 0 0.000414281765981
Gc3_345 0 n6 ns345 0 -0.0068550706116
Gc3_346 0 n6 ns346 0 -6.26191907513e-05
Gc3_347 0 n6 ns347 0 -0.00114267651534
Gc3_348 0 n6 ns348 0 -9.74196567282e-05
Gc3_349 0 n6 ns349 0 0.000173609830772
Gc3_350 0 n6 ns350 0 -0.000103446535557
Gc3_351 0 n6 ns351 0 -4.4876121037e-05
Gc3_352 0 n6 ns352 0 -0.00203497373408
Gc3_353 0 n6 ns353 0 0.00316500326853
Gc3_354 0 n6 ns354 0 0.000368407167099
Gc3_355 0 n6 ns355 0 -0.000629063460936
Gc3_356 0 n6 ns356 0 0.000399711749903
Gc3_357 0 n6 ns357 0 -0.000354836196494
Gc3_358 0 n6 ns358 0 0.000532216465264
Gc3_359 0 n6 ns359 0 0.00280536581885
Gc3_360 0 n6 ns360 0 0.000774459640209
Gc3_361 0 n6 ns361 0 -0.000717311870675
Gc3_362 0 n6 ns362 0 0.000395875558842
Gc3_363 0 n6 ns363 0 0.000180269956587
Gc3_364 0 n6 ns364 0 0.00277384892795
Gc3_365 0 n6 ns365 0 0.00152127458141
Gc3_366 0 n6 ns366 0 0.000423802926913
Gc3_367 0 n6 ns367 0 0.00192629513763
Gc3_368 0 n6 ns368 0 0.00159352407847
Gc3_369 0 n6 ns369 0 -0.00153840200632
Gc3_370 0 n6 ns370 0 0.00395065147774
Gc3_371 0 n6 ns371 0 -0.00152047601574
Gc3_372 0 n6 ns372 0 0.00123625239075
Gc3_373 0 n6 ns373 0 0.000719984936392
Gc3_374 0 n6 ns374 0 0.00295886252162
Gc3_375 0 n6 ns375 0 0.000337118677865
Gc3_376 0 n6 ns376 0 -0.00998116436546
Gc3_377 0 n6 ns377 0 0.0137510561481
Gc3_378 0 n6 ns378 0 0.00705267524108
Gc3_379 0 n6 ns379 0 -1.27763548493e-06
Gc3_380 0 n6 ns380 0 3.23048632438e-05
Gc3_381 0 n6 ns381 0 -0.00489722916399
Gc3_382 0 n6 ns382 0 -0.000520139469289
Gc3_383 0 n6 ns383 0 -0.00426715899177
Gc3_384 0 n6 ns384 0 0.000240498941205
Gc3_385 0 n6 ns385 0 -0.00130981856921
Gc3_386 0 n6 ns386 0 -0.000271237308189
Gc3_387 0 n6 ns387 0 0.000828752237602
Gc3_388 0 n6 ns388 0 -0.000130011664043
Gc3_389 0 n6 ns389 0 -2.80324130401e-05
Gc3_390 0 n6 ns390 0 1.9077892725e-05
Gc3_391 0 n6 ns391 0 0.00190189495316
Gc3_392 0 n6 ns392 0 0.000524589092507
Gc3_393 0 n6 ns393 0 -0.00013458214249
Gc3_394 0 n6 ns394 0 0.000367648073487
Gc3_395 0 n6 ns395 0 -0.000502850715907
Gc3_396 0 n6 ns396 0 0.00130883507817
Gc3_397 0 n6 ns397 0 -0.000967548708198
Gc3_398 0 n6 ns398 0 -0.00044451192416
Gc3_399 0 n6 ns399 0 -0.000296949658611
Gc3_400 0 n6 ns400 0 0.000398721765939
Gc3_401 0 n6 ns401 0 0.000292755609309
Gc3_402 0 n6 ns402 0 -0.0016659531542
Gc3_403 0 n6 ns403 0 5.49452483812e-05
Gc3_404 0 n6 ns404 0 0.000853397363771
Gc3_405 0 n6 ns405 0 0.00218956608149
Gc3_406 0 n6 ns406 0 0.0012937333399
Gc3_407 0 n6 ns407 0 -0.00193330763901
Gc3_408 0 n6 ns408 0 0.000252553172175
Gc3_409 0 n6 ns409 0 0.000703510196969
Gc3_410 0 n6 ns410 0 9.51178205647e-05
Gc3_411 0 n6 ns411 0 7.61277088268e-05
Gc3_412 0 n6 ns412 0 0.00255852219972
Gc3_413 0 n6 ns413 0 0.000150641348884
Gc3_414 0 n6 ns414 0 0.0245608108909
Gc3_415 0 n6 ns415 0 -0.0240859717404
Gc3_416 0 n6 ns416 0 0.00660293845825
Gc3_417 0 n6 ns417 0 -3.42304767512e-06
Gc3_418 0 n6 ns418 0 2.98106945013e-05
Gc3_419 0 n6 ns419 0 -0.00136739509407
Gc3_420 0 n6 ns420 0 -8.32083195738e-06
Gc3_421 0 n6 ns421 0 0.00152100834157
Gc3_422 0 n6 ns422 0 0.000735775877402
Gc3_423 0 n6 ns423 0 -0.000535059411874
Gc3_424 0 n6 ns424 0 0.000683358950135
Gc3_425 0 n6 ns425 0 -2.11468440104e-05
Gc3_426 0 n6 ns426 0 -0.000120364247599
Gc3_427 0 n6 ns427 0 1.02773951012e-05
Gc3_428 0 n6 ns428 0 -0.00271250196328
Gc3_429 0 n6 ns429 0 -0.000705028484668
Gc3_430 0 n6 ns430 0 0.00102286178745
Gc3_431 0 n6 ns431 0 -0.000149491796526
Gc3_432 0 n6 ns432 0 0.00025647167588
Gc3_433 0 n6 ns433 0 -0.000589175788372
Gc3_434 0 n6 ns434 0 -0.00217645111408
Gc3_435 0 n6 ns435 0 -0.00079819820469
Gc3_436 0 n6 ns436 0 -0.000219472730814
Gc3_437 0 n6 ns437 0 0.000523154593838
Gc3_438 0 n6 ns438 0 0.000537200683407
Gc3_439 0 n6 ns439 0 0.000174006101659
Gc3_440 0 n6 ns440 0 -0.00237674509286
Gc3_441 0 n6 ns441 0 0.00322972274664
Gc3_442 0 n6 ns442 0 0.000803822430102
Gc3_443 0 n6 ns443 0 0.00105168706728
Gc3_444 0 n6 ns444 0 0.000440997290278
Gc3_445 0 n6 ns445 0 -0.00162377425047
Gc3_446 0 n6 ns446 0 -8.49857943429e-06
Gc3_447 0 n6 ns447 0 0.00193164732918
Gc3_448 0 n6 ns448 0 -0.00168791836814
Gc3_449 0 n6 ns449 0 0.000699380494649
Gc3_450 0 n6 ns450 0 0.00178005629596
Gc3_451 0 n6 ns451 0 -0.000262106034526
Gc3_452 0 n6 ns452 0 0.0410213810569
Gc3_453 0 n6 ns453 0 -0.0415242322324
Gc3_454 0 n6 ns454 0 0.00350217126822
Gc3_455 0 n6 ns455 0 9.52463057811e-08
Gc3_456 0 n6 ns456 0 1.28122151452e-05
Gc3_457 0 n6 ns457 0 -0.000931054190035
Gc3_458 0 n6 ns458 0 0.00163882220731
Gc3_459 0 n6 ns459 0 -0.00270750000849
Gc3_460 0 n6 ns460 0 -3.02597254275e-05
Gc3_461 0 n6 ns461 0 -0.000222410839877
Gc3_462 0 n6 ns462 0 6.14141728937e-05
Gc3_463 0 n6 ns463 0 -0.000315593940646
Gc3_464 0 n6 ns464 0 -3.66350079301e-05
Gc3_465 0 n6 ns465 0 -2.62362232109e-05
Gc3_466 0 n6 ns466 0 -0.00114888840189
Gc3_467 0 n6 ns467 0 0.00170361257534
Gc3_468 0 n6 ns468 0 0.00015377190559
Gc3_469 0 n6 ns469 0 -0.000276261866541
Gc3_470 0 n6 ns470 0 -4.85527372438e-05
Gc3_471 0 n6 ns471 0 -0.000406096969248
Gc3_472 0 n6 ns472 0 0.000328398500376
Gc3_473 0 n6 ns473 0 0.00137455424608
Gc3_474 0 n6 ns474 0 -0.000209837578813
Gc3_475 0 n6 ns475 0 -0.000162962574478
Gc3_476 0 n6 ns476 0 0.000304554258954
Gc3_477 0 n6 ns477 0 -0.000102496850422
Gc3_478 0 n6 ns478 0 0.00157175025881
Gc3_479 0 n6 ns479 0 0.00138291883705
Gc3_480 0 n6 ns480 0 0.000229872119763
Gc3_481 0 n6 ns481 0 0.000740033628262
Gc3_482 0 n6 ns482 0 4.39354785034e-06
Gc3_483 0 n6 ns483 0 -0.00111989868175
Gc3_484 0 n6 ns484 0 0.00157159145848
Gc3_485 0 n6 ns485 0 -0.000332615909795
Gc3_486 0 n6 ns486 0 -0.000872678331062
Gc3_487 0 n6 ns487 0 0.00151221641483
Gc3_488 0 n6 ns488 0 0.00103662984238
Gc3_489 0 n6 ns489 0 -0.000640593899828
Gc3_490 0 n6 ns490 0 0.0309502200134
Gc3_491 0 n6 ns491 0 -0.0284999160008
Gc3_492 0 n6 ns492 0 0.00155889894676
Gc3_493 0 n6 ns493 0 -5.60671154336e-06
Gc3_494 0 n6 ns494 0 -8.59103644808e-06
Gc3_495 0 n6 ns495 0 -0.000507514559278
Gc3_496 0 n6 ns496 0 0.000881263499321
Gc3_497 0 n6 ns497 0 -0.00180433067102
Gc3_498 0 n6 ns498 0 -0.000303081241639
Gc3_499 0 n6 ns499 0 0.000113537869231
Gc3_500 0 n6 ns500 0 -0.000134656818748
Gc3_501 0 n6 ns501 0 0.000126752086576
Gc3_502 0 n6 ns502 0 -1.07541075677e-05
Gc3_503 0 n6 ns503 0 1.29086319871e-05
Gc3_504 0 n6 ns504 0 0.000777717468362
Gc3_505 0 n6 ns505 0 0.000578030634287
Gc3_506 0 n6 ns506 0 8.96908349004e-05
Gc3_507 0 n6 ns507 0 0.000190122483866
Gc3_508 0 n6 ns508 0 -0.000141389643123
Gc3_509 0 n6 ns509 0 -0.000201377843245
Gc3_510 0 n6 ns510 0 0.000732388643486
Gc3_511 0 n6 ns511 0 -0.00059894767533
Gc3_512 0 n6 ns512 0 -0.00048341942111
Gc3_513 0 n6 ns513 0 0.000415691101749
Gc3_514 0 n6 ns514 0 0.000173032087883
Gc3_515 0 n6 ns515 0 -8.91613780947e-05
Gc3_516 0 n6 ns516 0 0.000154998568295
Gc3_517 0 n6 ns517 0 -6.74066433591e-05
Gc3_518 0 n6 ns518 0 0.000637495866083
Gc3_519 0 n6 ns519 0 0.000843961567795
Gc3_520 0 n6 ns520 0 -0.000318988083233
Gc3_521 0 n6 ns521 0 -0.000848485927235
Gc3_522 0 n6 ns522 0 -0.000406166290303
Gc3_523 0 n6 ns523 0 -0.000305252965528
Gc3_524 0 n6 ns524 0 0.000262827790402
Gc3_525 0 n6 ns525 0 0.00128051165309
Gc3_526 0 n6 ns526 0 0.000488797195569
Gc3_527 0 n6 ns527 0 -0.000657131315734
Gc3_528 0 n6 ns528 0 0.0164474685028
Gc3_529 0 n6 ns529 0 -0.01513006029
Gc3_530 0 n6 ns530 0 0.000764732409876
Gc3_531 0 n6 ns531 0 -4.87792892811e-06
Gc3_532 0 n6 ns532 0 -2.63556567878e-05
Gc3_533 0 n6 ns533 0 0.000140421300179
Gc3_534 0 n6 ns534 0 -0.000129085560506
Gc3_535 0 n6 ns535 0 -0.00094397559154
Gc3_536 0 n6 ns536 0 -0.000246264522311
Gc3_537 0 n6 ns537 0 0.000104838187615
Gc3_538 0 n6 ns538 0 3.28029780688e-05
Gc3_539 0 n6 ns539 0 0.000127756291892
Gc3_540 0 n6 ns540 0 3.19563868268e-05
Gc3_541 0 n6 ns541 0 1.52194415219e-05
Gc3_542 0 n6 ns542 0 0.000115760223122
Gc3_543 0 n6 ns543 0 0.000115249462767
Gc3_544 0 n6 ns544 0 0.00025248625016
Gc3_545 0 n6 ns545 0 -0.000120458556671
Gc3_546 0 n6 ns546 0 -0.00016460155375
Gc3_547 0 n6 ns547 0 -3.47959979463e-05
Gc3_548 0 n6 ns548 0 -0.000737077243155
Gc3_549 0 n6 ns549 0 -0.000182063775171
Gc3_550 0 n6 ns550 0 0.00035199146394
Gc3_551 0 n6 ns551 0 0.000597766465277
Gc3_552 0 n6 ns552 0 0.000122193581461
Gc3_553 0 n6 ns553 0 -0.000160036960282
Gc3_554 0 n6 ns554 0 0.000266975211822
Gc3_555 0 n6 ns555 0 0.00118512964598
Gc3_556 0 n6 ns556 0 0.00112275566267
Gc3_557 0 n6 ns557 0 -4.93408816147e-05
Gc3_558 0 n6 ns558 0 -0.000714535093433
Gc3_559 0 n6 ns559 0 -0.000366735556239
Gc3_560 0 n6 ns560 0 0.000623495209346
Gc3_561 0 n6 ns561 0 0.000697721408952
Gc3_562 0 n6 ns562 0 0.0003633488484
Gc3_563 0 n6 ns563 0 0.00027046265523
Gc3_564 0 n6 ns564 0 5.8089750786e-05
Gc3_565 0 n6 ns565 0 -0.000398851205939
Gc3_566 0 n6 ns566 0 0.0140826840179
Gc3_567 0 n6 ns567 0 -0.0123371534732
Gc3_568 0 n6 ns568 0 0.000494760780578
Gc3_569 0 n6 ns569 0 -3.58479117526e-06
Gc3_570 0 n6 ns570 0 -3.52678628795e-05
Gc3_571 0 n6 ns571 0 0.000117133515536
Gc3_572 0 n6 ns572 0 -0.000233474950288
Gc3_573 0 n6 ns573 0 -0.00148974713148
Gc3_574 0 n6 ns574 0 -0.000127384452923
Gc3_575 0 n6 ns575 0 -0.000100071549139
Gc3_576 0 n6 ns576 0 -1.34735896973e-05
Gc3_577 0 n6 ns577 0 -4.53595349854e-05
Gc3_578 0 n6 ns578 0 -9.27597647519e-06
Gc3_579 0 n6 ns579 0 -1.33045843572e-05
Gc3_580 0 n6 ns580 0 -6.38513327411e-05
Gc3_581 0 n6 ns581 0 0.00111191040332
Gc3_582 0 n6 ns582 0 -3.86542832806e-05
Gc3_583 0 n6 ns583 0 -0.000560587768762
Gc3_584 0 n6 ns584 0 -0.000162452775257
Gc3_585 0 n6 ns585 0 5.40552063248e-05
Gc3_586 0 n6 ns586 0 -0.000382825305698
Gc3_587 0 n6 ns587 0 0.000889356743361
Gc3_588 0 n6 ns588 0 0.000638270356635
Gc3_589 0 n6 ns589 0 -4.02724040692e-05
Gc3_590 0 n6 ns590 0 -1.18057697847e-05
Gc3_591 0 n6 ns591 0 -0.000176146353428
Gc3_592 0 n6 ns592 0 0.00111461429341
Gc3_593 0 n6 ns593 0 0.000963045304003
Gc3_594 0 n6 ns594 0 0.000649035253041
Gc3_595 0 n6 ns595 0 -0.000572147663124
Gc3_596 0 n6 ns596 0 -0.000561823683224
Gc3_597 0 n6 ns597 0 6.51413186228e-05
Gc3_598 0 n6 ns598 0 0.00118097399715
Gc3_599 0 n6 ns599 0 0.000666104980098
Gc3_600 0 n6 ns600 0 0.000242955913078
Gc3_601 0 n6 ns601 0 -8.57605639531e-05
Gc3_602 0 n6 ns602 0 -6.8129557586e-05
Gc3_603 0 n6 ns603 0 -0.000232927547869
Gc3_604 0 n6 ns604 0 0.0141294490042
Gc3_605 0 n6 ns605 0 -0.0120853497652
Gc3_606 0 n6 ns606 0 0.000435438879883
Gc3_607 0 n6 ns607 0 -4.92568239407e-06
Gc3_608 0 n6 ns608 0 -3.07216359768e-05
Gc3_609 0 n6 ns609 0 0.000241840314321
Gc3_610 0 n6 ns610 0 -0.000289280325462
Gc3_611 0 n6 ns611 0 0.00744641178217
Gc3_612 0 n6 ns612 0 -9.88563163065e-05
Gc3_613 0 n6 ns613 0 -6.17609685817e-05
Gc3_614 0 n6 ns614 0 0.00026500663131
Gc3_615 0 n6 ns615 0 -0.000760318160802
Gc3_616 0 n6 ns616 0 -0.000136173675245
Gc3_617 0 n6 ns617 0 1.56928213196e-05
Gc3_618 0 n6 ns618 0 0.00185394214931
Gc3_619 0 n6 ns619 0 -0.00171306318822
Gc3_620 0 n6 ns620 0 -0.00044323255194
Gc3_621 0 n6 ns621 0 0.000758258465459
Gc3_622 0 n6 ns622 0 -0.000258231678607
Gc3_623 0 n6 ns623 0 0.000209516273028
Gc3_624 0 n6 ns624 0 -0.00224504993517
Gc3_625 0 n6 ns625 0 -0.00175671452909
Gc3_626 0 n6 ns626 0 0.000122272854233
Gc3_627 0 n6 ns627 0 0.000154359122428
Gc3_628 0 n6 ns628 0 0.000249938528504
Gc3_629 0 n6 ns629 0 0.000320587386877
Gc3_630 0 n6 ns630 0 -0.000291712944421
Gc3_631 0 n6 ns631 0 -0.0055657785844
Gc3_632 0 n6 ns632 0 -0.0020517090025
Gc3_633 0 n6 ns633 0 0.000799548602079
Gc3_634 0 n6 ns634 0 0.000215826883795
Gc3_635 0 n6 ns635 0 0.000994710280105
Gc3_636 0 n6 ns636 0 -0.00778815168375
Gc3_637 0 n6 ns637 0 -0.00317340258376
Gc3_638 0 n6 ns638 0 -0.00218205181558
Gc3_639 0 n6 ns639 0 0.000915353784223
Gc3_640 0 n6 ns640 0 0.00223412488793
Gc3_641 0 n6 ns641 0 0.00066423306441
Gc3_642 0 n6 ns642 0 -0.0776822597117
Gc3_643 0 n6 ns643 0 0.0721133631502
Gc3_644 0 n6 ns644 0 -0.00506761922153
Gc3_645 0 n6 ns645 0 -6.62397881271e-06
Gc3_646 0 n6 ns646 0 2.3313352576e-05
Gc3_647 0 n6 ns647 0 -0.000368880301751
Gc3_648 0 n6 ns648 0 -0.000443453701221
Gc3_649 0 n6 ns649 0 0.00566923431014
Gc3_650 0 n6 ns650 0 -0.000851349376416
Gc3_651 0 n6 ns651 0 -0.00090922687511
Gc3_652 0 n6 ns652 0 0.00142436759226
Gc3_653 0 n6 ns653 0 0.000412837535969
Gc3_654 0 n6 ns654 0 -0.000193265236392
Gc3_655 0 n6 ns655 0 -0.000150123260838
Gc3_656 0 n6 ns656 0 0.00154465780088
Gc3_657 0 n6 ns657 0 -0.00191623302323
Gc3_658 0 n6 ns658 0 -0.000381064483499
Gc3_659 0 n6 ns659 0 0.00101843060027
Gc3_660 0 n6 ns660 0 -0.000250994647742
Gc3_661 0 n6 ns661 0 0.000270011309973
Gc3_662 0 n6 ns662 0 -0.000994346700386
Gc3_663 0 n6 ns663 0 -0.00235821939028
Gc3_664 0 n6 ns664 0 -0.000280320634894
Gc3_665 0 n6 ns665 0 -0.000230600509096
Gc3_666 0 n6 ns666 0 0.000191547668944
Gc3_667 0 n6 ns667 0 0.000392307447137
Gc3_668 0 n6 ns668 0 0.000649447252296
Gc3_669 0 n6 ns669 0 -0.00467480526313
Gc3_670 0 n6 ns670 0 -0.00189179086708
Gc3_671 0 n6 ns671 0 8.5037814183e-05
Gc3_672 0 n6 ns672 0 -0.000222956690641
Gc3_673 0 n6 ns673 0 0.00126993774907
Gc3_674 0 n6 ns674 0 -0.00974436976319
Gc3_675 0 n6 ns675 0 -0.0042140296527
Gc3_676 0 n6 ns676 0 -0.00169505996469
Gc3_677 0 n6 ns677 0 0.00151809425543
Gc3_678 0 n6 ns678 0 0.00282228422834
Gc3_679 0 n6 ns679 0 0.000788383175088
Gc3_680 0 n6 ns680 0 -0.0653864951937
Gc3_681 0 n6 ns681 0 0.0632089945516
Gc3_682 0 n6 ns682 0 -0.00648535714009
Gc3_683 0 n6 ns683 0 -9.23852765602e-06
Gc3_684 0 n6 ns684 0 2.99229583905e-05
Gc3_685 0 n6 ns685 0 -0.0175123214145
Gc3_686 0 n6 ns686 0 -0.000546617781925
Gc3_687 0 n6 ns687 0 0.0192151034214
Gc3_688 0 n6 ns688 0 0.00635254314553
Gc3_689 0 n6 ns689 0 0.0101912780492
Gc3_690 0 n6 ns690 0 0.00150890405438
Gc3_691 0 n6 ns691 0 -0.00324412417215
Gc3_692 0 n6 ns692 0 -0.000495792653742
Gc3_693 0 n6 ns693 0 4.36660659774e-05
Gc3_694 0 n6 ns694 0 -0.00207522469871
Gc3_695 0 n6 ns695 0 -0.0140078316208
Gc3_696 0 n6 ns696 0 0.00171836332738
Gc3_697 0 n6 ns697 0 0.00176952459907
Gc3_698 0 n6 ns698 0 6.20937243615e-05
Gc3_699 0 n6 ns699 0 0.000240044634497
Gc3_700 0 n6 ns700 0 0.00109822406898
Gc3_701 0 n6 ns701 0 0.00111951203615
Gc3_702 0 n6 ns702 0 -0.000261280510824
Gc3_703 0 n6 ns703 0 -0.000231055047049
Gc3_704 0 n6 ns704 0 0.00039322516233
Gc3_705 0 n6 ns705 0 0.00048313163091
Gc3_706 0 n6 ns706 0 -0.0118973751004
Gc3_707 0 n6 ns707 0 -0.00718895738583
Gc3_708 0 n6 ns708 0 -0.00258166799277
Gc3_709 0 n6 ns709 0 -0.00120616294239
Gc3_710 0 n6 ns710 0 -0.000495910465977
Gc3_711 0 n6 ns711 0 0.00219979667651
Gc3_712 0 n6 ns712 0 0.00994004829771
Gc3_713 0 n6 ns713 0 -0.00597819638919
Gc3_714 0 n6 ns714 0 0.00109600620164
Gc3_715 0 n6 ns715 0 0.00157019982476
Gc3_716 0 n6 ns716 0 0.00334860887329
Gc3_717 0 n6 ns717 0 0.000277856284588
Gc3_718 0 n6 ns718 0 -0.107735036987
Gc3_719 0 n6 ns719 0 0.0701459719558
Gc3_720 0 n6 ns720 0 -0.0088445426426
Gc3_721 0 n6 ns721 0 -1.45081474661e-05
Gc3_722 0 n6 ns722 0 2.92989069836e-05
Gc3_723 0 n6 ns723 0 -0.000372137583255
Gc3_724 0 n6 ns724 0 -5.10968398352e-05
Gc3_725 0 n6 ns725 0 0.00639630091522
Gc3_726 0 n6 ns726 0 -0.00111572019128
Gc3_727 0 n6 ns727 0 -0.000582450914099
Gc3_728 0 n6 ns728 0 0.00184176734437
Gc3_729 0 n6 ns729 0 0.0004313561231
Gc3_730 0 n6 ns730 0 -0.000178117879794
Gc3_731 0 n6 ns731 0 -0.00020496927255
Gc3_732 0 n6 ns732 0 0.00189460399721
Gc3_733 0 n6 ns733 0 -0.00160277676098
Gc3_734 0 n6 ns734 0 -0.000606068070993
Gc3_735 0 n6 ns735 0 0.000382811825404
Gc3_736 0 n6 ns736 0 -0.000270116838307
Gc3_737 0 n6 ns737 0 0.000519078735912
Gc3_738 0 n6 ns738 0 5.75388542354e-05
Gc3_739 0 n6 ns739 0 -0.00386935299909
Gc3_740 0 n6 ns740 0 -0.00140211961534
Gc3_741 0 n6 ns741 0 0.000279199321764
Gc3_742 0 n6 ns742 0 0.000334878594427
Gc3_743 0 n6 ns743 0 0.000497744247212
Gc3_744 0 n6 ns744 0 0.000811648038204
Gc3_745 0 n6 ns745 0 -0.00497340093318
Gc3_746 0 n6 ns746 0 -0.00248908920211
Gc3_747 0 n6 ns747 0 -0.00121872213938
Gc3_748 0 n6 ns748 0 -0.000129547667263
Gc3_749 0 n6 ns749 0 0.00225526991506
Gc3_750 0 n6 ns750 0 -0.0124144364516
Gc3_751 0 n6 ns751 0 -0.00602863186903
Gc3_752 0 n6 ns752 0 -0.00118305463334
Gc3_753 0 n6 ns753 0 0.00309835073055
Gc3_754 0 n6 ns754 0 0.00315733831473
Gc3_755 0 n6 ns755 0 0.000335823630431
Gc3_756 0 n6 ns756 0 -0.0723727859384
Gc3_757 0 n6 ns757 0 0.0684312085061
Gc3_758 0 n6 ns758 0 -0.00650126849248
Gc3_759 0 n6 ns759 0 -1.17508234916e-05
Gc3_760 0 n6 ns760 0 2.6058374606e-05
Gc3_761 0 n6 ns761 0 0.000752765335229
Gc3_762 0 n6 ns762 0 -0.0010921660853
Gc3_763 0 n6 ns763 0 0.0115177824354
Gc3_764 0 n6 ns764 0 0.000244719168886
Gc3_765 0 n6 ns765 0 0.000644423723158
Gc3_766 0 n6 ns766 0 0.000366441394947
Gc3_767 0 n6 ns767 0 -0.000248469076888
Gc3_768 0 n6 ns768 0 -0.000116259478774
Gc3_769 0 n6 ns769 0 -6.32033382011e-06
Gc3_770 0 n6 ns770 0 0.000375229647325
Gc3_771 0 n6 ns771 0 -0.00444069934945
Gc3_772 0 n6 ns772 0 -0.000113494026116
Gc3_773 0 n6 ns773 0 0.00106569091515
Gc3_774 0 n6 ns774 0 0.000147819810992
Gc3_775 0 n6 ns775 0 0.000555218049337
Gc3_776 0 n6 ns776 0 -0.00126692789425
Gc3_777 0 n6 ns777 0 -0.00119481234046
Gc3_778 0 n6 ns778 0 -0.000641907365221
Gc3_779 0 n6 ns779 0 0.000236937855052
Gc3_780 0 n6 ns780 0 0.000353595081937
Gc3_781 0 n6 ns781 0 0.000127387948624
Gc3_782 0 n6 ns782 0 -0.0025055995496
Gc3_783 0 n6 ns783 0 -0.0050133530807
Gc3_784 0 n6 ns784 0 -0.00159014433348
Gc3_785 0 n6 ns785 0 -0.000201597761302
Gc3_786 0 n6 ns786 0 0.000416006413754
Gc3_787 0 n6 ns787 0 0.00161667325469
Gc3_788 0 n6 ns788 0 -0.00989223861536
Gc3_789 0 n6 ns789 0 -0.00607769437341
Gc3_790 0 n6 ns790 0 -0.00164182524298
Gc3_791 0 n6 ns791 0 0.0042007613316
Gc3_792 0 n6 ns792 0 0.00242520374571
Gc3_793 0 n6 ns793 0 -0.000295115204223
Gc3_794 0 n6 ns794 0 -0.0773657723286
Gc3_795 0 n6 ns795 0 0.0671980486691
Gc3_796 0 n6 ns796 0 -0.00311375665695
Gc3_797 0 n6 ns797 0 -9.38604135153e-06
Gc3_798 0 n6 ns798 0 -1.35226584054e-07
Gc3_799 0 n6 ns799 0 0.000305148491703
Gc3_800 0 n6 ns800 0 -0.000640809831479
Gc3_801 0 n6 ns801 0 0.00555904183105
Gc3_802 0 n6 ns802 0 -5.2966392244e-05
Gc3_803 0 n6 ns803 0 0.000371549934948
Gc3_804 0 n6 ns804 0 0.000369822915493
Gc3_805 0 n6 ns805 0 0.000175343372857
Gc3_806 0 n6 ns806 0 2.52490480478e-05
Gc3_807 0 n6 ns807 0 -2.60823601187e-06
Gc3_808 0 n6 ns808 0 -0.000420147001111
Gc3_809 0 n6 ns809 0 -0.00207893805366
Gc3_810 0 n6 ns810 0 0.000153528609964
Gc3_811 0 n6 ns811 0 0.000357665389172
Gc3_812 0 n6 ns812 0 0.000228437154559
Gc3_813 0 n6 ns813 0 0.000299178868862
Gc3_814 0 n6 ns814 0 0.000762725213273
Gc3_815 0 n6 ns815 0 -0.000726832186291
Gc3_816 0 n6 ns816 0 -0.000918040420708
Gc3_817 0 n6 ns817 0 5.58030635544e-05
Gc3_818 0 n6 ns818 0 0.000128806824898
Gc3_819 0 n6 ns819 0 2.45075878058e-06
Gc3_820 0 n6 ns820 0 -0.00101083511263
Gc3_821 0 n6 ns821 0 -0.00245448120728
Gc3_822 0 n6 ns822 0 -0.00113764326568
Gc3_823 0 n6 ns823 0 -0.00110915639612
Gc3_824 0 n6 ns824 0 0.000340089724628
Gc3_825 0 n6 ns825 0 0.00145164209682
Gc3_826 0 n6 ns826 0 -0.00623814681318
Gc3_827 0 n6 ns827 0 -0.00387668755615
Gc3_828 0 n6 ns828 0 -0.000186863230949
Gc3_829 0 n6 ns829 0 0.00333085352013
Gc3_830 0 n6 ns830 0 0.00136215158285
Gc3_831 0 n6 ns831 0 -0.000662897552721
Gc3_832 0 n6 ns832 0 -0.0325691792042
Gc3_833 0 n6 ns833 0 0.0273531642338
Gc3_834 0 n6 ns834 0 -0.00107948235938
Gc3_835 0 n6 ns835 0 -4.67347921153e-06
Gc3_836 0 n6 ns836 0 -2.08769104154e-05
Gc3_837 0 n6 ns837 0 0.000594652542447
Gc3_838 0 n6 ns838 0 -0.000747707677911
Gc3_839 0 n6 ns839 0 0.00341819508896
Gc3_840 0 n6 ns840 0 -0.000174314321763
Gc3_841 0 n6 ns841 0 0.000339613163821
Gc3_842 0 n6 ns842 0 0.000259881505485
Gc3_843 0 n6 ns843 0 -3.94225287566e-05
Gc3_844 0 n6 ns844 0 3.20811919877e-06
Gc3_845 0 n6 ns845 0 -4.87117021321e-05
Gc3_846 0 n6 ns846 0 0.000486570985591
Gc3_847 0 n6 ns847 0 -0.000565131653895
Gc3_848 0 n6 ns848 0 -0.000401347970274
Gc3_849 0 n6 ns849 0 -2.07740157053e-05
Gc3_850 0 n6 ns850 0 0.000131929522851
Gc3_851 0 n6 ns851 0 0.000181891129734
Gc3_852 0 n6 ns852 0 -1.39258681715e-05
Gc3_853 0 n6 ns853 0 -0.00124722443826
Gc3_854 0 n6 ns854 0 -0.00040883340635
Gc3_855 0 n6 ns855 0 0.000675878701861
Gc3_856 0 n6 ns856 0 0.000133867238743
Gc3_857 0 n6 ns857 0 -4.93953686765e-05
Gc3_858 0 n6 ns858 0 -0.000326372542562
Gc3_859 0 n6 ns859 0 -0.00141263746803
Gc3_860 0 n6 ns860 0 -0.00136700592637
Gc3_861 0 n6 ns861 0 -0.000593213365383
Gc3_862 0 n6 ns862 0 0.0006644253852
Gc3_863 0 n6 ns863 0 0.000893745133172
Gc3_864 0 n6 ns864 0 -0.00418249907624
Gc3_865 0 n6 ns865 0 -0.0012633048498
Gc3_866 0 n6 ns866 0 0.000635131780778
Gc3_867 0 n6 ns867 0 0.0018691633528
Gc3_868 0 n6 ns868 0 0.000606988916058
Gc3_869 0 n6 ns869 0 -0.000620440241862
Gc3_870 0 n6 ns870 0 -0.011586808229
Gc3_871 0 n6 ns871 0 0.00921323176123
Gc3_872 0 n6 ns872 0 -0.000327669271325
Gc3_873 0 n6 ns873 0 3.6049731246e-06
Gc3_874 0 n6 ns874 0 -3.50357504879e-05
Gc3_875 0 n6 ns875 0 0.000520718652382
Gc3_876 0 n6 ns876 0 -0.00105373301177
Gc3_877 0 n6 ns877 0 0.00192904019909
Gc3_878 0 n6 ns878 0 -0.00011335811562
Gc3_879 0 n6 ns879 0 0.000142817074516
Gc3_880 0 n6 ns880 0 2.83869340418e-05
Gc3_881 0 n6 ns881 0 3.53996219076e-05
Gc3_882 0 n6 ns882 0 -5.59420518048e-06
Gc3_883 0 n6 ns883 0 -2.87578455557e-07
Gc3_884 0 n6 ns884 0 0.0002862483347
Gc3_885 0 n6 ns885 0 -0.000898568022261
Gc3_886 0 n6 ns886 0 -0.000253654989132
Gc3_887 0 n6 ns887 0 0.000509014869697
Gc3_888 0 n6 ns888 0 0.000200650145625
Gc3_889 0 n6 ns889 0 3.51937561972e-05
Gc3_890 0 n6 ns890 0 -0.000650060477193
Gc3_891 0 n6 ns891 0 -5.59622531502e-05
Gc3_892 0 n6 ns892 0 0.000417891788788
Gc3_893 0 n6 ns893 0 0.000325892256831
Gc3_894 0 n6 ns894 0 3.20081112478e-05
Gc3_895 0 n6 ns895 0 -0.000166977558111
Gc3_896 0 n6 ns896 0 -2.55543098254e-05
Gc3_897 0 n6 ns897 0 -0.000931485800243
Gc3_898 0 n6 ns898 0 -0.00103989509717
Gc3_899 0 n6 ns899 0 7.52707924464e-05
Gc3_900 0 n6 ns900 0 0.000635079198017
Gc3_901 0 n6 ns901 0 0.000295938274883
Gc3_902 0 n6 ns902 0 -0.00198082619468
Gc3_903 0 n6 ns903 0 0.000359862167428
Gc3_904 0 n6 ns904 0 0.000694235213586
Gc3_905 0 n6 ns905 0 0.000677696730444
Gc3_906 0 n6 ns906 0 0.000160158674759
Gc3_907 0 n6 ns907 0 -0.000432081192314
Gc3_908 0 n6 ns908 0 -0.000317596835355
Gc3_909 0 n6 ns909 0 -3.982786237e-05
Gc3_910 0 n6 ns910 0 -4.10899771489e-05
Gc3_911 0 n6 ns911 0 7.30884720257e-06
Gc3_912 0 n6 ns912 0 -3.45327000001e-05
Gc3_913 0 n6 ns913 0 -4.90022399225e-05
Gc3_914 0 n6 ns914 0 2.48700341499e-05
Gc3_915 0 n6 ns915 0 -0.00088508901953
Gc3_916 0 n6 ns916 0 -0.00022850533789
Gc3_917 0 n6 ns917 0 0.000174101830801
Gc3_918 0 n6 ns918 0 6.00814869248e-05
Gc3_919 0 n6 ns919 0 0.000199156336288
Gc3_920 0 n6 ns920 0 3.65215364976e-05
Gc3_921 0 n6 ns921 0 -5.43594710428e-06
Gc3_922 0 n6 ns922 0 -0.00017705509221
Gc3_923 0 n6 ns923 0 -0.000764711723993
Gc3_924 0 n6 ns924 0 0.000176422271744
Gc3_925 0 n6 ns925 0 0.000543480305059
Gc3_926 0 n6 ns926 0 0.000163773212996
Gc3_927 0 n6 ns927 0 -8.97231613596e-05
Gc3_928 0 n6 ns928 0 -0.000244087991651
Gc3_929 0 n6 ns929 0 0.000719088648374
Gc3_930 0 n6 ns930 0 0.000522819683335
Gc3_931 0 n6 ns931 0 -0.000156733670145
Gc3_932 0 n6 ns932 0 -5.27307671076e-05
Gc3_933 0 n6 ns933 0 -0.000158133080478
Gc3_934 0 n6 ns934 0 0.000452610953699
Gc3_935 0 n6 ns935 0 -0.000379547338525
Gc3_936 0 n6 ns936 0 -0.000449938110445
Gc3_937 0 n6 ns937 0 5.96398263125e-05
Gc3_938 0 n6 ns938 0 0.000275195703972
Gc3_939 0 n6 ns939 0 7.61328956614e-05
Gc3_940 0 n6 ns940 0 5.73658704224e-05
Gc3_941 0 n6 ns941 0 0.000824578137652
Gc3_942 0 n6 ns942 0 0.00038447920209
Gc3_943 0 n6 ns943 0 -1.97886251846e-05
Gc3_944 0 n6 ns944 0 -3.92965316224e-05
Gc3_945 0 n6 ns945 0 -0.000230157695829
Gc3_946 0 n6 ns946 0 0.00851429129692
Gc3_947 0 n6 ns947 0 -0.0072586218528
Gc3_948 0 n6 ns948 0 0.000191856728836
Gc3_949 0 n6 ns949 0 6.22041296359e-06
Gc3_950 0 n6 ns950 0 -2.76941428825e-05
Gc3_951 0 n6 ns951 0 -0.0056653797083
Gc3_952 0 n6 ns952 0 -0.00427845960119
Gc3_953 0 n6 ns953 0 0.00662855947386
Gc3_954 0 n6 ns954 0 0.00244187173282
Gc3_955 0 n6 ns955 0 -0.00223554019754
Gc3_956 0 n6 ns956 0 0.000624225863761
Gc3_957 0 n6 ns957 0 0.00296188455614
Gc3_958 0 n6 ns958 0 1.33943329345e-05
Gc3_959 0 n6 ns959 0 -0.000274812420553
Gc3_960 0 n6 ns960 0 -0.00206380891864
Gc3_961 0 n6 ns961 0 -0.0011571349598
Gc3_962 0 n6 ns962 0 -3.78212158136e-05
Gc3_963 0 n6 ns963 0 0.00067035094363
Gc3_964 0 n6 ns964 0 -0.000256490537488
Gc3_965 0 n6 ns965 0 0.000282888153506
Gc3_966 0 n6 ns966 0 0.00328217515192
Gc3_967 0 n6 ns967 0 -0.000931463939493
Gc3_968 0 n6 ns968 0 -0.000524160976553
Gc3_969 0 n6 ns969 0 -0.00162680440285
Gc3_970 0 n6 ns970 0 -3.74044225793e-06
Gc3_971 0 n6 ns971 0 0.00020190054542
Gc3_972 0 n6 ns972 0 0.00243152000602
Gc3_973 0 n6 ns973 0 0.00201166178353
Gc3_974 0 n6 ns974 0 -6.48269269927e-05
Gc3_975 0 n6 ns975 0 -0.00212120231259
Gc3_976 0 n6 ns976 0 -0.00167446126116
Gc3_977 0 n6 ns977 0 0.00143754287731
Gc3_978 0 n6 ns978 0 -0.0116740937524
Gc3_979 0 n6 ns979 0 -0.00487606927742
Gc3_980 0 n6 ns980 0 0.00128329675901
Gc3_981 0 n6 ns981 0 0.00286144617977
Gc3_982 0 n6 ns982 0 0.00354673917793
Gc3_983 0 n6 ns983 0 0.000520981197184
Gc3_984 0 n6 ns984 0 0.0172371618488
Gc3_985 0 n6 ns985 0 -0.00749553857521
Gc3_986 0 n6 ns986 0 -0.0077784054428
Gc3_987 0 n6 ns987 0 -1.48071915471e-05
Gc3_988 0 n6 ns988 0 2.62645672333e-05
Gc3_989 0 n6 ns989 0 -0.00261820102326
Gc3_990 0 n6 ns990 0 -0.00255652351386
Gc3_991 0 n6 ns991 0 0.00690081184187
Gc3_992 0 n6 ns992 0 0.00100489332656
Gc3_993 0 n6 ns993 0 -0.00184060357298
Gc3_994 0 n6 ns994 0 0.00071256327578
Gc3_995 0 n6 ns995 0 0.00191762512684
Gc3_996 0 n6 ns996 0 3.38760783533e-05
Gc3_997 0 n6 ns997 0 -0.000237323948562
Gc3_998 0 n6 ns998 0 0.000281063330716
Gc3_999 0 n6 ns999 0 -0.000206685429083
Gc3_1000 0 n6 ns1000 0 -0.000638682339636
Gc3_1001 0 n6 ns1001 0 -4.82117516191e-05
Gc3_1002 0 n6 ns1002 0 -0.000408053822102
Gc3_1003 0 n6 ns1003 0 0.000447822590816
Gc3_1004 0 n6 ns1004 0 0.00210326326757
Gc3_1005 0 n6 ns1005 0 -0.00290029210227
Gc3_1006 0 n6 ns1006 0 -0.0011599727201
Gc3_1007 0 n6 ns1007 0 -0.000442485492437
Gc3_1008 0 n6 ns1008 0 0.000247616438647
Gc3_1009 0 n6 ns1009 0 0.000408461753286
Gc3_1010 0 n6 ns1010 0 0.00199046874011
Gc3_1011 0 n6 ns1011 0 -0.00162561631062
Gc3_1012 0 n6 ns1012 0 -0.00185997594886
Gc3_1013 0 n6 ns1013 0 -0.00200394792722
Gc3_1014 0 n6 ns1014 0 -0.000790137381484
Gc3_1015 0 n6 ns1015 0 0.00226389879032
Gc3_1016 0 n6 ns1016 0 -0.0111036167877
Gc3_1017 0 n6 ns1017 0 -0.00518813943161
Gc3_1018 0 n6 ns1018 0 -0.000124379286978
Gc3_1019 0 n6 ns1019 0 0.00237949874395
Gc3_1020 0 n6 ns1020 0 0.00319963219256
Gc3_1021 0 n6 ns1021 0 0.000344134592574
Gc3_1022 0 n6 ns1022 0 -0.0369364790025
Gc3_1023 0 n6 ns1023 0 0.03878351959
Gc3_1024 0 n6 ns1024 0 -0.00709999188768
Gc3_1025 0 n6 ns1025 0 -1.32368258351e-05
Gc3_1026 0 n6 ns1026 0 2.91922319381e-05
Gc3_1027 0 n6 ns1027 0 0.000220904250762
Gc3_1028 0 n6 ns1028 0 -0.0015290452747
Gc3_1029 0 n6 ns1029 0 0.0116899655429
Gc3_1030 0 n6 ns1030 0 0.000162034865116
Gc3_1031 0 n6 ns1031 0 0.000351212110977
Gc3_1032 0 n6 ns1032 0 0.000514732657546
Gc3_1033 0 n6 ns1033 0 -0.00047217159872
Gc3_1034 0 n6 ns1034 0 -0.000154924033549
Gc3_1035 0 n6 ns1035 0 -2.53594758534e-05
Gc3_1036 0 n6 ns1036 0 0.00128785160063
Gc3_1037 0 n6 ns1037 0 -0.00361829707751
Gc3_1038 0 n6 ns1038 0 -0.00045810927317
Gc3_1039 0 n6 ns1039 0 0.000846629245178
Gc3_1040 0 n6 ns1040 0 -4.87313936301e-05
Gc3_1041 0 n6 ns1041 0 0.000605494953291
Gc3_1042 0 n6 ns1042 0 -0.00152716955622
Gc3_1043 0 n6 ns1043 0 -0.00198613957748
Gc3_1044 0 n6 ns1044 0 -0.000708088659052
Gc3_1045 0 n6 ns1045 0 0.000356440112737
Gc3_1046 0 n6 ns1046 0 0.000418833106244
Gc3_1047 0 n6 ns1047 0 0.000240906003412
Gc3_1048 0 n6 ns1048 0 -0.0017794558813
Gc3_1049 0 n6 ns1049 0 -0.00565601300801
Gc3_1050 0 n6 ns1050 0 -0.00202049308377
Gc3_1051 0 n6 ns1051 0 -0.000271278732419
Gc3_1052 0 n6 ns1052 0 0.000343048035312
Gc3_1053 0 n6 ns1053 0 0.00185538524932
Gc3_1054 0 n6 ns1054 0 -0.0106929823101
Gc3_1055 0 n6 ns1055 0 -0.00615448981428
Gc3_1056 0 n6 ns1056 0 -0.00187787215247
Gc3_1057 0 n6 ns1057 0 0.00382834300351
Gc3_1058 0 n6 ns1058 0 0.00270024384639
Gc3_1059 0 n6 ns1059 0 -9.43971250943e-05
Gc3_1060 0 n6 ns1060 0 -0.0862790430633
Gc3_1061 0 n6 ns1061 0 0.0765030163636
Gc3_1062 0 n6 ns1062 0 -0.00418019261135
Gc3_1063 0 n6 ns1063 0 -9.58987667007e-06
Gc3_1064 0 n6 ns1064 0 1.24000788548e-05
Gc3_1065 0 n6 ns1065 0 0.000645313275166
Gc3_1066 0 n6 ns1066 0 -0.001517687933
Gc3_1067 0 n6 ns1067 0 0.00805736410845
Gc3_1068 0 n6 ns1068 0 0.000183919977725
Gc3_1069 0 n6 ns1069 0 9.4498526497e-06
Gc3_1070 0 n6 ns1070 0 4.76682572864e-05
Gc3_1071 0 n6 ns1071 0 0.000150313601153
Gc3_1072 0 n6 ns1072 0 1.53085556975e-05
Gc3_1073 0 n6 ns1073 0 4.96993385445e-05
Gc3_1074 0 n6 ns1074 0 -0.000440270694676
Gc3_1075 0 n6 ns1075 0 -0.00260030982695
Gc3_1076 0 n6 ns1076 0 0.00013278843551
Gc3_1077 0 n6 ns1077 0 0.00056672985183
Gc3_1078 0 n6 ns1078 0 0.000200875690669
Gc3_1079 0 n6 ns1079 0 0.000400506319948
Gc3_1080 0 n6 ns1080 0 0.000278423467589
Gc3_1081 0 n6 ns1081 0 -0.00035405786019
Gc3_1082 0 n6 ns1082 0 -0.000811188946062
Gc3_1083 0 n6 ns1083 0 -8.54526490561e-05
Gc3_1084 0 n6 ns1084 0 0.000194932838086
Gc3_1085 0 n6 ns1085 0 9.48594034479e-06
Gc3_1086 0 n6 ns1086 0 -0.00156825141184
Gc3_1087 0 n6 ns1087 0 -0.00294934178797
Gc3_1088 0 n6 ns1088 0 -0.00103162853201
Gc3_1089 0 n6 ns1089 0 -0.000943334030579
Gc3_1090 0 n6 ns1090 0 0.000253856997286
Gc3_1091 0 n6 ns1091 0 0.0015304898334
Gc3_1092 0 n6 ns1092 0 -0.00718870385152
Gc3_1093 0 n6 ns1093 0 -0.00446581971447
Gc3_1094 0 n6 ns1094 0 -0.000633299449957
Gc3_1095 0 n6 ns1095 0 0.00370966915802
Gc3_1096 0 n6 ns1096 0 0.001705686885
Gc3_1097 0 n6 ns1097 0 -0.000612087527497
Gc3_1098 0 n6 ns1098 0 -0.0439368208587
Gc3_1099 0 n6 ns1099 0 0.0372914850714
Gc3_1100 0 n6 ns1100 0 -0.00155244186357
Gc3_1101 0 n6 ns1101 0 -7.00267861338e-06
Gc3_1102 0 n6 ns1102 0 -1.15812134362e-05
Gc3_1103 0 n6 ns1103 0 0.000496634263402
Gc3_1104 0 n6 ns1104 0 -0.000799372783942
Gc3_1105 0 n6 ns1105 0 0.00421159053206
Gc3_1106 0 n6 ns1106 0 -0.000100563590293
Gc3_1107 0 n6 ns1107 0 0.000291113203805
Gc3_1108 0 n6 ns1108 0 0.000291464972419
Gc3_1109 0 n6 ns1109 0 2.82149097357e-06
Gc3_1110 0 n6 ns1110 0 2.82846102563e-05
Gc3_1111 0 n6 ns1111 0 -3.3595117428e-05
Gc3_1112 0 n6 ns1112 0 8.28079956752e-05
Gc3_1113 0 n6 ns1113 0 -0.000747987430045
Gc3_1114 0 n6 ns1114 0 -0.000210338024169
Gc3_1115 0 n6 ns1115 0 -8.45309996737e-05
Gc3_1116 0 n6 ns1116 0 0.000144984404372
Gc3_1117 0 n6 ns1117 0 0.000225355828948
Gc3_1118 0 n6 ns1118 0 0.00036283215893
Gc3_1119 0 n6 ns1119 0 -0.00128639174433
Gc3_1120 0 n6 ns1120 0 -0.000718473183923
Gc3_1121 0 n6 ns1121 0 0.000585221649634
Gc3_1122 0 n6 ns1122 0 0.000156591019973
Gc3_1123 0 n6 ns1123 0 -1.54086859378e-05
Gc3_1124 0 n6 ns1124 0 -0.000474891175393
Gc3_1125 0 n6 ns1125 0 -0.00163977370428
Gc3_1126 0 n6 ns1126 0 -0.00136645903744
Gc3_1127 0 n6 ns1127 0 -0.000945374579278
Gc3_1128 0 n6 ns1128 0 0.000572552022496
Gc3_1129 0 n6 ns1129 0 0.00119222455077
Gc3_1130 0 n6 ns1130 0 -0.00508845082064
Gc3_1131 0 n6 ns1131 0 -0.00201183229482
Gc3_1132 0 n6 ns1132 0 0.000542620306218
Gc3_1133 0 n6 ns1133 0 0.00241180842997
Gc3_1134 0 n6 ns1134 0 0.000835342728148
Gc3_1135 0 n6 ns1135 0 -0.000705760459934
Gc3_1136 0 n6 ns1136 0 -0.0169578815967
Gc3_1137 0 n6 ns1137 0 0.0137129749826
Gc3_1138 0 n6 ns1138 0 -0.000491869121794
Gc3_1139 0 n6 ns1139 0 3.83046221133e-07
Gc3_1140 0 n6 ns1140 0 -3.03846950365e-05
Gc3_1141 0 n6 ns1141 0 0.00061540817765
Gc3_1142 0 n6 ns1142 0 -0.0013715729615
Gc3_1143 0 n6 ns1143 0 0.00339031034877
Gc3_1144 0 n6 ns1144 0 7.80841508339e-06
Gc3_1145 0 n6 ns1145 0 0.000190966423168
Gc3_1146 0 n6 ns1146 0 0.000103462824569
Gc3_1147 0 n6 ns1147 0 -6.70387170416e-05
Gc3_1148 0 n6 ns1148 0 -2.34917508208e-05
Gc3_1149 0 n6 ns1149 0 -1.99286962231e-05
Gc3_1150 0 n6 ns1150 0 0.000376366089054
Gc3_1151 0 n6 ns1151 0 -0.000943062745607
Gc3_1152 0 n6 ns1152 0 -0.000406801111569
Gc3_1153 0 n6 ns1153 0 0.000355629334046
Gc3_1154 0 n6 ns1154 0 0.00020126194775
Gc3_1155 0 n6 ns1155 0 0.000112982160055
Gc3_1156 0 n6 ns1156 0 -0.000681921071019
Gc3_1157 0 n6 ns1157 0 -0.000683482229337
Gc3_1158 0 n6 ns1158 0 0.000160322582683
Gc3_1159 0 n6 ns1159 0 0.000611880527025
Gc3_1160 0 n6 ns1160 0 9.19861877672e-05
Gc3_1161 0 n6 ns1161 0 -0.00013126450892
Gc3_1162 0 n6 ns1162 0 -0.00029198700288
Gc3_1163 0 n6 ns1163 0 -0.00124037808609
Gc3_1164 0 n6 ns1164 0 -0.00130980067989
Gc3_1165 0 n6 ns1165 0 -8.88709881591e-05
Gc3_1166 0 n6 ns1166 0 0.00075086914311
Gc3_1167 0 n6 ns1167 0 0.000515749687136
Gc3_1168 0 n6 ns1168 0 -0.00324911194078
Gc3_1169 0 n6 ns1169 0 -0.000410070863707
Gc3_1170 0 n6 ns1170 0 0.000684868913782
Gc3_1171 0 n6 ns1171 0 0.00121441588379
Gc3_1172 0 n6 ns1172 0 0.000353973570878
Gc3_1173 0 n6 ns1173 0 -0.000488955405508
Gc3_1174 0 n6 ns1174 0 -0.00798401562339
Gc3_1175 0 n6 ns1175 0 0.00628973336322
Gc3_1176 0 n6 ns1176 0 -0.00023018643904
Gc3_1177 0 n6 ns1177 0 7.7867561197e-06
Gc3_1178 0 n6 ns1178 0 -3.7154695518e-05
Gc3_1179 0 n6 ns1179 0 0.000187003869675
Gc3_1180 0 n6 ns1180 0 -0.000331973664543
Gc3_1181 0 n6 ns1181 0 -0.000153622216725
Gc3_1182 0 n6 ns1182 0 -0.00024838056272
Gc3_1183 0 n6 ns1183 0 0.000165968267785
Gc3_1184 0 n6 ns1184 0 3.14603638629e-05
Gc3_1185 0 n6 ns1185 0 0.000173709250997
Gc3_1186 0 n6 ns1186 0 2.93093708839e-05
Gc3_1187 0 n6 ns1187 0 4.9721942416e-06
Gc3_1188 0 n6 ns1188 0 -1.26698695504e-05
Gc3_1189 0 n6 ns1189 0 -0.000885702568256
Gc3_1190 0 n6 ns1190 0 4.42903969714e-05
Gc3_1191 0 n6 ns1191 0 0.000623144922319
Gc3_1192 0 n6 ns1192 0 0.00019937094828
Gc3_1193 0 n6 ns1193 0 -6.14394310116e-05
Gc3_1194 0 n6 ns1194 0 -0.000409131989489
Gc3_1195 0 n6 ns1195 0 0.000621360916447
Gc3_1196 0 n6 ns1196 0 0.000583872605234
Gc3_1197 0 n6 ns1197 0 -4.58550229119e-05
Gc3_1198 0 n6 ns1198 0 -3.74490233384e-05
Gc3_1199 0 n6 ns1199 0 -0.000186179079371
Gc3_1200 0 n6 ns1200 0 0.000375389912433
Gc3_1201 0 n6 ns1201 0 -0.000569893076403
Gc3_1202 0 n6 ns1202 0 -0.000656910767021
Gc3_1203 0 n6 ns1203 0 9.52273569163e-05
Gc3_1204 0 n6 ns1204 0 0.000408288911667
Gc3_1205 0 n6 ns1205 0 0.000126495272332
Gc3_1206 0 n6 ns1206 0 -0.000425388180259
Gc3_1207 0 n6 ns1207 0 0.000774969809588
Gc3_1208 0 n6 ns1208 0 0.000484164855274
Gc3_1209 0 n6 ns1209 0 0.000133807855592
Gc3_1210 0 n6 ns1210 0 -1.95605895781e-06
Gc3_1211 0 n6 ns1211 0 -0.000290522694653
Gc3_1212 0 n6 ns1212 0 0.00656359190137
Gc3_1213 0 n6 ns1213 0 -0.00564803021227
Gc3_1214 0 n6 ns1214 0 0.000134005425126
Gc3_1215 0 n6 ns1215 0 5.68563089709e-06
Gc3_1216 0 n6 ns1216 0 -3.07446436093e-05
Gd3_1 0 n6 ni1 0 -0.00122555750225
Gd3_2 0 n6 ni2 0 -0.00166544885035
Gd3_3 0 n6 ni3 0 0.000355189191604
Gd3_4 0 n6 ni4 0 -0.00162903995271
Gd3_5 0 n6 ni5 0 -0.000315566523999
Gd3_6 0 n6 ni6 0 0.000202083241734
Gd3_7 0 n6 ni7 0 -5.47660651108e-05
Gd3_8 0 n6 ni8 0 -0.000102609906435
Gd3_9 0 n6 ni9 0 -9.71910243041e-05
Gd3_10 0 n6 ni10 0 -0.000570531481817
Gd3_11 0 n6 ni11 0 -0.00253824011324
Gd3_12 0 n6 ni12 0 -0.000697062609702
Gd3_13 0 n6 ni13 0 0.000169996738102
Gd3_14 0 n6 ni14 0 6.16036882871e-05
Gd3_15 0 n6 ni15 0 4.77712381499e-05
Gd3_16 0 n6 ni16 0 -4.90914694477e-05
Gd3_17 0 n6 ni17 0 2.85609768996e-05
Gd3_18 0 n6 ni18 0 -0.000504433652884
Gd3_19 0 n6 ni19 0 -0.00686366175462
Gd3_20 0 n6 ni20 0 -0.000388777107765
Gd3_21 0 n6 ni21 0 0.000494454778768
Gd3_22 0 n6 ni22 0 0.000188168011652
Gd3_23 0 n6 ni23 0 0.000252937182708
Gd3_24 0 n6 ni24 0 4.24714768018e-05
Gd3_25 0 n6 ni25 0 -5.77512762975e-05
Gd3_26 0 n6 ni26 0 -0.00313843987745
Gd3_27 0 n6 ni27 0 -0.00158025467099
Gd3_28 0 n6 ni28 0 -8.26855785507e-05
Gd3_29 0 n6 ni29 0 0.000185263205962
Gd3_30 0 n6 ni30 0 0.000196063984871
Gd3_31 0 n6 ni31 0 3.2981940417e-05
Gd3_32 0 n6 ni32 0 -5.31804540709e-06
Gc4_1 0 n8 ns1 0 -0.00120210658957
Gc4_2 0 n8 ns2 0 0.00260916367446
Gc4_3 0 n8 ns3 0 -0.00415380592757
Gc4_4 0 n8 ns4 0 0.000190401347327
Gc4_5 0 n8 ns5 0 -0.000475457493752
Gc4_6 0 n8 ns6 0 9.3683857369e-05
Gc4_7 0 n8 ns7 0 -0.000511448535998
Gc4_8 0 n8 ns8 0 -3.18870206871e-05
Gc4_9 0 n8 ns9 0 -1.3824023251e-05
Gc4_10 0 n8 ns10 0 -0.00153626879426
Gc4_11 0 n8 ns11 0 0.00163679853684
Gc4_12 0 n8 ns12 0 -0.000372579521033
Gc4_13 0 n8 ns13 0 -0.000425548374321
Gc4_14 0 n8 ns14 0 0.000154048689733
Gc4_15 0 n8 ns15 0 -0.000234261074138
Gc4_16 0 n8 ns16 0 -0.000133168630125
Gc4_17 0 n8 ns17 0 0.00267440576667
Gc4_18 0 n8 ns18 0 0.000125314494883
Gc4_19 0 n8 ns19 0 -0.000889441847177
Gc4_20 0 n8 ns20 0 0.000207293826391
Gc4_21 0 n8 ns21 0 1.08814393759e-05
Gc4_22 0 n8 ns22 0 0.00237825809303
Gc4_23 0 n8 ns23 0 0.00232657914798
Gc4_24 0 n8 ns24 0 -0.000518864901708
Gc4_25 0 n8 ns25 0 1.60692563469e-06
Gc4_26 0 n8 ns26 0 0.00046442636521
Gc4_27 0 n8 ns27 0 -0.000643105254529
Gc4_28 0 n8 ns28 0 0.00362093635338
Gc4_29 0 n8 ns29 0 0.000263817945253
Gc4_30 0 n8 ns30 0 -0.00189650101725
Gc4_31 0 n8 ns31 0 0.000664746321832
Gc4_32 0 n8 ns32 0 0.00113197550965
Gc4_33 0 n8 ns33 0 -0.000209694989638
Gc4_34 0 n8 ns34 0 0.0369015082763
Gc4_35 0 n8 ns35 0 -0.0337969640831
Gc4_36 0 n8 ns36 0 0.00190918767499
Gc4_37 0 n8 ns37 0 -6.34488565243e-06
Gc4_38 0 n8 ns38 0 1.85371650776e-05
Gc4_39 0 n8 ns39 0 -0.0014689859214
Gc4_40 0 n8 ns40 0 0.00171330479183
Gc4_41 0 n8 ns41 0 -0.00278631218656
Gc4_42 0 n8 ns42 0 0.000454171565279
Gc4_43 0 n8 ns43 0 -0.00069103526415
Gc4_44 0 n8 ns44 0 0.000263623645272
Gc4_45 0 n8 ns45 0 -0.000236638895422
Gc4_46 0 n8 ns46 0 -6.28937005779e-05
Gc4_47 0 n8 ns47 0 -1.11636989296e-05
Gc4_48 0 n8 ns48 0 -0.00175144470313
Gc4_49 0 n8 ns49 0 0.000832600842284
Gc4_50 0 n8 ns50 0 -7.58648283742e-05
Gc4_51 0 n8 ns51 0 -0.000317674207294
Gc4_52 0 n8 ns52 0 0.000247645660913
Gc4_53 0 n8 ns53 0 -0.000357796151036
Gc4_54 0 n8 ns54 0 -0.000795566449864
Gc4_55 0 n8 ns55 0 0.001576498472
Gc4_56 0 n8 ns56 0 -9.19994856293e-05
Gc4_57 0 n8 ns57 0 -0.000573316322022
Gc4_58 0 n8 ns58 0 0.000316127810037
Gc4_59 0 n8 ns59 0 0.000110447603563
Gc4_60 0 n8 ns60 0 0.000713050745042
Gc4_61 0 n8 ns61 0 0.00288609150257
Gc4_62 0 n8 ns62 0 -0.00024467070174
Gc4_63 0 n8 ns63 0 0.00036863878105
Gc4_64 0 n8 ns64 0 0.00061308798257
Gc4_65 0 n8 ns65 0 -0.000992368763289
Gc4_66 0 n8 ns66 0 0.00291574621378
Gc4_67 0 n8 ns67 0 0.00141527488158
Gc4_68 0 n8 ns68 0 -0.00203681141434
Gc4_69 0 n8 ns69 0 0.000522561802455
Gc4_70 0 n8 ns70 0 0.00143286061943
Gc4_71 0 n8 ns71 0 -0.000208257806213
Gc4_72 0 n8 ns72 0 0.045265608776
Gc4_73 0 n8 ns73 0 -0.0427346041587
Gc4_74 0 n8 ns74 0 0.00272857718848
Gc4_75 0 n8 ns75 0 -2.947544868e-06
Gc4_76 0 n8 ns76 0 2.19549293119e-05
Gc4_77 0 n8 ns77 0 -0.00194327552315
Gc4_78 0 n8 ns78 0 -0.00179517903321
Gc4_79 0 n8 ns79 0 0.00518590983598
Gc4_80 0 n8 ns80 0 0.000363081212395
Gc4_81 0 n8 ns81 0 -0.000380949933913
Gc4_82 0 n8 ns82 0 0.000525310925895
Gc4_83 0 n8 ns83 0 0.000424892753541
Gc4_84 0 n8 ns84 0 -0.000175791285222
Gc4_85 0 n8 ns85 0 -4.46541023821e-05
Gc4_86 0 n8 ns86 0 -0.0010887917437
Gc4_87 0 n8 ns87 0 -0.000709740839207
Gc4_88 0 n8 ns88 0 0.000990093371936
Gc4_89 0 n8 ns89 0 0.000367456124942
Gc4_90 0 n8 ns90 0 0.000460773211342
Gc4_91 0 n8 ns91 0 -0.000547825237163
Gc4_92 0 n8 ns92 0 0.000542393750625
Gc4_93 0 n8 ns93 0 -0.00267188344298
Gc4_94 0 n8 ns94 0 -0.000937465899336
Gc4_95 0 n8 ns95 0 9.4917625413e-05
Gc4_96 0 n8 ns96 0 0.000396043279626
Gc4_97 0 n8 ns97 0 0.000365194519574
Gc4_98 0 n8 ns98 0 -0.0046574554982
Gc4_99 0 n8 ns99 0 -0.001707433503
Gc4_100 0 n8 ns100 0 0.00035918972712
Gc4_101 0 n8 ns101 0 0.00196977401174
Gc4_102 0 n8 ns102 0 0.00122977756867
Gc4_103 0 n8 ns103 0 -0.00169824041119
Gc4_104 0 n8 ns104 0 -0.00659084195423
Gc4_105 0 n8 ns105 0 -0.0015327245858
Gc4_106 0 n8 ns106 0 -0.00122500031218
Gc4_107 0 n8 ns107 0 0.00110542292885
Gc4_108 0 n8 ns108 0 0.00256930181337
Gc4_109 0 n8 ns109 0 0.000259224303687
Gc4_110 0 n8 ns110 0 0.0147394144086
Gc4_111 0 n8 ns111 0 -0.0235623894572
Gc4_112 0 n8 ns112 0 0.00537048823859
Gc4_113 0 n8 ns113 0 2.29892333536e-06
Gc4_114 0 n8 ns114 0 2.69751026623e-05
Gc4_115 0 n8 ns115 0 -0.00351726473788
Gc4_116 0 n8 ns116 0 -0.000768083092112
Gc4_117 0 n8 ns117 0 -0.000408386461021
Gc4_118 0 n8 ns118 0 0.000551055339667
Gc4_119 0 n8 ns119 0 -0.000330606701889
Gc4_120 0 n8 ns120 0 0.000436484306617
Gc4_121 0 n8 ns121 0 -0.000165144411749
Gc4_122 0 n8 ns122 0 -0.000195770565782
Gc4_123 0 n8 ns123 0 -0.000105161844531
Gc4_124 0 n8 ns124 0 -0.00439820889101
Gc4_125 0 n8 ns125 0 0.0012740139554
Gc4_126 0 n8 ns126 0 0.00173134087049
Gc4_127 0 n8 ns127 0 -6.21993677473e-05
Gc4_128 0 n8 ns128 0 0.000433786653434
Gc4_129 0 n8 ns129 0 -0.000665163883485
Gc4_130 0 n8 ns130 0 -0.000289905721091
Gc4_131 0 n8 ns131 0 0.000822236682179
Gc4_132 0 n8 ns132 0 0.00038223879207
Gc4_133 0 n8 ns133 0 0.000607666166165
Gc4_134 0 n8 ns134 0 0.000643352303694
Gc4_135 0 n8 ns135 0 0.000233614927256
Gc4_136 0 n8 ns136 0 9.44887329787e-05
Gc4_137 0 n8 ns137 0 0.000830250887141
Gc4_138 0 n8 ns138 0 0.00141895708431
Gc4_139 0 n8 ns139 0 0.00312809502106
Gc4_140 0 n8 ns140 0 0.00135701884013
Gc4_141 0 n8 ns141 0 -0.00233907093616
Gc4_142 0 n8 ns142 0 -0.00110555521936
Gc4_143 0 n8 ns143 0 -0.00286268188091
Gc4_144 0 n8 ns144 0 0.00211414217332
Gc4_145 0 n8 ns145 0 0.00200974787912
Gc4_146 0 n8 ns146 0 0.00328321694844
Gc4_147 0 n8 ns147 0 2.30454302239e-05
Gc4_148 0 n8 ns148 0 -0.0264148621075
Gc4_149 0 n8 ns149 0 0.0255162439436
Gc4_150 0 n8 ns150 0 0.00690313849713
Gc4_151 0 n8 ns151 0 1.12034733695e-05
Gc4_152 0 n8 ns152 0 1.68012282851e-05
Gc4_153 0 n8 ns153 0 -0.00205873262025
Gc4_154 0 n8 ns154 0 -0.00195271072518
Gc4_155 0 n8 ns155 0 0.00391768540809
Gc4_156 0 n8 ns156 0 0.000329242123447
Gc4_157 0 n8 ns157 0 -0.000365047116981
Gc4_158 0 n8 ns158 0 0.000611988643815
Gc4_159 0 n8 ns159 0 0.00039426049109
Gc4_160 0 n8 ns160 0 -0.000174781576551
Gc4_161 0 n8 ns161 0 -8.64957462611e-05
Gc4_162 0 n8 ns162 0 -0.00136923172243
Gc4_163 0 n8 ns163 0 4.86422567223e-05
Gc4_164 0 n8 ns164 0 0.00108785934402
Gc4_165 0 n8 ns165 0 -0.000142856820534
Gc4_166 0 n8 ns166 0 0.00030669148662
Gc4_167 0 n8 ns167 0 -0.000509006440458
Gc4_168 0 n8 ns168 0 0.000117622954659
Gc4_169 0 n8 ns169 0 -0.00188461277694
Gc4_170 0 n8 ns170 0 -0.000337000415183
Gc4_171 0 n8 ns171 0 6.09367957306e-05
Gc4_172 0 n8 ns172 0 0.000380306721888
Gc4_173 0 n8 ns173 0 0.000208163388895
Gc4_174 0 n8 ns174 0 -0.00364417439597
Gc4_175 0 n8 ns175 0 -0.000903964950697
Gc4_176 0 n8 ns176 0 0.000862313376348
Gc4_177 0 n8 ns177 0 0.0013940662267
Gc4_178 0 n8 ns178 0 0.000770448335273
Gc4_179 0 n8 ns179 0 -0.00157140058622
Gc4_180 0 n8 ns180 0 -0.0052797743428
Gc4_181 0 n8 ns181 0 -0.00128826017518
Gc4_182 0 n8 ns182 0 -0.00122548307006
Gc4_183 0 n8 ns183 0 0.000822013928616
Gc4_184 0 n8 ns184 0 0.00242885813704
Gc4_185 0 n8 ns185 0 0.000242881580514
Gc4_186 0 n8 ns186 0 0.0219526409029
Gc4_187 0 n8 ns187 0 -0.0293592407878
Gc4_188 0 n8 ns188 0 0.00550577949946
Gc4_189 0 n8 ns189 0 1.95451173043e-06
Gc4_190 0 n8 ns190 0 3.69872985536e-06
Gc4_191 0 n8 ns191 0 -0.00147294101774
Gc4_192 0 n8 ns192 0 0.00114026638851
Gc4_193 0 n8 ns193 0 -0.00346824287283
Gc4_194 0 n8 ns194 0 0.000314823126222
Gc4_195 0 n8 ns195 0 -0.000592584805161
Gc4_196 0 n8 ns196 0 0.00027145145771
Gc4_197 0 n8 ns197 0 -0.000179394941754
Gc4_198 0 n8 ns198 0 -4.4651414545e-05
Gc4_199 0 n8 ns199 0 3.70444901205e-05
Gc4_200 0 n8 ns200 0 -0.00141163399596
Gc4_201 0 n8 ns201 0 0.0010208260371
Gc4_202 0 n8 ns202 0 0.000106368076348
Gc4_203 0 n8 ns203 0 -0.000509982202511
Gc4_204 0 n8 ns204 0 5.00419390314e-05
Gc4_205 0 n8 ns205 0 -0.000368829676397
Gc4_206 0 n8 ns206 0 -0.00141522681876
Gc4_207 0 n8 ns207 0 0.00123564252163
Gc4_208 0 n8 ns208 0 0.000212872061757
Gc4_209 0 n8 ns209 0 -3.14955987633e-05
Gc4_210 0 n8 ns210 0 0.000400386595776
Gc4_211 0 n8 ns211 0 -2.81052795558e-05
Gc4_212 0 n8 ns212 0 0.00084068447726
Gc4_213 0 n8 ns213 0 0.00385795600006
Gc4_214 0 n8 ns214 0 0.000788116732035
Gc4_215 0 n8 ns215 0 0.000205266638836
Gc4_216 0 n8 ns216 0 -5.99686133909e-05
Gc4_217 0 n8 ns217 0 -0.00120308591046
Gc4_218 0 n8 ns218 0 0.00359889854438
Gc4_219 0 n8 ns219 0 0.00214232107416
Gc4_220 0 n8 ns220 0 -0.00158565373476
Gc4_221 0 n8 ns221 0 0.0004114963106
Gc4_222 0 n8 ns222 0 0.0012566036618
Gc4_223 0 n8 ns223 0 -0.000440376927403
Gc4_224 0 n8 ns224 0 0.0540962093633
Gc4_225 0 n8 ns225 0 -0.0500300136724
Gc4_226 0 n8 ns226 0 0.00289175187185
Gc4_227 0 n8 ns227 0 -2.88413883896e-06
Gc4_228 0 n8 ns228 0 -1.81892761228e-05
Gc4_229 0 n8 ns229 0 -0.000966147888267
Gc4_230 0 n8 ns230 0 0.00230167854014
Gc4_231 0 n8 ns231 0 -0.00582902087885
Gc4_232 0 n8 ns232 0 -0.000433741272952
Gc4_233 0 n8 ns233 0 -0.000213308674388
Gc4_234 0 n8 ns234 0 -0.000354074582556
Gc4_235 0 n8 ns235 0 -6.14175324769e-05
Gc4_236 0 n8 ns236 0 -3.88127644494e-06
Gc4_237 0 n8 ns237 0 2.37224426544e-05
Gc4_238 0 n8 ns238 0 0.000773767315591
Gc4_239 0 n8 ns239 0 0.00217658844554
Gc4_240 0 n8 ns240 0 -0.000352437076628
Gc4_241 0 n8 ns241 0 -0.000126324696221
Gc4_242 0 n8 ns242 0 -0.000125820818381
Gc4_243 0 n8 ns243 0 -0.000234273695776
Gc4_244 0 n8 ns244 0 0.00131024325053
Gc4_245 0 n8 ns245 0 0.00115844978099
Gc4_246 0 n8 ns246 0 -0.00028028595607
Gc4_247 0 n8 ns247 0 -0.000281849419405
Gc4_248 0 n8 ns248 0 0.000188190015305
Gc4_249 0 n8 ns249 0 -0.000146263728515
Gc4_250 0 n8 ns250 0 0.00221533811404
Gc4_251 0 n8 ns251 0 0.000677525375113
Gc4_252 0 n8 ns252 0 0.000364156222474
Gc4_253 0 n8 ns253 0 0.000491578406353
Gc4_254 0 n8 ns254 0 -0.000244834164982
Gc4_255 0 n8 ns255 0 -0.000882558355219
Gc4_256 0 n8 ns256 0 0.00234455253924
Gc4_257 0 n8 ns257 0 -5.44474467094e-05
Gc4_258 0 n8 ns258 0 -0.000408107519373
Gc4_259 0 n8 ns259 0 0.00107141546275
Gc4_260 0 n8 ns260 0 0.000643023643774
Gc4_261 0 n8 ns261 0 -0.000671983254327
Gc4_262 0 n8 ns262 0 0.0353095297131
Gc4_263 0 n8 ns263 0 -0.0312867969955
Gc4_264 0 n8 ns264 0 0.00141014891269
Gc4_265 0 n8 ns265 0 -7.01027131072e-06
Gc4_266 0 n8 ns266 0 -2.49104174143e-05
Gc4_267 0 n8 ns267 0 -1.0832442555e-05
Gc4_268 0 n8 ns268 0 -0.000391236638339
Gc4_269 0 n8 ns269 0 0.00100205900362
Gc4_270 0 n8 ns270 0 -4.25089546807e-05
Gc4_271 0 n8 ns271 0 0.000142554901483
Gc4_272 0 n8 ns272 0 5.41759526042e-05
Gc4_273 0 n8 ns273 0 4.79208256138e-05
Gc4_274 0 n8 ns274 0 -1.43603855795e-05
Gc4_275 0 n8 ns275 0 7.58740077763e-06
Gc4_276 0 n8 ns276 0 -0.000246879072684
Gc4_277 0 n8 ns277 0 -0.000120631106774
Gc4_278 0 n8 ns278 0 0.000505683952023
Gc4_279 0 n8 ns279 0 0.00012289558123
Gc4_280 0 n8 ns280 0 -0.000136089643911
Gc4_281 0 n8 ns281 0 -0.000193235273633
Gc4_282 0 n8 ns282 0 -0.000306043736998
Gc4_283 0 n8 ns283 0 -0.000895133309725
Gc4_284 0 n8 ns284 0 -0.000200642851665
Gc4_285 0 n8 ns285 0 0.000788400434063
Gc4_286 0 n8 ns286 0 0.000195357490444
Gc4_287 0 n8 ns287 0 -8.77795078969e-05
Gc4_288 0 n8 ns288 0 -0.000609221132578
Gc4_289 0 n8 ns289 0 0.000377805181254
Gc4_290 0 n8 ns290 0 0.000853138048287
Gc4_291 0 n8 ns291 0 0.00072452892646
Gc4_292 0 n8 ns292 0 -0.000411184785247
Gc4_293 0 n8 ns293 0 -0.000731134933694
Gc4_294 0 n8 ns294 0 -0.00124330070719
Gc4_295 0 n8 ns295 0 -6.63287051888e-06
Gc4_296 0 n8 ns296 0 0.00046625215221
Gc4_297 0 n8 ns297 0 0.00115905770888
Gc4_298 0 n8 ns298 0 0.000394762410007
Gc4_299 0 n8 ns299 0 -0.000589735866282
Gc4_300 0 n8 ns300 0 0.00907869891103
Gc4_301 0 n8 ns301 0 -0.00886021805856
Gc4_302 0 n8 ns302 0 0.000517402679359
Gc4_303 0 n8 ns303 0 -3.29599552483e-06
Gc4_304 0 n8 ns304 0 -2.60046506468e-05
Gc4_305 0 n8 ns305 0 0.000395059544815
Gc4_306 0 n8 ns306 0 -0.00126339024821
Gc4_307 0 n8 ns307 0 0.00216609435621
Gc4_308 0 n8 ns308 0 0.000196760568084
Gc4_309 0 n8 ns309 0 -0.000144028110768
Gc4_310 0 n8 ns310 0 8.83854911062e-05
Gc4_311 0 n8 ns311 0 2.16252787227e-05
Gc4_312 0 n8 ns312 0 3.65279063225e-05
Gc4_313 0 n8 ns313 0 -3.60856161153e-05
Gc4_314 0 n8 ns314 0 -0.00136708897709
Gc4_315 0 n8 ns315 0 -4.40424755275e-05
Gc4_316 0 n8 ns316 0 0.000712808823568
Gc4_317 0 n8 ns317 0 -0.000253857995894
Gc4_318 0 n8 ns318 0 -0.000140785627359
Gc4_319 0 n8 ns319 0 -0.000128098596036
Gc4_320 0 n8 ns320 0 -0.00134652712629
Gc4_321 0 n8 ns321 0 -0.00014090084868
Gc4_322 0 n8 ns322 0 0.000460161568438
Gc4_323 0 n8 ns323 0 0.000740982867488
Gc4_324 0 n8 ns324 0 0.000154133568637
Gc4_325 0 n8 ns325 0 -0.000135540375028
Gc4_326 0 n8 ns326 0 -0.000432049518239
Gc4_327 0 n8 ns327 0 0.00129868717375
Gc4_328 0 n8 ns328 0 0.000975991116673
Gc4_329 0 n8 ns329 0 0.000137411233541
Gc4_330 0 n8 ns330 0 -0.000524217646302
Gc4_331 0 n8 ns331 0 -0.000379885266956
Gc4_332 0 n8 ns332 0 -0.0003905116692
Gc4_333 0 n8 ns333 0 0.000831854700763
Gc4_334 0 n8 ns334 0 0.000450690353637
Gc4_335 0 n8 ns335 0 0.000344846343876
Gc4_336 0 n8 ns336 0 8.93252517154e-05
Gc4_337 0 n8 ns337 0 -0.000354062655315
Gc4_338 0 n8 ns338 0 0.00685532583682
Gc4_339 0 n8 ns339 0 -0.00642720271899
Gc4_340 0 n8 ns340 0 0.000322579051104
Gc4_341 0 n8 ns341 0 -7.08859545546e-06
Gc4_342 0 n8 ns342 0 -2.33719806865e-05
Gc4_343 0 n8 ns343 0 -0.0019741695069
Gc4_344 0 n8 ns344 0 2.56395443838e-05
Gc4_345 0 n8 ns345 0 0.00200005927597
Gc4_346 0 n8 ns346 0 0.000655177340788
Gc4_347 0 n8 ns347 0 -0.000446944508903
Gc4_348 0 n8 ns348 0 0.000478495732221
Gc4_349 0 n8 ns349 0 0.000335149450383
Gc4_350 0 n8 ns350 0 -0.000169721826626
Gc4_351 0 n8 ns351 0 -4.4306957548e-06
Gc4_352 0 n8 ns352 0 -0.000629876129022
Gc4_353 0 n8 ns353 0 -0.000667625162623
Gc4_354 0 n8 ns354 0 0.00052567992589
Gc4_355 0 n8 ns355 0 8.72443914455e-05
Gc4_356 0 n8 ns356 0 0.000354060265365
Gc4_357 0 n8 ns357 0 -0.000496638725015
Gc4_358 0 n8 ns358 0 -0.000230199407031
Gc4_359 0 n8 ns359 0 -0.00219781627204
Gc4_360 0 n8 ns360 0 -0.000980704809886
Gc4_361 0 n8 ns361 0 -4.82281557589e-05
Gc4_362 0 n8 ns362 0 0.000338102076137
Gc4_363 0 n8 ns363 0 0.000332585832713
Gc4_364 0 n8 ns364 0 -0.00411813912365
Gc4_365 0 n8 ns365 0 0.0004856910684
Gc4_366 0 n8 ns366 0 0.000104371125233
Gc4_367 0 n8 ns367 0 0.00147118796705
Gc4_368 0 n8 ns368 0 0.00106553680229
Gc4_369 0 n8 ns369 0 -0.00147091258233
Gc4_370 0 n8 ns370 0 -0.00277734845184
Gc4_371 0 n8 ns371 0 0.00139413759308
Gc4_372 0 n8 ns372 0 -0.00180469246946
Gc4_373 0 n8 ns373 0 0.000528860408385
Gc4_374 0 n8 ns374 0 0.00209603722671
Gc4_375 0 n8 ns375 0 8.81217899615e-05
Gc4_376 0 n8 ns376 0 0.038332783988
Gc4_377 0 n8 ns377 0 -0.0419954725429
Gc4_378 0 n8 ns378 0 0.00446135827137
Gc4_379 0 n8 ns379 0 3.19221295993e-06
Gc4_380 0 n8 ns380 0 2.52445362906e-05
Gc4_381 0 n8 ns381 0 -0.00454042380825
Gc4_382 0 n8 ns382 0 -0.000324217693794
Gc4_383 0 n8 ns383 0 -0.00404549223861
Gc4_384 0 n8 ns384 0 -4.61654458587e-05
Gc4_385 0 n8 ns385 0 -0.000868959310778
Gc4_386 0 n8 ns386 0 5.47242629827e-05
Gc4_387 0 n8 ns387 0 0.000335662621897
Gc4_388 0 n8 ns388 0 -9.04284341352e-05
Gc4_389 0 n8 ns389 0 -2.84918204325e-05
Gc4_390 0 n8 ns390 0 -0.00223711979323
Gc4_391 0 n8 ns391 0 0.0018857300898
Gc4_392 0 n8 ns392 0 0.00104528306535
Gc4_393 0 n8 ns393 0 -0.000137142126056
Gc4_394 0 n8 ns394 0 0.000326263599675
Gc4_395 0 n8 ns395 0 -0.000561217709154
Gc4_396 0 n8 ns396 0 1.77310593456e-05
Gc4_397 0 n8 ns397 0 0.00095051613711
Gc4_398 0 n8 ns398 0 0.00030153247274
Gc4_399 0 n8 ns399 0 0.000328733334965
Gc4_400 0 n8 ns400 0 0.000583740075539
Gc4_401 0 n8 ns401 0 0.000193672431027
Gc4_402 0 n8 ns402 0 0.000980175201445
Gc4_403 0 n8 ns403 0 0.00145780220425
Gc4_404 0 n8 ns404 0 0.00117305792736
Gc4_405 0 n8 ns405 0 0.00284028061394
Gc4_406 0 n8 ns406 0 0.00134308441011
Gc4_407 0 n8 ns407 0 -0.00217329805036
Gc4_408 0 n8 ns408 0 0.00185180251006
Gc4_409 0 n8 ns409 0 -0.00170396786674
Gc4_410 0 n8 ns410 0 0.00182705713623
Gc4_411 0 n8 ns411 0 0.00147469063528
Gc4_412 0 n8 ns412 0 0.00306704360167
Gc4_413 0 n8 ns413 0 4.2323417955e-05
Gc4_414 0 n8 ns414 0 -0.0169642578107
Gc4_415 0 n8 ns415 0 0.0192770845981
Gc4_416 0 n8 ns416 0 0.006887345715
Gc4_417 0 n8 ns417 0 2.13013281087e-07
Gc4_418 0 n8 ns418 0 1.94528808965e-05
Gc4_419 0 n8 ns419 0 -0.00481109733883
Gc4_420 0 n8 ns420 0 -0.00106871435307
Gc4_421 0 n8 ns421 0 -0.00382182275335
Gc4_422 0 n8 ns422 0 0.000266345730811
Gc4_423 0 n8 ns423 0 -0.00117005422319
Gc4_424 0 n8 ns424 0 -2.79473999547e-05
Gc4_425 0 n8 ns425 0 0.000828344090418
Gc4_426 0 n8 ns426 0 -0.000117432572102
Gc4_427 0 n8 ns427 0 -8.2441747768e-05
Gc4_428 0 n8 ns428 0 -0.000822865962244
Gc4_429 0 n8 ns429 0 0.00197032872078
Gc4_430 0 n8 ns430 0 0.00100822326136
Gc4_431 0 n8 ns431 0 -0.00049920610787
Gc4_432 0 n8 ns432 0 0.000208051523906
Gc4_433 0 n8 ns433 0 -0.000541310680697
Gc4_434 0 n8 ns434 0 0.000349573751243
Gc4_435 0 n8 ns435 0 -0.000721945662115
Gc4_436 0 n8 ns436 0 0.000114198051281
Gc4_437 0 n8 ns437 0 6.97750887822e-05
Gc4_438 0 n8 ns438 0 0.000454760096184
Gc4_439 0 n8 ns439 0 0.000144159240582
Gc4_440 0 n8 ns440 0 -0.00137644851104
Gc4_441 0 n8 ns441 0 0.00102701439379
Gc4_442 0 n8 ns442 0 0.00157314172193
Gc4_443 0 n8 ns443 0 0.00185727718337
Gc4_444 0 n8 ns444 0 0.000786751848659
Gc4_445 0 n8 ns445 0 -0.0019689448314
Gc4_446 0 n8 ns446 0 0.000748871652444
Gc4_447 0 n8 ns447 0 0.000877062141557
Gc4_448 0 n8 ns448 0 0.000202891391501
Gc4_449 0 n8 ns449 0 4.96607025112e-06
Gc4_450 0 n8 ns450 0 0.00247263922369
Gc4_451 0 n8 ns451 0 9.49940598119e-05
Gc4_452 0 n8 ns452 0 0.0268741105833
Gc4_453 0 n8 ns453 0 -0.0258944355721
Gc4_454 0 n8 ns454 0 0.0066262784642
Gc4_455 0 n8 ns455 0 -3.38933726777e-06
Gc4_456 0 n8 ns456 0 8.09938516847e-06
Gc4_457 0 n8 ns457 0 -0.00172131756842
Gc4_458 0 n8 ns458 0 0.000580715538894
Gc4_459 0 n8 ns459 0 -0.00161315761573
Gc4_460 0 n8 ns460 0 0.000501224932605
Gc4_461 0 n8 ns461 0 -0.000505654967952
Gc4_462 0 n8 ns462 0 0.000625267283654
Gc4_463 0 n8 ns463 0 -1.3374776533e-05
Gc4_464 0 n8 ns464 0 -0.000130986457359
Gc4_465 0 n8 ns465 0 7.64820106617e-06
Gc4_466 0 n8 ns466 0 -0.00192799368554
Gc4_467 0 n8 ns467 0 0.000317234869045
Gc4_468 0 n8 ns468 0 0.000637662294758
Gc4_469 0 n8 ns469 0 -0.000544883323914
Gc4_470 0 n8 ns470 0 0.000151441048762
Gc4_471 0 n8 ns471 0 -0.000467082375116
Gc4_472 0 n8 ns472 0 -0.00184025332437
Gc4_473 0 n8 ns473 0 9.61344878456e-05
Gc4_474 0 n8 ns474 0 0.000176356777672
Gc4_475 0 n8 ns475 0 0.000134090277693
Gc4_476 0 n8 ns476 0 0.000451651178704
Gc4_477 0 n8 ns477 0 5.85049275407e-05
Gc4_478 0 n8 ns478 0 -0.000946633017322
Gc4_479 0 n8 ns479 0 0.00352538887567
Gc4_480 0 n8 ns480 0 0.000979872945022
Gc4_481 0 n8 ns481 0 0.000398965416016
Gc4_482 0 n8 ns482 0 0.000128659213115
Gc4_483 0 n8 ns483 0 -0.00137420307448
Gc4_484 0 n8 ns484 0 0.0017057091999
Gc4_485 0 n8 ns485 0 0.00211643815662
Gc4_486 0 n8 ns486 0 -0.00175008000092
Gc4_487 0 n8 ns487 0 0.000317504599394
Gc4_488 0 n8 ns488 0 0.00162004734232
Gc4_489 0 n8 ns489 0 -0.000258500515975
Gc4_490 0 n8 ns490 0 0.0515795060257
Gc4_491 0 n8 ns491 0 -0.0500648135828
Gc4_492 0 n8 ns492 0 0.00372281947916
Gc4_493 0 n8 ns493 0 -6.87548188893e-07
Gc4_494 0 n8 ns494 0 -8.75545286352e-06
Gc4_495 0 n8 ns495 0 -0.00126679303665
Gc4_496 0 n8 ns496 0 0.0025010820329
Gc4_497 0 n8 ns497 0 -0.00613791553925
Gc4_498 0 n8 ns498 0 -0.000280263620256
Gc4_499 0 n8 ns499 0 -0.000305019838501
Gc4_500 0 n8 ns500 0 -0.000167810946347
Gc4_501 0 n8 ns501 0 -0.000220468588788
Gc4_502 0 n8 ns502 0 -1.7093523594e-05
Gc4_503 0 n8 ns503 0 2.42156081803e-05
Gc4_504 0 n8 ns504 0 8.60416789686e-05
Gc4_505 0 n8 ns505 0 0.00228723747773
Gc4_506 0 n8 ns506 0 -0.00037889379218
Gc4_507 0 n8 ns507 0 -0.000319450473755
Gc4_508 0 n8 ns508 0 -6.55769496774e-05
Gc4_509 0 n8 ns509 0 -0.000283330785139
Gc4_510 0 n8 ns510 0 0.000829843718424
Gc4_511 0 n8 ns511 0 0.00182240493598
Gc4_512 0 n8 ns512 0 -0.000112200581815
Gc4_513 0 n8 ns513 0 -0.000475561016495
Gc4_514 0 n8 ns514 0 0.000243633530475
Gc4_515 0 n8 ns515 0 -0.000139314298638
Gc4_516 0 n8 ns516 0 0.00259473110235
Gc4_517 0 n8 ns517 0 0.00154395913981
Gc4_518 0 n8 ns518 0 0.000300732388965
Gc4_519 0 n8 ns519 0 0.000318759583626
Gc4_520 0 n8 ns520 0 -0.000165381194197
Gc4_521 0 n8 ns521 0 -0.000953925280449
Gc4_522 0 n8 ns522 0 0.00319101256577
Gc4_523 0 n8 ns523 0 0.000200111954121
Gc4_524 0 n8 ns524 0 -0.000866475679636
Gc4_525 0 n8 ns525 0 0.0010266471758
Gc4_526 0 n8 ns526 0 0.000850908475321
Gc4_527 0 n8 ns527 0 -0.000646088127299
Gc4_528 0 n8 ns528 0 0.0421474328886
Gc4_529 0 n8 ns529 0 -0.0376334514777
Gc4_530 0 n8 ns530 0 0.00180748164156
Gc4_531 0 n8 ns531 0 -6.43382324508e-06
Gc4_532 0 n8 ns532 0 -2.17694562858e-05
Gc4_533 0 n8 ns533 0 -0.000497847634132
Gc4_534 0 n8 ns534 0 0.000864794170111
Gc4_535 0 n8 ns535 0 -0.00179933213419
Gc4_536 0 n8 ns536 0 -0.000301786625127
Gc4_537 0 n8 ns537 0 0.000106837128381
Gc4_538 0 n8 ns538 0 -0.000139392436861
Gc4_539 0 n8 ns539 0 0.000125418946827
Gc4_540 0 n8 ns540 0 -1.03526887276e-05
Gc4_541 0 n8 ns541 0 1.37133740997e-05
Gc4_542 0 n8 ns542 0 0.000774738761323
Gc4_543 0 n8 ns543 0 0.000591983555751
Gc4_544 0 n8 ns544 0 8.82609009423e-05
Gc4_545 0 n8 ns545 0 0.000186006550612
Gc4_546 0 n8 ns546 0 -0.000141964644364
Gc4_547 0 n8 ns547 0 -0.000201341592752
Gc4_548 0 n8 ns548 0 0.00073052895906
Gc4_549 0 n8 ns549 0 -0.000590600236343
Gc4_550 0 n8 ns550 0 -0.00048010483814
Gc4_551 0 n8 ns551 0 0.000414138413271
Gc4_552 0 n8 ns552 0 0.000173109423458
Gc4_553 0 n8 ns553 0 -8.95697983048e-05
Gc4_554 0 n8 ns554 0 0.000160414388747
Gc4_555 0 n8 ns555 0 -5.88669711471e-05
Gc4_556 0 n8 ns556 0 0.00063861410616
Gc4_557 0 n8 ns557 0 0.000842079812619
Gc4_558 0 n8 ns558 0 -0.000319299870994
Gc4_559 0 n8 ns559 0 -0.000848312909678
Gc4_560 0 n8 ns560 0 -0.000391965748778
Gc4_561 0 n8 ns561 0 -0.000295232586675
Gc4_562 0 n8 ns562 0 0.000261268062113
Gc4_563 0 n8 ns563 0 0.00127482407632
Gc4_564 0 n8 ns564 0 0.000487715155921
Gc4_565 0 n8 ns565 0 -0.000656131205441
Gc4_566 0 n8 ns566 0 0.016531842354
Gc4_567 0 n8 ns567 0 -0.0152019228875
Gc4_568 0 n8 ns568 0 0.00076721447475
Gc4_569 0 n8 ns569 0 -4.86520407753e-06
Gc4_570 0 n8 ns570 0 -2.58848091456e-05
Gc4_571 0 n8 ns571 0 0.000364021875353
Gc4_572 0 n8 ns572 0 -0.000851871689759
Gc4_573 0 n8 ns573 0 0.00241802264161
Gc4_574 0 n8 ns574 0 6.18749911038e-05
Gc4_575 0 n8 ns575 0 0.000198571053496
Gc4_576 0 n8 ns576 0 0.000277758791982
Gc4_577 0 n8 ns577 0 6.97614785852e-06
Gc4_578 0 n8 ns578 0 4.67723800703e-06
Gc4_579 0 n8 ns579 0 -3.54833560527e-05
Gc4_580 0 n8 ns580 0 -0.00119473630034
Gc4_581 0 n8 ns581 0 -0.000506407646195
Gc4_582 0 n8 ns582 0 0.000808490028284
Gc4_583 0 n8 ns583 0 -7.91349341556e-05
Gc4_584 0 n8 ns584 0 -0.000144942317459
Gc4_585 0 n8 ns585 0 -0.000161550805897
Gc4_586 0 n8 ns586 0 -0.00125413074713
Gc4_587 0 n8 ns587 0 -0.000652787978246
Gc4_588 0 n8 ns588 0 0.000245741301992
Gc4_589 0 n8 ns589 0 0.000918291382914
Gc4_590 0 n8 ns590 0 0.000183949386194
Gc4_591 0 n8 ns591 0 -0.000118459704642
Gc4_592 0 n8 ns592 0 -0.000787387762441
Gc4_593 0 n8 ns593 0 0.00101634746736
Gc4_594 0 n8 ns594 0 0.00104392212284
Gc4_595 0 n8 ns595 0 0.000379046130484
Gc4_596 0 n8 ns596 0 -0.000536555698231
Gc4_597 0 n8 ns597 0 -0.000532274233598
Gc4_598 0 n8 ns598 0 -0.00102766455154
Gc4_599 0 n8 ns599 0 0.000180614629799
Gc4_600 0 n8 ns600 0 0.000366962441413
Gc4_601 0 n8 ns601 0 0.000752402224847
Gc4_602 0 n8 ns602 0 0.000243016503415
Gc4_603 0 n8 ns603 0 -0.000393589953997
Gc4_604 0 n8 ns604 0 0.0028942568654
Gc4_605 0 n8 ns605 0 -0.00322958937219
Gc4_606 0 n8 ns606 0 0.00025373734473
Gc4_607 0 n8 ns607 0 -3.87759192672e-06
Gc4_608 0 n8 ns608 0 -2.50942706744e-05
Gc4_609 0 n8 ns609 0 0.000366828716763
Gc4_610 0 n8 ns610 0 -0.00121403312344
Gc4_611 0 n8 ns611 0 0.00841514126117
Gc4_612 0 n8 ns612 0 0.000494580589866
Gc4_613 0 n8 ns613 0 -0.000143245686441
Gc4_614 0 n8 ns614 0 -8.74373243632e-05
Gc4_615 0 n8 ns615 0 0.000177377465906
Gc4_616 0 n8 ns616 0 -1.05102667116e-05
Gc4_617 0 n8 ns617 0 4.68744296148e-05
Gc4_618 0 n8 ns618 0 -0.00136236940624
Gc4_619 0 n8 ns619 0 -0.00286430213765
Gc4_620 0 n8 ns620 0 0.000839362791781
Gc4_621 0 n8 ns621 0 0.00070798711422
Gc4_622 0 n8 ns622 0 2.19021542418e-05
Gc4_623 0 n8 ns623 0 0.00021533652797
Gc4_624 0 n8 ns624 0 0.000229124470201
Gc4_625 0 n8 ns625 0 0.000801803574446
Gc4_626 0 n8 ns626 0 -0.000573165574671
Gc4_627 0 n8 ns627 0 -0.000959154918079
Gc4_628 0 n8 ns628 0 6.59381792138e-05
Gc4_629 0 n8 ns629 0 0.000111771508204
Gc4_630 0 n8 ns630 0 -0.00247100375975
Gc4_631 0 n8 ns631 0 -0.00298930029002
Gc4_632 0 n8 ns632 0 9.49396901688e-05
Gc4_633 0 n8 ns633 0 -1.57974510375e-05
Gc4_634 0 n8 ns634 0 -0.000277822359486
Gc4_635 0 n8 ns635 0 0.000824717053195
Gc4_636 0 n8 ns636 0 -0.00568734271362
Gc4_637 0 n8 ns637 0 -0.00473577242127
Gc4_638 0 n8 ns638 0 -0.00189438491057
Gc4_639 0 n8 ns639 0 0.00314375501635
Gc4_640 0 n8 ns640 0 0.00190918394647
Gc4_641 0 n8 ns641 0 -0.000106428073552
Gc4_642 0 n8 ns642 0 -0.052680742808
Gc4_643 0 n8 ns643 0 0.0456815615493
Gc4_644 0 n8 ns644 0 -0.00207894645747
Gc4_645 0 n8 ns645 0 -7.29025866929e-06
Gc4_646 0 n8 ns646 0 1.62872296534e-05
Gc4_647 0 n8 ns647 0 0.000436574741303
Gc4_648 0 n8 ns648 0 -0.000247860053303
Gc4_649 0 n8 ns649 0 0.00964305124096
Gc4_650 0 n8 ns650 0 0.000186195892381
Gc4_651 0 n8 ns651 0 0.000517053167822
Gc4_652 0 n8 ns652 0 0.000368542393233
Gc4_653 0 n8 ns653 0 -0.000215258973816
Gc4_654 0 n8 ns654 0 -9.18123013646e-05
Gc4_655 0 n8 ns655 0 2.00022795132e-05
Gc4_656 0 n8 ns656 0 -0.000863832158629
Gc4_657 0 n8 ns657 0 -0.00346906076956
Gc4_658 0 n8 ns658 0 0.000750918501991
Gc4_659 0 n8 ns659 0 0.000739779373236
Gc4_660 0 n8 ns660 0 -4.64645124251e-05
Gc4_661 0 n8 ns661 0 0.00029718008449
Gc4_662 0 n8 ns662 0 -0.00037967400206
Gc4_663 0 n8 ns663 0 -0.000102167749424
Gc4_664 0 n8 ns664 0 -0.000725134079908
Gc4_665 0 n8 ns665 0 -0.000630659663002
Gc4_666 0 n8 ns666 0 0.000194467658687
Gc4_667 0 n8 ns667 0 0.000216204963461
Gc4_668 0 n8 ns668 0 -0.00253595295539
Gc4_669 0 n8 ns669 0 -0.00421434851282
Gc4_670 0 n8 ns670 0 -0.000500626641615
Gc4_671 0 n8 ns671 0 -4.79657337453e-06
Gc4_672 0 n8 ns672 0 -0.000162642322937
Gc4_673 0 n8 ns673 0 0.0011752555927
Gc4_674 0 n8 ns674 0 -0.00764787644567
Gc4_675 0 n8 ns675 0 -0.00577327887204
Gc4_676 0 n8 ns676 0 -0.00226951748106
Gc4_677 0 n8 ns677 0 0.00356630502674
Gc4_678 0 n8 ns678 0 0.00235154511025
Gc4_679 0 n8 ns679 0 -2.76818505166e-05
Gc4_680 0 n8 ns680 0 -0.0713835543524
Gc4_681 0 n8 ns681 0 0.0625712707178
Gc4_682 0 n8 ns682 0 -0.00303397117285
Gc4_683 0 n8 ns683 0 -1.10090523276e-05
Gc4_684 0 n8 ns684 0 1.70886356837e-05
Gc4_685 0 n8 ns685 0 -0.00036134475856
Gc4_686 0 n8 ns686 0 -6.23173536399e-05
Gc4_687 0 n8 ns687 0 0.00636320151805
Gc4_688 0 n8 ns688 0 -0.00111316095938
Gc4_689 0 n8 ns689 0 -0.000592721586746
Gc4_690 0 n8 ns690 0 0.00183350161891
Gc4_691 0 n8 ns691 0 0.000428929152896
Gc4_692 0 n8 ns692 0 -0.000177588749392
Gc4_693 0 n8 ns693 0 -0.000203051321811
Gc4_694 0 n8 ns694 0 0.00189785498025
Gc4_695 0 n8 ns695 0 -0.00158002712522
Gc4_696 0 n8 ns696 0 -0.000609972414887
Gc4_697 0 n8 ns697 0 0.000376807832626
Gc4_698 0 n8 ns698 0 -0.000271805329929
Gc4_699 0 n8 ns699 0 0.000519487567774
Gc4_700 0 n8 ns700 0 5.87169409824e-05
Gc4_701 0 n8 ns701 0 -0.0038590889159
Gc4_702 0 n8 ns702 0 -0.00139834212634
Gc4_703 0 n8 ns703 0 0.000277522595625
Gc4_704 0 n8 ns704 0 0.000335039435665
Gc4_705 0 n8 ns705 0 0.000496295390236
Gc4_706 0 n8 ns706 0 0.000822133031042
Gc4_707 0 n8 ns707 0 -0.0049583993223
Gc4_708 0 n8 ns708 0 -0.002482866574
Gc4_709 0 n8 ns709 0 -0.00122078080666
Gc4_710 0 n8 ns710 0 -0.000132380408545
Gc4_711 0 n8 ns711 0 0.00225317627971
Gc4_712 0 n8 ns712 0 -0.0123824421475
Gc4_713 0 n8 ns713 0 -0.00600902432472
Gc4_714 0 n8 ns714 0 -0.00118163106871
Gc4_715 0 n8 ns715 0 0.00308772272449
Gc4_716 0 n8 ns716 0 0.0031532343451
Gc4_717 0 n8 ns717 0 0.000335504507451
Gc4_718 0 n8 ns718 0 -0.0721326837124
Gc4_719 0 n8 ns719 0 0.0682289759701
Gc4_720 0 n8 ns720 0 -0.00649476852886
Gc4_721 0 n8 ns721 0 -1.17356905069e-05
Gc4_722 0 n8 ns722 0 2.5668945545e-05
Gc4_723 0 n8 ns723 0 -0.0169250025213
Gc4_724 0 n8 ns724 0 -0.001356727186
Gc4_725 0 n8 ns725 0 0.0214149138666
Gc4_726 0 n8 ns726 0 0.00638114530191
Gc4_727 0 n8 ns727 0 0.0102319394065
Gc4_728 0 n8 ns728 0 0.00149394658725
Gc4_729 0 n8 ns729 0 -0.00340203327852
Gc4_730 0 n8 ns730 0 -0.000540825430249
Gc4_731 0 n8 ns731 0 4.23195635178e-05
Gc4_732 0 n8 ns732 0 -0.00110335910297
Gc4_733 0 n8 ns733 0 -0.0146786043223
Gc4_734 0 n8 ns734 0 0.000914744846488
Gc4_735 0 n8 ns735 0 0.00199135535525
Gc4_736 0 n8 ns736 0 0.000239573766902
Gc4_737 0 n8 ns737 0 0.000464237176024
Gc4_738 0 n8 ns738 0 9.07476698785e-05
Gc4_739 0 n8 ns739 0 0.000127330351638
Gc4_740 0 n8 ns740 0 -0.000126448889047
Gc4_741 0 n8 ns741 0 0.000659834093894
Gc4_742 0 n8 ns742 0 0.000556902746809
Gc4_743 0 n8 ns743 0 0.000390129049576
Gc4_744 0 n8 ns744 0 -0.0119221850257
Gc4_745 0 n8 ns745 0 -0.00787532658115
Gc4_746 0 n8 ns746 0 -0.00362740025099
Gc4_747 0 n8 ns747 0 -0.00137300866786
Gc4_748 0 n8 ns748 0 7.60689983473e-05
Gc4_749 0 n8 ns749 0 0.0026035973059
Gc4_750 0 n8 ns750 0 0.00751001534576
Gc4_751 0 n8 ns751 0 -0.00601146656529
Gc4_752 0 n8 ns752 0 0.00184983687448
Gc4_753 0 n8 ns753 0 0.00219123081645
Gc4_754 0 n8 ns754 0 0.00340652203768
Gc4_755 0 n8 ns755 0 -1.63875404459e-05
Gc4_756 0 n8 ns756 0 -0.112777476839
Gc4_757 0 n8 ns757 0 0.0739231672367
Gc4_758 0 n8 ns758 0 -0.00890621984799
Gc4_759 0 n8 ns759 0 -1.1248060079e-05
Gc4_760 0 n8 ns760 0 1.26475839724e-05
Gc4_761 0 n8 ns761 0 -0.000366699208279
Gc4_762 0 n8 ns762 0 2.42312661002e-05
Gc4_763 0 n8 ns763 0 0.0056802803676
Gc4_764 0 n8 ns764 0 -0.00132167960252
Gc4_765 0 n8 ns765 0 -0.000360292234874
Gc4_766 0 n8 ns766 0 0.00186528077451
Gc4_767 0 n8 ns767 0 0.000585890890682
Gc4_768 0 n8 ns768 0 -0.000158944135867
Gc4_769 0 n8 ns769 0 -0.000185965556191
Gc4_770 0 n8 ns770 0 0.00211007788022
Gc4_771 0 n8 ns771 0 -0.00275166898588
Gc4_772 0 n8 ns772 0 -0.000677167049232
Gc4_773 0 n8 ns773 0 0.00111158466111
Gc4_774 0 n8 ns774 0 -4.55972226411e-05
Gc4_775 0 n8 ns775 0 0.000499981074677
Gc4_776 0 n8 ns776 0 -0.000393436143023
Gc4_777 0 n8 ns777 0 -0.00333655236586
Gc4_778 0 n8 ns778 0 -0.00084499824959
Gc4_779 0 n8 ns779 0 0.000245396440777
Gc4_780 0 n8 ns780 0 0.000298545811901
Gc4_781 0 n8 ns781 0 0.000330282471005
Gc4_782 0 n8 ns782 0 0.00111007863905
Gc4_783 0 n8 ns783 0 -0.00545507161546
Gc4_784 0 n8 ns784 0 -0.00295981833776
Gc4_785 0 n8 ns785 0 -0.00100825242448
Gc4_786 0 n8 ns786 0 0.000188705309903
Gc4_787 0 n8 ns787 0 0.00224686997904
Gc4_788 0 n8 ns788 0 -0.0123036657367
Gc4_789 0 n8 ns789 0 -0.00540029211339
Gc4_790 0 n8 ns790 0 -0.000899465851505
Gc4_791 0 n8 ns791 0 0.0029006024195
Gc4_792 0 n8 ns792 0 0.00303557961896
Gc4_793 0 n8 ns793 0 0.000247881788229
Gc4_794 0 n8 ns794 0 -0.0676447471942
Gc4_795 0 n8 ns795 0 0.0643951987719
Gc4_796 0 n8 ns796 0 -0.00636306106797
Gc4_797 0 n8 ns797 0 -9.8645224123e-06
Gc4_798 0 n8 ns798 0 2.75661511271e-06
Gc4_799 0 n8 ns799 0 0.000905447535101
Gc4_800 0 n8 ns800 0 -0.000914357016439
Gc4_801 0 n8 ns801 0 0.0103615016227
Gc4_802 0 n8 ns802 0 -7.7583421066e-06
Gc4_803 0 n8 ns803 0 0.000768279919476
Gc4_804 0 n8 ns804 0 0.00046158511645
Gc4_805 0 n8 ns805 0 -0.000146838388926
Gc4_806 0 n8 ns806 0 -9.02717036002e-05
Gc4_807 0 n8 ns807 0 -2.27868252543e-05
Gc4_808 0 n8 ns808 0 -1.38330695624e-05
Gc4_809 0 n8 ns809 0 -0.00417994430043
Gc4_810 0 n8 ns810 0 0.000237889192826
Gc4_811 0 n8 ns811 0 0.0010678954783
Gc4_812 0 n8 ns812 0 0.000122584409021
Gc4_813 0 n8 ns813 0 0.000412851407172
Gc4_814 0 n8 ns814 0 -0.000972002712669
Gc4_815 0 n8 ns815 0 -0.000592275928575
Gc4_816 0 n8 ns816 0 -0.000452275146983
Gc4_817 0 n8 ns817 0 -0.000101754619261
Gc4_818 0 n8 ns818 0 0.000266277119378
Gc4_819 0 n8 ns819 0 7.28828185162e-05
Gc4_820 0 n8 ns820 0 -0.00235526746841
Gc4_821 0 n8 ns821 0 -0.00499711221131
Gc4_822 0 n8 ns822 0 -0.00154836632088
Gc4_823 0 n8 ns823 0 1.34326795646e-05
Gc4_824 0 n8 ns824 0 0.000464210648116
Gc4_825 0 n8 ns825 0 0.00145631576113
Gc4_826 0 n8 ns826 0 -0.00901898859291
Gc4_827 0 n8 ns827 0 -0.0052771423151
Gc4_828 0 n8 ns828 0 -0.00153658148496
Gc4_829 0 n8 ns829 0 0.00383942624771
Gc4_830 0 n8 ns830 0 0.00229097635404
Gc4_831 0 n8 ns831 0 -0.000328142184416
Gc4_832 0 n8 ns832 0 -0.069487254826
Gc4_833 0 n8 ns833 0 0.0605346955186
Gc4_834 0 n8 ns834 0 -0.00288968671705
Gc4_835 0 n8 ns835 0 -8.78853304441e-06
Gc4_836 0 n8 ns836 0 -2.13553150507e-05
Gc4_837 0 n8 ns837 0 0.000517199266387
Gc4_838 0 n8 ns838 0 -0.000954704841061
Gc4_839 0 n8 ns839 0 0.00580303285688
Gc4_840 0 n8 ns840 0 -7.78909727557e-05
Gc4_841 0 n8 ns841 0 0.000334092299353
Gc4_842 0 n8 ns842 0 0.000368853084502
Gc4_843 0 n8 ns843 0 0.000138172145798
Gc4_844 0 n8 ns844 0 2.6487757279e-05
Gc4_845 0 n8 ns845 0 -6.17974597303e-06
Gc4_846 0 n8 ns846 0 -0.000630396557947
Gc4_847 0 n8 ns847 0 -0.00155857951862
Gc4_848 0 n8 ns848 0 0.000294675449965
Gc4_849 0 n8 ns849 0 0.000133595372829
Gc4_850 0 n8 ns850 0 0.000147032249907
Gc4_851 0 n8 ns851 0 0.000240529556454
Gc4_852 0 n8 ns852 0 0.000989177565299
Gc4_853 0 n8 ns853 0 -0.000605201353248
Gc4_854 0 n8 ns854 0 -0.000954723539139
Gc4_855 0 n8 ns855 0 -8.74928249614e-05
Gc4_856 0 n8 ns856 0 8.9737160842e-05
Gc4_857 0 n8 ns857 0 1.50317794961e-05
Gc4_858 0 n8 ns858 0 -0.00115682598424
Gc4_859 0 n8 ns859 0 -0.00243521487449
Gc4_860 0 n8 ns860 0 -0.00108035328763
Gc4_861 0 n8 ns861 0 -0.000951292498502
Gc4_862 0 n8 ns862 0 0.000360734848047
Gc4_863 0 n8 ns863 0 0.00134555728597
Gc4_864 0 n8 ns864 0 -0.00611359586459
Gc4_865 0 n8 ns865 0 -0.00358818950314
Gc4_866 0 n8 ns866 0 -0.000132217778983
Gc4_867 0 n8 ns867 0 0.00324891157332
Gc4_868 0 n8 ns868 0 0.00133150018173
Gc4_869 0 n8 ns869 0 -0.000680622316215
Gc4_870 0 n8 ns870 0 -0.0309133900871
Gc4_871 0 n8 ns871 0 0.0259109925881
Gc4_872 0 n8 ns872 0 -0.00102872378539
Gc4_873 0 n8 ns873 0 -4.13586780014e-06
Gc4_874 0 n8 ns874 0 -2.88069722888e-05
Gc4_875 0 n8 ns875 0 0.000411522265204
Gc4_876 0 n8 ns876 0 -0.000536874448028
Gc4_877 0 n8 ns877 0 0.00317178179258
Gc4_878 0 n8 ns878 0 -0.000162874669438
Gc4_879 0 n8 ns879 0 0.000334559154644
Gc4_880 0 n8 ns880 0 0.000229793505901
Gc4_881 0 n8 ns881 0 9.82356658606e-06
Gc4_882 0 n8 ns882 0 9.40401136267e-06
Gc4_883 0 n8 ns883 0 -4.47718940786e-05
Gc4_884 0 n8 ns884 0 0.00068811024897
Gc4_885 0 n8 ns885 0 -0.000910384237165
Gc4_886 0 n8 ns886 0 -0.000520661671989
Gc4_887 0 n8 ns887 0 0.000146189345203
Gc4_888 0 n8 ns888 0 0.000189670913784
Gc4_889 0 n8 ns889 0 0.000226098801323
Gc4_890 0 n8 ns890 0 -0.000166795026673
Gc4_891 0 n8 ns891 0 -0.00130505953265
Gc4_892 0 n8 ns892 0 -0.000371231742848
Gc4_893 0 n8 ns893 0 0.000764022260173
Gc4_894 0 n8 ns894 0 0.000158603047463
Gc4_895 0 n8 ns895 0 -6.0081379968e-05
Gc4_896 0 n8 ns896 0 -0.00019991465515
Gc4_897 0 n8 ns897 0 -0.00139764881404
Gc4_898 0 n8 ns898 0 -0.00139114280954
Gc4_899 0 n8 ns899 0 -0.000703046968538
Gc4_900 0 n8 ns900 0 0.000641756237896
Gc4_901 0 n8 ns901 0 0.00096068899977
Gc4_902 0 n8 ns902 0 -0.00416994319524
Gc4_903 0 n8 ns903 0 -0.00139680593933
Gc4_904 0 n8 ns904 0 0.000593776387425
Gc4_905 0 n8 ns905 0 0.00188378252975
Gc4_906 0 n8 ns906 0 0.000616259896141
Gc4_907 0 n8 ns907 0 -0.000603548510818
Gc4_908 0 n8 ns908 0 -0.0120814201213
Gc4_909 0 n8 ns909 0 0.00966804850741
Gc4_910 0 n8 ns910 0 -0.00034678272543
Gc4_911 0 n8 ns911 0 2.6035202691e-06
Gc4_912 0 n8 ns912 0 -2.65633987483e-05
Gc4_913 0 n8 ns913 0 0.000123095332207
Gc4_914 0 n8 ns914 0 -0.00092599322405
Gc4_915 0 n8 ns915 0 0.0025506210505
Gc4_916 0 n8 ns916 0 0.000112621674115
Gc4_917 0 n8 ns917 0 9.3447928824e-05
Gc4_918 0 n8 ns918 0 -3.22632368033e-05
Gc4_919 0 n8 ns919 0 -2.14414591695e-05
Gc4_920 0 n8 ns920 0 -2.78702763644e-05
Gc4_921 0 n8 ns921 0 1.24116798168e-05
Gc4_922 0 n8 ns922 0 0.000688987857229
Gc4_923 0 n8 ns923 0 -0.0014574684939
Gc4_924 0 n8 ns924 0 -0.000597696774807
Gc4_925 0 n8 ns925 0 0.000666814779737
Gc4_926 0 n8 ns926 0 0.000278438738535
Gc4_927 0 n8 ns927 0 0.000173782746696
Gc4_928 0 n8 ns928 0 -0.0010263670118
Gc4_929 0 n8 ns929 0 -0.000545636419508
Gc4_930 0 n8 ns930 0 0.000332551138872
Gc4_931 0 n8 ns931 0 0.000658835299944
Gc4_932 0 n8 ns932 0 0.00011641822894
Gc4_933 0 n8 ns933 0 -0.000143817624796
Gc4_934 0 n8 ns934 0 -1.65497462849e-05
Gc4_935 0 n8 ns935 0 -0.000987638090842
Gc4_936 0 n8 ns936 0 -0.00113446127492
Gc4_937 0 n8 ns937 0 -0.000179719631293
Gc4_938 0 n8 ns938 0 0.000600203364496
Gc4_939 0 n8 ns939 0 0.000485174751017
Gc4_940 0 n8 ns940 0 -0.00274060902962
Gc4_941 0 n8 ns941 0 -0.000342415518611
Gc4_942 0 n8 ns942 0 0.000618346719336
Gc4_943 0 n8 ns943 0 0.000991675191036
Gc4_944 0 n8 ns944 0 0.000278892813597
Gc4_945 0 n8 ns945 0 -0.00040586998616
Gc4_946 0 n8 ns946 0 -0.00595119235919
Gc4_947 0 n8 ns947 0 0.00464829824905
Gc4_948 0 n8 ns948 0 -0.000184775443649
Gc4_949 0 n8 ns949 0 8.12993470833e-06
Gc4_950 0 n8 ns950 0 -2.10016432694e-05
Gc4_951 0 n8 ns951 0 6.83077635933e-05
Gc4_952 0 n8 ns952 0 -0.000586716974638
Gc4_953 0 n8 ns953 0 0.00924125634488
Gc4_954 0 n8 ns954 0 -0.000212776832265
Gc4_955 0 n8 ns955 0 5.83949644523e-05
Gc4_956 0 n8 ns956 0 0.000557017186894
Gc4_957 0 n8 ns957 0 -0.000580461001467
Gc4_958 0 n8 ns958 0 -8.22374371014e-05
Gc4_959 0 n8 ns959 0 6.77365629137e-06
Gc4_960 0 n8 ns960 0 0.00137449464251
Gc4_961 0 n8 ns961 0 -0.00141473076731
Gc4_962 0 n8 ns962 0 -0.000180754915626
Gc4_963 0 n8 ns963 0 8.30643016124e-05
Gc4_964 0 n8 ns964 0 -0.000319084888725
Gc4_965 0 n8 ns965 0 0.000422025752457
Gc4_966 0 n8 ns966 0 -0.000509807542166
Gc4_967 0 n8 ns967 0 -0.00251257234588
Gc4_968 0 n8 ns968 0 -0.00117234102156
Gc4_969 0 n8 ns969 0 0.00012936039416
Gc4_970 0 n8 ns970 0 0.00033186772536
Gc4_971 0 n8 ns971 0 0.000437477672287
Gc4_972 0 n8 ns972 0 -0.000404906164226
Gc4_973 0 n8 ns973 0 -0.00575740265307
Gc4_974 0 n8 ns974 0 -0.00214560178164
Gc4_975 0 n8 ns975 0 -0.000642493920224
Gc4_976 0 n8 ns976 0 2.26261316394e-05
Gc4_977 0 n8 ns977 0 0.00198200696095
Gc4_978 0 n8 ns978 0 -0.0100622701186
Gc4_979 0 n8 ns979 0 -0.00594948417227
Gc4_980 0 n8 ns980 0 -0.00226158885937
Gc4_981 0 n8 ns981 0 0.00284577563522
Gc4_982 0 n8 ns982 0 0.00276467639977
Gc4_983 0 n8 ns983 0 0.00030735381913
Gc4_984 0 n8 ns984 0 -0.0912137381863
Gc4_985 0 n8 ns985 0 0.0831775996568
Gc4_986 0 n8 ns986 0 -0.00528765285849
Gc4_987 0 n8 ns987 0 -1.25810342489e-05
Gc4_988 0 n8 ns988 0 2.05606896671e-05
Gc4_989 0 n8 ns989 0 -0.00546414283731
Gc4_990 0 n8 ns990 0 -0.00512900335646
Gc4_991 0 n8 ns991 0 0.00920265018547
Gc4_992 0 n8 ns992 0 0.00261862037063
Gc4_993 0 n8 ns993 0 -0.00211233287606
Gc4_994 0 n8 ns994 0 0.000661482637495
Gc4_995 0 n8 ns995 0 0.00280038621414
Gc4_996 0 n8 ns996 0 -6.78803258135e-07
Gc4_997 0 n8 ns997 0 -0.000308377327479
Gc4_998 0 n8 ns998 0 -0.000992057805575
Gc4_999 0 n8 ns999 0 -0.00146071031721
Gc4_1000 0 n8 ns1000 0 -0.000884849907842
Gc4_1001 0 n8 ns1001 0 0.000488097228861
Gc4_1002 0 n8 ns1002 0 -0.000156755420275
Gc4_1003 0 n8 ns1003 0 0.000584760053714
Gc4_1004 0 n8 ns1004 0 0.00278722651623
Gc4_1005 0 n8 ns1005 0 -0.00258097403311
Gc4_1006 0 n8 ns1006 0 -0.000892777691961
Gc4_1007 0 n8 ns1007 0 -0.000591939082069
Gc4_1008 0 n8 ns1008 0 0.00020209098551
Gc4_1009 0 n8 ns1009 0 0.000194622073413
Gc4_1010 0 n8 ns1010 0 0.00239048291658
Gc4_1011 0 n8 ns1011 0 0.00134793706144
Gc4_1012 0 n8 ns1012 0 -0.00116515839467
Gc4_1013 0 n8 ns1013 0 -0.00268364603314
Gc4_1014 0 n8 ns1014 0 -0.00115804925717
Gc4_1015 0 n8 ns1015 0 0.00210284503709
Gc4_1016 0 n8 ns1016 0 -0.0147044201926
Gc4_1017 0 n8 ns1017 0 -0.00568955592926
Gc4_1018 0 n8 ns1018 0 0.00202032153249
Gc4_1019 0 n8 ns1019 0 0.00390671294056
Gc4_1020 0 n8 ns1020 0 0.00372208360244
Gc4_1021 0 n8 ns1021 0 0.000173631342088
Gc4_1022 0 n8 ns1022 0 0.00890814142086
Gc4_1023 0 n8 ns1023 0 -0.0011439034664
Gc4_1024 0 n8 ns1024 0 -0.00787290208957
Gc4_1025 0 n8 ns1025 0 -1.31469283639e-05
Gc4_1026 0 n8 ns1026 0 1.54262071469e-05
Gc4_1027 0 n8 ns1027 0 -0.00257603843329
Gc4_1028 0 n8 ns1028 0 -0.00296267956797
Gc4_1029 0 n8 ns1029 0 0.00737413361659
Gc4_1030 0 n8 ns1030 0 0.000986041793909
Gc4_1031 0 n8 ns1031 0 -0.00171704007812
Gc4_1032 0 n8 ns1032 0 0.00063602403008
Gc4_1033 0 n8 ns1033 0 0.00199173414641
Gc4_1034 0 n8 ns1034 0 3.50022018378e-05
Gc4_1035 0 n8 ns1035 0 -0.000211413206197
Gc4_1036 0 n8 ns1036 0 0.000940570967753
Gc4_1037 0 n8 ns1037 0 -0.00157706683234
Gc4_1038 0 n8 ns1038 0 -0.00109030390762
Gc4_1039 0 n8 ns1039 0 0.000723433830019
Gc4_1040 0 n8 ns1040 0 -0.000135698025737
Gc4_1041 0 n8 ns1041 0 0.000547167188075
Gc4_1042 0 n8 ns1042 0 0.00127541080787
Gc4_1043 0 n8 ns1043 0 -0.00283933019883
Gc4_1044 0 n8 ns1044 0 -0.000618332738197
Gc4_1045 0 n8 ns1045 0 -0.000135882131618
Gc4_1046 0 n8 ns1046 0 0.000278454074456
Gc4_1047 0 n8 ns1047 0 0.000233868662673
Gc4_1048 0 n8 ns1048 0 0.00216025458871
Gc4_1049 0 n8 ns1049 0 -0.0023260190384
Gc4_1050 0 n8 ns1050 0 -0.00262129349887
Gc4_1051 0 n8 ns1051 0 -0.00183768466659
Gc4_1052 0 n8 ns1052 0 -0.000319327264657
Gc4_1053 0 n8 ns1053 0 0.0023787705869
Gc4_1054 0 n8 ns1054 0 -0.0119124416692
Gc4_1055 0 n8 ns1055 0 -0.00484952995603
Gc4_1056 0 n8 ns1056 0 0.000288014823405
Gc4_1057 0 n8 ns1057 0 0.0024484755508
Gc4_1058 0 n8 ns1058 0 0.00314128641449
Gc4_1059 0 n8 ns1059 0 0.000207772685998
Gc4_1060 0 n8 ns1060 0 -0.0367089666592
Gc4_1061 0 n8 ns1061 0 0.0384251814927
Gc4_1062 0 n8 ns1062 0 -0.0070684584083
Gc4_1063 0 n8 ns1063 0 -9.87091596794e-06
Gc4_1064 0 n8 ns1064 0 8.43981301626e-06
Gc4_1065 0 n8 ns1065 0 0.00029301846343
Gc4_1066 0 n8 ns1066 0 -0.00115784885769
Gc4_1067 0 n8 ns1067 0 0.0101494817401
Gc4_1068 0 n8 ns1068 0 -0.000151185658419
Gc4_1069 0 n8 ns1069 0 0.00053552518171
Gc4_1070 0 n8 ns1070 0 0.000600354884165
Gc4_1071 0 n8 ns1071 0 -0.000315575067595
Gc4_1072 0 n8 ns1072 0 -0.000121430654531
Gc4_1073 0 n8 ns1073 0 -2.66027031103e-05
Gc4_1074 0 n8 ns1074 0 0.00103185588495
Gc4_1075 0 n8 ns1075 0 -0.00385034091651
Gc4_1076 0 n8 ns1076 0 -0.000174569827835
Gc4_1077 0 n8 ns1077 0 0.00114739585866
Gc4_1078 0 n8 ns1078 0 2.17800336859e-05
Gc4_1079 0 n8 ns1079 0 0.000474497812024
Gc4_1080 0 n8 ns1080 0 -0.00142009277176
Gc4_1081 0 n8 ns1081 0 -0.00123328496925
Gc4_1082 0 n8 ns1082 0 -0.000339059569543
Gc4_1083 0 n8 ns1083 0 3.21155238955e-05
Gc4_1084 0 n8 ns1084 0 0.000328770063514
Gc4_1085 0 n8 ns1085 0 0.000133837441888
Gc4_1086 0 n8 ns1086 0 -0.00148043805724
Gc4_1087 0 n8 ns1087 0 -0.00576227284245
Gc4_1088 0 n8 ns1088 0 -0.00210522394687
Gc4_1089 0 n8 ns1089 0 -5.16844313807e-05
Gc4_1090 0 n8 ns1090 0 0.000457733564798
Gc4_1091 0 n8 ns1091 0 0.00172053223848
Gc4_1092 0 n8 ns1092 0 -0.00976292606694
Gc4_1093 0 n8 ns1093 0 -0.00526569106376
Gc4_1094 0 n8 ns1094 0 -0.00172627289298
Gc4_1095 0 n8 ns1095 0 0.00341873357393
Gc4_1096 0 n8 ns1096 0 0.00253817334184
Gc4_1097 0 n8 ns1097 0 -0.000139000661565
Gc4_1098 0 n8 ns1098 0 -0.077401208379
Gc4_1099 0 n8 ns1099 0 0.0690139095003
Gc4_1100 0 n8 ns1100 0 -0.00393207019229
Gc4_1101 0 n8 ns1101 0 -9.16811831609e-06
Gc4_1102 0 n8 ns1102 0 -1.21802009932e-05
Gc4_1103 0 n8 ns1103 0 0.000898009558987
Gc4_1104 0 n8 ns1104 0 -0.00172302961565
Gc4_1105 0 n8 ns1105 0 0.00790712646047
Gc4_1106 0 n8 ns1106 0 8.20182788874e-05
Gc4_1107 0 n8 ns1107 0 2.20278466779e-05
Gc4_1108 0 n8 ns1108 0 8.78946746631e-05
Gc4_1109 0 n8 ns1109 0 0.000139891643514
Gc4_1110 0 n8 ns1110 0 2.25496613915e-05
Gc4_1111 0 n8 ns1111 0 3.83526594248e-05
Gc4_1112 0 n8 ns1112 0 -0.000757219708622
Gc4_1113 0 n8 ns1113 0 -0.00198270424615
Gc4_1114 0 n8 ns1114 0 0.000380125734078
Gc4_1115 0 n8 ns1115 0 0.000321023613876
Gc4_1116 0 n8 ns1116 0 0.000104430947813
Gc4_1117 0 n8 ns1117 0 0.000301194252506
Gc4_1118 0 n8 ns1118 0 0.00062185851211
Gc4_1119 0 n8 ns1119 0 -8.94546012173e-05
Gc4_1120 0 n8 ns1120 0 -0.000819401194123
Gc4_1121 0 n8 ns1121 0 -0.00032765566721
Gc4_1122 0 n8 ns1122 0 0.000130381276103
Gc4_1123 0 n8 ns1123 0 1.230529833e-05
Gc4_1124 0 n8 ns1124 0 -0.00167878755595
Gc4_1125 0 n8 ns1125 0 -0.00293045664753
Gc4_1126 0 n8 ns1126 0 -0.000954294821933
Gc4_1127 0 n8 ns1127 0 -0.000730016525055
Gc4_1128 0 n8 ns1128 0 0.000281725958265
Gc4_1129 0 n8 ns1129 0 0.00138030352654
Gc4_1130 0 n8 ns1130 0 -0.00681790290849
Gc4_1131 0 n8 ns1131 0 -0.00399036093916
Gc4_1132 0 n8 ns1132 0 -0.000559705496329
Gc4_1133 0 n8 ns1133 0 0.003536428284
Gc4_1134 0 n8 ns1134 0 0.0016412138556
Gc4_1135 0 n8 ns1135 0 -0.000636957852604
Gc4_1136 0 n8 ns1136 0 -0.0402506961183
Gc4_1137 0 n8 ns1137 0 0.0341451500113
Gc4_1138 0 n8 ns1138 0 -0.00144597245037
Gc4_1139 0 n8 ns1139 0 -5.99718997779e-06
Gc4_1140 0 n8 ns1140 0 -2.7184429147e-05
Gc4_1141 0 n8 ns1141 0 0.000501385579846
Gc4_1142 0 n8 ns1142 0 -0.000803315592995
Gc4_1143 0 n8 ns1143 0 0.00421065058293
Gc4_1144 0 n8 ns1144 0 -9.88099137979e-05
Gc4_1145 0 n8 ns1145 0 0.000291938668581
Gc4_1146 0 n8 ns1146 0 0.000292967126268
Gc4_1147 0 n8 ns1147 0 2.39403736327e-06
Gc4_1148 0 n8 ns1148 0 2.78294910219e-05
Gc4_1149 0 n8 ns1149 0 -3.38243608961e-05
Gc4_1150 0 n8 ns1150 0 7.75945530793e-05
Gc4_1151 0 n8 ns1151 0 -0.000750997072906
Gc4_1152 0 n8 ns1152 0 -0.00020768978237
Gc4_1153 0 n8 ns1153 0 -8.36283596289e-05
Gc4_1154 0 n8 ns1154 0 0.000145039420897
Gc4_1155 0 n8 ns1155 0 0.000224558796572
Gc4_1156 0 n8 ns1156 0 0.000362486893764
Gc4_1157 0 n8 ns1157 0 -0.00128518933481
Gc4_1158 0 n8 ns1158 0 -0.00071839162829
Gc4_1159 0 n8 ns1159 0 0.00058370560139
Gc4_1160 0 n8 ns1160 0 0.000156147075587
Gc4_1161 0 n8 ns1161 0 -1.4983651551e-05
Gc4_1162 0 n8 ns1162 0 -0.000478445222435
Gc4_1163 0 n8 ns1163 0 -0.00163822290405
Gc4_1164 0 n8 ns1164 0 -0.0013632005361
Gc4_1165 0 n8 ns1165 0 -0.000942917553668
Gc4_1166 0 n8 ns1166 0 0.000571194589861
Gc4_1167 0 n8 ns1167 0 0.00119003508248
Gc4_1168 0 n8 ns1168 0 -0.00508435878976
Gc4_1169 0 n8 ns1169 0 -0.00200982728889
Gc4_1170 0 n8 ns1170 0 0.000541124432175
Gc4_1171 0 n8 ns1171 0 0.00240909333752
Gc4_1172 0 n8 ns1172 0 0.000834881289685
Gc4_1173 0 n8 ns1173 0 -0.00070463494311
Gc4_1174 0 n8 ns1174 0 -0.0169664351497
Gc4_1175 0 n8 ns1175 0 0.0137222359445
Gc4_1176 0 n8 ns1176 0 -0.000492588670605
Gc4_1177 0 n8 ns1177 0 3.80452281576e-07
Gc4_1178 0 n8 ns1178 0 -2.96850925935e-05
Gc4_1179 0 n8 ns1179 0 0.000256830216102
Gc4_1180 0 n8 ns1180 0 -0.00103863725243
Gc4_1181 0 n8 ns1181 0 0.00325825197305
Gc4_1182 0 n8 ns1182 0 6.47684105879e-05
Gc4_1183 0 n8 ns1183 0 0.00017384206389
Gc4_1184 0 n8 ns1184 0 3.6204768938e-05
Gc4_1185 0 n8 ns1185 0 -1.53330396085e-05
Gc4_1186 0 n8 ns1186 0 -2.0229598642e-05
Gc4_1187 0 n8 ns1187 0 -9.82416205194e-06
Gc4_1188 0 n8 ns1188 0 0.000864714893355
Gc4_1189 0 n8 ns1189 0 -0.00152012906913
Gc4_1190 0 n8 ns1190 0 -0.000703866750395
Gc4_1191 0 n8 ns1191 0 0.000602021463236
Gc4_1192 0 n8 ns1192 0 0.000289811260132
Gc4_1193 0 n8 ns1193 0 0.000223616521217
Gc4_1194 0 n8 ns1194 0 -0.000956557558113
Gc4_1195 0 n8 ns1195 0 -0.000942327514155
Gc4_1196 0 n8 ns1196 0 0.000160967154536
Gc4_1197 0 n8 ns1197 0 0.000826882848819
Gc4_1198 0 n8 ns1198 0 0.000149742855793
Gc4_1199 0 n8 ns1199 0 -0.000135208326605
Gc4_1200 0 n8 ns1200 0 -0.000116658481162
Gc4_1201 0 n8 ns1201 0 -0.00127392501121
Gc4_1202 0 n8 ns1202 0 -0.00137846337998
Gc4_1203 0 n8 ns1203 0 -0.000315357188734
Gc4_1204 0 n8 ns1204 0 0.000711056246738
Gc4_1205 0 n8 ns1205 0 0.000666679229717
Gc4_1206 0 n8 ns1206 0 -0.00348555525219
Gc4_1207 0 n8 ns1207 0 -0.000880418042941
Gc4_1208 0 n8 ns1208 0 0.000584911186462
Gc4_1209 0 n8 ns1209 0 0.00135090754226
Gc4_1210 0 n8 ns1210 0 0.000412396825932
Gc4_1211 0 n8 ns1211 0 -0.000451367869189
Gc4_1212 0 n8 ns1212 0 -0.0109263718066
Gc4_1213 0 n8 ns1213 0 0.00883440419021
Gc4_1214 0 n8 ns1214 0 -0.000323126322318
Gc4_1215 0 n8 ns1215 0 6.40431241542e-06
Gc4_1216 0 n8 ns1216 0 -2.33805834662e-05
Gd4_1 0 n8 ni1 0 0.000306422494153
Gd4_2 0 n8 ni2 0 -0.000195611228424
Gd4_3 0 n8 ni3 0 -0.00162903960744
Gd4_4 0 n8 ni4 0 0.000187908176881
Gd4_5 0 n8 ni5 0 -0.00181415199681
Gd4_6 0 n8 ni6 0 -0.000459264271072
Gd4_7 0 n8 ni7 0 0.000158851372704
Gd4_8 0 n8 ni8 0 -2.5924758225e-06
Gd4_9 0 n8 ni9 0 -4.96344569871e-05
Gd4_10 0 n8 ni10 0 -0.00102759103941
Gd4_11 0 n8 ni11 0 -0.000614659395142
Gd4_12 0 n8 ni12 0 -0.00264261611502
Gd4_13 0 n8 ni13 0 -0.000858683765909
Gd4_14 0 n8 ni14 0 7.54660087413e-05
Gd4_15 0 n8 ni15 0 6.22124079789e-05
Gd4_16 0 n8 ni16 0 0.000120889129583
Gd4_17 0 n8 ni17 0 0.000201230132968
Gd4_18 0 n8 ni18 0 0.000564920638699
Gd4_19 0 n8 ni19 0 -0.000390131137069
Gd4_20 0 n8 ni20 0 -0.00675642729721
Gd4_21 0 n8 ni21 0 -0.000393645622594
Gd4_22 0 n8 ni22 0 0.000609404511397
Gd4_23 0 n8 ni23 0 0.000227535118814
Gd4_24 0 n8 ni24 0 0.000209091436255
Gd4_25 0 n8 ni25 0 -0.000137645722713
Gd4_26 0 n8 ni26 0 -9.69198992849e-05
Gd4_27 0 n8 ni27 0 -0.0032303360456
Gd4_28 0 n8 ni28 0 -0.00169471270603
Gd4_29 0 n8 ni29 0 2.92824208302e-05
Gd4_30 0 n8 ni30 0 0.000266576698704
Gd4_31 0 n8 ni31 0 0.000197882884355
Gd4_32 0 n8 ni32 0 -7.28560128512e-05
Gc5_1 0 n10 ns1 0 -0.000854186808833
Gc5_2 0 n10 ns2 0 0.00176545983153
Gc5_3 0 n10 ns3 0 -0.00164633404827
Gc5_4 0 n10 ns4 0 -7.52874398345e-05
Gc5_5 0 n10 ns5 0 -0.000134294753749
Gc5_6 0 n10 ns6 0 -0.000322101433701
Gc5_7 0 n10 ns7 0 2.49763366746e-05
Gc5_8 0 n10 ns8 0 -4.36244189216e-05
Gc5_9 0 n10 ns9 0 1.29666024658e-05
Gc5_10 0 n10 ns10 0 0.000578927743159
Gc5_11 0 n10 ns11 0 0.000656836460519
Gc5_12 0 n10 ns12 0 -7.97210792258e-05
Gc5_13 0 n10 ns13 0 0.000511092806039
Gc5_14 0 n10 ns14 0 4.42347744581e-05
Gc5_15 0 n10 ns15 0 -0.000285172191172
Gc5_16 0 n10 ns16 0 0.00168592651798
Gc5_17 0 n10 ns17 0 -0.000520049945028
Gc5_18 0 n10 ns18 0 -0.00107017851175
Gc5_19 0 n10 ns19 0 1.41102074202e-07
Gc5_20 0 n10 ns20 0 0.000159920231832
Gc5_21 0 n10 ns21 0 6.41305865008e-05
Gc5_22 0 n10 ns22 0 -3.08418837822e-05
Gc5_23 0 n10 ns23 0 -0.00110248371647
Gc5_24 0 n10 ns24 0 -0.000306272222313
Gc5_25 0 n10 ns25 0 0.00136787672137
Gc5_26 0 n10 ns26 0 0.000362556435436
Gc5_27 0 n10 ns27 0 -0.00092301149348
Gc5_28 0 n10 ns28 0 -0.00113094711847
Gc5_29 0 n10 ns29 0 -0.000979381803807
Gc5_30 0 n10 ns30 0 -9.21957607029e-05
Gc5_31 0 n10 ns31 0 0.00165246414352
Gc5_32 0 n10 ns32 0 0.000755585367758
Gc5_33 0 n10 ns33 0 -0.000587071189094
Gc5_34 0 n10 ns34 0 0.0116328609635
Gc5_35 0 n10 ns35 0 -0.0114202045437
Gc5_36 0 n10 ns36 0 0.00074690260076
Gc5_37 0 n10 ns37 0 -9.94682499174e-06
Gc5_38 0 n10 ns38 0 3.3081037771e-06
Gc5_39 0 n10 ns39 0 -0.000881860972096
Gc5_40 0 n10 ns40 0 0.00217779898388
Gc5_41 0 n10 ns41 0 -0.00245181740195
Gc5_42 0 n10 ns42 0 -0.000180252006714
Gc5_43 0 n10 ns43 0 -0.000144753567971
Gc5_44 0 n10 ns44 0 -0.000266054442436
Gc5_45 0 n10 ns45 0 -8.67017782894e-05
Gc5_46 0 n10 ns46 0 -1.9446177477e-05
Gc5_47 0 n10 ns47 0 1.61152574724e-05
Gc5_48 0 n10 ns48 0 0.000236579227253
Gc5_49 0 n10 ns49 0 0.000963334011326
Gc5_50 0 n10 ns50 0 -9.50515940971e-05
Gc5_51 0 n10 ns51 0 0.000408388197665
Gc5_52 0 n10 ns52 0 3.85614231266e-05
Gc5_53 0 n10 ns53 0 -0.000346100801707
Gc5_54 0 n10 ns54 0 0.00146937732812
Gc5_55 0 n10 ns55 0 5.9727279602e-05
Gc5_56 0 n10 ns56 0 -0.000961561708883
Gc5_57 0 n10 ns57 0 -8.03129875393e-05
Gc5_58 0 n10 ns58 0 0.000227824911187
Gc5_59 0 n10 ns59 0 3.65660544909e-05
Gc5_60 0 n10 ns60 0 0.000522338953638
Gc5_61 0 n10 ns61 0 -0.00039907744972
Gc5_62 0 n10 ns62 0 -0.000251987053594
Gc5_63 0 n10 ns63 0 0.00134100878444
Gc5_64 0 n10 ns64 0 0.000353628292475
Gc5_65 0 n10 ns65 0 -0.00108979317263
Gc5_66 0 n10 ns66 0 -0.000176742355435
Gc5_67 0 n10 ns67 0 -0.000848452399038
Gc5_68 0 n10 ns68 0 -0.000439444888493
Gc5_69 0 n10 ns69 0 0.00172108023195
Gc5_70 0 n10 ns70 0 0.000921327217456
Gc5_71 0 n10 ns71 0 -0.000629699323954
Gc5_72 0 n10 ns72 0 0.0194080779687
Gc5_73 0 n10 ns73 0 -0.0183750981663
Gc5_74 0 n10 ns74 0 0.00108771138569
Gc5_75 0 n10 ns75 0 -8.1205955377e-06
Gc5_76 0 n10 ns76 0 4.40984490645e-06
Gc5_77 0 n10 ns77 0 -0.00110597504376
Gc5_78 0 n10 ns78 0 0.000392280372405
Gc5_79 0 n10 ns79 0 9.98611963426e-05
Gc5_80 0 n10 ns80 0 0.000572332645809
Gc5_81 0 n10 ns81 0 -0.000525090432151
Gc5_82 0 n10 ns82 0 0.000465855943181
Gc5_83 0 n10 ns83 0 -0.000208503882842
Gc5_84 0 n10 ns84 0 -4.33428941374e-05
Gc5_85 0 n10 ns85 0 -3.01113966486e-07
Gc5_86 0 n10 ns86 0 -0.00257343261477
Gc5_87 0 n10 ns87 0 7.54146825757e-06
Gc5_88 0 n10 ns88 0 0.000657315475889
Gc5_89 0 n10 ns89 0 -0.000245461900271
Gc5_90 0 n10 ns90 0 0.000118705299211
Gc5_91 0 n10 ns91 0 -0.000505170126707
Gc5_92 0 n10 ns92 0 -0.00195106744449
Gc5_93 0 n10 ns93 0 0.000466640061356
Gc5_94 0 n10 ns94 0 -4.0779004008e-05
Gc5_95 0 n10 ns95 0 0.000392487543863
Gc5_96 0 n10 ns96 0 0.000487226389788
Gc5_97 0 n10 ns97 0 5.25312392743e-05
Gc5_98 0 n10 ns98 0 -0.000519396923901
Gc5_99 0 n10 ns99 0 0.0036499643433
Gc5_100 0 n10 ns100 0 0.000684244834053
Gc5_101 0 n10 ns101 0 0.000783672494267
Gc5_102 0 n10 ns102 0 0.00018469619582
Gc5_103 0 n10 ns103 0 -0.00143351005306
Gc5_104 0 n10 ns104 0 0.00177166989396
Gc5_105 0 n10 ns105 0 0.00172410822029
Gc5_106 0 n10 ns106 0 -0.00156218235098
Gc5_107 0 n10 ns107 0 0.000893804751456
Gc5_108 0 n10 ns108 0 0.00144788124978
Gc5_109 0 n10 ns109 0 -0.000436184796365
Gc5_110 0 n10 ns110 0 0.0420271249692
Gc5_111 0 n10 ns111 0 -0.0402218064391
Gc5_112 0 n10 ns112 0 0.00263212653041
Gc5_113 0 n10 ns113 0 -2.02663807306e-06
Gc5_114 0 n10 ns114 0 3.23300365027e-07
Gc5_115 0 n10 ns115 0 -0.00205873285119
Gc5_116 0 n10 ns116 0 -0.00195271084964
Gc5_117 0 n10 ns117 0 0.00391768291117
Gc5_118 0 n10 ns118 0 0.000329242141088
Gc5_119 0 n10 ns119 0 -0.000365047799547
Gc5_120 0 n10 ns120 0 0.000611988149297
Gc5_121 0 n10 ns121 0 0.000394260546735
Gc5_122 0 n10 ns122 0 -0.000174781532339
Gc5_123 0 n10 ns123 0 -8.64956806271e-05
Gc5_124 0 n10 ns124 0 -0.00136923143348
Gc5_125 0 n10 ns125 0 4.86436560468e-05
Gc5_126 0 n10 ns126 0 0.00108785908037
Gc5_127 0 n10 ns127 0 -0.000142857142295
Gc5_128 0 n10 ns128 0 0.000306691410801
Gc5_129 0 n10 ns129 0 -0.000509006420443
Gc5_130 0 n10 ns130 0 0.000117622900333
Gc5_131 0 n10 ns131 0 -0.00188461196662
Gc5_132 0 n10 ns132 0 -0.000337000067876
Gc5_133 0 n10 ns133 0 6.09366969841e-05
Gc5_134 0 n10 ns134 0 0.000380306742186
Gc5_135 0 n10 ns135 0 0.0002081633106
Gc5_136 0 n10 ns136 0 -0.00364417339038
Gc5_137 0 n10 ns137 0 -0.000903963681334
Gc5_138 0 n10 ns138 0 0.000862313872059
Gc5_139 0 n10 ns139 0 0.00139406585896
Gc5_140 0 n10 ns140 0 0.000770448010095
Gc5_141 0 n10 ns141 0 -0.00157140060617
Gc5_142 0 n10 ns142 0 -0.00527977159402
Gc5_143 0 n10 ns143 0 -0.00128825821721
Gc5_144 0 n10 ns144 0 -0.00122548294503
Gc5_145 0 n10 ns145 0 0.000822012853458
Gc5_146 0 n10 ns146 0 0.00242885776062
Gc5_147 0 n10 ns147 0 0.000242881554749
Gc5_148 0 n10 ns148 0 0.0219526594456
Gc5_149 0 n10 ns149 0 -0.0293592560903
Gc5_150 0 n10 ns150 0 0.00550577993944
Gc5_151 0 n10 ns151 0 1.95450540315e-06
Gc5_152 0 n10 ns152 0 3.69872732241e-06
Gc5_153 0 n10 ns153 0 -0.00389957725937
Gc5_154 0 n10 ns154 0 -0.000114572894076
Gc5_155 0 n10 ns155 0 -0.0037010224307
Gc5_156 0 n10 ns156 0 0.000360458495488
Gc5_157 0 n10 ns157 0 -0.000454964378947
Gc5_158 0 n10 ns158 0 0.000222542728808
Gc5_159 0 n10 ns159 0 -0.000181114187559
Gc5_160 0 n10 ns160 0 -0.000205841106626
Gc5_161 0 n10 ns161 0 -5.8557213834e-05
Gc5_162 0 n10 ns162 0 -0.0033631270691
Gc5_163 0 n10 ns163 0 0.00238182212232
Gc5_164 0 n10 ns164 0 0.00120413536833
Gc5_165 0 n10 ns165 0 -0.000368439574987
Gc5_166 0 n10 ns166 0 0.000358996031766
Gc5_167 0 n10 ns167 0 -0.000540330480019
Gc5_168 0 n10 ns168 0 0.000204004976337
Gc5_169 0 n10 ns169 0 0.00161217018362
Gc5_170 0 n10 ns170 0 0.00064815692605
Gc5_171 0 n10 ns171 0 0.000193980934827
Gc5_172 0 n10 ns172 0 0.000561911954366
Gc5_173 0 n10 ns173 0 0.000151697009314
Gc5_174 0 n10 ns174 0 0.00142067960248
Gc5_175 0 n10 ns175 0 0.00106958218656
Gc5_176 0 n10 ns176 0 0.00152995294485
Gc5_177 0 n10 ns177 0 0.00256079045286
Gc5_178 0 n10 ns178 0 0.0011143137159
Gc5_179 0 n10 ns179 0 -0.00211947709571
Gc5_180 0 n10 ns180 0 0.000657022086694
Gc5_181 0 n10 ns181 0 -0.00245793558398
Gc5_182 0 n10 ns182 0 0.00208919842442
Gc5_183 0 n10 ns183 0 0.00154358231984
Gc5_184 0 n10 ns184 0 0.00310054458434
Gc5_185 0 n10 ns185 0 1.70424807682e-05
Gc5_186 0 n10 ns186 0 -0.0150728958936
Gc5_187 0 n10 ns187 0 0.0163274602897
Gc5_188 0 n10 ns188 0 0.00714329253705
Gc5_189 0 n10 ns189 0 1.05896828207e-05
Gc5_190 0 n10 ns190 0 -2.20971572388e-06
Gc5_191 0 n10 ns191 0 -0.00233226900589
Gc5_192 0 n10 ns192 0 -0.00124844479846
Gc5_193 0 n10 ns193 0 0.00146518541471
Gc5_194 0 n10 ns194 0 0.000135384761173
Gc5_195 0 n10 ns195 0 -0.000400017959545
Gc5_196 0 n10 ns196 0 0.000472544395141
Gc5_197 0 n10 ns197 0 0.000498459044114
Gc5_198 0 n10 ns198 0 -0.000156401010022
Gc5_199 0 n10 ns199 0 -5.74178726661e-05
Gc5_200 0 n10 ns200 0 -0.000494343232341
Gc5_201 0 n10 ns201 0 0.000312767640622
Gc5_202 0 n10 ns202 0 0.000737408134246
Gc5_203 0 n10 ns203 0 -0.000111017731006
Gc5_204 0 n10 ns204 0 0.000308271155171
Gc5_205 0 n10 ns205 0 -0.000431098239081
Gc5_206 0 n10 ns206 0 0.000456631834464
Gc5_207 0 n10 ns207 0 -0.00164549007006
Gc5_208 0 n10 ns208 0 -0.000302793483805
Gc5_209 0 n10 ns209 0 -0.00013028806933
Gc5_210 0 n10 ns210 0 0.000346031916694
Gc5_211 0 n10 ns211 0 0.000190215490888
Gc5_212 0 n10 ns212 0 -0.00298484318147
Gc5_213 0 n10 ns213 0 -0.000801522374395
Gc5_214 0 n10 ns214 0 0.000907765064461
Gc5_215 0 n10 ns215 0 0.00112852243489
Gc5_216 0 n10 ns216 0 0.000662817292203
Gc5_217 0 n10 ns217 0 -0.00147174351042
Gc5_218 0 n10 ns218 0 -0.00418113128461
Gc5_219 0 n10 ns219 0 -0.000909303150324
Gc5_220 0 n10 ns220 0 -0.00121823647973
Gc5_221 0 n10 ns221 0 0.000488808372605
Gc5_222 0 n10 ns222 0 0.00230313890662
Gc5_223 0 n10 ns223 0 0.000234596654225
Gc5_224 0 n10 ns224 0 0.0296354481212
Gc5_225 0 n10 ns225 0 -0.0356277933718
Gc5_226 0 n10 ns226 0 0.00567877324782
Gc5_227 0 n10 ns227 0 1.06832693124e-06
Gc5_228 0 n10 ns228 0 -2.66324527174e-06
Gc5_229 0 n10 ns229 0 -0.00132906669153
Gc5_230 0 n10 ns230 0 0.000771690272607
Gc5_231 0 n10 ns231 0 -0.00186235664604
Gc5_232 0 n10 ns232 0 0.000396352250453
Gc5_233 0 n10 ns233 0 -0.000482404754667
Gc5_234 0 n10 ns234 0 0.000434991320628
Gc5_235 0 n10 ns235 0 -0.000212090813167
Gc5_236 0 n10 ns236 0 -5.86296975056e-05
Gc5_237 0 n10 ns237 0 1.0910433511e-07
Gc5_238 0 n10 ns238 0 -0.00198565731271
Gc5_239 0 n10 ns239 0 0.00068633599817
Gc5_240 0 n10 ns240 0 0.000369494205697
Gc5_241 0 n10 ns241 0 -0.000487984572002
Gc5_242 0 n10 ns242 0 5.78836149486e-05
Gc5_243 0 n10 ns243 0 -0.00042290159599
Gc5_244 0 n10 ns244 0 -0.0016361774885
Gc5_245 0 n10 ns245 0 0.00103263351428
Gc5_246 0 n10 ns246 0 0.000175244483195
Gc5_247 0 n10 ns247 0 0.000100056091394
Gc5_248 0 n10 ns248 0 0.000422499656067
Gc5_249 0 n10 ns249 0 -1.42111621437e-05
Gc5_250 0 n10 ns250 0 0.000383118093018
Gc5_251 0 n10 ns251 0 0.00372921040423
Gc5_252 0 n10 ns252 0 0.000739046137249
Gc5_253 0 n10 ns253 0 0.000387981771903
Gc5_254 0 n10 ns254 0 2.0214956938e-05
Gc5_255 0 n10 ns255 0 -0.00126702053525
Gc5_256 0 n10 ns256 0 0.00278187681743
Gc5_257 0 n10 ns257 0 0.00177334304832
Gc5_258 0 n10 ns258 0 -0.00160897743553
Gc5_259 0 n10 ns259 0 0.000684585506538
Gc5_260 0 n10 ns260 0 0.00135973122893
Gc5_261 0 n10 ns261 0 -0.000432748844709
Gc5_262 0 n10 ns262 0 0.0483129790078
Gc5_263 0 n10 ns263 0 -0.0453033008548
Gc5_264 0 n10 ns264 0 0.00276374141912
Gc5_265 0 n10 ns265 0 -1.91876006281e-06
Gc5_266 0 n10 ns266 0 -9.40029162124e-06
Gc5_267 0 n10 ns267 0 -0.000610624257093
Gc5_268 0 n10 ns268 0 0.00147609919148
Gc5_269 0 n10 ns269 0 -0.00219414873054
Gc5_270 0 n10 ns270 0 -0.000163730450879
Gc5_271 0 n10 ns271 0 -0.000170193827631
Gc5_272 0 n10 ns272 0 -0.000154855891247
Gc5_273 0 n10 ns273 0 -0.000119910011358
Gc5_274 0 n10 ns274 0 -9.42691502168e-06
Gc5_275 0 n10 ns275 0 -1.91922802066e-05
Gc5_276 0 n10 ns276 0 -0.000507217754815
Gc5_277 0 n10 ns277 0 0.00137084160642
Gc5_278 0 n10 ns278 0 0.000227237881341
Gc5_279 0 n10 ns279 0 3.45525914497e-05
Gc5_280 0 n10 ns280 0 -8.25227432456e-05
Gc5_281 0 n10 ns281 0 -0.000376491254277
Gc5_282 0 n10 ns282 0 0.000740573271107
Gc5_283 0 n10 ns283 0 0.000524913676486
Gc5_284 0 n10 ns284 0 -0.000457547176155
Gc5_285 0 n10 ns285 0 0.000121298243076
Gc5_286 0 n10 ns286 0 0.000271263699528
Gc5_287 0 n10 ns287 0 -8.54564084444e-05
Gc5_288 0 n10 ns288 0 0.000951623571439
Gc5_289 0 n10 ns289 0 0.000551242925955
Gc5_290 0 n10 ns290 0 0.000301610313902
Gc5_291 0 n10 ns291 0 0.00103057021401
Gc5_292 0 n10 ns292 0 -3.42934797493e-05
Gc5_293 0 n10 ns293 0 -0.00110814456201
Gc5_294 0 n10 ns294 0 0.000636092921912
Gc5_295 0 n10 ns295 0 -0.000422260536251
Gc5_296 0 n10 ns296 0 -0.000384673865522
Gc5_297 0 n10 ns297 0 0.00152065055345
Gc5_298 0 n10 ns298 0 0.000821610105123
Gc5_299 0 n10 ns299 0 -0.000667642164947
Gc5_300 0 n10 ns300 0 0.0238471497342
Gc5_301 0 n10 ns301 0 -0.0219704055105
Gc5_302 0 n10 ns302 0 0.00116183971141
Gc5_303 0 n10 ns303 0 -6.17886798062e-06
Gc5_304 0 n10 ns304 0 -7.01965801557e-06
Gc5_305 0 n10 ns305 0 -0.000137826640094
Gc5_306 0 n10 ns306 0 -0.000285884620037
Gc5_307 0 n10 ns307 0 0.00254878022341
Gc5_308 0 n10 ns308 0 8.01611725258e-05
Gc5_309 0 n10 ns309 0 9.53876345137e-06
Gc5_310 0 n10 ns310 0 -9.21711479541e-05
Gc5_311 0 n10 ns311 0 0.000183857683291
Gc5_312 0 n10 ns312 0 2.00864872089e-05
Gc5_313 0 n10 ns313 0 3.38872704733e-05
Gc5_314 0 n10 ns314 0 -9.18047876118e-05
Gc5_315 0 n10 ns315 0 -0.00102308748848
Gc5_316 0 n10 ns316 0 0.000528461240212
Gc5_317 0 n10 ns317 0 0.00066299194393
Gc5_318 0 n10 ns318 0 -2.30940852963e-06
Gc5_319 0 n10 ns319 0 -0.00025563287696
Gc5_320 0 n10 ns320 0 -9.79714196151e-05
Gc5_321 0 n10 ns321 0 -0.00183929725875
Gc5_322 0 n10 ns322 0 -0.000777897382176
Gc5_323 0 n10 ns323 0 0.000985818137768
Gc5_324 0 n10 ns324 0 0.000240918339077
Gc5_325 0 n10 ns325 0 5.7824520126e-05
Gc5_326 0 n10 ns326 0 -0.00180008427829
Gc5_327 0 n10 ns327 0 -0.000211601106359
Gc5_328 0 n10 ns328 0 0.00053551752511
Gc5_329 0 n10 ns329 0 0.00137006892308
Gc5_330 0 n10 ns330 0 -3.04010183613e-05
Gc5_331 0 n10 ns331 0 -0.000946254133471
Gc5_332 0 n10 ns332 0 -0.00243772999431
Gc5_333 0 n10 ns333 0 -0.00012188372683
Gc5_334 0 n10 ns334 0 0.000472411678161
Gc5_335 0 n10 ns335 0 0.00135439089152
Gc5_336 0 n10 ns336 0 0.000499988438675
Gc5_337 0 n10 ns337 0 -0.000558520957785
Gc5_338 0 n10 ns338 0 0.00127264679355
Gc5_339 0 n10 ns339 0 -0.00247397149451
Gc5_340 0 n10 ns340 0 0.000353465474852
Gc5_341 0 n10 ns341 0 -7.41379485336e-06
Gc5_342 0 n10 ns342 0 -7.11069076166e-06
Gc5_343 0 n10 ns343 0 -0.000886328682984
Gc5_344 0 n10 ns344 0 0.00179440171469
Gc5_345 0 n10 ns345 0 -0.00193514850774
Gc5_346 0 n10 ns346 0 0.000138418972851
Gc5_347 0 n10 ns347 0 -0.000269050981744
Gc5_348 0 n10 ns348 0 0.000173553968315
Gc5_349 0 n10 ns349 0 -0.000304953760046
Gc5_350 0 n10 ns350 0 -4.18484983337e-07
Gc5_351 0 n10 ns351 0 1.0973863087e-05
Gc5_352 0 n10 ns352 0 -0.0016566514246
Gc5_353 0 n10 ns353 0 0.000435245958961
Gc5_354 0 n10 ns354 0 0.000291811142264
Gc5_355 0 n10 ns355 0 6.15672082024e-05
Gc5_356 0 n10 ns356 0 7.33883784645e-05
Gc5_357 0 n10 ns357 0 -0.000428663602318
Gc5_358 0 n10 ns358 0 -0.00074909494403
Gc5_359 0 n10 ns359 0 0.000856452522455
Gc5_360 0 n10 ns360 0 -0.000274654141183
Gc5_361 0 n10 ns361 0 0.000199634668687
Gc5_362 0 n10 ns362 0 0.000402413368704
Gc5_363 0 n10 ns363 0 1.58238800875e-05
Gc5_364 0 n10 ns364 0 0.000635695347009
Gc5_365 0 n10 ns365 0 0.00253198174815
Gc5_366 0 n10 ns366 0 0.000317669303014
Gc5_367 0 n10 ns367 0 0.000884770148738
Gc5_368 0 n10 ns368 0 0.000186650389296
Gc5_369 0 n10 ns369 0 -0.0012890804038
Gc5_370 0 n10 ns370 0 0.00202279750977
Gc5_371 0 n10 ns371 0 0.000620602379663
Gc5_372 0 n10 ns372 0 -0.00129385415212
Gc5_373 0 n10 ns373 0 0.00122899434969
Gc5_374 0 n10 ns374 0 0.00120179660391
Gc5_375 0 n10 ns375 0 -0.000525779690235
Gc5_376 0 n10 ns376 0 0.0353447905843
Gc5_377 0 n10 ns377 0 -0.0329755270498
Gc5_378 0 n10 ns378 0 0.00189872989823
Gc5_379 0 n10 ns379 0 -4.54015027542e-06
Gc5_380 0 n10 ns380 0 1.94210121442e-06
Gc5_381 0 n10 ns381 0 -0.00184865347939
Gc5_382 0 n10 ns382 0 -0.000626914292479
Gc5_383 0 n10 ns383 0 0.00241814627486
Gc5_384 0 n10 ns384 0 0.000655052129673
Gc5_385 0 n10 ns385 0 -0.000334723318479
Gc5_386 0 n10 ns386 0 0.000699107325416
Gc5_387 0 n10 ns387 0 0.000346954092112
Gc5_388 0 n10 ns388 0 -0.000153842989524
Gc5_389 0 n10 ns389 0 -5.55505955941e-05
Gc5_390 0 n10 ns390 0 -0.0014296694931
Gc5_391 0 n10 ns391 0 -0.000522397496539
Gc5_392 0 n10 ns392 0 0.000993649036042
Gc5_393 0 n10 ns393 0 -0.000290882871971
Gc5_394 0 n10 ns394 0 0.000190581899731
Gc5_395 0 n10 ns395 0 -0.000535771017321
Gc5_396 0 n10 ns396 0 -0.00118642386321
Gc5_397 0 n10 ns397 0 -0.00192495667267
Gc5_398 0 n10 ns398 0 -0.000411480536296
Gc5_399 0 n10 ns399 0 0.000316778576154
Gc5_400 0 n10 ns400 0 0.000398174661136
Gc5_401 0 n10 ns401 0 0.000180789613286
Gc5_402 0 n10 ns402 0 -0.00379070741671
Gc5_403 0 n10 ns403 0 0.00151762030639
Gc5_404 0 n10 ns404 0 0.000846226042666
Gc5_405 0 n10 ns405 0 0.00113290436195
Gc5_406 0 n10 ns406 0 0.000547243414981
Gc5_407 0 n10 ns407 0 -0.00151656341177
Gc5_408 0 n10 ns408 0 -0.0021760647492
Gc5_409 0 n10 ns409 0 0.00166928602231
Gc5_410 0 n10 ns410 0 -0.00168237907201
Gc5_411 0 n10 ns411 0 0.000427216646757
Gc5_412 0 n10 ns412 0 0.0019993680124
Gc5_413 0 n10 ns413 0 1.92175563669e-05
Gc5_414 0 n10 ns414 0 0.0415818448205
Gc5_415 0 n10 ns415 0 -0.0445770947422
Gc5_416 0 n10 ns416 0 0.00450128381008
Gc5_417 0 n10 ns417 0 3.12008237531e-06
Gc5_418 0 n10 ns418 0 3.31753960765e-06
Gc5_419 0 n10 ns419 0 -0.00496106523035
Gc5_420 0 n10 ns420 0 0.000305714189794
Gc5_421 0 n10 ns421 0 -0.00706883707597
Gc5_422 0 n10 ns422 0 -0.000228444725124
Gc5_423 0 n10 ns423 0 -0.000855231409383
Gc5_424 0 n10 ns424 0 4.76024937465e-06
Gc5_425 0 n10 ns425 0 0.000327104486312
Gc5_426 0 n10 ns426 0 -0.00010605046009
Gc5_427 0 n10 ns427 0 -3.19145256878e-05
Gc5_428 0 n10 ns428 0 -0.0015419036084
Gc5_429 0 n10 ns429 0 0.00288712699655
Gc5_430 0 n10 ns430 0 0.000687793091553
Gc5_431 0 n10 ns431 0 -0.000539973495192
Gc5_432 0 n10 ns432 0 0.000223709379658
Gc5_433 0 n10 ns433 0 -0.00044779033196
Gc5_434 0 n10 ns434 0 0.000327976036253
Gc5_435 0 n10 ns435 0 0.00182169321869
Gc5_436 0 n10 ns436 0 0.000690439226383
Gc5_437 0 n10 ns437 0 -4.99876845357e-05
Gc5_438 0 n10 ns438 0 0.000502611252765
Gc5_439 0 n10 ns439 0 8.01875371712e-05
Gc5_440 0 n10 ns440 0 0.0023651475773
Gc5_441 0 n10 ns441 0 0.00172838927332
Gc5_442 0 n10 ns442 0 0.00134077696901
Gc5_443 0 n10 ns443 0 0.00219843847444
Gc5_444 0 n10 ns444 0 0.00103745582219
Gc5_445 0 n10 ns445 0 -0.00192940347726
Gc5_446 0 n10 ns446 0 0.00344055062236
Gc5_447 0 n10 ns447 0 -0.00159661907095
Gc5_448 0 n10 ns448 0 0.00176231065914
Gc5_449 0 n10 ns449 0 0.00114153272713
Gc5_450 0 n10 ns450 0 0.00292601447855
Gc5_451 0 n10 ns451 0 3.9611074519e-05
Gc5_452 0 n10 ns452 0 -0.00722364654272
Gc5_453 0 n10 ns453 0 0.011407062227
Gc5_454 0 n10 ns454 0 0.00709071612416
Gc5_455 0 n10 ns455 0 -1.16973074022e-06
Gc5_456 0 n10 ns456 0 -1.91047313428e-06
Gc5_457 0 n10 ns457 0 -0.00520131545628
Gc5_458 0 n10 ns458 0 -0.000164149210262
Gc5_459 0 n10 ns459 0 -0.00721501977295
Gc5_460 0 n10 ns460 0 2.65600923625e-05
Gc5_461 0 n10 ns461 0 -0.00125390947655
Gc5_462 0 n10 ns462 0 -0.000254635069977
Gc5_463 0 n10 ns463 0 0.000918430975016
Gc5_464 0 n10 ns464 0 -9.90528642065e-05
Gc5_465 0 n10 ns465 0 -3.34150678214e-05
Gc5_466 0 n10 ns466 0 0.000394490828317
Gc5_467 0 n10 ns467 0 0.00255861815254
Gc5_468 0 n10 ns468 0 0.000481206805223
Gc5_469 0 n10 ns469 0 -0.000545924233685
Gc5_470 0 n10 ns470 0 0.000190101608288
Gc5_471 0 n10 ns471 0 -0.000422250124194
Gc5_472 0 n10 ns472 0 0.000860466994266
Gc5_473 0 n10 ns473 0 -0.00027658906096
Gc5_474 0 n10 ns474 0 0.000206025996161
Gc5_475 0 n10 ns475 0 -0.000246062738936
Gc5_476 0 n10 ns476 0 0.000394443355082
Gc5_477 0 n10 ns477 0 0.000107081510309
Gc5_478 0 n10 ns478 0 -0.000356747657525
Gc5_479 0 n10 ns479 0 0.0011541428249
Gc5_480 0 n10 ns480 0 0.00162868707366
Gc5_481 0 n10 ns481 0 0.00144073690246
Gc5_482 0 n10 ns482 0 0.00062390072309
Gc5_483 0 n10 ns483 0 -0.0018029973684
Gc5_484 0 n10 ns484 0 0.0023034374781
Gc5_485 0 n10 ns485 0 0.00135739462837
Gc5_486 0 n10 ns486 0 0.000207680879716
Gc5_487 0 n10 ns487 0 -0.00045047380251
Gc5_488 0 n10 ns488 0 0.00229777994399
Gc5_489 0 n10 ns489 0 8.4897014329e-05
Gc5_490 0 n10 ns490 0 0.0376649924165
Gc5_491 0 n10 ns491 0 -0.0346901091898
Gc5_492 0 n10 ns492 0 0.00686432532144
Gc5_493 0 n10 ns493 0 -4.18169473357e-06
Gc5_494 0 n10 ns494 0 -5.7981224517e-06
Gc5_495 0 n10 ns495 0 -0.00171802401523
Gc5_496 0 n10 ns496 0 0.000574844808128
Gc5_497 0 n10 ns497 0 -0.00157957240711
Gc5_498 0 n10 ns498 0 0.000503316642577
Gc5_499 0 n10 ns499 0 -0.000507028993991
Gc5_500 0 n10 ns500 0 0.000625953125929
Gc5_501 0 n10 ns501 0 -1.88468575221e-05
Gc5_502 0 n10 ns502 0 -0.000131922204558
Gc5_503 0 n10 ns503 0 8.5030372146e-06
Gc5_504 0 n10 ns504 0 -0.00193636358787
Gc5_505 0 n10 ns505 0 0.000324688776111
Gc5_506 0 n10 ns506 0 0.000638573684351
Gc5_507 0 n10 ns507 0 -0.000548202089413
Gc5_508 0 n10 ns508 0 0.000150578721667
Gc5_509 0 n10 ns509 0 -0.000468531534005
Gc5_510 0 n10 ns510 0 -0.00184051308004
Gc5_511 0 n10 ns511 0 9.56738623983e-05
Gc5_512 0 n10 ns512 0 0.00017376462479
Gc5_513 0 n10 ns513 0 0.000134674855259
Gc5_514 0 n10 ns514 0 0.00045237948641
Gc5_515 0 n10 ns515 0 5.85688155411e-05
Gc5_516 0 n10 ns516 0 -0.000952102516069
Gc5_517 0 n10 ns517 0 0.00352195859305
Gc5_518 0 n10 ns518 0 0.000977380660769
Gc5_519 0 n10 ns519 0 0.000403449537552
Gc5_520 0 n10 ns520 0 0.000130321574871
Gc5_521 0 n10 ns521 0 -0.00137663481583
Gc5_522 0 n10 ns522 0 0.00168637599782
Gc5_523 0 n10 ns523 0 0.00210805202034
Gc5_524 0 n10 ns524 0 -0.00174896788061
Gc5_525 0 n10 ns525 0 0.000326327424818
Gc5_526 0 n10 ns526 0 0.00162254784031
Gc5_527 0 n10 ns527 0 -0.000260607623461
Gc5_528 0 n10 ns528 0 0.0514668789785
Gc5_529 0 n10 ns529 0 -0.0499722841405
Gc5_530 0 n10 ns530 0 0.00371976390415
Gc5_531 0 n10 ns531 0 -7.40813863388e-07
Gc5_532 0 n10 ns532 0 -8.66401822065e-06
Gc5_533 0 n10 ns533 0 -0.000926619139602
Gc5_534 0 n10 ns534 0 0.00163229892114
Gc5_535 0 n10 ns535 0 -0.00271180789435
Gc5_536 0 n10 ns536 0 -3.27769458458e-05
Gc5_537 0 n10 ns537 0 -0.000222082825531
Gc5_538 0 n10 ns538 0 6.07267187485e-05
Gc5_539 0 n10 ns539 0 -0.000313687506356
Gc5_540 0 n10 ns540 0 -3.62905779801e-05
Gc5_541 0 n10 ns541 0 -2.62706902768e-05
Gc5_542 0 n10 ns542 0 -0.00114239654545
Gc5_543 0 n10 ns543 0 0.0017036699841
Gc5_544 0 n10 ns544 0 0.00015305431292
Gc5_545 0 n10 ns545 0 -0.000275547483861
Gc5_546 0 n10 ns546 0 -4.91432317713e-05
Gc5_547 0 n10 ns547 0 -0.000405861480785
Gc5_548 0 n10 ns548 0 0.00032973723516
Gc5_549 0 n10 ns549 0 0.00137232743999
Gc5_550 0 n10 ns550 0 -0.000210066256443
Gc5_551 0 n10 ns551 0 -0.000162225227339
Gc5_552 0 n10 ns552 0 0.000304371655957
Gc5_553 0 n10 ns553 0 -0.000102682591672
Gc5_554 0 n10 ns554 0 0.00157110422787
Gc5_555 0 n10 ns555 0 0.00138333930575
Gc5_556 0 n10 ns556 0 0.000231189311853
Gc5_557 0 n10 ns557 0 0.000740158573141
Gc5_558 0 n10 ns558 0 3.81371895491e-06
Gc5_559 0 n10 ns559 0 -0.00111997372994
Gc5_560 0 n10 ns560 0 0.00157624460014
Gc5_561 0 n10 ns561 0 -0.000327019734784
Gc5_562 0 n10 ns562 0 -0.000871699885884
Gc5_563 0 n10 ns563 0 0.00150893682188
Gc5_564 0 n10 ns564 0 0.00103543737555
Gc5_565 0 n10 ns565 0 -0.000640358112079
Gc5_566 0 n10 ns566 0 0.0309884388508
Gc5_567 0 n10 ns567 0 -0.0285311819824
Gc5_568 0 n10 ns568 0 0.00155953681542
Gc5_569 0 n10 ns569 0 -5.61713074929e-06
Gc5_570 0 n10 ns570 0 -8.2017609998e-06
Gc5_571 0 n10 ns571 0 -0.00037246829708
Gc5_572 0 n10 ns572 0 0.000608244221008
Gc5_573 0 n10 ns573 0 0.00104724168649
Gc5_574 0 n10 ns574 0 -4.1024920622e-05
Gc5_575 0 n10 ns575 0 0.000136400617677
Gc5_576 0 n10 ns576 0 -3.58790816351e-05
Gc5_577 0 n10 ns577 0 0.000137201083587
Gc5_578 0 n10 ns578 0 -3.62097392592e-06
Gc5_579 0 n10 ns579 0 2.98182925057e-06
Gc5_580 0 n10 ns580 0 3.57119114669e-07
Gc5_581 0 n10 ns581 0 -0.000601018974272
Gc5_582 0 n10 ns582 0 0.000489180071659
Gc5_583 0 n10 ns583 0 0.000627731749326
Gc5_584 0 n10 ns584 0 -2.55741360372e-05
Gc5_585 0 n10 ns585 0 -0.000319913545842
Gc5_586 0 n10 ns586 0 0.000418345390176
Gc5_587 0 n10 ns587 0 -0.00155282307112
Gc5_588 0 n10 ns588 0 -0.000905899013537
Gc5_589 0 n10 ns589 0 0.000804706219045
Gc5_590 0 n10 ns590 0 0.000254635913171
Gc5_591 0 n10 ns591 0 3.35427228738e-05
Gc5_592 0 n10 ns592 0 -0.00128327487137
Gc5_593 0 n10 ns593 0 -0.000442952201273
Gc5_594 0 n10 ns594 0 0.000428639895249
Gc5_595 0 n10 ns595 0 0.00148746076558
Gc5_596 0 n10 ns596 0 6.48585752738e-06
Gc5_597 0 n10 ns597 0 -0.00107925274231
Gc5_598 0 n10 ns598 0 -0.00216635533245
Gc5_599 0 n10 ns599 0 -0.000576231585009
Gc5_600 0 n10 ns600 0 0.00031172203249
Gc5_601 0 n10 ns601 0 0.00167139410182
Gc5_602 0 n10 ns602 0 0.000653293408528
Gc5_603 0 n10 ns603 0 -0.000647904148211
Gc5_604 0 n10 ns604 0 0.00550912426303
Gc5_605 0 n10 ns605 0 -0.00627505211375
Gc5_606 0 n10 ns606 0 0.000543903335994
Gc5_607 0 n10 ns607 0 -6.39849967359e-06
Gc5_608 0 n10 ns608 0 -6.35812687298e-06
Gc5_609 0 n10 ns609 0 -2.80010623827e-05
Gc5_610 0 n10 ns610 0 0.000225360269855
Gc5_611 0 n10 ns611 0 0.00409929348989
Gc5_612 0 n10 ns612 0 -6.46959369192e-05
Gc5_613 0 n10 ns613 0 0.000297947450052
Gc5_614 0 n10 ns614 0 0.000425977882002
Gc5_615 0 n10 ns615 0 -1.70761121737e-05
Gc5_616 0 n10 ns616 0 3.23189628989e-05
Gc5_617 0 n10 ns617 0 -4.23519217955e-05
Gc5_618 0 n10 ns618 0 -0.000497559932902
Gc5_619 0 n10 ns619 0 -0.000101474308805
Gc5_620 0 n10 ns620 0 0.000227613525454
Gc5_621 0 n10 ns621 0 -0.000622774968599
Gc5_622 0 n10 ns622 0 -4.91078274074e-05
Gc5_623 0 n10 ns623 0 0.000204080729446
Gc5_624 0 n10 ns624 0 0.00146043731438
Gc5_625 0 n10 ns625 0 -0.0014522953878
Gc5_626 0 n10 ns626 0 -0.00148409353406
Gc5_627 0 n10 ns627 0 0.000156622490823
Gc5_628 0 n10 ns628 0 0.000114768724097
Gc5_629 0 n10 ns629 0 0.000192307424448
Gc5_630 0 n10 ns630 0 -0.000842528896379
Gc5_631 0 n10 ns631 0 -0.00137592895254
Gc5_632 0 n10 ns632 0 -0.000583036899986
Gc5_633 0 n10 ns633 0 -0.00131304089547
Gc5_634 0 n10 ns634 0 3.50657753508e-06
Gc5_635 0 n10 ns635 0 0.00126658705265
Gc5_636 0 n10 ns636 0 -0.00514106261266
Gc5_637 0 n10 ns637 0 -0.00356383825579
Gc5_638 0 n10 ns638 0 -0.000170827041349
Gc5_639 0 n10 ns639 0 0.0028940757214
Gc5_640 0 n10 ns640 0 0.00115381193629
Gc5_641 0 n10 ns641 0 -0.000535687225739
Gc5_642 0 n10 ns642 0 -0.0257879338992
Gc5_643 0 n10 ns643 0 0.0214743560041
Gc5_644 0 n10 ns644 0 -0.000821208595743
Gc5_645 0 n10 ns645 0 -1.22419348231e-06
Gc5_646 0 n10 ns646 0 3.15920347646e-06
Gc5_647 0 n10 ns647 0 7.26520463674e-05
Gc5_648 0 n10 ns648 0 -0.000478156265128
Gc5_649 0 n10 ns649 0 0.00619537776116
Gc5_650 0 n10 ns650 0 0.000226086623618
Gc5_651 0 n10 ns651 0 0.00016929461301
Gc5_652 0 n10 ns652 0 0.000350143847687
Gc5_653 0 n10 ns653 0 7.48376721259e-06
Gc5_654 0 n10 ns654 0 6.07604542794e-06
Gc5_655 0 n10 ns655 0 -2.37108150441e-05
Gc5_656 0 n10 ns656 0 -0.000710609073148
Gc5_657 0 n10 ns657 0 -0.00100981553312
Gc5_658 0 n10 ns658 0 0.000258298020474
Gc5_659 0 n10 ns659 0 -0.000354639342149
Gc5_660 0 n10 ns660 0 1.01205100631e-05
Gc5_661 0 n10 ns661 0 0.000310112483086
Gc5_662 0 n10 ns662 0 0.00122761315948
Gc5_663 0 n10 ns663 0 -0.00128689168328
Gc5_664 0 n10 ns664 0 -0.00149277714667
Gc5_665 0 n10 ns665 0 8.0662534871e-05
Gc5_666 0 n10 ns666 0 0.00015836283293
Gc5_667 0 n10 ns667 0 0.000176213414501
Gc5_668 0 n10 ns668 0 -0.0013617889659
Gc5_669 0 n10 ns669 0 -0.00202358547763
Gc5_670 0 n10 ns670 0 -0.000675209035167
Gc5_671 0 n10 ns671 0 -0.00129888736869
Gc5_672 0 n10 ns672 0 2.7880371692e-05
Gc5_673 0 n10 ns673 0 0.00145245579589
Gc5_674 0 n10 ns674 0 -0.00642951783335
Gc5_675 0 n10 ns675 0 -0.00453124836158
Gc5_676 0 n10 ns676 0 -0.000467461747626
Gc5_677 0 n10 ns677 0 0.00352910121589
Gc5_678 0 n10 ns678 0 0.00148788367759
Gc5_679 0 n10 ns679 0 -0.000563927509462
Gc5_680 0 n10 ns680 0 -0.0376890378993
Gc5_681 0 n10 ns681 0 0.0317249332442
Gc5_682 0 n10 ns682 0 -0.00123734540743
Gc5_683 0 n10 ns683 0 -5.79433577389e-06
Gc5_684 0 n10 ns684 0 2.00424335925e-06
Gc5_685 0 n10 ns685 0 0.000754834932639
Gc5_686 0 n10 ns686 0 -0.00107597507119
Gc5_687 0 n10 ns687 0 0.0115012969935
Gc5_688 0 n10 ns688 0 0.000241405704877
Gc5_689 0 n10 ns689 0 0.000653746228159
Gc5_690 0 n10 ns690 0 0.000372418704616
Gc5_691 0 n10 ns691 0 -0.000248589378764
Gc5_692 0 n10 ns692 0 -0.000116622362325
Gc5_693 0 n10 ns693 0 -6.74766818054e-06
Gc5_694 0 n10 ns694 0 0.000377420649383
Gc5_695 0 n10 ns695 0 -0.00445432358207
Gc5_696 0 n10 ns696 0 -0.000112298807143
Gc5_697 0 n10 ns697 0 0.001069376544
Gc5_698 0 n10 ns698 0 0.000148904352353
Gc5_699 0 n10 ns699 0 0.000555375269676
Gc5_700 0 n10 ns700 0 -0.00126455530048
Gc5_701 0 n10 ns701 0 -0.00120119251573
Gc5_702 0 n10 ns702 0 -0.000644715352644
Gc5_703 0 n10 ns703 0 0.0002375198253
Gc5_704 0 n10 ns704 0 0.000353281182079
Gc5_705 0 n10 ns705 0 0.000127895080394
Gc5_706 0 n10 ns706 0 -0.00250730185817
Gc5_707 0 n10 ns707 0 -0.00502043635666
Gc5_708 0 n10 ns708 0 -0.00159289546305
Gc5_709 0 n10 ns709 0 -0.000201011969677
Gc5_710 0 n10 ns710 0 0.000417329814115
Gc5_711 0 n10 ns711 0 0.00161713964344
Gc5_712 0 n10 ns712 0 -0.00990043525664
Gc5_713 0 n10 ns713 0 -0.00608853215652
Gc5_714 0 n10 ns714 0 -0.00164290189642
Gc5_715 0 n10 ns715 0 0.0042047079626
Gc5_716 0 n10 ns716 0 0.00242644188275
Gc5_717 0 n10 ns717 0 -0.000294635830397
Gc5_718 0 n10 ns718 0 -0.0774197343016
Gc5_719 0 n10 ns719 0 0.0672428588653
Gc5_720 0 n10 ns720 0 -0.00311496502969
Gc5_721 0 n10 ns721 0 -9.34558600957e-06
Gc5_722 0 n10 ns722 0 -2.25322050835e-07
Gc5_723 0 n10 ns723 0 -0.000365026238266
Gc5_724 0 n10 ns724 0 3.08840555205e-05
Gc5_725 0 n10 ns725 0 0.00569154472599
Gc5_726 0 n10 ns726 0 -0.00132358801142
Gc5_727 0 n10 ns727 0 -0.000357121298358
Gc5_728 0 n10 ns728 0 0.00186815545381
Gc5_729 0 n10 ns729 0 0.000585780415563
Gc5_730 0 n10 ns730 0 -0.000159329905758
Gc5_731 0 n10 ns731 0 -0.000186337126784
Gc5_732 0 n10 ns732 0 0.00210831533183
Gc5_733 0 n10 ns733 0 -0.002759829809
Gc5_734 0 n10 ns734 0 -0.000676121747678
Gc5_735 0 n10 ns735 0 0.00111380668146
Gc5_736 0 n10 ns736 0 -4.49656093135e-05
Gc5_737 0 n10 ns737 0 0.000500144535178
Gc5_738 0 n10 ns738 0 -0.000395366522765
Gc5_739 0 n10 ns739 0 -0.00333988554974
Gc5_740 0 n10 ns740 0 -0.000846267426576
Gc5_741 0 n10 ns741 0 0.000246526827582
Gc5_742 0 n10 ns742 0 0.000298811988036
Gc5_743 0 n10 ns743 0 0.000330644758012
Gc5_744 0 n10 ns744 0 0.00110446258225
Gc5_745 0 n10 ns745 0 -0.0054593406844
Gc5_746 0 n10 ns746 0 -0.0029615756749
Gc5_747 0 n10 ns747 0 -0.00100668764314
Gc5_748 0 n10 ns748 0 0.00019009182826
Gc5_749 0 n10 ns749 0 0.00224713262193
Gc5_750 0 n10 ns750 0 -0.0123170880015
Gc5_751 0 n10 ns751 0 -0.00540690780917
Gc5_752 0 n10 ns752 0 -0.000899137412903
Gc5_753 0 n10 ns753 0 0.00290556080925
Gc5_754 0 n10 ns754 0 0.00303711011078
Gc5_755 0 n10 ns755 0 0.000247535154789
Gc5_756 0 n10 ns756 0 -0.0677147614293
Gc5_757 0 n10 ns757 0 0.0644507122445
Gc5_758 0 n10 ns758 0 -0.00636423582598
Gc5_759 0 n10 ns759 0 -9.86317764732e-06
Gc5_760 0 n10 ns760 0 2.67941512633e-06
Gc5_761 0 n10 ns761 0 -0.0168107362926
Gc5_762 0 n10 ns762 0 -0.00160933015476
Gc5_763 0 n10 ns763 0 0.0209244772942
Gc5_764 0 n10 ns764 0 0.00623084003604
Gc5_765 0 n10 ns765 0 0.0102886659653
Gc5_766 0 n10 ns766 0 0.00152545880136
Gc5_767 0 n10 ns767 0 -0.00330583730465
Gc5_768 0 n10 ns768 0 -0.00050841348634
Gc5_769 0 n10 ns769 0 2.92033995281e-05
Gc5_770 0 n10 ns770 0 -0.00155258874809
Gc5_771 0 n10 ns771 0 -0.0143778290291
Gc5_772 0 n10 ns772 0 0.00127156416752
Gc5_773 0 n10 ns773 0 0.00197633231114
Gc5_774 0 n10 ns774 0 0.000209814564321
Gc5_775 0 n10 ns775 0 0.000320673184354
Gc5_776 0 n10 ns776 0 0.000385103864517
Gc5_777 0 n10 ns777 0 0.000734947611884
Gc5_778 0 n10 ns778 0 6.23607677061e-05
Gc5_779 0 n10 ns779 0 0.000313655018578
Gc5_780 0 n10 ns780 0 0.000468125359138
Gc5_781 0 n10 ns781 0 0.000335506314157
Gc5_782 0 n10 ns782 0 -0.0118555791813
Gc5_783 0 n10 ns783 0 -0.00792126441636
Gc5_784 0 n10 ns784 0 -0.00364080330901
Gc5_785 0 n10 ns785 0 -0.00112807730918
Gc5_786 0 n10 ns786 0 0.00016540072618
Gc5_787 0 n10 ns787 0 0.00245519818452
Gc5_788 0 n10 ns788 0 0.00827077936096
Gc5_789 0 n10 ns789 0 -0.00526010028549
Gc5_790 0 n10 ns790 0 0.00194794811539
Gc5_791 0 n10 ns791 0 0.00182739975748
Gc5_792 0 n10 ns792 0 0.00326850481658
Gc5_793 0 n10 ns793 0 -4.22308314148e-05
Gc5_794 0 n10 ns794 0 -0.107296937532
Gc5_795 0 n10 ns795 0 0.0694006958329
Gc5_796 0 n10 ns796 0 -0.00877785859535
Gc5_797 0 n10 ns797 0 -1.07498679476e-05
Gc5_798 0 n10 ns798 0 -8.29341999196e-06
Gc5_799 0 n10 ns799 0 -0.000166935589404
Gc5_800 0 n10 ns800 0 -0.000243786099696
Gc5_801 0 n10 ns801 0 0.00597173945669
Gc5_802 0 n10 ns802 0 -0.00132829031258
Gc5_803 0 n10 ns803 0 -0.000416915644815
Gc5_804 0 n10 ns804 0 0.0018620625683
Gc5_805 0 n10 ns805 0 0.000527825594976
Gc5_806 0 n10 ns806 0 -0.000161658474658
Gc5_807 0 n10 ns807 0 -0.000185669598801
Gc5_808 0 n10 ns808 0 0.00185322848093
Gc5_809 0 n10 ns809 0 -0.00220733289776
Gc5_810 0 n10 ns810 0 -0.000528865971745
Gc5_811 0 n10 ns811 0 0.00087165916972
Gc5_812 0 n10 ns812 0 -0.000128972543519
Gc5_813 0 n10 ns813 0 0.000441857422054
Gc5_814 0 n10 ns814 0 -0.00018174230054
Gc5_815 0 n10 ns815 0 -0.00321602160128
Gc5_816 0 n10 ns816 0 -0.000883693061872
Gc5_817 0 n10 ns817 0 0.000109276552908
Gc5_818 0 n10 ns818 0 0.000263054946898
Gc5_819 0 n10 ns819 0 0.000342154345781
Gc5_820 0 n10 ns820 0 0.000937929039334
Gc5_821 0 n10 ns821 0 -0.00544386358451
Gc5_822 0 n10 ns822 0 -0.00291097879739
Gc5_823 0 n10 ns823 0 -0.00084922847885
Gc5_824 0 n10 ns824 0 0.000216131347354
Gc5_825 0 n10 ns825 0 0.0021481749341
Gc5_826 0 n10 ns826 0 -0.012243633795
Gc5_827 0 n10 ns827 0 -0.00509469858922
Gc5_828 0 n10 ns828 0 -0.000827520659656
Gc5_829 0 n10 ns829 0 0.00283762219009
Gc5_830 0 n10 ns830 0 0.00301085349394
Gc5_831 0 n10 ns831 0 0.000218731836037
Gc5_832 0 n10 ns832 0 -0.0660549004271
Gc5_833 0 n10 ns833 0 0.0629908610692
Gc5_834 0 n10 ns834 0 -0.00631247239523
Gc5_835 0 n10 ns835 0 -8.40567827432e-06
Gc5_836 0 n10 ns836 0 -6.58276178057e-06
Gc5_837 0 n10 ns837 0 0.000787249396521
Gc5_838 0 n10 ns838 0 -0.000806062395375
Gc5_839 0 n10 ns839 0 0.0102874668688
Gc5_840 0 n10 ns840 0 2.08671782432e-05
Gc5_841 0 n10 ns841 0 0.000737626363195
Gc5_842 0 n10 ns842 0 0.000415801536666
Gc5_843 0 n10 ns843 0 -0.000128560922698
Gc5_844 0 n10 ns844 0 -8.66442925674e-05
Gc5_845 0 n10 ns845 0 -1.08135093802e-05
Gc5_846 0 n10 ns846 0 0.000133578083767
Gc5_847 0 n10 ns847 0 -0.00445435613443
Gc5_848 0 n10 ns848 0 0.000122175069112
Gc5_849 0 n10 ns849 0 0.00120895162713
Gc5_850 0 n10 ns850 0 0.000176777487619
Gc5_851 0 n10 ns851 0 0.000453267790011
Gc5_852 0 n10 ns852 0 -0.00114980535827
Gc5_853 0 n10 ns853 0 -0.000633051392277
Gc5_854 0 n10 ns854 0 -0.00040310036816
Gc5_855 0 n10 ns855 0 -4.86072031263e-06
Gc5_856 0 n10 ns856 0 0.000293693547088
Gc5_857 0 n10 ns857 0 6.03659296653e-05
Gc5_858 0 n10 ns858 0 -0.00224068959957
Gc5_859 0 n10 ns859 0 -0.00495351731835
Gc5_860 0 n10 ns860 0 -0.00156865788655
Gc5_861 0 n10 ns861 0 -9.13955854702e-05
Gc5_862 0 n10 ns862 0 0.000443149011172
Gc5_863 0 n10 ns863 0 0.00151858535203
Gc5_864 0 n10 ns864 0 -0.00903094277991
Gc5_865 0 n10 ns865 0 -0.00539360315411
Gc5_866 0 n10 ns866 0 -0.00157086025902
Gc5_867 0 n10 ns867 0 0.00385847446958
Gc5_868 0 n10 ns868 0 0.00230069367933
Gc5_869 0 n10 ns869 0 -0.000313982125003
Gc5_870 0 n10 ns870 0 -0.0701337202054
Gc5_871 0 n10 ns871 0 0.0611066604927
Gc5_872 0 n10 ns872 0 -0.00291113837181
Gc5_873 0 n10 ns873 0 -9.73423685179e-06
Gc5_874 0 n10 ns874 0 -1.27858892729e-05
Gc5_875 0 n10 ns875 0 0.000265223209725
Gc5_876 0 n10 ns876 0 -0.000970319357274
Gc5_877 0 n10 ns877 0 0.00671804456155
Gc5_878 0 n10 ns878 0 0.000146651146242
Gc5_879 0 n10 ns879 0 0.000289051106125
Gc5_880 0 n10 ns880 0 0.000325714171633
Gc5_881 0 n10 ns881 0 6.99277771394e-05
Gc5_882 0 n10 ns882 0 7.26284378196e-07
Gc5_883 0 n10 ns883 0 3.82610674171e-06
Gc5_884 0 n10 ns884 0 -0.000297911787217
Gc5_885 0 n10 ns885 0 -0.00208568472238
Gc5_886 0 n10 ns886 0 -1.49355363648e-05
Gc5_887 0 n10 ns887 0 0.000261542906328
Gc5_888 0 n10 ns888 0 0.000214495785965
Gc5_889 0 n10 ns889 0 0.000371390020854
Gc5_890 0 n10 ns890 0 0.000627258305686
Gc5_891 0 n10 ns891 0 -0.00112678769878
Gc5_892 0 n10 ns892 0 -0.00106992963096
Gc5_893 0 n10 ns893 0 0.000245571038045
Gc5_894 0 n10 ns894 0 0.000173939920172
Gc5_895 0 n10 ns895 0 4.78006169512e-05
Gc5_896 0 n10 ns896 0 -0.00122809978008
Gc5_897 0 n10 ns897 0 -0.00250548443131
Gc5_898 0 n10 ns898 0 -0.00117162234974
Gc5_899 0 n10 ns899 0 -0.0011757164412
Gc5_900 0 n10 ns900 0 0.000333889833192
Gc5_901 0 n10 ns901 0 0.00152133575789
Gc5_902 0 n10 ns902 0 -0.00694346019398
Gc5_903 0 n10 ns903 0 -0.00438193099149
Gc5_904 0 n10 ns904 0 -0.000237555391611
Gc5_905 0 n10 ns905 0 0.00359065364086
Gc5_906 0 n10 ns906 0 0.00145880340314
Gc5_907 0 n10 ns907 0 -0.000644279456294
Gc5_908 0 n10 ns908 0 -0.0382859484654
Gc5_909 0 n10 ns909 0 0.0321375185113
Gc5_910 0 n10 ns910 0 -0.00123260410142
Gc5_911 0 n10 ns911 0 -4.95375671526e-06
Gc5_912 0 n10 ns912 0 -7.6022182567e-06
Gc5_913 0 n10 ns913 0 0.000128852720004
Gc5_914 0 n10 ns914 0 -0.000581886502074
Gc5_915 0 n10 ns915 0 0.00434772486701
Gc5_916 0 n10 ns916 0 0.000197002895387
Gc5_917 0 n10 ns917 0 0.000174061560858
Gc5_918 0 n10 ns918 0 0.00021686092942
Gc5_919 0 n10 ns919 0 -0.000168856980989
Gc5_920 0 n10 ns920 0 -1.90544916546e-05
Gc5_921 0 n10 ns921 0 -7.12103286187e-05
Gc5_922 0 n10 ns922 0 0.000605335417572
Gc5_923 0 n10 ns923 0 -0.000251422661349
Gc5_924 0 n10 ns924 0 -0.000585437776719
Gc5_925 0 n10 ns925 0 -0.000433689366488
Gc5_926 0 n10 ns926 0 2.9016058978e-05
Gc5_927 0 n10 ns927 0 0.000303612794576
Gc5_928 0 n10 ns928 0 2.56750692476e-05
Gc5_929 0 n10 ns929 0 -0.00209917696326
Gc5_930 0 n10 ns930 0 -0.000916777764456
Gc5_931 0 n10 ns931 0 0.000988862644857
Gc5_932 0 n10 ns932 0 0.000229561770039
Gc5_933 0 n10 ns933 0 9.80268723219e-05
Gc5_934 0 n10 ns934 0 -0.00057619762613
Gc5_935 0 n10 ns935 0 -0.00114212770773
Gc5_936 0 n10 ns936 0 -0.00114196221372
Gc5_937 0 n10 ns937 0 -0.000944612667597
Gc5_938 0 n10 ns938 0 0.000433720707995
Gc5_939 0 n10 ns939 0 0.00106275150101
Gc5_940 0 n10 ns940 0 -0.00494256000613
Gc5_941 0 n10 ns941 0 -0.00218135696065
Gc5_942 0 n10 ns942 0 0.000432227045036
Gc5_943 0 n10 ns943 0 0.00223932121467
Gc5_944 0 n10 ns944 0 0.000773085298445
Gc5_945 0 n10 ns945 0 -0.000549415795303
Gc5_946 0 n10 ns946 0 -0.0190544453858
Gc5_947 0 n10 ns947 0 0.0154745974812
Gc5_948 0 n10 ns948 0 -0.000532564923631
Gc5_949 0 n10 ns949 0 3.60068315982e-06
Gc5_950 0 n10 ns950 0 -5.8872153649e-06
Gc5_951 0 n10 ns951 0 0.000606131212153
Gc5_952 0 n10 ns952 0 -0.00201970660069
Gc5_953 0 n10 ns953 0 0.0107613221659
Gc5_954 0 n10 ns954 0 0.000564988366286
Gc5_955 0 n10 ns955 0 7.73078031965e-05
Gc5_956 0 n10 ns956 0 6.50967103283e-05
Gc5_957 0 n10 ns957 0 -3.01179739581e-05
Gc5_958 0 n10 ns958 0 -4.84542452337e-05
Gc5_959 0 n10 ns959 0 9.477957357e-06
Gc5_960 0 n10 ns960 0 -0.000277420354166
Gc5_961 0 n10 ns961 0 -0.00309293938218
Gc5_962 0 n10 ns962 0 -1.63028460909e-05
Gc5_963 0 n10 ns963 0 0.000503073803981
Gc5_964 0 n10 ns964 0 0.00011908352386
Gc5_965 0 n10 ns965 0 0.000504040367319
Gc5_966 0 n10 ns966 0 -0.000303461812985
Gc5_967 0 n10 ns967 0 -0.000821586638612
Gc5_968 0 n10 ns968 0 -0.000881453742347
Gc5_969 0 n10 ns969 0 9.11840378844e-05
Gc5_970 0 n10 ns970 0 0.000272187948427
Gc5_971 0 n10 ns971 0 9.4579941274e-05
Gc5_972 0 n10 ns972 0 -0.00235758294112
Gc5_973 0 n10 ns973 0 -0.00360171768447
Gc5_974 0 n10 ns974 0 -0.000975951991299
Gc5_975 0 n10 ns975 0 -0.000596960737428
Gc5_976 0 n10 ns976 0 0.000203368846077
Gc5_977 0 n10 ns977 0 0.00147211965966
Gc5_978 0 n10 ns978 0 -0.00838582359259
Gc5_979 0 n10 ns979 0 -0.00567293510984
Gc5_980 0 n10 ns980 0 -0.00130388047399
Gc5_981 0 n10 ns981 0 0.00414429649173
Gc5_982 0 n10 ns982 0 0.00209047347155
Gc5_983 0 n10 ns983 0 -0.000416004624066
Gc5_984 0 n10 ns984 0 -0.0622433637869
Gc5_985 0 n10 ns985 0 0.0533331208018
Gc5_986 0 n10 ns986 0 -0.0022468216981
Gc5_987 0 n10 ns987 0 -8.73872630434e-06
Gc5_988 0 n10 ns988 0 1.29407397678e-07
Gc5_989 0 n10 ns989 0 0.000212155586257
Gc5_990 0 n10 ns990 0 -0.00110525700414
Gc5_991 0 n10 ns991 0 0.00990025754953
Gc5_992 0 n10 ns992 0 -0.00024372021169
Gc5_993 0 n10 ns993 0 0.000171414327712
Gc5_994 0 n10 ns994 0 0.000484854388756
Gc5_995 0 n10 ns995 0 -0.000518522038127
Gc5_996 0 n10 ns996 0 -8.47865874143e-05
Gc5_997 0 n10 ns997 0 3.49358158881e-05
Gc5_998 0 n10 ns998 0 0.00200821918694
Gc5_999 0 n10 ns999 0 -0.00275392468351
Gc5_1000 0 n10 ns1000 0 -0.000629975974402
Gc5_1001 0 n10 ns1001 0 0.000842608420941
Gc5_1002 0 n10 ns1002 0 -4.93767992735e-05
Gc5_1003 0 n10 ns1003 0 0.000520919833135
Gc5_1004 0 n10 ns1004 0 -0.00135362352461
Gc5_1005 0 n10 ns1005 0 -0.00244790241484
Gc5_1006 0 n10 ns1006 0 -0.000628163908925
Gc5_1007 0 n10 ns1007 0 0.000441520113463
Gc5_1008 0 n10 ns1008 0 0.000366242536848
Gc5_1009 0 n10 ns1009 0 0.000262337008207
Gc5_1010 0 n10 ns1010 0 -0.000254701456581
Gc5_1011 0 n10 ns1011 0 -0.00645992582368
Gc5_1012 0 n10 ns1012 0 -0.00291612690821
Gc5_1013 0 n10 ns1013 0 -0.000476203406789
Gc5_1014 0 n10 ns1014 0 0.00049977833898
Gc5_1015 0 n10 ns1015 0 0.00210466320891
Gc5_1016 0 n10 ns1016 0 -0.0109233722078
Gc5_1017 0 n10 ns1017 0 -0.005626270088
Gc5_1018 0 n10 ns1018 0 -0.00184910447646
Gc5_1019 0 n10 ns1019 0 0.00293498538561
Gc5_1020 0 n10 ns1020 0 0.00271259093573
Gc5_1021 0 n10 ns1021 0 0.000165677990546
Gc5_1022 0 n10 ns1022 0 -0.0914857779492
Gc5_1023 0 n10 ns1023 0 0.0832358602131
Gc5_1024 0 n10 ns1024 0 -0.00526694242121
Gc5_1025 0 n10 ns1025 0 -1.00310479405e-05
Gc5_1026 0 n10 ns1026 0 -7.35289938372e-07
Gc5_1027 0 n10 ns1027 0 -0.0053648568296
Gc5_1028 0 n10 ns1028 0 -0.00437424447268
Gc5_1029 0 n10 ns1029 0 0.00723999864187
Gc5_1030 0 n10 ns1030 0 0.00220493480331
Gc5_1031 0 n10 ns1031 0 -0.00189123805239
Gc5_1032 0 n10 ns1032 0 0.000821102726822
Gc5_1033 0 n10 ns1033 0 0.00298907447853
Gc5_1034 0 n10 ns1034 0 2.72405356577e-05
Gc5_1035 0 n10 ns1035 0 -0.000322545678227
Gc5_1036 0 n10 ns1036 0 -0.00121277590888
Gc5_1037 0 n10 ns1037 0 -0.00181401604313
Gc5_1038 0 n10 ns1038 0 -0.00059409381763
Gc5_1039 0 n10 ns1039 0 0.000829582599055
Gc5_1040 0 n10 ns1040 0 -7.84934014819e-05
Gc5_1041 0 n10 ns1041 0 0.000459512585638
Gc5_1042 0 n10 ns1042 0 0.00287332977732
Gc5_1043 0 n10 ns1043 0 -0.00186813297847
Gc5_1044 0 n10 ns1044 0 -0.000537351329213
Gc5_1045 0 n10 ns1045 0 -0.00090441249422
Gc5_1046 0 n10 ns1046 0 0.000116798240621
Gc5_1047 0 n10 ns1047 0 9.13496458562e-05
Gc5_1048 0 n10 ns1048 0 0.00268166502036
Gc5_1049 0 n10 ns1049 0 0.00120026100569
Gc5_1050 0 n10 ns1050 0 -0.0012643314064
Gc5_1051 0 n10 ns1051 0 -0.00246458982762
Gc5_1052 0 n10 ns1052 0 -0.00103780875347
Gc5_1053 0 n10 ns1053 0 0.0019796362712
Gc5_1054 0 n10 ns1054 0 -0.0138089472644
Gc5_1055 0 n10 ns1055 0 -0.00472974477611
Gc5_1056 0 n10 ns1056 0 0.00220444648205
Gc5_1057 0 n10 ns1057 0 0.00349518450613
Gc5_1058 0 n10 ns1058 0 0.00355957329574
Gc5_1059 0 n10 ns1059 0 0.000111737379214
Gc5_1060 0 n10 ns1060 0 0.018463755138
Gc5_1061 0 n10 ns1061 0 -0.00921703906398
Gc5_1062 0 n10 ns1062 0 -0.00760325294902
Gc5_1063 0 n10 ns1063 0 -1.14434623753e-05
Gc5_1064 0 n10 ns1064 0 -7.94349290332e-06
Gc5_1065 0 n10 ns1065 0 -0.00243124581003
Gc5_1066 0 n10 ns1066 0 -0.00307012855472
Gc5_1067 0 n10 ns1067 0 0.00714037923676
Gc5_1068 0 n10 ns1068 0 0.000924165666334
Gc5_1069 0 n10 ns1069 0 -0.00170154863008
Gc5_1070 0 n10 ns1070 0 0.000683407456108
Gc5_1071 0 n10 ns1071 0 0.00198045468026
Gc5_1072 0 n10 ns1072 0 3.99828340451e-05
Gc5_1073 0 n10 ns1073 0 -0.000226347959561
Gc5_1074 0 n10 ns1074 0 0.000573227539835
Gc5_1075 0 n10 ns1075 0 -0.00100603386355
Gc5_1076 0 n10 ns1076 0 -0.000824557757348
Gc5_1077 0 n10 ns1077 0 0.000485061206707
Gc5_1078 0 n10 ns1078 0 -0.000228266232212
Gc5_1079 0 n10 ns1079 0 0.000446789767805
Gc5_1080 0 n10 ns1080 0 0.00160939885736
Gc5_1081 0 n10 ns1081 0 -0.00257949715959
Gc5_1082 0 n10 ns1082 0 -0.00062988448351
Gc5_1083 0 n10 ns1083 0 -0.000374413278019
Gc5_1084 0 n10 ns1084 0 0.000215882556803
Gc5_1085 0 n10 ns1085 0 0.000237055409142
Gc5_1086 0 n10 ns1086 0 0.0020308030516
Gc5_1087 0 n10 ns1087 0 -0.00230405760681
Gc5_1088 0 n10 ns1088 0 -0.00254465332554
Gc5_1089 0 n10 ns1089 0 -0.00162584099669
Gc5_1090 0 n10 ns1090 0 -0.00029007574782
Gc5_1091 0 n10 ns1091 0 0.00223411312769
Gc5_1092 0 n10 ns1092 0 -0.0115461359646
Gc5_1093 0 n10 ns1093 0 -0.00431948864701
Gc5_1094 0 n10 ns1094 0 0.000384898286426
Gc5_1095 0 n10 ns1095 0 0.00226783519473
Gc5_1096 0 n10 ns1096 0 0.00307286239979
Gc5_1097 0 n10 ns1097 0 0.000170478747565
Gc5_1098 0 n10 ns1098 0 -0.0326123693699
Gc5_1099 0 n10 ns1099 0 0.0349150578242
Gc5_1100 0 n10 ns1100 0 -0.00694789148667
Gc5_1101 0 n10 ns1101 0 -8.5614647456e-06
Gc5_1102 0 n10 ns1102 0 -8.28477205304e-06
Gc5_1103 0 n10 ns1103 0 0.00029544688274
Gc5_1104 0 n10 ns1104 0 -0.00114723084107
Gc5_1105 0 n10 ns1105 0 0.0101522967916
Gc5_1106 0 n10 ns1106 0 -0.000154558377471
Gc5_1107 0 n10 ns1107 0 0.000535007016149
Gc5_1108 0 n10 ns1108 0 0.00060023083156
Gc5_1109 0 n10 ns1109 0 -0.000313298802444
Gc5_1110 0 n10 ns1110 0 -0.000121042760236
Gc5_1111 0 n10 ns1111 0 -2.67970719762e-05
Gc5_1112 0 n10 ns1112 0 0.00103290828771
Gc5_1113 0 n10 ns1113 0 -0.00385871013776
Gc5_1114 0 n10 ns1114 0 -0.000174585814668
Gc5_1115 0 n10 ns1115 0 0.00114999989927
Gc5_1116 0 n10 ns1116 0 2.25160224432e-05
Gc5_1117 0 n10 ns1117 0 0.000475799013345
Gc5_1118 0 n10 ns1118 0 -0.00142021989879
Gc5_1119 0 n10 ns1119 0 -0.00123236635592
Gc5_1120 0 n10 ns1120 0 -0.000340489198731
Gc5_1121 0 n10 ns1121 0 3.16499669058e-05
Gc5_1122 0 n10 ns1122 0 0.000329332038117
Gc5_1123 0 n10 ns1123 0 0.000133625091349
Gc5_1124 0 n10 ns1124 0 -0.00148549669966
Gc5_1125 0 n10 ns1125 0 -0.00576853511871
Gc5_1126 0 n10 ns1126 0 -0.00210775358692
Gc5_1127 0 n10 ns1127 0 -5.28329535558e-05
Gc5_1128 0 n10 ns1128 0 0.000459315661249
Gc5_1129 0 n10 ns1129 0 0.00172363622649
Gc5_1130 0 n10 ns1130 0 -0.00977623343731
Gc5_1131 0 n10 ns1131 0 -0.00526676192413
Gc5_1132 0 n10 ns1132 0 -0.00172365812692
Gc5_1133 0 n10 ns1133 0 0.00342451846346
Gc5_1134 0 n10 ns1134 0 0.00253960542851
Gc5_1135 0 n10 ns1135 0 -0.000141593203482
Gc5_1136 0 n10 ns1136 0 -0.0774302325548
Gc5_1137 0 n10 ns1137 0 0.0690348710012
Gc5_1138 0 n10 ns1138 0 -0.0039320274758
Gc5_1139 0 n10 ns1139 0 -9.21123716581e-06
Gc5_1140 0 n10 ns1140 0 -1.1961760468e-05
Gc5_1141 0 n10 ns1141 0 0.00064896170207
Gc5_1142 0 n10 ns1142 0 -0.00152821159947
Gc5_1143 0 n10 ns1143 0 0.00806406470577
Gc5_1144 0 n10 ns1144 0 0.000189309214524
Gc5_1145 0 n10 ns1145 0 9.01815074193e-06
Gc5_1146 0 n10 ns1146 0 4.73678782762e-05
Gc5_1147 0 n10 ns1147 0 0.000147176061257
Gc5_1148 0 n10 ns1148 0 1.47370263567e-05
Gc5_1149 0 n10 ns1149 0 5.00783166346e-05
Gc5_1150 0 n10 ns1150 0 -0.000443861440254
Gc5_1151 0 n10 ns1151 0 -0.00259863210091
Gc5_1152 0 n10 ns1152 0 0.000132294318728
Gc5_1153 0 n10 ns1153 0 0.000565213581543
Gc5_1154 0 n10 ns1154 0 0.000201008662641
Gc5_1155 0 n10 ns1155 0 0.000400463936389
Gc5_1156 0 n10 ns1156 0 0.000276389814637
Gc5_1157 0 n10 ns1157 0 -0.000356407050971
Gc5_1158 0 n10 ns1158 0 -0.00081102796394
Gc5_1159 0 n10 ns1159 0 -8.38408692056e-05
Gc5_1160 0 n10 ns1160 0 0.000194927899016
Gc5_1161 0 n10 ns1161 0 9.50481821782e-06
Gc5_1162 0 n10 ns1162 0 -0.00157232102137
Gc5_1163 0 n10 ns1163 0 -0.00294859174595
Gc5_1164 0 n10 ns1164 0 -0.00103182920323
Gc5_1165 0 n10 ns1165 0 -0.000940368474248
Gc5_1166 0 n10 ns1166 0 0.000254914582186
Gc5_1167 0 n10 ns1167 0 0.00152875574167
Gc5_1168 0 n10 ns1168 0 -0.00718899667025
Gc5_1169 0 n10 ns1169 0 -0.00445880158139
Gc5_1170 0 n10 ns1170 0 -0.000631367077747
Gc5_1171 0 n10 ns1171 0 0.00370670950023
Gc5_1172 0 n10 ns1172 0 0.00170453879801
Gc5_1173 0 n10 ns1173 0 -0.000612002997242
Gc5_1174 0 n10 ns1174 0 -0.0439258502842
Gc5_1175 0 n10 ns1175 0 0.0372819224239
Gc5_1176 0 n10 ns1176 0 -0.00155209698101
Gc5_1177 0 n10 ns1177 0 -7.05763444413e-06
Gc5_1178 0 n10 ns1178 0 -1.10898748813e-05
Gc5_1179 0 n10 ns1179 0 0.000234731867087
Gc5_1180 0 n10 ns1180 0 -0.000938746874636
Gc5_1181 0 n10 ns1181 0 0.00555681656577
Gc5_1182 0 n10 ns1182 0 0.000235874049002
Gc5_1183 0 n10 ns1183 0 0.000136237286239
Gc5_1184 0 n10 ns1184 0 0.00021531711597
Gc5_1185 0 n10 ns1185 0 -0.000137505094727
Gc5_1186 0 n10 ns1186 0 -2.14516509259e-06
Gc5_1187 0 n10 ns1187 0 -3.94042155534e-05
Gc5_1188 0 n10 ns1188 0 0.000383147880689
Gc5_1189 0 n10 ns1189 0 -0.00056681259989
Gc5_1190 0 n10 ns1190 0 -0.000492251915228
Gc5_1191 0 n10 ns1191 0 -0.000376424058823
Gc5_1192 0 n10 ns1192 0 7.29843979886e-05
Gc5_1193 0 n10 ns1193 0 0.000356236305433
Gc5_1194 0 n10 ns1194 0 0.000318707484828
Gc5_1195 0 n10 ns1195 0 -0.00208920005929
Gc5_1196 0 n10 ns1196 0 -0.0011190558211
Gc5_1197 0 n10 ns1197 0 0.00089086461277
Gc5_1198 0 n10 ns1198 0 0.000236406735909
Gc5_1199 0 n10 ns1199 0 9.7603578422e-05
Gc5_1200 0 n10 ns1200 0 -0.000810204845011
Gc5_1201 0 n10 ns1201 0 -0.0016133853006
Gc5_1202 0 n10 ns1202 0 -0.00129668897756
Gc5_1203 0 n10 ns1203 0 -0.00113522958608
Gc5_1204 0 n10 ns1204 0 0.000469705322945
Gc5_1205 0 n10 ns1205 0 0.00131594846091
Gc5_1206 0 n10 ns1206 0 -0.00602902507464
Gc5_1207 0 n10 ns1207 0 -0.0029536710808
Gc5_1208 0 n10 ns1208 0 0.00036507035778
Gc5_1209 0 n10 ns1209 0 0.00281350498928
Gc5_1210 0 n10 ns1210 0 0.0010028740181
Gc5_1211 0 n10 ns1211 0 -0.000642275247475
Gc5_1212 0 n10 ns1212 0 -0.0261554829972
Gc5_1213 0 n10 ns1213 0 0.0214981356376
Gc5_1214 0 n10 ns1214 0 -0.000758713827395
Gc5_1215 0 n10 ns1215 0 4.85041461253e-08
Gc5_1216 0 n10 ns1216 0 -6.95478086849e-06
Gd5_1 0 n10 ni1 0 0.000210792948632
Gd5_2 0 n10 ni2 0 0.000342807759922
Gd5_3 0 n10 ni3 0 -0.000315566510412
Gd5_4 0 n10 ni4 0 -0.0018141522814
Gd5_5 0 n10 ni5 0 1.62804099106e-05
Gd5_6 0 n10 ni6 0 -0.0018679255442
Gd5_7 0 n10 ni7 0 -0.000401639154868
Gd5_8 0 n10 ni8 0 0.000288386925256
Gd5_9 0 n10 ni9 0 4.88805954268e-05
Gd5_10 0 n10 ni10 0 0.000258576689409
Gd5_11 0 n10 ni11 0 -0.00114556924557
Gd5_12 0 n10 ni12 0 -0.000804794623296
Gd5_13 0 n10 ni13 0 -0.0027553492282
Gd5_14 0 n10 ni14 0 -0.000857063241763
Gd5_15 0 n10 ni15 0 0.000170111785117
Gd5_16 0 n10 ni16 0 0.000185258868211
Gd5_17 0 n10 ni17 0 0.000264557136081
Gd5_18 0 n10 ni18 0 0.000144148639037
Gd5_19 0 n10 ni19 0 0.000499618211595
Gd5_20 0 n10 ni20 0 -0.000389735924086
Gd5_21 0 n10 ni21 0 -0.00677271482937
Gd5_22 0 n10 ni22 0 -0.000348001146151
Gd5_23 0 n10 ni23 0 0.000577173930614
Gd5_24 0 n10 ni24 0 0.000104163276293
Gd5_25 0 n10 ni25 0 7.21662568549e-05
Gd5_26 0 n10 ni26 0 0.000125029866883
Gd5_27 0 n10 ni27 0 -0.000183339225194
Gd5_28 0 n10 ni28 0 -0.00301363110159
Gd5_29 0 n10 ni29 0 -0.00164741161918
Gd5_30 0 n10 ni30 0 3.38773221392e-05
Gd5_31 0 n10 ni31 0 0.000184178739495
Gd5_32 0 n10 ni32 0 4.96403988332e-05
Gc6_1 0 n12 ns1 0 0.000242516669936
Gc6_2 0 n12 ns2 0 -0.000400365302132
Gc6_3 0 n12 ns3 0 0.0028614920033
Gc6_4 0 n12 ns4 0 0.000158912003115
Gc6_5 0 n12 ns5 0 0.000154937913045
Gc6_6 0 n12 ns6 0 0.000101030472673
Gc6_7 0 n12 ns7 0 4.37144243779e-05
Gc6_8 0 n12 ns8 0 2.47311205348e-05
Gc6_9 0 n12 ns9 0 2.3867775395e-05
Gc6_10 0 n12 ns10 0 -0.000761878741095
Gc6_11 0 n12 ns11 0 -0.0010252028585
Gc6_12 0 n12 ns12 0 0.000758315783287
Gc6_13 0 n12 ns13 0 0.00029664437571
Gc6_14 0 n12 ns14 0 -8.74786449731e-05
Gc6_15 0 n12 ns15 0 -0.000206091881428
Gc6_16 0 n12 ns16 0 -0.000886996361611
Gc6_17 0 n12 ns17 0 -0.00156969960576
Gc6_18 0 n12 ns18 0 -0.000313938276675
Gc6_19 0 n12 ns19 0 0.00109180342856
Gc6_20 0 n12 ns20 0 0.000221240553474
Gc6_21 0 n12 ns21 0 -5.72958343614e-06
Gc6_22 0 n12 ns22 0 -0.00186118658157
Gc6_23 0 n12 ns23 0 0.000387117057935
Gc6_24 0 n12 ns24 0 0.000813662472834
Gc6_25 0 n12 ns25 0 0.0010830061242
Gc6_26 0 n12 ns26 0 -0.000214440847669
Gc6_27 0 n12 ns27 0 -0.000819685184773
Gc6_28 0 n12 ns28 0 -0.00230083033788
Gc6_29 0 n12 ns29 0 0.000537504829535
Gc6_30 0 n12 ns30 0 0.000710604590331
Gc6_31 0 n12 ns31 0 0.00109898403942
Gc6_32 0 n12 ns32 0 0.000371185166133
Gc6_33 0 n12 ns33 0 -0.000578806172846
Gc6_34 0 n12 ns34 0 0.00335330786035
Gc6_35 0 n12 ns35 0 -0.00413816682486
Gc6_36 0 n12 ns36 0 0.000362676206342
Gc6_37 0 n12 ns37 0 -7.17472745122e-06
Gc6_38 0 n12 ns38 0 -1.79550190497e-05
Gc6_39 0 n12 ns39 0 9.67544763418e-05
Gc6_40 0 n12 ns40 0 -0.00070619346867
Gc6_41 0 n12 ns41 0 0.00265716280261
Gc6_42 0 n12 ns42 0 0.000121722267686
Gc6_43 0 n12 ns43 0 1.7848409249e-05
Gc6_44 0 n12 ns44 0 8.99785374631e-06
Gc6_45 0 n12 ns45 0 9.02419574172e-05
Gc6_46 0 n12 ns46 0 1.4968957992e-05
Gc6_47 0 n12 ns47 0 1.14675263123e-05
Gc6_48 0 n12 ns48 0 -0.00070785599621
Gc6_49 0 n12 ns49 0 -0.00065206541818
Gc6_50 0 n12 ns50 0 0.000747775227921
Gc6_51 0 n12 ns51 0 0.00033910235947
Gc6_52 0 n12 ns52 0 -8.88347920123e-05
Gc6_53 0 n12 ns53 0 -0.000269221268299
Gc6_54 0 n12 ns54 0 -0.000575349284506
Gc6_55 0 n12 ns55 0 -0.00141733515962
Gc6_56 0 n12 ns56 0 -0.00040549509057
Gc6_57 0 n12 ns57 0 0.00106279512037
Gc6_58 0 n12 ns58 0 0.000257850265176
Gc6_59 0 n12 ns59 0 -2.57328281651e-05
Gc6_60 0 n12 ns60 0 -0.00143608010619
Gc6_61 0 n12 ns61 0 0.000369687979053
Gc6_62 0 n12 ns62 0 0.000828956424225
Gc6_63 0 n12 ns63 0 0.00111401142951
Gc6_64 0 n12 ns64 0 -0.000260118581166
Gc6_65 0 n12 ns65 0 -0.000909590222448
Gc6_66 0 n12 ns66 0 -0.00197625461843
Gc6_67 0 n12 ns67 0 0.000124839469724
Gc6_68 0 n12 ns68 0 0.00051337831538
Gc6_69 0 n12 ns69 0 0.00125850977932
Gc6_70 0 n12 ns70 0 0.000448954911538
Gc6_71 0 n12 ns71 0 -0.00058977829357
Gc6_72 0 n12 ns72 0 0.0045951190258
Gc6_73 0 n12 ns73 0 -0.0052696887683
Gc6_74 0 n12 ns74 0 0.000433145226657
Gc6_75 0 n12 ns75 0 -5.06636517325e-06
Gc6_76 0 n12 ns76 0 -1.87287164436e-05
Gc6_77 0 n12 ns77 0 -0.000788934594622
Gc6_78 0 n12 ns78 0 0.00175847409088
Gc6_79 0 n12 ns79 0 -0.00354985564621
Gc6_80 0 n12 ns80 0 -0.000253968464802
Gc6_81 0 n12 ns81 0 -0.00013629989993
Gc6_82 0 n12 ns82 0 -0.000181982749242
Gc6_83 0 n12 ns83 0 -0.000143641112951
Gc6_84 0 n12 ns84 0 -2.41508671159e-05
Gc6_85 0 n12 ns85 0 -1.44450646222e-05
Gc6_86 0 n12 ns86 0 -5.9444100241e-05
Gc6_87 0 n12 ns87 0 0.00183284882641
Gc6_88 0 n12 ns88 0 3.88676539323e-07
Gc6_89 0 n12 ns89 0 -0.000133360602833
Gc6_90 0 n12 ns90 0 -0.000123331963662
Gc6_91 0 n12 ns91 0 -0.000312723455135
Gc6_92 0 n12 ns92 0 0.00100199284179
Gc6_93 0 n12 ns93 0 0.000886998749582
Gc6_94 0 n12 ns94 0 -0.000333941232891
Gc6_95 0 n12 ns95 0 -9.5157894439e-05
Gc6_96 0 n12 ns96 0 0.000221816215147
Gc6_97 0 n12 ns97 0 -0.000127345712009
Gc6_98 0 n12 ns98 0 0.00156941994774
Gc6_99 0 n12 ns99 0 0.000515999098968
Gc6_100 0 n12 ns100 0 0.000301025753879
Gc6_101 0 n12 ns101 0 0.000754706237776
Gc6_102 0 n12 ns102 0 -0.000133805066501
Gc6_103 0 n12 ns103 0 -0.000978485481567
Gc6_104 0 n12 ns104 0 0.00120729215902
Gc6_105 0 n12 ns105 0 -0.000515089981733
Gc6_106 0 n12 ns106 0 -0.000422186491282
Gc6_107 0 n12 ns107 0 0.00143754560195
Gc6_108 0 n12 ns108 0 0.000779042626915
Gc6_109 0 n12 ns109 0 -0.000668171511527
Gc6_110 0 n12 ns110 0 0.0273787911182
Gc6_111 0 n12 ns111 0 -0.0248012574952
Gc6_112 0 n12 ns112 0 0.00123038972752
Gc6_113 0 n12 ns113 0 -6.9945879664e-06
Gc6_114 0 n12 ns114 0 -1.94130941035e-05
Gc6_115 0 n12 ns115 0 -0.00147294104207
Gc6_116 0 n12 ns116 0 0.00114026611505
Gc6_117 0 n12 ns117 0 -0.00346824446273
Gc6_118 0 n12 ns118 0 0.000314822915418
Gc6_119 0 n12 ns119 0 -0.000592585426904
Gc6_120 0 n12 ns120 0 0.000271450936357
Gc6_121 0 n12 ns121 0 -0.000179394770872
Gc6_122 0 n12 ns122 0 -4.46513270261e-05
Gc6_123 0 n12 ns123 0 3.70445460362e-05
Gc6_124 0 n12 ns124 0 -0.00141163335945
Gc6_125 0 n12 ns125 0 0.00102082729868
Gc6_126 0 n12 ns126 0 0.000106367750825
Gc6_127 0 n12 ns127 0 -0.000509982447465
Gc6_128 0 n12 ns128 0 5.00418591639e-05
Gc6_129 0 n12 ns129 0 -0.00036882963827
Gc6_130 0 n12 ns130 0 -0.00141522673846
Gc6_131 0 n12 ns131 0 0.00123564313631
Gc6_132 0 n12 ns132 0 0.000212872300899
Gc6_133 0 n12 ns133 0 -3.14957099124e-05
Gc6_134 0 n12 ns134 0 0.000400386602751
Gc6_135 0 n12 ns135 0 -2.81053390073e-05
Gc6_136 0 n12 ns136 0 0.000840685281393
Gc6_137 0 n12 ns137 0 0.00385795691676
Gc6_138 0 n12 ns138 0 0.000788117090581
Gc6_139 0 n12 ns139 0 0.000205266375968
Gc6_140 0 n12 ns140 0 -5.99688472238e-05
Gc6_141 0 n12 ns141 0 -0.00120308593681
Gc6_142 0 n12 ns142 0 0.00359890056849
Gc6_143 0 n12 ns143 0 0.00214232240796
Gc6_144 0 n12 ns144 0 -0.00158565369183
Gc6_145 0 n12 ns145 0 0.000411495592941
Gc6_146 0 n12 ns146 0 0.00125660342273
Gc6_147 0 n12 ns147 0 -0.000440376943192
Gc6_148 0 n12 ns148 0 0.0540962236035
Gc6_149 0 n12 ns149 0 -0.0500300255752
Gc6_150 0 n12 ns150 0 0.00289175225506
Gc6_151 0 n12 ns151 0 -2.88413977579e-06
Gc6_152 0 n12 ns152 0 -1.81892769702e-05
Gc6_153 0 n12 ns153 0 -0.00233226899874
Gc6_154 0 n12 ns154 0 -0.00124844495523
Gc6_155 0 n12 ns155 0 0.0014651860748
Gc6_156 0 n12 ns156 0 0.000135384861578
Gc6_157 0 n12 ns157 0 -0.000400017995663
Gc6_158 0 n12 ns158 0 0.000472544407838
Gc6_159 0 n12 ns159 0 0.000498458983872
Gc6_160 0 n12 ns160 0 -0.000156401023428
Gc6_161 0 n12 ns161 0 -5.74178697514e-05
Gc6_162 0 n12 ns162 0 -0.000494343497409
Gc6_163 0 n12 ns163 0 0.000312767605573
Gc6_164 0 n12 ns164 0 0.000737408203356
Gc6_165 0 n12 ns165 0 -0.000111017742206
Gc6_166 0 n12 ns166 0 0.000308271163677
Gc6_167 0 n12 ns167 0 -0.000431098255513
Gc6_168 0 n12 ns168 0 0.000456631728695
Gc6_169 0 n12 ns169 0 -0.00164549010882
Gc6_170 0 n12 ns170 0 -0.000302793487928
Gc6_171 0 n12 ns171 0 -0.000130288024831
Gc6_172 0 n12 ns172 0 0.000346031924979
Gc6_173 0 n12 ns173 0 0.000190215498818
Gc6_174 0 n12 ns174 0 -0.00298484335696
Gc6_175 0 n12 ns175 0 -0.000801522352874
Gc6_176 0 n12 ns176 0 0.000907765068182
Gc6_177 0 n12 ns177 0 0.00112852248284
Gc6_178 0 n12 ns178 0 0.000662817307374
Gc6_179 0 n12 ns179 0 -0.00147174352579
Gc6_180 0 n12 ns180 0 -0.0041811315029
Gc6_181 0 n12 ns181 0 -0.000909303172859
Gc6_182 0 n12 ns182 0 -0.00121823648098
Gc6_183 0 n12 ns183 0 0.000488808399743
Gc6_184 0 n12 ns184 0 0.0023031389187
Gc6_185 0 n12 ns185 0 0.000234596663916
Gc6_186 0 n12 ns186 0 0.0296354458314
Gc6_187 0 n12 ns187 0 -0.035627791404
Gc6_188 0 n12 ns188 0 0.00567877316593
Gc6_189 0 n12 ns189 0 1.06832810549e-06
Gc6_190 0 n12 ns190 0 -2.66324534105e-06
Gc6_191 0 n12 ns191 0 -0.00376793547052
Gc6_192 0 n12 ns192 0 -0.000564841615406
Gc6_193 0 n12 ns193 0 -0.00212732558654
Gc6_194 0 n12 ns194 0 0.000464140928555
Gc6_195 0 n12 ns195 0 -0.000407684683673
Gc6_196 0 n12 ns196 0 0.00034596549022
Gc6_197 0 n12 ns197 0 -0.000216708692561
Gc6_198 0 n12 ns198 0 -0.000218417882519
Gc6_199 0 n12 ns199 0 -9.03014978234e-05
Gc6_200 0 n12 ns200 0 -0.00393573232099
Gc6_201 0 n12 ns201 0 0.00217325762693
Gc6_202 0 n12 ns202 0 0.0014545055508
Gc6_203 0 n12 ns203 0 -0.000382257988854
Gc6_204 0 n12 ns204 0 0.000358816258651
Gc6_205 0 n12 ns205 0 -0.000596469826895
Gc6_206 0 n12 ns206 0 -8.18735667026e-06
Gc6_207 0 n12 ns207 0 0.00145190018561
Gc6_208 0 n12 ns208 0 0.000626934817187
Gc6_209 0 n12 ns209 0 0.000318295181998
Gc6_210 0 n12 ns210 0 0.000586917703255
Gc6_211 0 n12 ns211 0 0.000161042925309
Gc6_212 0 n12 ns212 0 0.00100812302891
Gc6_213 0 n12 ns213 0 0.000989110705418
Gc6_214 0 n12 ns214 0 0.00150986710203
Gc6_215 0 n12 ns215 0 0.00273347751937
Gc6_216 0 n12 ns216 0 0.00117911496347
Gc6_217 0 n12 ns217 0 -0.00219396123356
Gc6_218 0 n12 ns218 0 -7.41211479131e-05
Gc6_219 0 n12 ns219 0 -0.00276631592294
Gc6_220 0 n12 ns220 0 0.00207446282918
Gc6_221 0 n12 ns221 0 0.00178654033854
Gc6_222 0 n12 ns222 0 0.00319476382402
Gc6_223 0 n12 ns223 0 1.53428875616e-05
Gc6_224 0 n12 ns224 0 -0.0201348350494
Gc6_225 0 n12 ns225 0 0.0204411227799
Gc6_226 0 n12 ns226 0 0.00703362041084
Gc6_227 0 n12 ns227 0 1.0258948407e-05
Gc6_228 0 n12 ns228 0 6.4911101819e-06
Gc6_229 0 n12 ns229 0 -0.0018963969527
Gc6_230 0 n12 ns230 0 -0.00221264316934
Gc6_231 0 n12 ns231 0 0.00512746135529
Gc6_232 0 n12 ns232 0 0.000391288122614
Gc6_233 0 n12 ns233 0 -0.000381005022159
Gc6_234 0 n12 ns234 0 0.000652259614212
Gc6_235 0 n12 ns235 0 0.00044320268149
Gc6_236 0 n12 ns236 0 -0.00015864398944
Gc6_237 0 n12 ns237 0 -9.68771311968e-05
Gc6_238 0 n12 ns238 0 -0.00176333100449
Gc6_239 0 n12 ns239 0 -0.000439406691559
Gc6_240 0 n12 ns240 0 0.00130815385232
Gc6_241 0 n12 ns241 0 4.04430615944e-05
Gc6_242 0 n12 ns242 0 0.000348825860761
Gc6_243 0 n12 ns243 0 -0.000572734368766
Gc6_244 0 n12 ns244 0 -0.000122628717312
Gc6_245 0 n12 ns245 0 -0.00224984300325
Gc6_246 0 n12 ns246 0 -0.000464922378935
Gc6_247 0 n12 ns247 0 0.000273795384947
Gc6_248 0 n12 ns248 0 0.000430227478809
Gc6_249 0 n12 ns249 0 0.000247817590866
Gc6_250 0 n12 ns250 0 -0.00422493897847
Gc6_251 0 n12 ns251 0 -0.000869767122071
Gc6_252 0 n12 ns252 0 0.000868921283092
Gc6_253 0 n12 ns253 0 0.00165942345302
Gc6_254 0 n12 ns254 0 0.000861136427932
Gc6_255 0 n12 ns255 0 -0.00170102339628
Gc6_256 0 n12 ns256 0 -0.00579421355074
Gc6_257 0 n12 ns257 0 -0.00120236919461
Gc6_258 0 n12 ns258 0 -0.00119059790482
Gc6_259 0 n12 ns259 0 0.000903118939769
Gc6_260 0 n12 ns260 0 0.00246831448532
Gc6_261 0 n12 ns261 0 0.000237506504269
Gc6_262 0 n12 ns262 0 0.0186735616771
Gc6_263 0 n12 ns263 0 -0.0267046164046
Gc6_264 0 n12 ns264 0 0.00543309579324
Gc6_265 0 n12 ns265 0 2.62308060543e-06
Gc6_266 0 n12 ns266 0 1.66589745772e-05
Gc6_267 0 n12 ns267 0 -0.00121584723812
Gc6_268 0 n12 ns268 0 0.000745625067927
Gc6_269 0 n12 ns269 0 -0.000225433035762
Gc6_270 0 n12 ns270 0 0.000538582863719
Gc6_271 0 n12 ns271 0 -0.000585921430645
Gc6_272 0 n12 ns272 0 0.000326494605733
Gc6_273 0 n12 ns273 0 -0.00015482963405
Gc6_274 0 n12 ns274 0 -3.88994141689e-05
Gc6_275 0 n12 ns275 0 3.41975946283e-05
Gc6_276 0 n12 ns276 0 -0.00199206467039
Gc6_277 0 n12 ns277 0 -0.000215294892799
Gc6_278 0 n12 ns278 0 0.000409478896347
Gc6_279 0 n12 ns279 0 3.04673253087e-05
Gc6_280 0 n12 ns280 0 0.000202807292256
Gc6_281 0 n12 ns281 0 -0.000485224895301
Gc6_282 0 n12 ns282 0 -0.00149441888297
Gc6_283 0 n12 ns283 0 0.000145869947443
Gc6_284 0 n12 ns284 0 -0.000376817186631
Gc6_285 0 n12 ns285 0 0.000293921568036
Gc6_286 0 n12 ns286 0 0.00047100298885
Gc6_287 0 n12 ns287 0 0.000134402270431
Gc6_288 0 n12 ns288 0 -0.000810308929111
Gc6_289 0 n12 ns289 0 0.00317963571145
Gc6_290 0 n12 ns290 0 0.000401444519129
Gc6_291 0 n12 ns291 0 0.00101334321783
Gc6_292 0 n12 ns292 0 0.000410964721504
Gc6_293 0 n12 ns293 0 -0.00146387146282
Gc6_294 0 n12 ns294 0 0.0014956293399
Gc6_295 0 n12 ns295 0 0.00172222318527
Gc6_296 0 n12 ns296 0 -0.00156533074221
Gc6_297 0 n12 ns297 0 0.000911546265356
Gc6_298 0 n12 ns298 0 0.00147321012039
Gc6_299 0 n12 ns299 0 -0.000422890065295
Gc6_300 0 n12 ns300 0 0.041147991637
Gc6_301 0 n12 ns301 0 -0.0395528491838
Gc6_302 0 n12 ns302 0 0.00262805542173
Gc6_303 0 n12 ns303 0 -1.62005376048e-06
Gc6_304 0 n12 ns304 0 1.32705511959e-05
Gc6_305 0 n12 ns305 0 -0.00127006207989
Gc6_306 0 n12 ns306 0 0.00273646588901
Gc6_307 0 n12 ns307 0 -0.00444104374374
Gc6_308 0 n12 ns308 0 -0.000190248291973
Gc6_309 0 n12 ns309 0 -0.000357519340845
Gc6_310 0 n12 ns310 0 -0.000444359121475
Gc6_311 0 n12 ns311 0 -0.000119673993222
Gc6_312 0 n12 ns312 0 -3.02786944069e-05
Gc6_313 0 n12 ns313 0 3.41664801894e-07
Gc6_314 0 n12 ns314 0 0.000729595646525
Gc6_315 0 n12 ns315 0 0.00192788638104
Gc6_316 0 n12 ns316 0 -0.000584372757092
Gc6_317 0 n12 ns317 0 0.000164559508581
Gc6_318 0 n12 ns318 0 6.51600373371e-05
Gc6_319 0 n12 ns319 0 -0.000248269656393
Gc6_320 0 n12 ns320 0 0.00220186037424
Gc6_321 0 n12 ns321 0 0.00100584487937
Gc6_322 0 n12 ns322 0 -0.000870079259224
Gc6_323 0 n12 ns323 0 -0.000724364810112
Gc6_324 0 n12 ns324 0 0.000121935003322
Gc6_325 0 n12 ns325 0 2.66445556131e-05
Gc6_326 0 n12 ns326 0 0.00163416417956
Gc6_327 0 n12 ns327 0 -0.000698198081709
Gc6_328 0 n12 ns328 0 -0.000667586414171
Gc6_329 0 n12 ns329 0 0.000953124027391
Gc6_330 0 n12 ns330 0 0.00047227926059
Gc6_331 0 n12 ns331 0 -0.000815745843172
Gc6_332 0 n12 ns332 0 0.000899465556989
Gc6_333 0 n12 ns333 0 -0.00108523887284
Gc6_334 0 n12 ns334 0 -0.000722285026217
Gc6_335 0 n12 ns335 0 0.00144972399888
Gc6_336 0 n12 ns336 0 0.000870222935565
Gc6_337 0 n12 ns337 0 -0.000506101915915
Gc6_338 0 n12 ns338 0 0.0225373929514
Gc6_339 0 n12 ns339 0 -0.0206673705499
Gc6_340 0 n12 ns340 0 0.00112982328728
Gc6_341 0 n12 ns341 0 -9.7337762679e-06
Gc6_342 0 n12 ns342 0 1.41388790639e-05
Gc6_343 0 n12 ns343 0 -0.000413546038135
Gc6_344 0 n12 ns344 0 0.000864996809432
Gc6_345 0 n12 ns345 0 -0.00122516970844
Gc6_346 0 n12 ns346 0 -8.20049986178e-05
Gc6_347 0 n12 ns347 0 -4.12376973443e-05
Gc6_348 0 n12 ns348 0 -0.00011033854895
Gc6_349 0 n12 ns349 0 -3.73671049317e-05
Gc6_350 0 n12 ns350 0 -3.14883971105e-05
Gc6_351 0 n12 ns351 0 -2.03493180161e-05
Gc6_352 0 n12 ns352 0 -0.000381813904784
Gc6_353 0 n12 ns353 0 0.000923949811122
Gc6_354 0 n12 ns354 0 0.000402148080212
Gc6_355 0 n12 ns355 0 7.15166171394e-05
Gc6_356 0 n12 ns356 0 -0.000121153783529
Gc6_357 0 n12 ns357 0 -0.000321333062371
Gc6_358 0 n12 ns358 0 0.000583724496047
Gc6_359 0 n12 ns359 0 -0.000117148602489
Gc6_360 0 n12 ns360 0 -0.000415431348938
Gc6_361 0 n12 ns361 0 0.000378432746417
Gc6_362 0 n12 ns362 0 0.000227206141864
Gc6_363 0 n12 ns363 0 -9.36716760916e-05
Gc6_364 0 n12 ns364 0 0.000333383181114
Gc6_365 0 n12 ns365 0 0.000169300734284
Gc6_366 0 n12 ns366 0 0.0004865329742
Gc6_367 0 n12 ns367 0 0.00100187943184
Gc6_368 0 n12 ns368 0 -0.000171368982226
Gc6_369 0 n12 ns369 0 -0.000972229389343
Gc6_370 0 n12 ns370 0 -0.000294104839376
Gc6_371 0 n12 ns371 0 -0.000346911459647
Gc6_372 0 n12 ns372 0 6.35801594562e-05
Gc6_373 0 n12 ns373 0 0.00145441433179
Gc6_374 0 n12 ns374 0 0.000635117089454
Gc6_375 0 n12 ns375 0 -0.000677188428463
Gc6_376 0 n12 ns376 0 0.0178394526279
Gc6_377 0 n12 ns377 0 -0.0165909115423
Gc6_378 0 n12 ns378 0 0.000874224799999
Gc6_379 0 n12 ns379 0 -6.42728204608e-06
Gc6_380 0 n12 ns380 0 -1.87589910957e-05
Gc6_381 0 n12 ns381 0 -0.00116831237537
Gc6_382 0 n12 ns382 0 0.00223994210764
Gc6_383 0 n12 ns383 0 -0.0048000947495
Gc6_384 0 n12 ns384 0 -5.8094765145e-05
Gc6_385 0 n12 ns385 0 -0.000256870898319
Gc6_386 0 n12 ns386 0 0.000116002766461
Gc6_387 0 n12 ns387 0 -0.000338130520044
Gc6_388 0 n12 ns388 0 -1.81769758542e-05
Gc6_389 0 n12 ns389 0 1.53101479762e-05
Gc6_390 0 n12 ns390 0 -0.00098080212276
Gc6_391 0 n12 ns391 0 0.00150211312613
Gc6_392 0 n12 ns392 0 -7.00064936214e-05
Gc6_393 0 n12 ns393 0 -0.00035751515185
Gc6_394 0 n12 ns394 0 -3.29268683965e-05
Gc6_395 0 n12 ns395 0 -0.000316403694343
Gc6_396 0 n12 ns396 0 -0.000452013964154
Gc6_397 0 n12 ns397 0 0.00176125906261
Gc6_398 0 n12 ns398 0 0.000127282775009
Gc6_399 0 n12 ns399 0 -0.000176124309227
Gc6_400 0 n12 ns400 0 0.000322251400441
Gc6_401 0 n12 ns401 0 -0.000100442788825
Gc6_402 0 n12 ns402 0 0.00202485240389
Gc6_403 0 n12 ns403 0 0.00285542837439
Gc6_404 0 n12 ns404 0 0.000502620945712
Gc6_405 0 n12 ns405 0 0.000247664795115
Gc6_406 0 n12 ns406 0 -0.000125871547107
Gc6_407 0 n12 ns407 0 -0.00105129187304
Gc6_408 0 n12 ns408 0 0.00365998626927
Gc6_409 0 n12 ns409 0 0.000811968976673
Gc6_410 0 n12 ns410 0 -0.00134151958857
Gc6_411 0 n12 ns411 0 0.00087061263361
Gc6_412 0 n12 ns412 0 0.00104743295964
Gc6_413 0 n12 ns413 0 -0.000531892274768
Gc6_414 0 n12 ns414 0 0.0454115358439
Gc6_415 0 n12 ns415 0 -0.0411048155797
Gc6_416 0 n12 ns416 0 0.00210294187915
Gc6_417 0 n12 ns417 0 -5.2727610362e-06
Gc6_418 0 n12 ns418 0 -1.9992416123e-05
Gc6_419 0 n12 ns419 0 -0.00219284017244
Gc6_420 0 n12 ns420 0 0.000219719874317
Gc6_421 0 n12 ns421 0 -0.000826973425243
Gc6_422 0 n12 ns422 0 0.000426093353897
Gc6_423 0 n12 ns423 0 -0.000418401967872
Gc6_424 0 n12 ns424 0 0.000480149047643
Gc6_425 0 n12 ns425 0 0.000417680741776
Gc6_426 0 n12 ns426 0 -0.000139189830548
Gc6_427 0 n12 ns427 0 -3.2501943183e-06
Gc6_428 0 n12 ns428 0 -0.000255911442454
Gc6_429 0 n12 ns429 0 6.96241660166e-05
Gc6_430 0 n12 ns430 0 0.000475732347189
Gc6_431 0 n12 ns431 0 -0.000346348733888
Gc6_432 0 n12 ns432 0 0.000171889052703
Gc6_433 0 n12 ns433 0 -0.000420140069888
Gc6_434 0 n12 ns434 0 -0.000692864523222
Gc6_435 0 n12 ns435 0 -0.00148679290441
Gc6_436 0 n12 ns436 0 -0.000324690457049
Gc6_437 0 n12 ns437 0 7.04124668236e-06
Gc6_438 0 n12 ns438 0 0.000339141861491
Gc6_439 0 n12 ns439 0 0.000145930143962
Gc6_440 0 n12 ns440 0 -0.00280245904847
Gc6_441 0 n12 ns441 0 0.00164639505465
Gc6_442 0 n12 ns442 0 0.000896838348954
Gc6_443 0 n12 ns443 0 0.000727097393918
Gc6_444 0 n12 ns444 0 0.00038930716305
Gc6_445 0 n12 ns445 0 -0.001353590145
Gc6_446 0 n12 ns446 0 -0.000682463199339
Gc6_447 0 n12 ns447 0 0.00213219077805
Gc6_448 0 n12 ns448 0 -0.00167587342043
Gc6_449 0 n12 ns449 0 -8.79609428277e-06
Gc6_450 0 n12 ns450 0 0.00182999205943
Gc6_451 0 n12 ns451 0 9.19422372057e-06
Gc6_452 0 n12 ns452 0 0.0519573478742
Gc6_453 0 n12 ns453 0 -0.0530348933577
Gc6_454 0 n12 ns454 0 0.00473095706314
Gc6_455 0 n12 ns455 0 1.58105329693e-06
Gc6_456 0 n12 ns456 0 -1.09654037701e-05
Gc6_457 0 n12 ns457 0 -0.00499187838349
Gc6_458 0 n12 ns458 0 0.000346843652367
Gc6_459 0 n12 ns459 0 -0.00719399217578
Gc6_460 0 n12 ns460 0 -0.000239346623631
Gc6_461 0 n12 ns461 0 -0.000863378477949
Gc6_462 0 n12 ns462 0 -7.09295168345e-06
Gc6_463 0 n12 ns463 0 0.000340858276351
Gc6_464 0 n12 ns464 0 -0.000102889941653
Gc6_465 0 n12 ns465 0 -3.25951213988e-05
Gc6_466 0 n12 ns466 0 -0.001501623712
Gc6_467 0 n12 ns467 0 0.00291781697494
Gc6_468 0 n12 ns468 0 0.00067705859856
Gc6_469 0 n12 ns469 0 -0.000543441061479
Gc6_470 0 n12 ns470 0 0.000221438723304
Gc6_471 0 n12 ns471 0 -0.000447354496419
Gc6_472 0 n12 ns472 0 0.000344585173959
Gc6_473 0 n12 ns473 0 0.00183836771681
Gc6_474 0 n12 ns474 0 0.000695052051154
Gc6_475 0 n12 ns475 0 -5.83294303735e-05
Gc6_476 0 n12 ns476 0 0.00050269351484
Gc6_477 0 n12 ns477 0 7.74227574035e-05
Gc6_478 0 n12 ns478 0 0.002404509357
Gc6_479 0 n12 ns479 0 0.00174304377453
Gc6_480 0 n12 ns480 0 0.0013472810813
Gc6_481 0 n12 ns481 0 0.00218908608175
Gc6_482 0 n12 ns482 0 0.00103122531377
Gc6_483 0 n12 ns483 0 -0.00193040498077
Gc6_484 0 n12 ns484 0 0.00351447415168
Gc6_485 0 n12 ns485 0 -0.00157385111515
Gc6_486 0 n12 ns486 0 0.00176168403008
Gc6_487 0 n12 ns487 0 0.00112794355818
Gc6_488 0 n12 ns488 0 0.00292232713777
Gc6_489 0 n12 ns489 0 3.61869862081e-05
Gc6_490 0 n12 ns490 0 -0.0068174890009
Gc6_491 0 n12 ns491 0 0.0110962017628
Gc6_492 0 n12 ns492 0 0.00709864027093
Gc6_493 0 n12 ns493 0 -1.47683393478e-06
Gc6_494 0 n12 ns494 0 -1.59644997802e-06
Gc6_495 0 n12 ns495 0 -0.00485327394058
Gc6_496 0 n12 ns496 0 -0.00104071861804
Gc6_497 0 n12 ns497 0 -0.00391252491473
Gc6_498 0 n12 ns498 0 0.000261986186482
Gc6_499 0 n12 ns499 0 -0.00118083412494
Gc6_500 0 n12 ns500 0 -3.40796441504e-05
Gc6_501 0 n12 ns501 0 0.00084074409392
Gc6_502 0 n12 ns502 0 -0.000115083668337
Gc6_503 0 n12 ns503 0 -8.36157044412e-05
Gc6_504 0 n12 ns504 0 -0.000800879448248
Gc6_505 0 n12 ns505 0 0.00198412714716
Gc6_506 0 n12 ns506 0 0.00100391010013
Gc6_507 0 n12 ns507 0 -0.000500453121539
Gc6_508 0 n12 ns508 0 0.000207063669999
Gc6_509 0 n12 ns509 0 -0.000542406718492
Gc6_510 0 n12 ns510 0 0.000355606568289
Gc6_511 0 n12 ns511 0 -0.000715425430006
Gc6_512 0 n12 ns512 0 0.000116726095552
Gc6_513 0 n12 ns513 0 6.67494097254e-05
Gc6_514 0 n12 ns514 0 0.000456472368161
Gc6_515 0 n12 ns515 0 0.000142310179462
Gc6_516 0 n12 ns516 0 -0.00135405725554
Gc6_517 0 n12 ns517 0 0.00104132735712
Gc6_518 0 n12 ns518 0 0.00158341915927
Gc6_519 0 n12 ns519 0 0.00185162542557
Gc6_520 0 n12 ns520 0 0.000780024207082
Gc6_521 0 n12 ns521 0 -0.00197445637892
Gc6_522 0 n12 ns522 0 0.00079410884631
Gc6_523 0 n12 ns523 0 0.00088969069384
Gc6_524 0 n12 ns524 0 0.0002004458037
Gc6_525 0 n12 ns525 0 -2.60888777902e-06
Gc6_526 0 n12 ns526 0 0.00247135146644
Gc6_527 0 n12 ns527 0 8.94088203631e-05
Gc6_528 0 n12 ns528 0 0.0271992457333
Gc6_529 0 n12 ns529 0 -0.0261609716188
Gc6_530 0 n12 ns530 0 0.00663109224469
Gc6_531 0 n12 ns531 0 -3.70176583791e-06
Gc6_532 0 n12 ns532 0 8.55325537569e-06
Gc6_533 0 n12 ns533 0 -0.00136227019177
Gc6_534 0 n12 ns534 0 -1.98750845245e-05
Gc6_535 0 n12 ns535 0 0.00155560965753
Gc6_536 0 n12 ns536 0 0.000734099113906
Gc6_537 0 n12 ns537 0 -0.000536661423897
Gc6_538 0 n12 ns538 0 0.000683065572037
Gc6_539 0 n12 ns539 0 -2.44680023433e-05
Gc6_540 0 n12 ns540 0 -0.000120666081009
Gc6_541 0 n12 ns541 0 1.105045403e-05
Gc6_542 0 n12 ns542 0 -0.00271604323104
Gc6_543 0 n12 ns543 0 -0.000698226666654
Gc6_544 0 n12 ns544 0 0.00102335990052
Gc6_545 0 n12 ns545 0 -0.000151581880435
Gc6_546 0 n12 ns546 0 0.000255301161947
Gc6_547 0 n12 ns547 0 -0.000590141408246
Gc6_548 0 n12 ns548 0 -0.00217673113306
Gc6_549 0 n12 ns549 0 -0.000799481481777
Gc6_550 0 n12 ns550 0 -0.000221117184001
Gc6_551 0 n12 ns551 0 0.000525003519041
Gc6_552 0 n12 ns552 0 0.000537821212002
Gc6_553 0 n12 ns553 0 0.00017378192802
Gc6_554 0 n12 ns554 0 -0.00238101435009
Gc6_555 0 n12 ns555 0 0.00322664227687
Gc6_556 0 n12 ns556 0 0.000803153369818
Gc6_557 0 n12 ns557 0 0.00105551850926
Gc6_558 0 n12 ns558 0 0.000441511336426
Gc6_559 0 n12 ns559 0 -0.00162573173552
Gc6_560 0 n12 ns560 0 -2.51483127606e-05
Gc6_561 0 n12 ns561 0 0.00192254325032
Gc6_562 0 n12 ns562 0 -0.0016868347751
Gc6_563 0 n12 ns563 0 0.000706916671108
Gc6_564 0 n12 ns564 0 0.00178185244933
Gc6_565 0 n12 ns565 0 -0.000263224757121
Gc6_566 0 n12 ns566 0 0.0409168618516
Gc6_567 0 n12 ns567 0 -0.0414385057523
Gc6_568 0 n12 ns568 0 0.00349939878713
Gc6_569 0 n12 ns569 0 1.16306691692e-07
Gc6_570 0 n12 ns570 0 1.31058589702e-05
Gc6_571 0 n12 ns571 0 -0.00128665833571
Gc6_572 0 n12 ns572 0 0.00261747519083
Gc6_573 0 n12 ns573 0 -0.00364527453676
Gc6_574 0 n12 ns574 0 -6.67189163893e-05
Gc6_575 0 n12 ns575 0 -0.000315672801356
Gc6_576 0 n12 ns576 0 -0.000159887572639
Gc6_577 0 n12 ns577 0 -0.000232269401444
Gc6_578 0 n12 ns578 0 -3.63150739124e-05
Gc6_579 0 n12 ns579 0 6.14665363311e-06
Gc6_580 0 n12 ns580 0 -0.000161620698523
Gc6_581 0 n12 ns581 0 0.00142884336332
Gc6_582 0 n12 ns582 0 -0.000349321294122
Gc6_583 0 n12 ns583 0 0.000161823192136
Gc6_584 0 n12 ns584 0 0.000124238841814
Gc6_585 0 n12 ns585 0 -0.000353750188966
Gc6_586 0 n12 ns586 0 0.00138170163061
Gc6_587 0 n12 ns587 0 0.00107453851285
Gc6_588 0 n12 ns588 0 -0.000805690207197
Gc6_589 0 n12 ns589 0 -0.000566120270676
Gc6_590 0 n12 ns590 0 0.000233506030866
Gc6_591 0 n12 ns591 0 5.10049390899e-05
Gc6_592 0 n12 ns592 0 0.00131064168375
Gc6_593 0 n12 ns593 0 0.000241018114336
Gc6_594 0 n12 ns594 0 -0.000545801591887
Gc6_595 0 n12 ns595 0 0.00106159345228
Gc6_596 0 n12 ns596 0 0.000530512682929
Gc6_597 0 n12 ns597 0 -0.00105749940148
Gc6_598 0 n12 ns598 0 0.00105277531389
Gc6_599 0 n12 ns599 0 -0.000694108595829
Gc6_600 0 n12 ns600 0 -0.00101749096537
Gc6_601 0 n12 ns601 0 0.00158877579442
Gc6_602 0 n12 ns602 0 0.00112256734872
Gc6_603 0 n12 ns603 0 -0.000556318861468
Gc6_604 0 n12 ns604 0 0.0277768180177
Gc6_605 0 n12 ns605 0 -0.0259329976821
Gc6_606 0 n12 ns606 0 0.0015219822901
Gc6_607 0 n12 ns607 0 -7.29658096612e-06
Gc6_608 0 n12 ns608 0 1.59040436037e-05
Gc6_609 0 n12 ns609 0 0.000203226013473
Gc6_610 0 n12 ns610 0 -0.00076518431104
Gc6_611 0 n12 ns611 0 0.00392091843632
Gc6_612 0 n12 ns612 0 0.000214436048556
Gc6_613 0 n12 ns613 0 0.000161794024233
Gc6_614 0 n12 ns614 0 0.000121368303534
Gc6_615 0 n12 ns615 0 -0.000187770905632
Gc6_616 0 n12 ns616 0 -5.3807726612e-05
Gc6_617 0 n12 ns617 0 -4.32225726101e-05
Gc6_618 0 n12 ns618 0 0.00083358288647
Gc6_619 0 n12 ns619 0 -0.000811189421616
Gc6_620 0 n12 ns620 0 -0.00076528867184
Gc6_621 0 n12 ns621 0 3.54942675383e-05
Gc6_622 0 n12 ns622 0 0.000144991465167
Gc6_623 0 n12 ns623 0 0.000281827637528
Gc6_624 0 n12 ns624 0 -0.000692674981077
Gc6_625 0 n12 ns625 0 -0.00169757844005
Gc6_626 0 n12 ns626 0 -0.000361261143159
Gc6_627 0 n12 ns627 0 0.00105344542402
Gc6_628 0 n12 ns628 0 0.00021850322776
Gc6_629 0 n12 ns629 0 -3.57874967997e-06
Gc6_630 0 n12 ns630 0 -0.000394713479408
Gc6_631 0 n12 ns631 0 -0.00108132161827
Gc6_632 0 n12 ns632 0 -0.00125896813536
Gc6_633 0 n12 ns633 0 -0.000627273683974
Gc6_634 0 n12 ns634 0 0.000570467204675
Gc6_635 0 n12 ns635 0 0.000854018148384
Gc6_636 0 n12 ns636 0 -0.00443753308823
Gc6_637 0 n12 ns637 0 -0.00123775118285
Gc6_638 0 n12 ns638 0 0.000683542245678
Gc6_639 0 n12 ns639 0 0.0017995102616
Gc6_640 0 n12 ns640 0 0.0005839829916
Gc6_641 0 n12 ns641 0 -0.000556738877739
Gc6_642 0 n12 ns642 0 -0.0128765453064
Gc6_643 0 n12 ns643 0 0.0101816252973
Gc6_644 0 n12 ns644 0 -0.00033876041197
Gc6_645 0 n12 ns645 0 6.41906866637e-06
Gc6_646 0 n12 ns646 0 -1.54946306539e-05
Gc6_647 0 n12 ns647 0 0.000245359734471
Gc6_648 0 n12 ns648 0 -0.000706367578991
Gc6_649 0 n12 ns649 0 0.00413282711038
Gc6_650 0 n12 ns650 0 6.88045225632e-05
Gc6_651 0 n12 ns651 0 0.000208384779813
Gc6_652 0 n12 ns652 0 0.00016116619694
Gc6_653 0 n12 ns653 0 -0.000107786394786
Gc6_654 0 n12 ns654 0 -1.81401439193e-05
Gc6_655 0 n12 ns655 0 -3.98698503898e-05
Gc6_656 0 n12 ns656 0 0.00091058565217
Gc6_657 0 n12 ns657 0 -0.0008180926713
Gc6_658 0 n12 ns658 0 -0.00075899760126
Gc6_659 0 n12 ns659 0 -1.6107815555e-05
Gc6_660 0 n12 ns660 0 0.00015965175039
Gc6_661 0 n12 ns661 0 0.000324508247254
Gc6_662 0 n12 ns662 0 -0.000299132837566
Gc6_663 0 n12 ns663 0 -0.00180065456838
Gc6_664 0 n12 ns664 0 -0.000577534232112
Gc6_665 0 n12 ns665 0 0.00100313564247
Gc6_666 0 n12 ns666 0 0.000221465058714
Gc6_667 0 n12 ns667 0 4.2201965508e-07
Gc6_668 0 n12 ns668 0 -0.000347191549328
Gc6_669 0 n12 ns669 0 -0.001352948866
Gc6_670 0 n12 ns670 0 -0.00137091454818
Gc6_671 0 n12 ns671 0 -0.000870555354629
Gc6_672 0 n12 ns672 0 0.000576224680092
Gc6_673 0 n12 ns673 0 0.00106880244178
Gc6_674 0 n12 ns674 0 -0.00485040725816
Gc6_675 0 n12 ns675 0 -0.0019840173539
Gc6_676 0 n12 ns676 0 0.000533049289449
Gc6_677 0 n12 ns677 0 0.00217157783007
Gc6_678 0 n12 ns678 0 0.000721628270966
Gc6_679 0 n12 ns679 0 -0.000588923585028
Gc6_680 0 n12 ns680 0 -0.0178229549419
Gc6_681 0 n12 ns681 0 0.0145188705112
Gc6_682 0 n12 ns682 0 -0.000516524976693
Gc6_683 0 n12 ns683 0 2.61320497319e-06
Gc6_684 0 n12 ns684 0 -1.69899561442e-05
Gc6_685 0 n12 ns685 0 0.000308531423357
Gc6_686 0 n12 ns686 0 -0.000640674417103
Gc6_687 0 n12 ns687 0 0.00557030031922
Gc6_688 0 n12 ns688 0 -5.10183017287e-05
Gc6_689 0 n12 ns689 0 0.000379350233393
Gc6_690 0 n12 ns690 0 0.000376359130062
Gc6_691 0 n12 ns691 0 0.00017374416868
Gc6_692 0 n12 ns692 0 2.4252672215e-05
Gc6_693 0 n12 ns693 0 -3.52386807048e-06
Gc6_694 0 n12 ns694 0 -0.000427762726553
Gc6_695 0 n12 ns695 0 -0.00209393997891
Gc6_696 0 n12 ns696 0 0.000157027141965
Gc6_697 0 n12 ns697 0 0.000360558026479
Gc6_698 0 n12 ns698 0 0.000229647657124
Gc6_699 0 n12 ns699 0 0.000298842337031
Gc6_700 0 n12 ns700 0 0.0007596664205
Gc6_701 0 n12 ns701 0 -0.000733340806399
Gc6_702 0 n12 ns702 0 -0.000919838303462
Gc6_703 0 n12 ns703 0 5.81850868535e-05
Gc6_704 0 n12 ns704 0 0.000128992387346
Gc6_705 0 n12 ns705 0 3.03612797974e-06
Gc6_706 0 n12 ns706 0 -0.00101745595867
Gc6_707 0 n12 ns707 0 -0.00245978323054
Gc6_708 0 n12 ns708 0 -0.00114006097579
Gc6_709 0 n12 ns709 0 -0.00110738180813
Gc6_710 0 n12 ns710 0 0.000341728310825
Gc6_711 0 n12 ns711 0 0.00145175849242
Gc6_712 0 n12 ns712 0 -0.00625323636715
Gc6_713 0 n12 ns713 0 -0.00388647009045
Gc6_714 0 n12 ns714 0 -0.000187325604938
Gc6_715 0 n12 ns715 0 0.00333579240703
Gc6_716 0 n12 ns716 0 0.001363707015
Gc6_717 0 n12 ns717 0 -0.000662495110411
Gc6_718 0 n12 ns718 0 -0.0326694026189
Gc6_719 0 n12 ns719 0 0.0274346165834
Gc6_720 0 n12 ns720 0 -0.00108136461328
Gc6_721 0 n12 ns721 0 -4.72225906176e-06
Gc6_722 0 n12 ns722 0 -2.09102423464e-05
Gc6_723 0 n12 ns723 0 0.000906417078282
Gc6_724 0 n12 ns724 0 -0.000915596860151
Gc6_725 0 n12 ns725 0 0.0103586924585
Gc6_726 0 n12 ns726 0 -1.06848452792e-05
Gc6_727 0 n12 ns727 0 0.000764064082643
Gc6_728 0 n12 ns728 0 0.00045613666608
Gc6_729 0 n12 ns729 0 -0.000146679528193
Gc6_730 0 n12 ns730 0 -8.93163120332e-05
Gc6_731 0 n12 ns731 0 -2.14284797002e-05
Gc6_732 0 n12 ns732 0 -5.23303764935e-06
Gc6_733 0 n12 ns733 0 -0.00416936039103
Gc6_734 0 n12 ns734 0 0.000233985337889
Gc6_735 0 n12 ns735 0 0.00106599401365
Gc6_736 0 n12 ns736 0 0.000121811773446
Gc6_737 0 n12 ns737 0 0.000413736987564
Gc6_738 0 n12 ns738 0 -0.000968683779853
Gc6_739 0 n12 ns739 0 -0.000588300112881
Gc6_740 0 n12 ns740 0 -0.000451747601713
Gc6_741 0 n12 ns741 0 -0.000103170538958
Gc6_742 0 n12 ns742 0 0.000266285035876
Gc6_743 0 n12 ns743 0 7.23806365754e-05
Gc6_744 0 n12 ns744 0 -0.0023493024751
Gc6_745 0 n12 ns745 0 -0.00499474150284
Gc6_746 0 n12 ns746 0 -0.00154758853785
Gc6_747 0 n12 ns747 0 1.09198137592e-05
Gc6_748 0 n12 ns748 0 0.000463207507704
Gc6_749 0 n12 ns749 0 0.00145705516305
Gc6_750 0 n12 ns750 0 -0.00901237872012
Gc6_751 0 n12 ns751 0 -0.00527806377609
Gc6_752 0 n12 ns752 0 -0.0015379432867
Gc6_753 0 n12 ns753 0 0.00383884790279
Gc6_754 0 n12 ns754 0 0.00229087654239
Gc6_755 0 n12 ns755 0 -0.000327772880595
Gc6_756 0 n12 ns756 0 -0.0694481756639
Gc6_757 0 n12 ns757 0 0.0605009644883
Gc6_758 0 n12 ns758 0 -0.00288836659919
Gc6_759 0 n12 ns759 0 -8.81037315192e-06
Gc6_760 0 n12 ns760 0 -2.16790930984e-05
Gc6_761 0 n12 ns761 0 -0.000161998533523
Gc6_762 0 n12 ns762 0 -0.000243981922902
Gc6_763 0 n12 ns763 0 0.00598812967636
Gc6_764 0 n12 ns764 0 -0.00132656810447
Gc6_765 0 n12 ns765 0 -0.000415579822514
Gc6_766 0 n12 ns766 0 0.00186489988919
Gc6_767 0 n12 ns767 0 0.000525537405132
Gc6_768 0 n12 ns768 0 -0.000162565622296
Gc6_769 0 n12 ns769 0 -0.000185901958505
Gc6_770 0 n12 ns770 0 0.00184512938951
Gc6_771 0 n12 ns771 0 -0.00221300721253
Gc6_772 0 n12 ns772 0 -0.00052636900033
Gc6_773 0 n12 ns773 0 0.00087239027692
Gc6_774 0 n12 ns774 0 -0.000128686567916
Gc6_775 0 n12 ns775 0 0.000441525482549
Gc6_776 0 n12 ns776 0 -0.000185959020087
Gc6_777 0 n12 ns777 0 -0.00321876910742
Gc6_778 0 n12 ns778 0 -0.000884431200689
Gc6_779 0 n12 ns779 0 0.000110987170279
Gc6_780 0 n12 ns780 0 0.000263534269918
Gc6_781 0 n12 ns781 0 0.000342477563529
Gc6_782 0 n12 ns782 0 0.000929886196953
Gc6_783 0 n12 ns783 0 -0.005445666974
Gc6_784 0 n12 ns784 0 -0.00291192044029
Gc6_785 0 n12 ns785 0 -0.000846742611082
Gc6_786 0 n12 ns786 0 0.000217687600828
Gc6_787 0 n12 ns787 0 0.0021478188987
Gc6_788 0 n12 ns788 0 -0.0122571184418
Gc6_789 0 n12 ns789 0 -0.00509736177573
Gc6_790 0 n12 ns790 0 -0.000826049558959
Gc6_791 0 n12 ns791 0 0.00284176448352
Gc6_792 0 n12 ns792 0 0.00301192996518
Gc6_793 0 n12 ns793 0 0.000218071631203
Gc6_794 0 n12 ns794 0 -0.0661064010307
Gc6_795 0 n12 ns795 0 0.0630285124675
Gc6_796 0 n12 ns796 0 -0.0063126408597
Gc6_797 0 n12 ns797 0 -8.3470953108e-06
Gc6_798 0 n12 ns798 0 -6.71658539769e-06
Gc6_799 0 n12 ns799 0 -0.0171244149083
Gc6_800 0 n12 ns800 0 -0.00133797431694
Gc6_801 0 n12 ns801 0 0.0204700780882
Gc6_802 0 n12 ns802 0 0.00627616624231
Gc6_803 0 n12 ns803 0 0.010287517303
Gc6_804 0 n12 ns804 0 0.00147546959818
Gc6_805 0 n12 ns805 0 -0.0032292508161
Gc6_806 0 n12 ns806 0 -0.000492544004875
Gc6_807 0 n12 ns807 0 3.2096407728e-05
Gc6_808 0 n12 ns808 0 -0.00128527549685
Gc6_809 0 n12 ns809 0 -0.0147918989841
Gc6_810 0 n12 ns810 0 0.00113099952375
Gc6_811 0 n12 ns811 0 0.00217341648641
Gc6_812 0 n12 ns812 0 0.000273844504962
Gc6_813 0 n12 ns813 0 0.000373716031977
Gc6_814 0 n12 ns814 0 0.000258991933447
Gc6_815 0 n12 ns815 0 0.000666679362475
Gc6_816 0 n12 ns816 0 9.78785890703e-05
Gc6_817 0 n12 ns817 0 0.000393559046188
Gc6_818 0 n12 ns818 0 0.000491329803743
Gc6_819 0 n12 ns819 0 0.000322883632076
Gc6_820 0 n12 ns820 0 -0.0117015779513
Gc6_821 0 n12 ns821 0 -0.00792058404737
Gc6_822 0 n12 ns822 0 -0.00367385533135
Gc6_823 0 n12 ns823 0 -0.00124554912678
Gc6_824 0 n12 ns824 0 0.00014274565323
Gc6_825 0 n12 ns825 0 0.00253014598735
Gc6_826 0 n12 ns826 0 0.00834687658929
Gc6_827 0 n12 ns827 0 -0.00537871381792
Gc6_828 0 n12 ns828 0 0.00191202831998
Gc6_829 0 n12 ns829 0 0.00182874477011
Gc6_830 0 n12 ns830 0 0.00327434493758
Gc6_831 0 n12 ns831 0 -3.32589540868e-05
Gc6_832 0 n12 ns832 0 -0.107101683328
Gc6_833 0 n12 ns833 0 0.0692617185434
Gc6_834 0 n12 ns834 0 -0.00877623174303
Gc6_835 0 n12 ns835 0 -1.13153749527e-05
Gc6_836 0 n12 ns836 0 7.69935890434e-07
Gc6_837 0 n12 ns837 0 -0.000313067538347
Gc6_838 0 n12 ns838 0 -0.000420279784912
Gc6_839 0 n12 ns839 0 0.00698861684646
Gc6_840 0 n12 ns840 0 -0.0011204310851
Gc6_841 0 n12 ns841 0 -0.000486591267594
Gc6_842 0 n12 ns842 0 0.00179386165217
Gc6_843 0 n12 ns843 0 0.000462072169548
Gc6_844 0 n12 ns844 0 -0.000183103806057
Gc6_845 0 n12 ns845 0 -0.000170686311941
Gc6_846 0 n12 ns846 0 0.00220624007747
Gc6_847 0 n12 ns847 0 -0.00267297583771
Gc6_848 0 n12 ns848 0 -0.000851215098144
Gc6_849 0 n12 ns849 0 0.000989978608436
Gc6_850 0 n12 ns850 0 -6.39539181039e-05
Gc6_851 0 n12 ns851 0 0.00057245568269
Gc6_852 0 n12 ns852 0 -0.00054530401356
Gc6_853 0 n12 ns853 0 -0.00370640382612
Gc6_854 0 n12 ns854 0 -0.000984423503589
Gc6_855 0 n12 ns855 0 0.000438813349796
Gc6_856 0 n12 ns856 0 0.000347499014856
Gc6_857 0 n12 ns857 0 0.00037159535397
Gc6_858 0 n12 ns858 0 0.000896662558667
Gc6_859 0 n12 ns859 0 -0.00548418898858
Gc6_860 0 n12 ns860 0 -0.00299449833153
Gc6_861 0 n12 ns861 0 -0.00107891665017
Gc6_862 0 n12 ns862 0 0.000184756555965
Gc6_863 0 n12 ns863 0 0.00232065257629
Gc6_864 0 n12 ns864 0 -0.013018825368
Gc6_865 0 n12 ns865 0 -0.00589175090605
Gc6_866 0 n12 ns866 0 -0.000948418301207
Gc6_867 0 n12 ns867 0 0.00316859780006
Gc6_868 0 n12 ns868 0 0.00313455040378
Gc6_869 0 n12 ns869 0 0.000261146872717
Gc6_870 0 n12 ns870 0 -0.073426323299
Gc6_871 0 n12 ns871 0 0.0692190054463
Gc6_872 0 n12 ns872 0 -0.00651269279597
Gc6_873 0 n12 ns873 0 -9.96720400085e-06
Gc6_874 0 n12 ns874 0 1.59743699084e-05
Gc6_875 0 n12 ns875 0 0.000708365118547
Gc6_876 0 n12 ns876 0 -0.00101203068516
Gc6_877 0 n12 ns877 0 0.0116025604129
Gc6_878 0 n12 ns878 0 0.000324675678074
Gc6_879 0 n12 ns879 0 0.000582488692116
Gc6_880 0 n12 ns880 0 0.000419412038297
Gc6_881 0 n12 ns881 0 -0.000311490071658
Gc6_882 0 n12 ns882 0 -0.000121707197573
Gc6_883 0 n12 ns883 0 -3.35065002279e-05
Gc6_884 0 n12 ns884 0 3.0671351286e-05
Gc6_885 0 n12 ns885 0 -0.00372322059747
Gc6_886 0 n12 ns886 0 8.48172446816e-05
Gc6_887 0 n12 ns887 0 0.000612682475647
Gc6_888 0 n12 ns888 0 2.48923957186e-06
Gc6_889 0 n12 ns889 0 0.000517565029109
Gc6_890 0 n12 ns890 0 -0.000925732931621
Gc6_891 0 n12 ns891 0 -0.00138425394001
Gc6_892 0 n12 ns892 0 -0.000947863945935
Gc6_893 0 n12 ns893 0 0.000186079559559
Gc6_894 0 n12 ns894 0 0.000358560342793
Gc6_895 0 n12 ns895 0 0.000221384536532
Gc6_896 0 n12 ns896 0 -0.0026399696837
Gc6_897 0 n12 ns897 0 -0.00468117719352
Gc6_898 0 n12 ns898 0 -0.00128422983222
Gc6_899 0 n12 ns899 0 -0.000300496840103
Gc6_900 0 n12 ns900 0 0.000223451978941
Gc6_901 0 n12 ns901 0 0.00159125724518
Gc6_902 0 n12 ns902 0 -0.00973188958924
Gc6_903 0 n12 ns903 0 -0.00622578962625
Gc6_904 0 n12 ns904 0 -0.00177453300712
Gc6_905 0 n12 ns905 0 0.00421513211165
Gc6_906 0 n12 ns906 0 0.00245934623402
Gc6_907 0 n12 ns907 0 -0.000250887159334
Gc6_908 0 n12 ns908 0 -0.0779811248318
Gc6_909 0 n12 ns909 0 0.067734563931
Gc6_910 0 n12 ns910 0 -0.00313203819607
Gc6_911 0 n12 ns911 0 -1.03181780032e-05
Gc6_912 0 n12 ns912 0 1.18901558461e-05
Gc6_913 0 n12 ns913 0 -5.83180477824e-06
Gc6_914 0 n12 ns914 0 3.34850734174e-05
Gc6_915 0 n12 ns915 0 0.00510056852312
Gc6_916 0 n12 ns916 0 9.59362950821e-05
Gc6_917 0 n12 ns917 0 0.000157714198181
Gc6_918 0 n12 ns918 0 0.000366697365787
Gc6_919 0 n12 ns919 0 0.000130905280998
Gc6_920 0 n12 ns920 0 3.72234335507e-05
Gc6_921 0 n12 ns921 0 -6.36907174779e-06
Gc6_922 0 n12 ns922 0 -0.00138172891746
Gc6_923 0 n12 ns923 0 -0.000903780712937
Gc6_924 0 n12 ns924 0 0.000793968709278
Gc6_925 0 n12 ns925 0 -0.00030036297314
Gc6_926 0 n12 ns926 0 -3.98665231581e-05
Gc6_927 0 n12 ns927 0 0.00015818092998
Gc6_928 0 n12 ns928 0 0.00169842257413
Gc6_929 0 n12 ns929 0 -0.000594191285708
Gc6_930 0 n12 ns930 0 -0.00149076775088
Gc6_931 0 n12 ns931 0 -0.000442334340738
Gc6_932 0 n12 ns932 0 5.8626822404e-05
Gc6_933 0 n12 ns933 0 0.000205204466881
Gc6_934 0 n12 ns934 0 -0.00142254637886
Gc6_935 0 n12 ns935 0 -0.00176379145201
Gc6_936 0 n12 ns936 0 -0.000208301209715
Gc6_937 0 n12 ns937 0 -0.00114388500493
Gc6_938 0 n12 ns938 0 -0.000199398517983
Gc6_939 0 n12 ns939 0 0.00123566030664
Gc6_940 0 n12 ns940 0 -0.00541052638112
Gc6_941 0 n12 ns941 0 -0.00417571900859
Gc6_942 0 n12 ns942 0 -0.000665149876563
Gc6_943 0 n12 ns943 0 0.00317993149852
Gc6_944 0 n12 ns944 0 0.00142356789905
Gc6_945 0 n12 ns945 0 -0.000467137591616
Gc6_946 0 n12 ns946 0 -0.0331170645443
Gc6_947 0 n12 ns947 0 0.0279564035895
Gc6_948 0 n12 ns948 0 -0.00113177029459
Gc6_949 0 n12 ns949 0 -4.56143798962e-06
Gc6_950 0 n12 ns950 0 1.22367434412e-05
Gc6_951 0 n12 ns951 0 0.000240944600082
Gc6_952 0 n12 ns952 0 -0.000357932902001
Gc6_953 0 n12 ns953 0 0.00433032315001
Gc6_954 0 n12 ns954 0 -0.000230038386518
Gc6_955 0 n12 ns955 0 0.000436938376323
Gc6_956 0 n12 ns956 0 0.000380133823814
Gc6_957 0 n12 ns957 0 8.0004065748e-05
Gc6_958 0 n12 ns958 0 2.34174529065e-05
Gc6_959 0 n12 ns959 0 -1.70171912268e-05
Gc6_960 0 n12 ns960 0 0.000264892941479
Gc6_961 0 n12 ns961 0 -0.00134777706233
Gc6_962 0 n12 ns962 0 -0.000246890070243
Gc6_963 0 n12 ns963 0 0.000145023034798
Gc6_964 0 n12 ns964 0 0.000212251034249
Gc6_965 0 n12 ns965 0 0.000295932329638
Gc6_966 0 n12 ns966 0 0.000628315827626
Gc6_967 0 n12 ns967 0 -0.00125334288169
Gc6_968 0 n12 ns968 0 -0.000872752977516
Gc6_969 0 n12 ns969 0 0.000427340797727
Gc6_970 0 n12 ns970 0 0.000145089854829
Gc6_971 0 n12 ns971 0 4.78895506122e-06
Gc6_972 0 n12 ns972 0 -0.000476025957978
Gc6_973 0 n12 ns973 0 -0.00193355918454
Gc6_974 0 n12 ns974 0 -0.00125688814377
Gc6_975 0 n12 ns975 0 -0.00119859262465
Gc6_976 0 n12 ns976 0 0.000408068435549
Gc6_977 0 n12 ns977 0 0.00136813215375
Gc6_978 0 n12 ns978 0 -0.00552448248796
Gc6_979 0 n12 ns979 0 -0.00326188892791
Gc6_980 0 n12 ns980 0 0.000142250568983
Gc6_981 0 n12 ns981 0 0.00290656116193
Gc6_982 0 n12 ns982 0 0.00108118622598
Gc6_983 0 n12 ns983 0 -0.000655679447143
Gc6_984 0 n12 ns984 0 -0.0250550206343
Gc6_985 0 n12 ns985 0 0.020846167145
Gc6_986 0 n12 ns986 0 -0.000793047575418
Gc6_987 0 n12 ns987 0 -1.79218092749e-06
Gc6_988 0 n12 ns988 0 -1.81730934983e-05
Gc6_989 0 n12 ns989 0 0.000716629219303
Gc6_990 0 n12 ns990 0 -0.00170279927919
Gc6_991 0 n12 ns991 0 0.00920529583741
Gc6_992 0 n12 ns992 0 0.000226696971663
Gc6_993 0 n12 ns993 0 0.000262459627049
Gc6_994 0 n12 ns994 0 0.000147554939459
Gc6_995 0 n12 ns995 0 0.000152286814677
Gc6_996 0 n12 ns996 0 -1.07926193646e-05
Gc6_997 0 n12 ns997 0 5.67714761863e-06
Gc6_998 0 n12 ns998 0 -0.000473664640939
Gc6_999 0 n12 ns999 0 -0.00336547192415
Gc6_1000 0 n12 ns1000 0 0.000251196608528
Gc6_1001 0 n12 ns1001 0 0.000823784406563
Gc6_1002 0 n12 ns1002 0 0.000192484902348
Gc6_1003 0 n12 ns1003 0 0.000381256578416
Gc6_1004 0 n12 ns1004 0 -0.000191831893688
Gc6_1005 0 n12 ns1005 0 -7.6000654427e-05
Gc6_1006 0 n12 ns1006 0 -0.000519101381556
Gc6_1007 0 n12 ns1007 0 -0.000232147993846
Gc6_1008 0 n12 ns1008 0 0.000184457693123
Gc6_1009 0 n12 ns1009 0 -1.22212659654e-05
Gc6_1010 0 n12 ns1010 0 -0.00205534113509
Gc6_1011 0 n12 ns1011 0 -0.00371082275583
Gc6_1012 0 n12 ns1012 0 -0.00106217054262
Gc6_1013 0 n12 ns1013 0 -0.000381320045116
Gc6_1014 0 n12 ns1014 0 0.000319772479444
Gc6_1015 0 n12 ns1015 0 0.00134205821656
Gc6_1016 0 n12 ns1016 0 -0.00743329235421
Gc6_1017 0 n12 ns1017 0 -0.00478620973487
Gc6_1018 0 n12 ns1018 0 -0.00115847490256
Gc6_1019 0 n12 ns1019 0 0.00373630945031
Gc6_1020 0 n12 ns1020 0 0.00192873182195
Gc6_1021 0 n12 ns1021 0 -0.000462314741809
Gc6_1022 0 n12 ns1022 0 -0.0532849425465
Gc6_1023 0 n12 ns1023 0 0.0457767916891
Gc6_1024 0 n12 ns1024 0 -0.00199471482828
Gc6_1025 0 n12 ns1025 0 -8.40609034014e-06
Gc6_1026 0 n12 ns1026 0 -2.38614733387e-05
Gc6_1027 0 n12 ns1027 0 0.000441791997743
Gc6_1028 0 n12 ns1028 0 -0.00126163317831
Gc6_1029 0 n12 ns1029 0 0.00975354588991
Gc6_1030 0 n12 ns1030 0 -0.000332235409099
Gc6_1031 0 n12 ns1031 0 0.000175397789244
Gc6_1032 0 n12 ns1032 0 0.000525106906605
Gc6_1033 0 n12 ns1033 0 -0.000534650454145
Gc6_1034 0 n12 ns1034 0 -7.98836528635e-05
Gc6_1035 0 n12 ns1035 0 2.3445585014e-05
Gc6_1036 0 n12 ns1036 0 0.00165362787527
Gc6_1037 0 n12 ns1037 0 -0.00214395787251
Gc6_1038 0 n12 ns1038 0 -0.000371068797267
Gc6_1039 0 n12 ns1039 0 0.000593896597139
Gc6_1040 0 n12 ns1040 0 -0.000146132592734
Gc6_1041 0 n12 ns1041 0 0.00042166800018
Gc6_1042 0 n12 ns1042 0 -0.00102458664095
Gc6_1043 0 n12 ns1043 0 -0.00217462730799
Gc6_1044 0 n12 ns1044 0 -0.000635000343449
Gc6_1045 0 n12 ns1045 0 0.000202676092061
Gc6_1046 0 n12 ns1046 0 0.000305071397759
Gc6_1047 0 n12 ns1047 0 0.000263543238569
Gc6_1048 0 n12 ns1048 0 -0.000384538272075
Gc6_1049 0 n12 ns1049 0 -0.00644474169109
Gc6_1050 0 n12 ns1050 0 -0.00284135473475
Gc6_1051 0 n12 ns1051 0 -0.000263730171698
Gc6_1052 0 n12 ns1052 0 0.000530847807222
Gc6_1053 0 n12 ns1053 0 0.0019607106057
Gc6_1054 0 n12 ns1054 0 -0.0105908155177
Gc6_1055 0 n12 ns1055 0 -0.00511789486723
Gc6_1056 0 n12 ns1056 0 -0.00175577731459
Gc6_1057 0 n12 ns1057 0 0.00277208229615
Gc6_1058 0 n12 ns1058 0 0.00264999563528
Gc6_1059 0 n12 ns1059 0 0.000129048694333
Gc6_1060 0 n12 ns1060 0 -0.0876173730511
Gc6_1061 0 n12 ns1061 0 0.0799134379233
Gc6_1062 0 n12 ns1062 0 -0.00515183076681
Gc6_1063 0 n12 ns1063 0 -8.33465351961e-06
Gc6_1064 0 n12 ns1064 0 -1.75130205798e-05
Gc6_1065 0 n12 ns1065 0 -0.00538255973348
Gc6_1066 0 n12 ns1066 0 -0.00436866878457
Gc6_1067 0 n12 ns1067 0 0.00720233808376
Gc6_1068 0 n12 ns1068 0 0.00220483640032
Gc6_1069 0 n12 ns1069 0 -0.00190248619834
Gc6_1070 0 n12 ns1070 0 0.000817417732536
Gc6_1071 0 n12 ns1071 0 0.00299704759398
Gc6_1072 0 n12 ns1072 0 2.87481892539e-05
Gc6_1073 0 n12 ns1073 0 -0.000323339375781
Gc6_1074 0 n12 ns1074 0 -0.00120589451388
Gc6_1075 0 n12 ns1075 0 -0.0018146585199
Gc6_1076 0 n12 ns1076 0 -0.000596902122512
Gc6_1077 0 n12 ns1077 0 0.000832094852473
Gc6_1078 0 n12 ns1078 0 -7.78384084948e-05
Gc6_1079 0 n12 ns1079 0 0.000461131650739
Gc6_1080 0 n12 ns1080 0 0.00287524346226
Gc6_1081 0 n12 ns1081 0 -0.0018644560935
Gc6_1082 0 n12 ns1082 0 -0.000536688253136
Gc6_1083 0 n12 ns1083 0 -0.000906164962016
Gc6_1084 0 n12 ns1084 0 0.000117286059236
Gc6_1085 0 n12 ns1085 0 9.07435889064e-05
Gc6_1086 0 n12 ns1086 0 0.0026893760872
Gc6_1087 0 n12 ns1087 0 0.00120300393128
Gc6_1088 0 n12 ns1088 0 -0.00126534048844
Gc6_1089 0 n12 ns1089 0 -0.0024702971712
Gc6_1090 0 n12 ns1090 0 -0.00103900613008
Gc6_1091 0 n12 ns1091 0 0.00198467769122
Gc6_1092 0 n12 ns1092 0 -0.0137957843396
Gc6_1093 0 n12 ns1093 0 -0.00470268213926
Gc6_1094 0 n12 ns1094 0 0.00221246314111
Gc6_1095 0 n12 ns1095 0 0.00348780540494
Gc6_1096 0 n12 ns1096 0 0.00355750160159
Gc6_1097 0 n12 ns1097 0 0.000106272161439
Gc6_1098 0 n12 ns1098 0 0.018697795575
Gc6_1099 0 n12 ns1099 0 -0.00941519265439
Gc6_1100 0 n12 ns1100 0 -0.00759730124678
Gc6_1101 0 n12 ns1101 0 -1.14793219513e-05
Gc6_1102 0 n12 ns1102 0 -7.68829588059e-06
Gc6_1103 0 n12 ns1103 0 -0.00258754479568
Gc6_1104 0 n12 ns1104 0 -0.00291730141103
Gc6_1105 0 n12 ns1105 0 0.00733083107615
Gc6_1106 0 n12 ns1106 0 0.000985420128734
Gc6_1107 0 n12 ns1107 0 -0.00172267359653
Gc6_1108 0 n12 ns1108 0 0.000647465210339
Gc6_1109 0 n12 ns1109 0 0.00199634701387
Gc6_1110 0 n12 ns1110 0 3.33202946697e-05
Gc6_1111 0 n12 ns1111 0 -0.000213975039589
Gc6_1112 0 n12 ns1112 0 0.000929090722201
Gc6_1113 0 n12 ns1113 0 -0.00160676987489
Gc6_1114 0 n12 ns1114 0 -0.00108618125086
Gc6_1115 0 n12 ns1115 0 0.000732195998377
Gc6_1116 0 n12 ns1116 0 -0.000132981589842
Gc6_1117 0 n12 ns1117 0 0.000548707496607
Gc6_1118 0 n12 ns1118 0 0.00126341540671
Gc6_1119 0 n12 ns1119 0 -0.0028473281839
Gc6_1120 0 n12 ns1120 0 -0.000619383985806
Gc6_1121 0 n12 ns1121 0 -0.00013191751941
Gc6_1122 0 n12 ns1122 0 0.000280584825599
Gc6_1123 0 n12 ns1123 0 0.000234063762597
Gc6_1124 0 n12 ns1124 0 0.00215122910221
Gc6_1125 0 n12 ns1125 0 -0.00234015704364
Gc6_1126 0 n12 ns1126 0 -0.00263009859543
Gc6_1127 0 n12 ns1127 0 -0.00183863199194
Gc6_1128 0 n12 ns1128 0 -0.000315556249792
Gc6_1129 0 n12 ns1129 0 0.00238666025876
Gc6_1130 0 n12 ns1130 0 -0.0119360896113
Gc6_1131 0 n12 ns1131 0 -0.00483262120826
Gc6_1132 0 n12 ns1132 0 0.000298425202073
Gc6_1133 0 n12 ns1133 0 0.00245290100128
Gc6_1134 0 n12 ns1134 0 0.00314329537681
Gc6_1135 0 n12 ns1135 0 0.000198768233558
Gc6_1136 0 n12 ns1136 0 -0.0366787304521
Gc6_1137 0 n12 ns1137 0 0.0383937006211
Gc6_1138 0 n12 ns1138 0 -0.00706494674482
Gc6_1139 0 n12 ns1139 0 -1.00234687131e-05
Gc6_1140 0 n12 ns1140 0 8.78521929779e-06
Gc6_1141 0 n12 ns1141 0 0.000214280994902
Gc6_1142 0 n12 ns1142 0 -0.00149750482953
Gc6_1143 0 n12 ns1143 0 0.011641866574
Gc6_1144 0 n12 ns1144 0 0.00015819664524
Gc6_1145 0 n12 ns1145 0 0.000362571374671
Gc6_1146 0 n12 ns1146 0 0.000522555103228
Gc6_1147 0 n12 ns1147 0 -0.000466701060693
Gc6_1148 0 n12 ns1148 0 -0.000154895940714
Gc6_1149 0 n12 ns1149 0 -2.73663727518e-05
Gc6_1150 0 n12 ns1150 0 0.00129483763764
Gc6_1151 0 n12 ns1151 0 -0.0036446819037
Gc6_1152 0 n12 ns1152 0 -0.00045763264308
Gc6_1153 0 n12 ns1153 0 0.000854252665283
Gc6_1154 0 n12 ns1154 0 -4.61642548113e-05
Gc6_1155 0 n12 ns1155 0 0.00060692370321
Gc6_1156 0 n12 ns1156 0 -0.00152202184567
Gc6_1157 0 n12 ns1157 0 -0.001993356134
Gc6_1158 0 n12 ns1158 0 -0.000711986529755
Gc6_1159 0 n12 ns1159 0 0.000356597988083
Gc6_1160 0 n12 ns1160 0 0.000418396061686
Gc6_1161 0 n12 ns1161 0 0.000240920297337
Gc6_1162 0 n12 ns1162 0 -0.00178035445844
Gc6_1163 0 n12 ns1163 0 -0.00566715515207
Gc6_1164 0 n12 ns1164 0 -0.00202592188285
Gc6_1165 0 n12 ns1165 0 -0.000272394579595
Gc6_1166 0 n12 ns1166 0 0.00034592127577
Gc6_1167 0 n12 ns1167 0 0.00185807569762
Gc6_1168 0 n12 ns1168 0 -0.0106976445326
Gc6_1169 0 n12 ns1169 0 -0.00615802593568
Gc6_1170 0 n12 ns1170 0 -0.00187520085483
Gc6_1171 0 n12 ns1171 0 0.00383095903744
Gc6_1172 0 n12 ns1172 0 0.00270004659786
Gc6_1173 0 n12 ns1173 0 -9.59657589919e-05
Gc6_1174 0 n12 ns1174 0 -0.0862458683294
Gc6_1175 0 n12 ns1175 0 0.0764738724231
Gc6_1176 0 n12 ns1176 0 -0.00417859617949
Gc6_1177 0 n12 ns1177 0 -9.60791631381e-06
Gc6_1178 0 n12 ns1178 0 1.27778727098e-05
Gc6_1179 0 n12 ns1179 0 0.000396194925356
Gc6_1180 0 n12 ns1180 0 -0.00090778667454
Gc6_1181 0 n12 ns1181 0 0.00748963755778
Gc6_1182 0 n12 ns1182 0 0.000282646962593
Gc6_1183 0 n12 ns1183 0 -0.000144753485459
Gc6_1184 0 n12 ns1184 0 9.08472257525e-05
Gc6_1185 0 n12 ns1185 0 6.54766116858e-05
Gc6_1186 0 n12 ns1186 0 1.95506281356e-05
Gc6_1187 0 n12 ns1187 0 2.7710992745e-05
Gc6_1188 0 n12 ns1188 0 -0.00115304185393
Gc6_1189 0 n12 ns1189 0 -0.00125120096904
Gc6_1190 0 n12 ns1190 0 0.000600159136973
Gc6_1191 0 n12 ns1191 0 -0.000199724691828
Gc6_1192 0 n12 ns1192 0 -6.83545439237e-05
Gc6_1193 0 n12 ns1193 0 0.000295849502639
Gc6_1194 0 n12 ns1194 0 0.00111818338276
Gc6_1195 0 n12 ns1195 0 -0.000430463625928
Gc6_1196 0 n12 ns1196 0 -0.00136729850263
Gc6_1197 0 n12 ns1197 0 -0.000400830298443
Gc6_1198 0 n12 ns1198 0 0.000158062422846
Gc6_1199 0 n12 ns1199 0 0.000189951637788
Gc6_1200 0 n12 ns1200 0 -0.0017877595149
Gc6_1201 0 n12 ns1201 0 -0.00226964036858
Gc6_1202 0 n12 ns1202 0 -0.000268307542335
Gc6_1203 0 n12 ns1203 0 -0.00108480892381
Gc6_1204 0 n12 ns1204 0 -0.000212716485108
Gc6_1205 0 n12 ns1205 0 0.00140121728138
Gc6_1206 0 n12 ns1206 0 -0.00643691695335
Gc6_1207 0 n12 ns1207 0 -0.00475755922469
Gc6_1208 0 n12 ns1208 0 -0.0010171145438
Gc6_1209 0 n12 ns1209 0 0.00362375726251
Gc6_1210 0 n12 ns1210 0 0.0017589402592
Gc6_1211 0 n12 ns1211 0 -0.000473374817984
Gc6_1212 0 n12 ns1212 0 -0.043954349616
Gc6_1213 0 n12 ns1213 0 0.037465983612
Gc6_1214 0 n12 ns1214 0 -0.00158783173655
Gc6_1215 0 n12 ns1215 0 -8.51197754003e-06
Gc6_1216 0 n12 ns1216 0 1.04850501726e-05
Gd6_1 0 n12 ni1 0 0.000231246963703
Gd6_2 0 n12 ni2 0 2.78531652706e-05
Gd6_3 0 n12 ni3 0 0.000202083279943
Gd6_4 0 n12 ni4 0 -0.000459264423126
Gd6_5 0 n12 ni5 0 -0.00186792555624
Gd6_6 0 n12 ni6 0 3.27074744597e-05
Gd6_7 0 n12 ni7 0 -0.00173926465719
Gd6_8 0 n12 ni8 0 -0.000282001098031
Gd6_9 0 n12 ni9 0 0.000241825243635
Gd6_10 0 n12 ni10 0 0.000162224408336
Gd6_11 0 n12 ni11 0 0.000104421675752
Gd6_12 0 n12 ni12 0 -0.00124349982533
Gd6_13 0 n12 ni13 0 -0.000808013305895
Gd6_14 0 n12 ni14 0 -0.00266595941435
Gd6_15 0 n12 ni15 0 -0.000696975417531
Gd6_16 0 n12 ni16 0 0.000239383619298
Gd6_17 0 n12 ni17 0 2.92846212769e-05
Gd6_18 0 n12 ni18 0 7.52087549074e-05
Gd6_19 0 n12 ni19 0 0.000190125296363
Gd6_20 0 n12 ni20 0 0.000609591640353
Gd6_21 0 n12 ni21 0 -0.00034501844251
Gd6_22 0 n12 ni22 0 -0.00687711329485
Gd6_23 0 n12 ni23 0 -0.000457068375483
Gd6_24 0 n12 ni24 0 0.000515697710233
Gd6_25 0 n12 ni25 0 0.000262513363495
Gd6_26 0 n12 ni26 0 0.000205737847283
Gd6_27 0 n12 ni27 0 0.000236435650592
Gd6_28 0 n12 ni28 0 -0.000101411521359
Gd6_29 0 n12 ni29 0 -0.00302603335441
Gd6_30 0 n12 ni30 0 -0.00169455599584
Gd6_31 0 n12 ni31 0 -7.92644125767e-05
Gd6_32 0 n12 ni32 0 0.00024853604259
Gc7_1 0 n14 ns1 0 0.000159226535081
Gc7_2 0 n14 ns2 0 -0.000745426331039
Gc7_3 0 n14 ns3 0 0.000393693596106
Gc7_4 0 n14 ns4 0 0.000109014574098
Gc7_5 0 n14 ns5 0 -0.000122269311734
Gc7_6 0 n14 ns6 0 8.40001240551e-05
Gc7_7 0 n14 ns7 0 -3.88652872688e-06
Gc7_8 0 n14 ns8 0 1.37974690629e-05
Gc7_9 0 n14 ns9 0 -5.45030243121e-05
Gc7_10 0 n14 ns10 0 -0.000941736694744
Gc7_11 0 n14 ns11 0 0.000487653499575
Gc7_12 0 n14 ns12 0 0.000399371716455
Gc7_13 0 n14 ns13 0 -0.000444658301284
Gc7_14 0 n14 ns14 0 -0.000144799974515
Gc7_15 0 n14 ns15 0 -4.07158915043e-05
Gc7_16 0 n14 ns16 0 -0.000933772355858
Gc7_17 0 n14 ns17 0 0.000462212355607
Gc7_18 0 n14 ns18 0 0.000595020562125
Gc7_19 0 n14 ns19 0 0.000326739903576
Gc7_20 0 n14 ns20 0 6.64185383634e-05
Gc7_21 0 n14 ns21 0 -0.00015712672273
Gc7_22 0 n14 ns22 0 0.000355819199963
Gc7_23 0 n14 ns23 0 0.00117374537681
Gc7_24 0 n14 ns24 0 0.000807079696684
Gc7_25 0 n14 ns25 0 -0.000239561075848
Gc7_26 0 n14 ns26 0 -0.000538050126986
Gc7_27 0 n14 ns27 0 -0.000144058194703
Gc7_28 0 n14 ns28 0 0.00047565367504
Gc7_29 0 n14 ns29 0 0.000724511930054
Gc7_30 0 n14 ns30 0 0.00030236145821
Gc7_31 0 n14 ns31 0 8.42132901279e-05
Gc7_32 0 n14 ns32 0 1.62925682861e-07
Gc7_33 0 n14 ns33 0 -0.00026345275233
Gc7_34 0 n14 ns34 0 0.00962528093984
Gc7_35 0 n14 ns35 0 -0.00843381839374
Gc7_36 0 n14 ns36 0 0.000335830157828
Gc7_37 0 n14 ns37 0 -7.28323799093e-06
Gc7_38 0 n14 ns38 0 -2.76480232124e-05
Gc7_39 0 n14 ns39 0 0.000331765987652
Gc7_40 0 n14 ns40 0 -0.000970511517412
Gc7_41 0 n14 ns41 0 0.000832687696068
Gc7_42 0 n14 ns42 0 8.89825709511e-05
Gc7_43 0 n14 ns43 0 -9.4271202818e-05
Gc7_44 0 n14 ns44 0 7.64336836645e-05
Gc7_45 0 n14 ns45 0 -4.18409997249e-05
Gc7_46 0 n14 ns46 0 1.33960576448e-05
Gc7_47 0 n14 ns47 0 -2.16921873932e-05
Gc7_48 0 n14 ns48 0 -0.000948222518372
Gc7_49 0 n14 ns49 0 0.00041073489658
Gc7_50 0 n14 ns50 0 0.000476683689225
Gc7_51 0 n14 ns51 0 -0.000415607915282
Gc7_52 0 n14 ns52 0 -0.000173190932913
Gc7_53 0 n14 ns53 0 -6.26986070936e-05
Gc7_54 0 n14 ns54 0 -0.00110271210963
Gc7_55 0 n14 ns55 0 0.000214141192252
Gc7_56 0 n14 ns56 0 0.000572821145585
Gc7_57 0 n14 ns57 0 0.000530691325895
Gc7_58 0 n14 ns58 0 0.000108822354518
Gc7_59 0 n14 ns59 0 -0.000169692962383
Gc7_60 0 n14 ns60 0 0.000159500652298
Gc7_61 0 n14 ns61 0 0.00128924856066
Gc7_62 0 n14 ns62 0 0.000975923700404
Gc7_63 0 n14 ns63 0 -0.000133123197747
Gc7_64 0 n14 ns64 0 -0.000619090003706
Gc7_65 0 n14 ns65 0 -0.000252944124747
Gc7_66 0 n14 ns66 0 0.00016519008763
Gc7_67 0 n14 ns67 0 0.000757171753577
Gc7_68 0 n14 ns68 0 0.000409176826778
Gc7_69 0 n14 ns69 0 0.000261618886643
Gc7_70 0 n14 ns70 0 4.95147739371e-05
Gc7_71 0 n14 ns71 0 -0.00035277585932
Gc7_72 0 n14 ns72 0 0.0104219429619
Gc7_73 0 n14 ns73 0 -0.00932047319897
Gc7_74 0 n14 ns74 0 0.000397319670644
Gc7_75 0 n14 ns75 0 -3.92742897792e-06
Gc7_76 0 n14 ns76 0 -3.05520334255e-05
Gc7_77 0 n14 ns77 0 -0.000169028982382
Gc7_78 0 n14 ns78 0 3.6187531046e-05
Gc7_79 0 n14 ns79 0 -0.000728822086198
Gc7_80 0 n14 ns80 0 -0.000154957822539
Gc7_81 0 n14 ns81 0 6.3553074671e-05
Gc7_82 0 n14 ns82 0 -9.24674284252e-05
Gc7_83 0 n14 ns83 0 0.000114259925128
Gc7_84 0 n14 ns84 0 3.76987264482e-06
Gc7_85 0 n14 ns85 0 3.69252366093e-05
Gc7_86 0 n14 ns86 0 0.000385203119531
Gc7_87 0 n14 ns87 0 0.000132368570853
Gc7_88 0 n14 ns88 0 0.000239608531864
Gc7_89 0 n14 ns89 0 0.000132782414731
Gc7_90 0 n14 ns90 0 -0.00013876848278
Gc7_91 0 n14 ns91 0 -0.000135311640703
Gc7_92 0 n14 ns92 0 -7.24426070887e-05
Gc7_93 0 n14 ns93 0 -0.000717213314237
Gc7_94 0 n14 ns94 0 -0.000171314457703
Gc7_95 0 n14 ns95 0 0.000657805819888
Gc7_96 0 n14 ns96 0 0.000171697767723
Gc7_97 0 n14 ns97 0 -0.000100885457221
Gc7_98 0 n14 ns98 0 -0.000146801348746
Gc7_99 0 n14 ns99 0 0.000487828034731
Gc7_100 0 n14 ns100 0 0.000902670381173
Gc7_101 0 n14 ns101 0 0.000539328003056
Gc7_102 0 n14 ns102 0 -0.000493803924037
Gc7_103 0 n14 ns103 0 -0.000665422111898
Gc7_104 0 n14 ns104 0 -0.000409666927062
Gc7_105 0 n14 ns105 0 0.000340902592655
Gc7_106 0 n14 ns106 0 0.000483229177116
Gc7_107 0 n14 ns107 0 0.000888286453694
Gc7_108 0 n14 ns108 0 0.000292333308054
Gc7_109 0 n14 ns109 0 -0.00059603647187
Gc7_110 0 n14 ns110 0 0.0149470393606
Gc7_111 0 n14 ns111 0 -0.0136517575838
Gc7_112 0 n14 ns112 0 0.00064690769572
Gc7_113 0 n14 ns113 0 -3.9258054791e-06
Gc7_114 0 n14 ns114 0 -3.35478424469e-05
Gc7_115 0 n14 ns115 0 -0.000966147803056
Gc7_116 0 n14 ns116 0 0.00230167889976
Gc7_117 0 n14 ns117 0 -0.00582902008523
Gc7_118 0 n14 ns118 0 -0.000433741592612
Gc7_119 0 n14 ns119 0 -0.000213308148183
Gc7_120 0 n14 ns120 0 -0.000354074270555
Gc7_121 0 n14 ns121 0 -6.1417349049e-05
Gc7_122 0 n14 ns122 0 -3.88126817377e-06
Gc7_123 0 n14 ns123 0 2.37223729644e-05
Gc7_124 0 n14 ns124 0 0.000773767824292
Gc7_125 0 n14 ns125 0 0.00217658742497
Gc7_126 0 n14 ns126 0 -0.000352437097536
Gc7_127 0 n14 ns127 0 -0.000126324393322
Gc7_128 0 n14 ns128 0 -0.000125820769149
Gc7_129 0 n14 ns129 0 -0.000234273649012
Gc7_130 0 n14 ns130 0 0.00131024344448
Gc7_131 0 n14 ns131 0 0.00115844920834
Gc7_132 0 n14 ns132 0 -0.000280286215042
Gc7_133 0 n14 ns133 0 -0.000281849378141
Gc7_134 0 n14 ns134 0 0.000188190003805
Gc7_135 0 n14 ns135 0 -0.000146263681086
Gc7_136 0 n14 ns136 0 0.00221533780333
Gc7_137 0 n14 ns137 0 0.000677524530883
Gc7_138 0 n14 ns138 0 0.000364155928838
Gc7_139 0 n14 ns139 0 0.000491578484835
Gc7_140 0 n14 ns140 0 -0.000244834027971
Gc7_141 0 n14 ns141 0 -0.000882558277732
Gc7_142 0 n14 ns142 0 0.0023445512608
Gc7_143 0 n14 ns143 0 -5.44490992304e-05
Gc7_144 0 n14 ns144 0 -0.000408107807726
Gc7_145 0 n14 ns145 0 0.00107141610516
Gc7_146 0 n14 ns146 0 0.000643023876693
Gc7_147 0 n14 ns147 0 -0.000671983163777
Gc7_148 0 n14 ns148 0 0.0353095161871
Gc7_149 0 n14 ns149 0 -0.0312867853679
Gc7_150 0 n14 ns150 0 0.00141014846348
Gc7_151 0 n14 ns151 0 -7.01026673702e-06
Gc7_152 0 n14 ns152 0 -2.49104104649e-05
Gc7_153 0 n14 ns153 0 -0.00132906724275
Gc7_154 0 n14 ns154 0 0.000771690518049
Gc7_155 0 n14 ns155 0 -0.00186235919511
Gc7_156 0 n14 ns156 0 0.000396352489671
Gc7_157 0 n14 ns157 0 -0.000482405331032
Gc7_158 0 n14 ns158 0 0.000434991005497
Gc7_159 0 n14 ns159 0 -0.000212090817507
Gc7_160 0 n14 ns160 0 -5.86296889237e-05
Gc7_161 0 n14 ns161 0 1.09138000737e-07
Gc7_162 0 n14 ns162 0 -0.00198565763585
Gc7_163 0 n14 ns163 0 0.000686336981585
Gc7_164 0 n14 ns164 0 0.000369494188926
Gc7_165 0 n14 ns165 0 -0.000487984818477
Gc7_166 0 n14 ns166 0 5.78835796803e-05
Gc7_167 0 n14 ns167 0 -0.000422901631243
Gc7_168 0 n14 ns168 0 -0.00163617768031
Gc7_169 0 n14 ns169 0 0.00103263424471
Gc7_170 0 n14 ns170 0 0.000175244812193
Gc7_171 0 n14 ns171 0 0.000100056022798
Gc7_172 0 n14 ns172 0 0.000422499669173
Gc7_173 0 n14 ns173 0 -1.42112234536e-05
Gc7_174 0 n14 ns174 0 0.000383118691089
Gc7_175 0 n14 ns175 0 0.00372921164807
Gc7_176 0 n14 ns176 0 0.000739046611762
Gc7_177 0 n14 ns177 0 0.000387981605323
Gc7_178 0 n14 ns178 0 2.02147145089e-05
Gc7_179 0 n14 ns179 0 -0.00126702064074
Gc7_180 0 n14 ns180 0 0.0027818791721
Gc7_181 0 n14 ns181 0 0.00177334556459
Gc7_182 0 n14 ns182 0 -0.00160897705256
Gc7_183 0 n14 ns183 0 0.000684584429981
Gc7_184 0 n14 ns184 0 0.00135973084131
Gc7_185 0 n14 ns185 0 -0.000432748964902
Gc7_186 0 n14 ns186 0 0.0483130016853
Gc7_187 0 n14 ns187 0 -0.0453033202031
Gc7_188 0 n14 ns188 0 0.00276374214227
Gc7_189 0 n14 ns189 0 -1.91876833389e-06
Gc7_190 0 n14 ns190 0 -9.40029752583e-06
Gc7_191 0 n14 ns191 0 -0.00189639694261
Gc7_192 0 n14 ns192 0 -0.00221264311991
Gc7_193 0 n14 ns193 0 0.00512746208236
Gc7_194 0 n14 ns194 0 0.000391288166406
Gc7_195 0 n14 ns195 0 -0.000381004842625
Gc7_196 0 n14 ns196 0 0.000652259762616
Gc7_197 0 n14 ns197 0 0.00044320267712
Gc7_198 0 n14 ns198 0 -0.000158644002091
Gc7_199 0 n14 ns199 0 -9.68771548542e-05
Gc7_200 0 n14 ns200 0 -0.00176333115346
Gc7_201 0 n14 ns201 0 -0.000439407205895
Gc7_202 0 n14 ns202 0 0.0013081539463
Gc7_203 0 n14 ns203 0 4.0443189874e-05
Gc7_204 0 n14 ns204 0 0.000348825898402
Gc7_205 0 n14 ns205 0 -0.000572734374361
Gc7_206 0 n14 ns206 0 -0.000122628733646
Gc7_207 0 n14 ns207 0 -0.00224984326239
Gc7_208 0 n14 ns208 0 -0.00046492248611
Gc7_209 0 n14 ns209 0 0.000273795420881
Gc7_210 0 n14 ns210 0 0.000430227470926
Gc7_211 0 n14 ns211 0 0.000247817618542
Gc7_212 0 n14 ns212 0 -0.00422493937873
Gc7_213 0 n14 ns213 0 -0.000869767483598
Gc7_214 0 n14 ns214 0 0.00086892114252
Gc7_215 0 n14 ns215 0 0.00165942361654
Gc7_216 0 n14 ns216 0 0.000861136540959
Gc7_217 0 n14 ns217 0 -0.00170102341564
Gc7_218 0 n14 ns218 0 -0.00579421432243
Gc7_219 0 n14 ns219 0 -0.00120236959223
Gc7_220 0 n14 ns220 0 -0.00119059791211
Gc7_221 0 n14 ns221 0 0.000903119180233
Gc7_222 0 n14 ns222 0 0.00246831457115
Gc7_223 0 n14 ns223 0 0.000237506512113
Gc7_224 0 n14 ns224 0 0.018673556568
Gc7_225 0 n14 ns225 0 -0.0267046121713
Gc7_226 0 n14 ns226 0 0.00543309566291
Gc7_227 0 n14 ns227 0 2.62308178542e-06
Gc7_228 0 n14 ns228 0 1.66589772003e-05
Gc7_229 0 n14 ns229 0 -0.00362763185131
Gc7_230 0 n14 ns230 0 -0.00039749786861
Gc7_231 0 n14 ns231 0 -0.000627353822116
Gc7_232 0 n14 ns232 0 0.000571997068955
Gc7_233 0 n14 ns233 0 -0.000374769902909
Gc7_234 0 n14 ns234 0 0.000324719092779
Gc7_235 0 n14 ns235 0 -0.000159926380145
Gc7_236 0 n14 ns236 0 -0.000202614063853
Gc7_237 0 n14 ns237 0 -6.65479211154e-05
Gc7_238 0 n14 ns238 0 -0.00392867584311
Gc7_239 0 n14 ns239 0 0.00101421587555
Gc7_240 0 n14 ns240 0 0.0015132658528
Gc7_241 0 n14 ns241 0 0.000205862394475
Gc7_242 0 n14 ns242 0 0.000519662860408
Gc7_243 0 n14 ns243 0 -0.00065202352086
Gc7_244 0 n14 ns244 0 0.000129810366462
Gc7_245 0 n14 ns245 0 0.00047148829215
Gc7_246 0 n14 ns246 0 3.77681860948e-05
Gc7_247 0 n14 ns247 0 0.000527699639899
Gc7_248 0 n14 ns248 0 0.000630471622479
Gc7_249 0 n14 ns249 0 0.00031920978014
Gc7_250 0 n14 ns250 0 -0.000267933200622
Gc7_251 0 n14 ns251 0 0.000345090875809
Gc7_252 0 n14 ns252 0 0.00112852217775
Gc7_253 0 n14 ns253 0 0.00338292695696
Gc7_254 0 n14 ns254 0 0.00159476959064
Gc7_255 0 n14 ns255 0 -0.00237768011861
Gc7_256 0 n14 ns256 0 -0.00150245308129
Gc7_257 0 n14 ns257 0 -0.00285276392119
Gc7_258 0 n14 ns258 0 0.00214352920056
Gc7_259 0 n14 ns259 0 0.00205363658978
Gc7_260 0 n14 ns260 0 0.00331089379295
Gc7_261 0 n14 ns261 0 1.97893238597e-05
Gc7_262 0 n14 ns262 0 -0.0277010298563
Gc7_263 0 n14 ns263 0 0.0265047521224
Gc7_264 0 n14 ns264 0 0.00688653542759
Gc7_265 0 n14 ns265 0 1.14037648988e-05
Gc7_266 0 n14 ns266 0 2.81372195045e-05
Gc7_267 0 n14 ns267 0 -0.00219425717887
Gc7_268 0 n14 ns268 0 -0.00113254439591
Gc7_269 0 n14 ns269 0 0.00287919427405
Gc7_270 0 n14 ns270 0 0.000343241967264
Gc7_271 0 n14 ns271 0 -0.000540660058108
Gc7_272 0 n14 ns272 0 0.000380764482041
Gc7_273 0 n14 ns273 0 0.000375141170469
Gc7_274 0 n14 ns274 0 -0.00018460458529
Gc7_275 0 n14 ns275 0 -6.25327960114e-05
Gc7_276 0 n14 ns276 0 -0.000705050767546
Gc7_277 0 n14 ns277 0 0.000133132475962
Gc7_278 0 n14 ns278 0 0.000537177424091
Gc7_279 0 n14 ns279 0 0.000137065520159
Gc7_280 0 n14 ns280 0 0.000498025771125
Gc7_281 0 n14 ns281 0 -0.000440428279176
Gc7_282 0 n14 ns282 0 0.00115057118658
Gc7_283 0 n14 ns283 0 -0.00169812046173
Gc7_284 0 n14 ns284 0 -0.000796481252858
Gc7_285 0 n14 ns285 0 -0.000527520009184
Gc7_286 0 n14 ns286 0 0.000289054820633
Gc7_287 0 n14 ns287 0 0.000358323782691
Gc7_288 0 n14 ns288 0 -0.0035781015723
Gc7_289 0 n14 ns289 0 -0.00186926853517
Gc7_290 0 n14 ns290 0 -4.55502222346e-05
Gc7_291 0 n14 ns291 0 0.00157369399054
Gc7_292 0 n14 ns292 0 0.00136028746894
Gc7_293 0 n14 ns293 0 -0.00141634655742
Gc7_294 0 n14 ns294 0 -0.00533764801463
Gc7_295 0 n14 ns295 0 -0.00145099100123
Gc7_296 0 n14 ns296 0 -0.00148547242774
Gc7_297 0 n14 ns297 0 0.000736711595207
Gc7_298 0 n14 ns298 0 0.00249798681883
Gc7_299 0 n14 ns299 0 0.000376736723174
Gc7_300 0 n14 ns300 0 0.0207304722819
Gc7_301 0 n14 ns301 0 -0.0284076960894
Gc7_302 0 n14 ns302 0 0.00551433553505
Gc7_303 0 n14 ns303 0 2.13211798997e-06
Gc7_304 0 n14 ns304 0 3.44584118492e-05
Gc7_305 0 n14 ns305 0 -0.001165898476
Gc7_306 0 n14 ns306 0 0.000771264234973
Gc7_307 0 n14 ns307 0 -0.00100196392281
Gc7_308 0 n14 ns308 0 0.00072687242756
Gc7_309 0 n14 ns309 0 -0.00068269870125
Gc7_310 0 n14 ns310 0 0.000506228774622
Gc7_311 0 n14 ns311 0 -0.000369859998009
Gc7_312 0 n14 ns312 0 -5.48346111867e-05
Gc7_313 0 n14 ns313 0 -1.22435561402e-05
Gc7_314 0 n14 ns314 0 -0.0027563870851
Gc7_315 0 n14 ns315 0 0.000400629004543
Gc7_316 0 n14 ns316 0 0.000110977578587
Gc7_317 0 n14 ns317 0 -0.000664891282251
Gc7_318 0 n14 ns318 0 0.000251128798944
Gc7_319 0 n14 ns319 0 -0.000245140990479
Gc7_320 0 n14 ns320 0 -0.0020811560343
Gc7_321 0 n14 ns321 0 0.00204596253214
Gc7_322 0 n14 ns322 0 0.000522369560896
Gc7_323 0 n14 ns323 0 -0.000530413994459
Gc7_324 0 n14 ns324 0 0.000289799452876
Gc7_325 0 n14 ns325 0 8.82137613944e-05
Gc7_326 0 n14 ns326 0 0.000679323533572
Gc7_327 0 n14 ns327 0 0.0038848540386
Gc7_328 0 n14 ns328 0 -9.55917164384e-05
Gc7_329 0 n14 ns329 0 -0.000241886625308
Gc7_330 0 n14 ns330 0 0.000483840015892
Gc7_331 0 n14 ns331 0 -0.000674806015164
Gc7_332 0 n14 ns332 0 0.00319582405365
Gc7_333 0 n14 ns333 0 0.00189329559282
Gc7_334 0 n14 ns334 0 -0.00212939140819
Gc7_335 0 n14 ns335 0 3.69553240638e-05
Gc7_336 0 n14 ns336 0 0.0013136290047
Gc7_337 0 n14 ns337 0 -3.56394731002e-05
Gc7_338 0 n14 ns338 0 0.0413926584273
Gc7_339 0 n14 ns339 0 -0.0392548270082
Gc7_340 0 n14 ns340 0 0.00261420254441
Gc7_341 0 n14 ns341 0 -2.40109501957e-06
Gc7_342 0 n14 ns342 0 2.27390768535e-05
Gc7_343 0 n14 ns343 0 8.53045292599e-05
Gc7_344 0 n14 ns344 0 -0.000282271482133
Gc7_345 0 n14 ns345 0 -5.60458074627e-05
Gc7_346 0 n14 ns346 0 -6.57854700886e-05
Gc7_347 0 n14 ns347 0 4.28595899967e-05
Gc7_348 0 n14 ns348 0 -2.56799131396e-05
Gc7_349 0 n14 ns349 0 4.2394128161e-05
Gc7_350 0 n14 ns350 0 1.21807955833e-05
Gc7_351 0 n14 ns351 0 3.00424201744e-05
Gc7_352 0 n14 ns352 0 1.85039088615e-05
Gc7_353 0 n14 ns353 0 0.000320259459295
Gc7_354 0 n14 ns354 0 0.000329770971799
Gc7_355 0 n14 ns355 0 -0.00018905823331
Gc7_356 0 n14 ns356 0 -0.0002064960899
Gc7_357 0 n14 ns357 0 -8.73925144304e-05
Gc7_358 0 n14 ns358 0 -0.000484058325777
Gc7_359 0 n14 ns359 0 -0.000478037558763
Gc7_360 0 n14 ns360 0 0.000141244011942
Gc7_361 0 n14 ns361 0 0.000627766446577
Gc7_362 0 n14 ns362 0 0.000129210409248
Gc7_363 0 n14 ns363 0 -0.0001390298894
Gc7_364 0 n14 ns364 0 -0.00017142597021
Gc7_365 0 n14 ns365 0 0.000680883473021
Gc7_366 0 n14 ns366 0 0.000969918845695
Gc7_367 0 n14 ns367 0 0.000315075615488
Gc7_368 0 n14 ns368 0 -0.000557152608195
Gc7_369 0 n14 ns369 0 -0.000515104028395
Gc7_370 0 n14 ns370 0 -0.000411885321591
Gc7_371 0 n14 ns371 0 0.00035016489073
Gc7_372 0 n14 ns372 0 0.000470924684175
Gc7_373 0 n14 ns373 0 0.00074681984692
Gc7_374 0 n14 ns374 0 0.000229678637406
Gc7_375 0 n14 ns375 0 -0.000510077795565
Gc7_376 0 n14 ns376 0 0.0120900902286
Gc7_377 0 n14 ns377 0 -0.0110619168034
Gc7_378 0 n14 ns378 0 0.000522217324144
Gc7_379 0 n14 ns379 0 -3.13359514569e-06
Gc7_380 0 n14 ns380 0 -3.27280097993e-05
Gc7_381 0 n14 ns381 0 -0.000690152585441
Gc7_382 0 n14 ns382 0 0.00162417503309
Gc7_383 0 n14 ns383 0 -0.00445902916443
Gc7_384 0 n14 ns384 0 -0.000315346308575
Gc7_385 0 n14 ns385 0 -0.000138575044614
Gc7_386 0 n14 ns386 0 -0.000345651195463
Gc7_387 0 n14 ns387 0 3.96971324566e-05
Gc7_388 0 n14 ns388 0 -1.31005694119e-05
Gc7_389 0 n14 ns389 0 3.3041200148e-05
Gc7_390 0 n14 ns390 0 0.000792373315623
Gc7_391 0 n14 ns391 0 0.00152996757793
Gc7_392 0 n14 ns392 0 -0.000117179826715
Gc7_393 0 n14 ns393 0 1.85921437002e-05
Gc7_394 0 n14 ns394 0 -0.000138277030615
Gc7_395 0 n14 ns395 0 -0.000203880048494
Gc7_396 0 n14 ns396 0 0.00106496410852
Gc7_397 0 n14 ns397 0 0.000335274598708
Gc7_398 0 n14 ns398 0 -0.000316486758299
Gc7_399 0 n14 ns399 0 7.13994148826e-05
Gc7_400 0 n14 ns400 0 0.000168071432095
Gc7_401 0 n14 ns401 0 -0.000129533795858
Gc7_402 0 n14 ns402 0 0.0013174953564
Gc7_403 0 n14 ns403 0 0.000341198174514
Gc7_404 0 n14 ns404 0 0.00056013740322
Gc7_405 0 n14 ns405 0 0.000598004688996
Gc7_406 0 n14 ns406 0 -0.00033698043939
Gc7_407 0 n14 ns407 0 -0.000815681886543
Gc7_408 0 n14 ns408 0 0.0012627577741
Gc7_409 0 n14 ns409 0 0.00019627723019
Gc7_410 0 n14 ns410 0 8.19195918471e-05
Gc7_411 0 n14 ns411 0 0.000983704203364
Gc7_412 0 n14 ns412 0 0.000453595577687
Gc7_413 0 n14 ns413 0 -0.000688065457965
Gc7_414 0 n14 ns414 0 0.0287119978076
Gc7_415 0 n14 ns415 0 -0.0254609145508
Gc7_416 0 n14 ns416 0 0.0011142197516
Gc7_417 0 n14 ns417 0 -6.6876635552e-06
Gc7_418 0 n14 ns418 0 -3.11466048746e-05
Gc7_419 0 n14 ns419 0 -0.00116634216246
Gc7_420 0 n14 ns420 0 0.002237824163
Gc7_421 0 n14 ns421 0 -0.00479798051313
Gc7_422 0 n14 ns422 0 -6.10260118068e-05
Gc7_423 0 n14 ns423 0 -0.0002529488613
Gc7_424 0 n14 ns424 0 0.000117633912922
Gc7_425 0 n14 ns425 0 -0.000337540660634
Gc7_426 0 n14 ns426 0 -1.85068928498e-05
Gc7_427 0 n14 ns427 0 1.50821726106e-05
Gc7_428 0 n14 ns428 0 -0.000974079416032
Gc7_429 0 n14 ns429 0 0.00149856094323
Gc7_430 0 n14 ns430 0 -7.08667522665e-05
Gc7_431 0 n14 ns431 0 -0.000355562129091
Gc7_432 0 n14 ns432 0 -3.2999913406e-05
Gc7_433 0 n14 ns433 0 -0.000315953619053
Gc7_434 0 n14 ns434 0 -0.000446883872012
Gc7_435 0 n14 ns435 0 0.00175702650641
Gc7_436 0 n14 ns436 0 0.000125033197046
Gc7_437 0 n14 ns437 0 -0.000176375304566
Gc7_438 0 n14 ns438 0 0.000321760036981
Gc7_439 0 n14 ns439 0 -0.000100220893681
Gc7_440 0 n14 ns440 0 0.00202324342078
Gc7_441 0 n14 ns441 0 0.00284718157451
Gc7_442 0 n14 ns442 0 0.000500581389145
Gc7_443 0 n14 ns443 0 0.000248615607356
Gc7_444 0 n14 ns444 0 -0.000124947611477
Gc7_445 0 n14 ns445 0 -0.00105044722158
Gc7_446 0 n14 ns446 0 0.00365341813869
Gc7_447 0 n14 ns447 0 0.000804241697115
Gc7_448 0 n14 ns448 0 -0.00134202797658
Gc7_449 0 n14 ns449 0 0.000872286975646
Gc7_450 0 n14 ns450 0 0.00104769267535
Gc7_451 0 n14 ns451 0 -0.000530832551094
Gc7_452 0 n14 ns452 0 0.0453491722302
Gc7_453 0 n14 ns453 0 -0.0410514578563
Gc7_454 0 n14 ns454 0 0.00210112410397
Gc7_455 0 n14 ns455 0 -5.33296495537e-06
Gc7_456 0 n14 ns456 0 -1.9700520753e-05
Gc7_457 0 n14 ns457 0 -0.00184202304327
Gc7_458 0 n14 ns458 0 -0.000642603189211
Gc7_459 0 n14 ns459 0 0.00249356163551
Gc7_460 0 n14 ns460 0 0.000663236285398
Gc7_461 0 n14 ns461 0 -0.000336109609093
Gc7_462 0 n14 ns462 0 0.000702875493655
Gc7_463 0 n14 ns463 0 0.000334989444241
Gc7_464 0 n14 ns464 0 -0.000155676139032
Gc7_465 0 n14 ns465 0 -5.41087165676e-05
Gc7_466 0 n14 ns466 0 -0.00146008573377
Gc7_467 0 n14 ns467 0 -0.000521162640066
Gc7_468 0 n14 ns468 0 0.00100019572235
Gc7_469 0 n14 ns469 0 -0.000294840154164
Gc7_470 0 n14 ns470 0 0.000189952757518
Gc7_471 0 n14 ns471 0 -0.000538192717643
Gc7_472 0 n14 ns472 0 -0.00119846953783
Gc7_473 0 n14 ns473 0 -0.00192584882602
Gc7_474 0 n14 ns474 0 -0.000412583309507
Gc7_475 0 n14 ns475 0 0.000321880510324
Gc7_476 0 n14 ns476 0 0.000399601816658
Gc7_477 0 n14 ns477 0 0.000181157963557
Gc7_478 0 n14 ns478 0 -0.00380395711765
Gc7_479 0 n14 ns479 0 0.0015182367463
Gc7_480 0 n14 ns480 0 0.000843440914599
Gc7_481 0 n14 ns481 0 0.00113924175683
Gc7_482 0 n14 ns482 0 0.000549841601641
Gc7_483 0 n14 ns483 0 -0.00151909496507
Gc7_484 0 n14 ns484 0 -0.00221200785744
Gc7_485 0 n14 ns485 0 0.00165508955128
Gc7_486 0 n14 ns486 0 -0.00168004249132
Gc7_487 0 n14 ns487 0 0.000441755891598
Gc7_488 0 n14 ns488 0 0.00200325010221
Gc7_489 0 n14 ns489 0 1.69646517752e-05
Gc7_490 0 n14 ns490 0 0.0413284146446
Gc7_491 0 n14 ns491 0 -0.0443650763137
Gc7_492 0 n14 ns492 0 0.00449371728642
Gc7_493 0 n14 ns493 0 3.12339031554e-06
Gc7_494 0 n14 ns494 0 3.47665035596e-06
Gc7_495 0 n14 ns495 0 -0.00457494130311
Gc7_496 0 n14 ns496 0 -0.000317137140575
Gc7_497 0 n14 ns497 0 -0.00409850727042
Gc7_498 0 n14 ns498 0 -4.96476645717e-05
Gc7_499 0 n14 ns499 0 -0.000874618457549
Gc7_500 0 n14 ns500 0 5.02089162713e-05
Gc7_501 0 n14 ns501 0 0.000348673204685
Gc7_502 0 n14 ns502 0 -8.81560942145e-05
Gc7_503 0 n14 ns503 0 -3.02972062178e-05
Gc7_504 0 n14 ns504 0 -0.00221535314164
Gc7_505 0 n14 ns505 0 0.00188681595925
Gc7_506 0 n14 ns506 0 0.00104261514864
Gc7_507 0 n14 ns507 0 -0.000134248645363
Gc7_508 0 n14 ns508 0 0.000325971240954
Gc7_509 0 n14 ns509 0 -0.00056193555913
Gc7_510 0 n14 ns510 0 2.3807408589e-05
Gc7_511 0 n14 ns511 0 0.000946672051511
Gc7_512 0 n14 ns512 0 0.000299774917481
Gc7_513 0 n14 ns513 0 0.000329363960442
Gc7_514 0 n14 ns514 0 0.000585277106989
Gc7_515 0 n14 ns515 0 0.00019294149833
Gc7_516 0 n14 ns516 0 0.000988730084353
Gc7_517 0 n14 ns517 0 0.00146453776549
Gc7_518 0 n14 ns518 0 0.00118061388025
Gc7_519 0 n14 ns519 0 0.00284061355167
Gc7_520 0 n14 ns520 0 0.0013394147315
Gc7_521 0 n14 ns521 0 -0.00217834807461
Gc7_522 0 n14 ns522 0 0.00187891084725
Gc7_523 0 n14 ns523 0 -0.00169066690574
Gc7_524 0 n14 ns524 0 0.00182909770691
Gc7_525 0 n14 ns525 0 0.00147049649416
Gc7_526 0 n14 ns526 0 0.00306683025707
Gc7_527 0 n14 ns527 0 3.7826086708e-05
Gc7_528 0 n14 ns528 0 -0.0167611794723
Gc7_529 0 n14 ns529 0 0.0191201396033
Gc7_530 0 n14 ns530 0 0.00688912459664
Gc7_531 0 n14 ns531 0 1.92252741962e-07
Gc7_532 0 n14 ns532 0 2.00312130936e-05
Gc7_533 0 n14 ns533 0 -0.0048913112154
Gc7_534 0 n14 ns534 0 -0.000510946271858
Gc7_535 0 n14 ns535 0 -0.00429226558805
Gc7_536 0 n14 ns536 0 0.000233000449011
Gc7_537 0 n14 ns537 0 -0.00131198654885
Gc7_538 0 n14 ns538 0 -0.000275459127696
Gc7_539 0 n14 ns539 0 0.000833064938489
Gc7_540 0 n14 ns540 0 -0.000128589544528
Gc7_541 0 n14 ns541 0 -2.79099384698e-05
Gc7_542 0 n14 ns542 0 3.4310171207e-05
Gc7_543 0 n14 ns543 0 0.00191223614217
Gc7_544 0 n14 ns544 0 0.000519032175784
Gc7_545 0 n14 ns545 0 -0.000135780168761
Gc7_546 0 n14 ns546 0 0.000366103003153
Gc7_547 0 n14 ns547 0 -0.000501894946287
Gc7_548 0 n14 ns548 0 0.00131064359782
Gc7_549 0 n14 ns549 0 -0.000960846059075
Gc7_550 0 n14 ns550 0 -0.000442788326195
Gc7_551 0 n14 ns551 0 -0.000297057332218
Gc7_552 0 n14 ns552 0 0.000398818625596
Gc7_553 0 n14 ns553 0 0.00029186016914
Gc7_554 0 n14 ns554 0 -0.00165346690983
Gc7_555 0 n14 ns555 0 6.38690247224e-05
Gc7_556 0 n14 ns556 0 0.000856893075804
Gc7_557 0 n14 ns557 0 0.00218863615575
Gc7_558 0 n14 ns558 0 0.00129129046986
Gc7_559 0 n14 ns559 0 -0.00193391184146
Gc7_560 0 n14 ns560 0 0.000275302274855
Gc7_561 0 n14 ns561 0 0.000715437030439
Gc7_562 0 n14 ns562 0 9.90998031784e-05
Gc7_563 0 n14 ns563 0 7.05778933331e-05
Gc7_564 0 n14 ns564 0 0.00255584351587
Gc7_565 0 n14 ns565 0 0.000150233455581
Gc7_566 0 n14 ns566 0 0.0247035916385
Gc7_567 0 n14 ns567 0 -0.0241996623644
Gc7_568 0 n14 ns568 0 0.00660910666653
Gc7_569 0 n14 ns569 0 -3.43434288081e-06
Gc7_570 0 n14 ns570 0 2.99280534396e-05
Gc7_571 0 n14 ns571 0 -0.00153960565184
Gc7_572 0 n14 ns572 0 0.000912687458154
Gc7_573 0 n14 ns573 0 -0.00142484041275
Gc7_574 0 n14 ns574 0 0.000682166642811
Gc7_575 0 n14 ns575 0 -0.000756754694197
Gc7_576 0 n14 ns576 0 0.000550378522814
Gc7_577 0 n14 ns577 0 -0.000132979198349
Gc7_578 0 n14 ns578 0 -0.000123179410295
Gc7_579 0 n14 ns579 0 -1.7959251649e-05
Gc7_580 0 n14 ns580 0 -0.00241790592064
Gc7_581 0 n14 ns581 0 0.000424775742856
Gc7_582 0 n14 ns582 0 0.000333138401889
Gc7_583 0 n14 ns583 0 -0.000590602696198
Gc7_584 0 n14 ns584 0 0.000337560944655
Gc7_585 0 n14 ns585 0 -0.000369391843473
Gc7_586 0 n14 ns586 0 -0.00164788265603
Gc7_587 0 n14 ns587 0 0.00103579721437
Gc7_588 0 n14 ns588 0 0.000248679699125
Gc7_589 0 n14 ns589 0 -0.000535356822756
Gc7_590 0 n14 ns590 0 0.000339361445405
Gc7_591 0 n14 ns591 0 0.000163185996485
Gc7_592 0 n14 ns592 0 -0.000559333522302
Gc7_593 0 n14 ns593 0 0.00323598192763
Gc7_594 0 n14 ns594 0 3.4445032856e-05
Gc7_595 0 n14 ns595 0 0.000114933525689
Gc7_596 0 n14 ns596 0 0.000691967471502
Gc7_597 0 n14 ns597 0 -0.000964439624328
Gc7_598 0 n14 ns598 0 0.00207430456856
Gc7_599 0 n14 ns599 0 0.00198532329815
Gc7_600 0 n14 ns600 0 -0.00230081702231
Gc7_601 0 n14 ns601 0 -5.32957353952e-05
Gc7_602 0 n14 ns602 0 0.00166630999826
Gc7_603 0 n14 ns603 0 6.14376957433e-05
Gc7_604 0 n14 ns604 0 0.0471448263067
Gc7_605 0 n14 ns605 0 -0.0462949823527
Gc7_606 0 n14 ns606 0 0.00365338415146
Gc7_607 0 n14 ns607 0 -4.58999617682e-07
Gc7_608 0 n14 ns608 0 2.80897435795e-05
Gc7_609 0 n14 ns609 0 4.46761710962e-05
Gc7_610 0 n14 ns610 0 -0.000411819315651
Gc7_611 0 n14 ns611 0 0.000842174213105
Gc7_612 0 n14 ns612 0 -0.000123153869455
Gc7_613 0 n14 ns613 0 0.000175623596353
Gc7_614 0 n14 ns614 0 1.36762553714e-05
Gc7_615 0 n14 ns615 0 0.000126029459711
Gc7_616 0 n14 ns616 0 4.48384942344e-06
Gc7_617 0 n14 ns617 0 1.50838077581e-05
Gc7_618 0 n14 ns618 0 0.00042241694543
Gc7_619 0 n14 ns619 0 -0.00145969158301
Gc7_620 0 n14 ns620 0 -0.000278735471602
Gc7_621 0 n14 ns621 0 0.000802198065788
Gc7_622 0 n14 ns622 0 0.000273295531356
Gc7_623 0 n14 ns623 0 5.91874534617e-05
Gc7_624 0 n14 ns624 0 -0.00077098965244
Gc7_625 0 n14 ns625 0 9.64653230493e-05
Gc7_626 0 n14 ns626 0 0.000505244360337
Gc7_627 0 n14 ns627 0 0.000285927062477
Gc7_628 0 n14 ns628 0 3.61357123569e-05
Gc7_629 0 n14 ns629 0 -0.000170530962435
Gc7_630 0 n14 ns630 0 0.000251651992846
Gc7_631 0 n14 ns631 0 -0.000779803962637
Gc7_632 0 n14 ns632 0 -0.000874547712955
Gc7_633 0 n14 ns633 0 -4.46660253784e-05
Gc7_634 0 n14 ns634 0 0.000483312665459
Gc7_635 0 n14 ns635 0 0.000293855150232
Gc7_636 0 n14 ns636 0 -0.00141374134693
Gc7_637 0 n14 ns637 0 0.000163942089664
Gc7_638 0 n14 ns638 0 0.000495446384778
Gc7_639 0 n14 ns639 0 0.000507731314393
Gc7_640 0 n14 ns640 0 0.000124625530951
Gc7_641 0 n14 ns641 0 -0.000316016072123
Gc7_642 0 n14 ns642 0 0.000280790156261
Gc7_643 0 n14 ns643 0 -0.000404810167358
Gc7_644 0 n14 ns644 0 -3.71338990617e-05
Gc7_645 0 n14 ns645 0 7.50854250232e-06
Gc7_646 0 n14 ns646 0 -2.53281433412e-05
Gc7_647 0 n14 ns647 0 0.000200971828854
Gc7_648 0 n14 ns648 0 -0.000610211251056
Gc7_649 0 n14 ns649 0 0.00146344782817
Gc7_650 0 n14 ns650 0 -0.000108333040252
Gc7_651 0 n14 ns651 0 0.000200135395889
Gc7_652 0 n14 ns652 0 3.56720040055e-05
Gc7_653 0 n14 ns653 0 0.000100041398695
Gc7_654 0 n14 ns654 0 -3.49962537077e-06
Gc7_655 0 n14 ns655 0 -2.0521746546e-06
Gc7_656 0 n14 ns656 0 0.000572247750289
Gc7_657 0 n14 ns657 0 -0.00146201928814
Gc7_658 0 n14 ns658 0 -0.000409973040256
Gc7_659 0 n14 ns659 0 0.00075457574409
Gc7_660 0 n14 ns660 0 0.000284073301727
Gc7_661 0 n14 ns661 0 9.81299749373e-05
Gc7_662 0 n14 ns662 0 -0.000853049885448
Gc7_663 0 n14 ns663 0 -0.000179779744527
Gc7_664 0 n14 ns664 0 0.000452948182797
Gc7_665 0 n14 ns665 0 0.000458156300735
Gc7_666 0 n14 ns666 0 6.80997275615e-05
Gc7_667 0 n14 ns667 0 -0.000179433578606
Gc7_668 0 n14 ns668 0 0.000172240402588
Gc7_669 0 n14 ns669 0 -0.000961893938015
Gc7_670 0 n14 ns670 0 -0.00109239548775
Gc7_671 0 n14 ns671 0 -0.000106873641173
Gc7_672 0 n14 ns672 0 0.000600551389928
Gc7_673 0 n14 ns673 0 0.000411635321704
Gc7_674 0 n14 ns674 0 -0.00205214603667
Gc7_675 0 n14 ns675 0 5.20432410008e-05
Gc7_676 0 n14 ns676 0 0.000629069565982
Gc7_677 0 n14 ns677 0 0.000749389175339
Gc7_678 0 n14 ns678 0 0.000190031963798
Gc7_679 0 n14 ns679 0 -0.000408456549039
Gc7_680 0 n14 ns680 0 -0.00151740997669
Gc7_681 0 n14 ns681 0 0.00102241029256
Gc7_682 0 n14 ns682 0 -8.15523391208e-05
Gc7_683 0 n14 ns683 0 6.06126841847e-06
Gc7_684 0 n14 ns684 0 -2.84743880961e-05
Gc7_685 0 n14 ns685 0 0.000592386538946
Gc7_686 0 n14 ns686 0 -0.000753625372158
Gc7_687 0 n14 ns687 0 0.00341036659114
Gc7_688 0 n14 ns688 0 -0.000174774505189
Gc7_689 0 n14 ns689 0 0.000332702328655
Gc7_690 0 n14 ns690 0 0.000255572718558
Gc7_691 0 n14 ns691 0 -3.85646646501e-05
Gc7_692 0 n14 ns692 0 3.59931737106e-06
Gc7_693 0 n14 ns693 0 -4.82389632269e-05
Gc7_694 0 n14 ns694 0 0.000488312077191
Gc7_695 0 n14 ns695 0 -0.00055184312689
Gc7_696 0 n14 ns696 0 -0.000403255643547
Gc7_697 0 n14 ns697 0 -2.37772270813e-05
Gc7_698 0 n14 ns698 0 0.000131207897135
Gc7_699 0 n14 ns699 0 0.000181800350499
Gc7_700 0 n14 ns700 0 -1.36628406885e-05
Gc7_701 0 n14 ns701 0 -0.00123982694294
Gc7_702 0 n14 ns702 0 -0.000405825587166
Gc7_703 0 n14 ns703 0 0.000674497731373
Gc7_704 0 n14 ns704 0 0.000133913767658
Gc7_705 0 n14 ns705 0 -5.01244585609e-05
Gc7_706 0 n14 ns706 0 -0.0003175357225
Gc7_707 0 n14 ns707 0 -0.00140479369742
Gc7_708 0 n14 ns708 0 -0.00136359822569
Gc7_709 0 n14 ns709 0 -0.000596592313114
Gc7_710 0 n14 ns710 0 0.000661684794196
Gc7_711 0 n14 ns711 0 0.000893941448664
Gc7_712 0 n14 ns712 0 -0.00416837078724
Gc7_713 0 n14 ns713 0 -0.0012559987963
Gc7_714 0 n14 ns714 0 0.000635648637507
Gc7_715 0 n14 ns715 0 0.00186565553775
Gc7_716 0 n14 ns716 0 0.000605757452498
Gc7_717 0 n14 ns717 0 -0.000621028849958
Gc7_718 0 n14 ns718 0 -0.0114874559208
Gc7_719 0 n14 ns719 0 0.00913179542564
Gc7_720 0 n14 ns720 0 -0.000325787718639
Gc7_721 0 n14 ns721 0 3.58996822933e-06
Gc7_722 0 n14 ns722 0 -3.48132949698e-05
Gc7_723 0 n14 ns723 0 0.000513058735154
Gc7_724 0 n14 ns724 0 -0.000959057965437
Gc7_725 0 n14 ns725 0 0.00582622398973
Gc7_726 0 n14 ns726 0 -7.44787761152e-05
Gc7_727 0 n14 ns727 0 0.000337725427245
Gc7_728 0 n14 ns728 0 0.000372479815793
Gc7_729 0 n14 ns729 0 0.000137172561652
Gc7_730 0 n14 ns730 0 2.58744253015e-05
Gc7_731 0 n14 ns731 0 -6.84774690685e-06
Gc7_732 0 n14 ns732 0 -0.00063836873685
Gc7_733 0 n14 ns733 0 -0.00156919915974
Gc7_734 0 n14 ns734 0 0.000297816388553
Gc7_735 0 n14 ns735 0 0.000135566367094
Gc7_736 0 n14 ns736 0 0.000147929102605
Gc7_737 0 n14 ns737 0 0.000240233304788
Gc7_738 0 n14 ns738 0 0.000986231399973
Gc7_739 0 n14 ns739 0 -0.000609823004658
Gc7_740 0 n14 ns740 0 -0.000956138328159
Gc7_741 0 n14 ns741 0 -8.56563792287e-05
Gc7_742 0 n14 ns742 0 8.99300938386e-05
Gc7_743 0 n14 ns743 0 1.55293328491e-05
Gc7_744 0 n14 ns744 0 -0.00116387673406
Gc7_745 0 n14 ns745 0 -0.00243920782206
Gc7_746 0 n14 ns746 0 -0.00108256528395
Gc7_747 0 n14 ns747 0 -0.000949491417983
Gc7_748 0 n14 ns748 0 0.000362418492824
Gc7_749 0 n14 ns749 0 0.00134572432776
Gc7_750 0 n14 ns750 0 -0.00612739344872
Gc7_751 0 n14 ns751 0 -0.00359527232762
Gc7_752 0 n14 ns752 0 -0.000132519956283
Gc7_753 0 n14 ns753 0 0.00325262488581
Gc7_754 0 n14 ns754 0 0.00133270765274
Gc7_755 0 n14 ns755 0 -0.000680242925965
Gc7_756 0 n14 ns756 0 -0.0310280484481
Gc7_757 0 n14 ns757 0 0.0260072066582
Gc7_758 0 n14 ns758 0 -0.00103176680947
Gc7_759 0 n14 ns759 0 -4.11399391982e-06
Gc7_760 0 n14 ns760 0 -2.89252456222e-05
Gc7_761 0 n14 ns761 0 0.0007855672834
Gc7_762 0 n14 ns762 0 -0.000799295608929
Gc7_763 0 n14 ns763 0 0.0102711095846
Gc7_764 0 n14 ns764 0 1.52965702474e-05
Gc7_765 0 n14 ns765 0 0.000737817661205
Gc7_766 0 n14 ns766 0 0.000414778300729
Gc7_767 0 n14 ns767 0 -0.00012517937415
Gc7_768 0 n14 ns768 0 -8.57709300301e-05
Gc7_769 0 n14 ns769 0 -1.07794926238e-05
Gc7_770 0 n14 ns770 0 0.000144658848785
Gc7_771 0 n14 ns771 0 -0.00445434112738
Gc7_772 0 n14 ns772 0 0.000119370853529
Gc7_773 0 n14 ns773 0 0.00121037257943
Gc7_774 0 n14 ns774 0 0.000176701195663
Gc7_775 0 n14 ns775 0 0.000454063200449
Gc7_776 0 n14 ns776 0 -0.00114585867085
Gc7_777 0 n14 ns777 0 -0.000632613895481
Gc7_778 0 n14 ns778 0 -0.000403514226041
Gc7_779 0 n14 ns779 0 -6.21163769397e-06
Gc7_780 0 n14 ns780 0 0.000293392081879
Gc7_781 0 n14 ns781 0 6.02100949284e-05
Gc7_782 0 n14 ns782 0 -0.00223519707495
Gc7_783 0 n14 ns783 0 -0.00495443903018
Gc7_784 0 n14 ns784 0 -0.00156883682537
Gc7_785 0 n14 ns785 0 -9.33064948434e-05
Gc7_786 0 n14 ns786 0 0.000442538314974
Gc7_787 0 n14 ns787 0 0.00151927892821
Gc7_788 0 n14 ns788 0 -0.00902438653204
Gc7_789 0 n14 ns789 0 -0.00539723322792
Gc7_790 0 n14 ns790 0 -0.00157269655183
Gc7_791 0 n14 ns791 0 0.00385789854693
Gc7_792 0 n14 ns792 0 0.00230059765139
Gc7_793 0 n14 ns793 0 -0.00031336318432
Gc7_794 0 n14 ns794 0 -0.0701110408008
Gc7_795 0 n14 ns795 0 0.0610892893357
Gc7_796 0 n14 ns796 0 -0.00291082802618
Gc7_797 0 n14 ns797 0 -9.75554941266e-06
Gc7_798 0 n14 ns798 0 -1.28814920861e-05
Gc7_799 0 n14 ns799 0 -0.000312874550907
Gc7_800 0 n14 ns800 0 -0.000432256419049
Gc7_801 0 n14 ns801 0 0.00698990879073
Gc7_802 0 n14 ns802 0 -0.00111851060095
Gc7_803 0 n14 ns803 0 -0.000489361880925
Gc7_804 0 n14 ns804 0 0.0017903692016
Gc7_805 0 n14 ns805 0 0.000462228464244
Gc7_806 0 n14 ns806 0 -0.000182741025851
Gc7_807 0 n14 ns807 0 -0.000170214275004
Gc7_808 0 n14 ns808 0 0.00221109823744
Gc7_809 0 n14 ns809 0 -0.00266726542931
Gc7_810 0 n14 ns810 0 -0.000853773468273
Gc7_811 0 n14 ns811 0 0.000988547075967
Gc7_812 0 n14 ns812 0 -6.46534213287e-05
Gc7_813 0 n14 ns813 0 0.000572982868666
Gc7_814 0 n14 ns814 0 -0.000543474700605
Gc7_815 0 n14 ns815 0 -0.00370427210673
Gc7_816 0 n14 ns816 0 -0.000983954968104
Gc7_817 0 n14 ns817 0 0.000437724691973
Gc7_818 0 n14 ns818 0 0.000347360262101
Gc7_819 0 n14 ns819 0 0.000371321468062
Gc7_820 0 n14 ns820 0 0.000898134554953
Gc7_821 0 n14 ns821 0 -0.00548147129953
Gc7_822 0 n14 ns822 0 -0.00299293708009
Gc7_823 0 n14 ns823 0 -0.00107895496814
Gc7_824 0 n14 ns824 0 0.000184258587436
Gc7_825 0 n14 ns825 0 0.00231995557809
Gc7_826 0 n14 ns826 0 -0.0130111704046
Gc7_827 0 n14 ns827 0 -0.00588988550717
Gc7_828 0 n14 ns828 0 -0.000948980071206
Gc7_829 0 n14 ns829 0 0.00316687963164
Gc7_830 0 n14 ns830 0 0.00313369422907
Gc7_831 0 n14 ns831 0 0.0002613901236
Gc7_832 0 n14 ns832 0 -0.0733840452509
Gc7_833 0 n14 ns833 0 0.0691824700535
Gc7_834 0 n14 ns834 0 -0.0065112116802
Gc7_835 0 n14 ns835 0 -9.96245095336e-06
Gc7_836 0 n14 ns836 0 1.57507067953e-05
Gc7_837 0 n14 ns837 0 -0.0170654306033
Gc7_838 0 n14 ns838 0 -0.00132130498683
Gc7_839 0 n14 ns839 0 0.0213277216648
Gc7_840 0 n14 ns840 0 0.00645963908129
Gc7_841 0 n14 ns841 0 0.0101756531989
Gc7_842 0 n14 ns842 0 0.00151109719317
Gc7_843 0 n14 ns843 0 -0.00342166047413
Gc7_844 0 n14 ns844 0 -0.000531869203785
Gc7_845 0 n14 ns845 0 1.15678728554e-05
Gc7_846 0 n14 ns846 0 -0.00133137052752
Gc7_847 0 n14 ns847 0 -0.0139885335987
Gc7_848 0 n14 ns848 0 0.00108428616689
Gc7_849 0 n14 ns849 0 0.00156263541786
Gc7_850 0 n14 ns850 0 9.63937193564e-05
Gc7_851 0 n14 ns851 0 0.00043546494241
Gc7_852 0 n14 ns852 0 0.000467961047276
Gc7_853 0 n14 ns853 0 -3.9584837546e-05
Gc7_854 0 n14 ns854 0 -0.000426792267268
Gc7_855 0 n14 ns855 0 0.000592847081983
Gc7_856 0 n14 ns856 0 0.000559653389746
Gc7_857 0 n14 ns857 0 0.000479382815867
Gc7_858 0 n14 ns858 0 -0.0119887495307
Gc7_859 0 n14 ns859 0 -0.00752864964175
Gc7_860 0 n14 ns860 0 -0.0033084515358
Gc7_861 0 n14 ns861 0 -0.00149216017936
Gc7_862 0 n14 ns862 0 -0.000129721393491
Gc7_863 0 n14 ns863 0 0.00258196348708
Gc7_864 0 n14 ns864 0 0.00784284334357
Gc7_865 0 n14 ns865 0 -0.00613955313303
Gc7_866 0 n14 ns866 0 0.00169721622898
Gc7_867 0 n14 ns867 0 0.00216255184582
Gc7_868 0 n14 ns868 0 0.00342486086007
Gc7_869 0 n14 ns869 0 3.10305914679e-05
Gc7_870 0 n14 ns870 0 -0.112786000308
Gc7_871 0 n14 ns871 0 0.0739894041658
Gc7_872 0 n14 ns872 0 -0.00891191451716
Gc7_873 0 n14 ns873 0 -1.30381332801e-05
Gc7_874 0 n14 ns874 0 2.43299356349e-05
Gc7_875 0 n14 ns875 0 -0.000499778510398
Gc7_876 0 n14 ns876 0 0.000497711408963
Gc7_877 0 n14 ns877 0 0.00502297793652
Gc7_878 0 n14 ns878 0 -0.00129833975999
Gc7_879 0 n14 ns879 0 -0.000554005087756
Gc7_880 0 n14 ns880 0 0.00187471145928
Gc7_881 0 n14 ns881 0 0.000525891056576
Gc7_882 0 n14 ns882 0 -0.000158686754067
Gc7_883 0 n14 ns883 0 -0.000180747305625
Gc7_884 0 n14 ns884 0 0.00127117564478
Gc7_885 0 n14 ns885 0 -0.00137489136714
Gc7_886 0 n14 ns886 0 -8.76165552671e-05
Gc7_887 0 n14 ns887 0 0.000423121455826
Gc7_888 0 n14 ns888 0 -0.000326732997779
Gc7_889 0 n14 ns889 0 0.000353247575047
Gc7_890 0 n14 ns890 0 0.000533240832549
Gc7_891 0 n14 ns891 0 -0.00304877547278
Gc7_892 0 n14 ns892 0 -0.00132442442472
Gc7_893 0 n14 ns893 0 -0.000281426959182
Gc7_894 0 n14 ns894 0 0.000226986758048
Gc7_895 0 n14 ns895 0 0.000512201582192
Gc7_896 0 n14 ns896 0 0.000953070867644
Gc7_897 0 n14 ns897 0 -0.0046237477704
Gc7_898 0 n14 ns898 0 -0.00194882886956
Gc7_899 0 n14 ns899 0 -0.0011080884898
Gc7_900 0 n14 ns900 0 -0.000420333291274
Gc7_901 0 n14 ns901 0 0.00201736349907
Gc7_902 0 n14 ns902 0 -0.0110129898496
Gc7_903 0 n14 ns903 0 -0.00583608134575
Gc7_904 0 n14 ns904 0 -0.00152658052275
Gc7_905 0 n14 ns905 0 0.0027096867906
Gc7_906 0 n14 ns906 0 0.00309459618558
Gc7_907 0 n14 ns907 0 0.000479317707924
Gc7_908 0 n14 ns908 0 -0.068139426088
Gc7_909 0 n14 ns909 0 0.0651371519074
Gc7_910 0 n14 ns910 0 -0.00643572639856
Gc7_911 0 n14 ns911 0 -1.31736906093e-05
Gc7_912 0 n14 ns912 0 3.19204741877e-05
Gc7_913 0 n14 ns913 0 0.00064197667708
Gc7_914 0 n14 ns914 0 -0.00059475472316
Gc7_915 0 n14 ns915 0 0.00929949064344
Gc7_916 0 n14 ns916 0 0.00032992110096
Gc7_917 0 n14 ns917 0 0.000224405520364
Gc7_918 0 n14 ns918 0 5.49319434793e-05
Gc7_919 0 n14 ns919 0 -0.000186310360177
Gc7_920 0 n14 ns920 0 -0.000116243379571
Gc7_921 0 n14 ns921 0 3.30277244384e-05
Gc7_922 0 n14 ns922 0 -0.000609045059652
Gc7_923 0 n14 ns923 0 -0.00374319435272
Gc7_924 0 n14 ns924 0 0.000610484797188
Gc7_925 0 n14 ns925 0 0.00117637545776
Gc7_926 0 n14 ns926 0 -1.74055936413e-05
Gc7_927 0 n14 ns927 0 0.00021877951568
Gc7_928 0 n14 ns928 0 -0.00119914391935
Gc7_929 0 n14 ns929 0 0.00056095600489
Gc7_930 0 n14 ns930 0 -6.40140466573e-05
Gc7_931 0 n14 ns931 0 -0.000767418938576
Gc7_932 0 n14 ns932 0 0.000148977404176
Gc7_933 0 n14 ns933 0 0.000145151987271
Gc7_934 0 n14 ns934 0 -0.00265271404831
Gc7_935 0 n14 ns935 0 -0.00410131339398
Gc7_936 0 n14 ns936 0 -0.000316519866143
Gc7_937 0 n14 ns937 0 0.000702327809411
Gc7_938 0 n14 ns938 0 -0.000120632379423
Gc7_939 0 n14 ns939 0 0.000695194540281
Gc7_940 0 n14 ns940 0 -0.00652408348366
Gc7_941 0 n14 ns941 0 -0.00453726821319
Gc7_942 0 n14 ns942 0 -0.00230936945931
Gc7_943 0 n14 ns943 0 0.00275210123271
Gc7_944 0 n14 ns944 0 0.00213968961065
Gc7_945 0 n14 ns945 0 0.000123408376537
Gc7_946 0 n14 ns946 0 -0.0655171878675
Gc7_947 0 n14 ns947 0 0.0577381543793
Gc7_948 0 n14 ns948 0 -0.00292335766341
Gc7_949 0 n14 ns949 0 -7.47669228185e-06
Gc7_950 0 n14 ns950 0 2.01186810583e-05
Gc7_951 0 n14 ns951 0 0.000526913501405
Gc7_952 0 n14 ns952 0 -0.000610962572218
Gc7_953 0 n14 ns953 0 0.00273138440492
Gc7_954 0 n14 ns954 0 -0.000167841408547
Gc7_955 0 n14 ns955 0 0.000339868512056
Gc7_956 0 n14 ns956 0 0.000187364016632
Gc7_957 0 n14 ns957 0 -2.49695094608e-06
Gc7_958 0 n14 ns958 0 -1.2796158599e-05
Gc7_959 0 n14 ns959 0 -4.05224005643e-05
Gc7_960 0 n14 ns960 0 0.000710704150049
Gc7_961 0 n14 ns961 0 -0.000966635219176
Gc7_962 0 n14 ns962 0 -0.000495187606311
Gc7_963 0 n14 ns963 0 0.000316275414625
Gc7_964 0 n14 ns964 0 0.000191887311681
Gc7_965 0 n14 ns965 0 0.000152059558582
Gc7_966 0 n14 ns966 0 -0.000451518983968
Gc7_967 0 n14 ns967 0 -0.000971805037128
Gc7_968 0 n14 ns968 0 -4.20480730037e-05
Gc7_969 0 n14 ns969 0 0.000668136522657
Gc7_970 0 n14 ns970 0 0.00011111228725
Gc7_971 0 n14 ns971 0 -0.000103402545051
Gc7_972 0 n14 ns972 0 -0.00018249122646
Gc7_973 0 n14 ns973 0 -0.00134851568059
Gc7_974 0 n14 ns974 0 -0.00136860238423
Gc7_975 0 n14 ns975 0 -0.000338696897503
Gc7_976 0 n14 ns976 0 0.000712066426725
Gc7_977 0 n14 ns977 0 0.000695527163344
Gc7_978 0 n14 ns978 0 -0.00356695999615
Gc7_979 0 n14 ns979 0 -0.000717066849652
Gc7_980 0 n14 ns980 0 0.000687851394362
Gc7_981 0 n14 ns981 0 0.00146260702782
Gc7_982 0 n14 ns982 0 0.000455189891803
Gc7_983 0 n14 ns983 0 -0.000547785907769
Gc7_984 0 n14 ns984 0 -0.00771619607738
Gc7_985 0 n14 ns985 0 0.005963812088
Gc7_986 0 n14 ns986 0 -0.00020756873569
Gc7_987 0 n14 ns987 0 5.58585685021e-06
Gc7_988 0 n14 ns988 0 -3.1966980899e-05
Gc7_989 0 n14 ns989 0 0.000518128311804
Gc7_990 0 n14 ns990 0 -0.000608899448517
Gc7_991 0 n14 ns991 0 0.00423812797828
Gc7_992 0 n14 ns992 0 -0.000331306554628
Gc7_993 0 n14 ns993 0 0.000451672385759
Gc7_994 0 n14 ns994 0 0.00042979608543
Gc7_995 0 n14 ns995 0 7.16815999059e-05
Gc7_996 0 n14 ns996 0 2.98821571914e-05
Gc7_997 0 n14 ns997 0 -3.00404007794e-05
Gc7_998 0 n14 ns998 0 -8.75164175038e-05
Gc7_999 0 n14 ns999 0 -0.000759102573567
Gc7_1000 0 n14 ns1000 0 1.48122521756e-05
Gc7_1001 0 n14 ns1001 0 -9.19010203454e-05
Gc7_1002 0 n14 ns1002 0 0.000119595455856
Gc7_1003 0 n14 ns1003 0 0.000194565531672
Gc7_1004 0 n14 ns1004 0 0.000952920520702
Gc7_1005 0 n14 ns1005 0 -0.000983564582591
Gc7_1006 0 n14 ns1006 0 -0.000876552825057
Gc7_1007 0 n14 ns1007 0 0.000191791753314
Gc7_1008 0 n14 ns1008 0 8.3376741937e-05
Gc7_1009 0 n14 ns1009 0 6.87807821515e-06
Gc7_1010 0 n14 ns1010 0 -0.000585896054989
Gc7_1011 0 n14 ns1011 0 -0.00190962421534
Gc7_1012 0 n14 ns1012 0 -0.00118329105366
Gc7_1013 0 n14 ns1013 0 -0.000992578019232
Gc7_1014 0 n14 ns1014 0 0.000436432171538
Gc7_1015 0 n14 ns1015 0 0.0012238103217
Gc7_1016 0 n14 ns1016 0 -0.00518905272683
Gc7_1017 0 n14 ns1017 0 -0.00278606373499
Gc7_1018 0 n14 ns1018 0 0.000228594889509
Gc7_1019 0 n14 ns1019 0 0.00274632561067
Gc7_1020 0 n14 ns1020 0 0.00101845271875
Gc7_1021 0 n14 ns1021 0 -0.000687288980806
Gc7_1022 0 n14 ns1022 0 -0.0213944855694
Gc7_1023 0 n14 ns1023 0 0.0177064538974
Gc7_1024 0 n14 ns1024 0 -0.000683979601312
Gc7_1025 0 n14 ns1025 0 -1.02673631656e-06
Gc7_1026 0 n14 ns1026 0 -3.28754287618e-05
Gc7_1027 0 n14 ns1027 0 0.000714323334425
Gc7_1028 0 n14 ns1028 0 -0.00169181794785
Gc7_1029 0 n14 ns1029 0 0.00918700838295
Gc7_1030 0 n14 ns1030 0 0.000225139446123
Gc7_1031 0 n14 ns1031 0 0.000265735252225
Gc7_1032 0 n14 ns1032 0 0.000150420196661
Gc7_1033 0 n14 ns1033 0 0.000152082210516
Gc7_1034 0 n14 ns1034 0 -1.11038792308e-05
Gc7_1035 0 n14 ns1035 0 5.45213194237e-06
Gc7_1036 0 n14 ns1036 0 -0.000472565857196
Gc7_1037 0 n14 ns1037 0 -0.00336555848543
Gc7_1038 0 n14 ns1038 0 0.000251142746737
Gc7_1039 0 n14 ns1039 0 0.000823438543812
Gc7_1040 0 n14 ns1040 0 0.000192669150858
Gc7_1041 0 n14 ns1041 0 0.000381094389643
Gc7_1042 0 n14 ns1042 0 -0.000188695430531
Gc7_1043 0 n14 ns1043 0 -7.66425523595e-05
Gc7_1044 0 n14 ns1044 0 -0.000519454186107
Gc7_1045 0 n14 ns1045 0 -0.000232905416908
Gc7_1046 0 n14 ns1046 0 0.000183946241279
Gc7_1047 0 n14 ns1047 0 -1.2236867917e-05
Gc7_1048 0 n14 ns1048 0 -0.00205063705102
Gc7_1049 0 n14 ns1049 0 -0.00371130466289
Gc7_1050 0 n14 ns1050 0 -0.00106212069168
Gc7_1051 0 n14 ns1051 0 -0.000383392185557
Gc7_1052 0 n14 ns1052 0 0.000318848272741
Gc7_1053 0 n14 ns1053 0 0.00134250807235
Gc7_1054 0 n14 ns1054 0 -0.0074294228932
Gc7_1055 0 n14 ns1055 0 -0.00479229655514
Gc7_1056 0 n14 ns1056 0 -0.00115996302569
Gc7_1057 0 n14 ns1057 0 0.00373609914077
Gc7_1058 0 n14 ns1058 0 0.00192848759324
Gc7_1059 0 n14 ns1059 0 -0.000461312417395
Gc7_1060 0 n14 ns1060 0 -0.0532865501877
Gc7_1061 0 n14 ns1061 0 0.0457799958981
Gc7_1062 0 n14 ns1062 0 -0.00199491228112
Gc7_1063 0 n14 ns1063 0 -8.50704328876e-06
Gc7_1064 0 n14 ns1064 0 -2.36217411066e-05
Gc7_1065 0 n14 ns1065 0 0.000200390669345
Gc7_1066 0 n14 ns1066 0 -0.00108591755024
Gc7_1067 0 n14 ns1067 0 0.00986692191383
Gc7_1068 0 n14 ns1068 0 -0.000248163852592
Gc7_1069 0 n14 ns1069 0 0.000174922735808
Gc7_1070 0 n14 ns1070 0 0.000484301478559
Gc7_1071 0 n14 ns1071 0 -0.000510702737249
Gc7_1072 0 n14 ns1072 0 -8.36376225912e-05
Gc7_1073 0 n14 ns1073 0 3.36677479054e-05
Gc7_1074 0 n14 ns1074 0 0.00202294121237
Gc7_1075 0 n14 ns1075 0 -0.00276918274448
Gc7_1076 0 n14 ns1076 0 -0.000633525302766
Gc7_1077 0 n14 ns1077 0 0.000848361042258
Gc7_1078 0 n14 ns1078 0 -4.78809670887e-05
Gc7_1079 0 n14 ns1079 0 0.000523303228801
Gc7_1080 0 n14 ns1080 0 -0.00134840192011
Gc7_1081 0 n14 ns1081 0 -0.00244588699358
Gc7_1082 0 n14 ns1082 0 -0.000629089101692
Gc7_1083 0 n14 ns1083 0 0.000439097968566
Gc7_1084 0 n14 ns1084 0 0.000365874245373
Gc7_1085 0 n14 ns1085 0 0.000261629197624
Gc7_1086 0 n14 ns1086 0 -0.000251767647992
Gc7_1087 0 n14 ns1087 0 -0.00646472027649
Gc7_1088 0 n14 ns1088 0 -0.0029168419199
Gc7_1089 0 n14 ns1089 0 -0.000479398236287
Gc7_1090 0 n14 ns1090 0 0.000499804522352
Gc7_1091 0 n14 ns1091 0 0.00210717421555
Gc7_1092 0 n14 ns1092 0 -0.010917454371
Gc7_1093 0 n14 ns1093 0 -0.00562736843746
Gc7_1094 0 n14 ns1094 0 -0.0018481808882
Gc7_1095 0 n14 ns1095 0 0.00293652595015
Gc7_1096 0 n14 ns1096 0 0.00271213291303
Gc7_1097 0 n14 ns1097 0 0.000164030549069
Gc7_1098 0 n14 ns1098 0 -0.0914148918544
Gc7_1099 0 n14 ns1099 0 0.0831755779233
Gc7_1100 0 n14 ns1100 0 -0.00526443987146
Gc7_1101 0 n14 ns1101 0 -1.01469776492e-05
Gc7_1102 0 n14 ns1102 0 -2.30344262122e-07
Gc7_1103 0 n14 ns1103 0 -0.00539205625639
Gc7_1104 0 n14 ns1104 0 -0.00495568471572
Gc7_1105 0 n14 ns1105 0 0.00904909251859
Gc7_1106 0 n14 ns1106 0 0.00256407521815
Gc7_1107 0 n14 ns1107 0 -0.0020999616009
Gc7_1108 0 n14 ns1108 0 0.000705644791694
Gc7_1109 0 n14 ns1109 0 0.00280190885195
Gc7_1110 0 n14 ns1110 0 -7.13140214829e-06
Gc7_1111 0 n14 ns1111 0 -0.000312380879752
Gc7_1112 0 n14 ns1112 0 -0.00100964602837
Gc7_1113 0 n14 ns1113 0 -0.00149365995896
Gc7_1114 0 n14 ns1114 0 -0.000873007115363
Gc7_1115 0 n14 ns1115 0 0.000496849307805
Gc7_1116 0 n14 ns1116 0 -0.000153596024566
Gc7_1117 0 n14 ns1117 0 0.000583932027222
Gc7_1118 0 n14 ns1118 0 0.00276877150325
Gc7_1119 0 n14 ns1119 0 -0.00259791777977
Gc7_1120 0 n14 ns1120 0 -0.000896650525306
Gc7_1121 0 n14 ns1121 0 -0.000582038764481
Gc7_1122 0 n14 ns1122 0 0.000204843365838
Gc7_1123 0 n14 ns1123 0 0.000195900969563
Gc7_1124 0 n14 ns1124 0 0.00238699038558
Gc7_1125 0 n14 ns1125 0 0.00132519381843
Gc7_1126 0 n14 ns1126 0 -0.00117795274137
Gc7_1127 0 n14 ns1127 0 -0.0026869377265
Gc7_1128 0 n14 ns1128 0 -0.00115328892235
Gc7_1129 0 n14 ns1129 0 0.0021111723304
Gc7_1130 0 n14 ns1130 0 -0.0147552031506
Gc7_1131 0 n14 ns1131 0 -0.00567964081696
Gc7_1132 0 n14 ns1132 0 0.00203405996172
Gc7_1133 0 n14 ns1133 0 0.003918501366
Gc7_1134 0 n14 ns1134 0 0.00372598895886
Gc7_1135 0 n14 ns1135 0 0.000165809149275
Gc7_1136 0 n14 ns1136 0 0.0088617466689
Gc7_1137 0 n14 ns1137 0 -0.00109795610955
Gc7_1138 0 n14 ns1138 0 -0.00787504772415
Gc7_1139 0 n14 ns1139 0 -1.33823435006e-05
Gc7_1140 0 n14 ns1140 0 1.59857276659e-05
Gc7_1141 0 n14 ns1141 0 -0.0026248249511
Gc7_1142 0 n14 ns1142 0 -0.00250150936354
Gc7_1143 0 n14 ns1143 0 0.00678970538533
Gc7_1144 0 n14 ns1144 0 0.000989032662343
Gc7_1145 0 n14 ns1145 0 -0.00183155988903
Gc7_1146 0 n14 ns1146 0 0.000721702609638
Gc7_1147 0 n14 ns1147 0 0.00192790453115
Gc7_1148 0 n14 ns1148 0 3.43469938238e-05
Gc7_1149 0 n14 ns1149 0 -0.000239383190087
Gc7_1150 0 n14 ns1150 0 0.000300508721496
Gc7_1151 0 n14 ns1151 0 -0.000223094036259
Gc7_1152 0 n14 ns1152 0 -0.000640764329977
Gc7_1153 0 n14 ns1153 0 -4.07776289598e-05
Gc7_1154 0 n14 ns1154 0 -0.000406395914243
Gc7_1155 0 n14 ns1155 0 0.00044906638764
Gc7_1156 0 n14 ns1156 0 0.00211367488502
Gc7_1157 0 n14 ns1157 0 -0.00290023932017
Gc7_1158 0 n14 ns1158 0 -0.00116105454568
Gc7_1159 0 n14 ns1159 0 -0.000446043832654
Gc7_1160 0 n14 ns1160 0 0.000246356757038
Gc7_1161 0 n14 ns1161 0 0.000407619619796
Gc7_1162 0 n14 ns1162 0 0.00200551505959
Gc7_1163 0 n14 ns1163 0 -0.00162818138709
Gc7_1164 0 n14 ns1164 0 -0.00186006650819
Gc7_1165 0 n14 ns1165 0 -0.00200830782592
Gc7_1166 0 n14 ns1166 0 -0.00079099196696
Gc7_1167 0 n14 ns1167 0 0.00226469827611
Gc7_1168 0 n14 ns1168 0 -0.0110790972211
Gc7_1169 0 n14 ns1169 0 -0.00518365340672
Gc7_1170 0 n14 ns1170 0 -0.000122694320366
Gc7_1171 0 n14 ns1171 0 0.00237336201499
Gc7_1172 0 n14 ns1172 0 0.00319631667441
Gc7_1173 0 n14 ns1173 0 0.000344570964736
Gc7_1174 0 n14 ns1174 0 -0.0366984607303
Gc7_1175 0 n14 ns1175 0 0.0385908302476
Gc7_1176 0 n14 ns1176 0 -0.00709720209601
Gc7_1177 0 n14 ns1177 0 -1.32851979824e-05
Gc7_1178 0 n14 ns1178 0 2.9250989238e-05
Gc7_1179 0 n14 ns1179 0 -6.0013224157e-05
Gc7_1180 0 n14 ns1180 0 -0.000826487449231
Gc7_1181 0 n14 ns1181 0 0.00945070221136
Gc7_1182 0 n14 ns1182 0 0.000112683037911
Gc7_1183 0 n14 ns1183 0 0.000168033935367
Gc7_1184 0 n14 ns1184 0 0.000396961141926
Gc7_1185 0 n14 ns1185 0 -0.00037379713231
Gc7_1186 0 n14 ns1186 0 -0.000140398758179
Gc7_1187 0 n14 ns1187 0 2.61422235382e-05
Gc7_1188 0 n14 ns1188 0 0.000105404666939
Gc7_1189 0 n14 ns1189 0 -0.00318475103451
Gc7_1190 0 n14 ns1190 0 0.000396001530381
Gc7_1191 0 n14 ns1191 0 0.00098166433076
Gc7_1192 0 n14 ns1192 0 -0.000154660131624
Gc7_1193 0 n14 ns1193 0 0.000291887659136
Gc7_1194 0 n14 ns1194 0 -0.00105692703879
Gc7_1195 0 n14 ns1195 0 -0.00028735463201
Gc7_1196 0 n14 ns1196 0 -0.000313978742088
Gc7_1197 0 n14 ns1197 0 -0.000682810755756
Gc7_1198 0 n14 ns1198 0 0.000208859113072
Gc7_1199 0 n14 ns1199 0 0.000245087362182
Gc7_1200 0 n14 ns1200 0 -0.00176264126647
Gc7_1201 0 n14 ns1201 0 -0.00494565111943
Gc7_1202 0 n14 ns1202 0 -0.000895354589635
Gc7_1203 0 n14 ns1203 0 0.000301643046392
Gc7_1204 0 n14 ns1204 0 -0.00018213026605
Gc7_1205 0 n14 ns1205 0 0.00117086893067
Gc7_1206 0 n14 ns1206 0 -0.00775374882768
Gc7_1207 0 n14 ns1207 0 -0.00535348865112
Gc7_1208 0 n14 ns1208 0 -0.00258913475452
Gc7_1209 0 n14 ns1209 0 0.00280248536207
Gc7_1210 0 n14 ns1210 0 0.00252590298925
Gc7_1211 0 n14 ns1211 0 0.000258791149156
Gc7_1212 0 n14 ns1212 0 -0.0779126588344
Gc7_1213 0 n14 ns1213 0 0.0700467003755
Gc7_1214 0 n14 ns1214 0 -0.00407956402557
Gc7_1215 0 n14 ns1215 0 -1.02536174152e-05
Gc7_1216 0 n14 ns1216 0 2.32140813401e-05
Gd7_1 0 n14 ni1 0 -0.000109735902482
Gd7_2 0 n14 ni2 0 -7.13235131946e-05
Gd7_3 0 n14 ni3 0 -5.47660317985e-05
Gd7_4 0 n14 ni4 0 0.000158851590184
Gd7_5 0 n14 ni5 0 -0.000401639507894
Gd7_6 0 n14 ni6 0 -0.00173926460533
Gd7_7 0 n14 ni7 0 0.000222400285657
Gd7_8 0 n14 ni8 0 -0.00166847203374
Gd7_9 0 n14 ni9 0 -0.000224787403112
Gd7_10 0 n14 ni10 0 1.47061921325e-05
Gd7_11 0 n14 ni11 0 7.64265483252e-05
Gd7_12 0 n14 ni12 0 0.000105001696494
Gd7_13 0 n14 ni13 0 -0.00114412590385
Gd7_14 0 n14 ni14 0 -0.000636319861569
Gd7_15 0 n14 ni15 0 -0.00252682089516
Gd7_16 0 n14 ni16 0 -0.000609864646759
Gd7_17 0 n14 ni17 0 -8.35572022799e-05
Gd7_18 0 n14 ni18 0 -2.49048768417e-05
Gd7_19 0 n14 ni19 0 0.000249566896738
Gd7_20 0 n14 ni20 0 0.000224783863168
Gd7_21 0 n14 ni21 0 0.000577689166962
Gd7_22 0 n14 ni22 0 -0.000461109212092
Gd7_23 0 n14 ni23 0 -0.0068073687948
Gd7_24 0 n14 ni24 0 -0.000294863682785
Gd7_25 0 n14 ni25 0 0.0005545798267
Gd7_26 0 n14 ni26 0 0.000245576240865
Gd7_27 0 n14 ni27 0 0.000286501601488
Gd7_28 0 n14 ni28 0 0.000238339095725
Gd7_29 0 n14 ni29 0 -0.000184660191134
Gd7_30 0 n14 ni30 0 -0.00315131313771
Gd7_31 0 n14 ni31 0 -0.00157308281944
Gd7_32 0 n14 ni32 0 -5.17839937585e-05
Gc8_1 0 n16 ns1 0 -0.000156108531224
Gc8_2 0 n16 ns2 0 0.000326827886763
Gc8_3 0 n16 ns3 0 -0.00265882849357
Gc8_4 0 n16 ns4 0 -0.000195133594275
Gc8_5 0 n16 ns5 0 -0.000133788401299
Gc8_6 0 n16 ns6 0 -0.000141676417972
Gc8_7 0 n16 ns7 0 2.48125928856e-05
Gc8_8 0 n16 ns8 0 -7.01266399668e-06
Gc8_9 0 n16 ns9 0 9.3996286223e-06
Gc8_10 0 n16 ns10 0 0.000676122399134
Gc8_11 0 n16 ns11 0 0.00103667844827
Gc8_12 0 n16 ns12 0 -0.000376226448491
Gc8_13 0 n16 ns13 0 -0.000344227285136
Gc8_14 0 n16 ns14 0 -8.31698099637e-05
Gc8_15 0 n16 ns15 0 0.000102014465274
Gc8_16 0 n16 ns16 0 0.000221503333621
Gc8_17 0 n16 ns17 0 0.000816533517432
Gc8_18 0 n16 ns18 0 0.000367685411268
Gc8_19 0 n16 ns19 0 -0.000306832802412
Gc8_20 0 n16 ns20 0 -6.44407241749e-05
Gc8_21 0 n16 ns21 0 -0.000102696305327
Gc8_22 0 n16 ns22 0 0.00118709155205
Gc8_23 0 n16 ns23 0 0.000480477527482
Gc8_24 0 n16 ns24 0 0.000294971022135
Gc8_25 0 n16 ns25 0 -0.00055130283538
Gc8_26 0 n16 ns26 0 -0.00034796835487
Gc8_27 0 n16 ns27 0 0.000164974018695
Gc8_28 0 n16 ns28 0 0.00138237574919
Gc8_29 0 n16 ns29 0 0.000674999000945
Gc8_30 0 n16 ns30 0 0.000178530625328
Gc8_31 0 n16 ns31 0 -0.000264201105666
Gc8_32 0 n16 ns32 0 -0.000116512646152
Gc8_33 0 n16 ns33 0 -0.000154786616018
Gc8_34 0 n16 ns34 0 0.0143687519581
Gc8_35 0 n16 ns35 0 -0.0121367369855
Gc8_36 0 n16 ns36 0 0.000416908566327
Gc8_37 0 n16 ns37 0 -7.39569523342e-06
Gc8_38 0 n16 ns38 0 -2.53088639781e-05
Gc8_39 0 n16 ns39 0 -5.86239807635e-05
Gc8_40 0 n16 ns40 0 0.000223450681488
Gc8_41 0 n16 ns41 0 -0.00302063302621
Gc8_42 0 n16 ns42 0 -0.000234044693205
Gc8_43 0 n16 ns43 0 -0.000194958313054
Gc8_44 0 n16 ns44 0 -0.00017369139309
Gc8_45 0 n16 ns45 0 1.84926821787e-05
Gc8_46 0 n16 ns46 0 1.2395189094e-06
Gc8_47 0 n16 ns47 0 1.39685495222e-05
Gc8_48 0 n16 ns48 0 0.000640030612953
Gc8_49 0 n16 ns49 0 0.00131989395051
Gc8_50 0 n16 ns50 0 -0.0003715929125
Gc8_51 0 n16 ns51 0 -0.000480188650811
Gc8_52 0 n16 ns52 0 -0.000126521765188
Gc8_53 0 n16 ns53 0 0.000111486226426
Gc8_54 0 n16 ns54 0 6.62881276446e-05
Gc8_55 0 n16 ns55 0 0.00102433262491
Gc8_56 0 n16 ns56 0 0.000537030165137
Gc8_57 0 n16 ns57 0 -0.000276327482841
Gc8_58 0 n16 ns58 0 -5.46435084731e-05
Gc8_59 0 n16 ns59 0 -0.000148775944962
Gc8_60 0 n16 ns60 0 0.00146131041943
Gc8_61 0 n16 ns61 0 0.000803075391768
Gc8_62 0 n16 ns62 0 0.000490692695076
Gc8_63 0 n16 ns63 0 -0.000684032694309
Gc8_64 0 n16 ns64 0 -0.000498505840314
Gc8_65 0 n16 ns65 0 0.000161627423941
Gc8_66 0 n16 ns66 0 0.00181285488355
Gc8_67 0 n16 ns67 0 0.000862694177866
Gc8_68 0 n16 ns68 0 0.000197824766483
Gc8_69 0 n16 ns69 0 -0.000342210153714
Gc8_70 0 n16 ns70 0 -0.000151310791001
Gc8_71 0 n16 ns71 0 -0.000187485560795
Gc8_72 0 n16 ns72 0 0.0176875494966
Gc8_73 0 n16 ns73 0 -0.0149239500387
Gc8_74 0 n16 ns74 0 0.000503922174772
Gc8_75 0 n16 ns75 0 -5.22817470585e-06
Gc8_76 0 n16 ns76 0 -2.80334173774e-05
Gc8_77 0 n16 ns77 0 0.000174180845613
Gc8_78 0 n16 ns78 0 -0.000409599494613
Gc8_79 0 n16 ns79 0 -0.00148269945164
Gc8_80 0 n16 ns80 0 -0.000109863904815
Gc8_81 0 n16 ns81 0 -0.000132952514453
Gc8_82 0 n16 ns82 0 -6.33275956898e-05
Gc8_83 0 n16 ns83 0 5.62018472919e-05
Gc8_84 0 n16 ns84 0 3.13271664792e-05
Gc8_85 0 n16 ns85 0 8.82298177796e-06
Gc8_86 0 n16 ns86 0 -9.8228543244e-05
Gc8_87 0 n16 ns87 0 0.000677137705725
Gc8_88 0 n16 ns88 0 0.000131530236744
Gc8_89 0 n16 ns89 0 -0.000383645553765
Gc8_90 0 n16 ns90 0 -0.000170770087013
Gc8_91 0 n16 ns91 0 1.55022418612e-05
Gc8_92 0 n16 ns92 0 -0.000780111284611
Gc8_93 0 n16 ns93 0 0.00045875673507
Gc8_94 0 n16 ns94 0 0.00061434555032
Gc8_95 0 n16 ns95 0 0.000345308721004
Gc8_96 0 n16 ns96 0 7.39073901571e-05
Gc8_97 0 n16 ns97 0 -0.000188167657141
Gc8_98 0 n16 ns98 0 0.000805574768727
Gc8_99 0 n16 ns99 0 0.00140719364761
Gc8_100 0 n16 ns100 0 0.00102947741321
Gc8_101 0 n16 ns101 0 -0.000403480255624
Gc8_102 0 n16 ns102 0 -0.000731581710424
Gc8_103 0 n16 ns103 0 -0.000148630709841
Gc8_104 0 n16 ns104 0 0.00124009896919
Gc8_105 0 n16 ns105 0 0.0011329475129
Gc8_106 0 n16 ns106 0 0.00041711414027
Gc8_107 0 n16 ns107 0 -6.52225475591e-05
Gc8_108 0 n16 ns108 0 -7.53330970699e-05
Gc8_109 0 n16 ns109 0 -0.000358774958437
Gc8_110 0 n16 ns110 0 0.0178944666373
Gc8_111 0 n16 ns111 0 -0.0154119208922
Gc8_112 0 n16 ns112 0 0.000560093661378
Gc8_113 0 n16 ns113 0 -3.67044327591e-06
Gc8_114 0 n16 ns114 0 -3.3777482231e-05
Gc8_115 0 n16 ns115 0 -1.0832861221e-05
Gc8_116 0 n16 ns116 0 -0.000391236555878
Gc8_117 0 n16 ns117 0 0.00100205508282
Gc8_118 0 n16 ns118 0 -4.25090839161e-05
Gc8_119 0 n16 ns119 0 0.000142553947101
Gc8_120 0 n16 ns120 0 5.41752141359e-05
Gc8_121 0 n16 ns121 0 4.79210060565e-05
Gc8_122 0 n16 ns122 0 -1.43602928121e-05
Gc8_123 0 n16 ns123 0 7.58748604179e-06
Gc8_124 0 n16 ns124 0 -0.000246878371047
Gc8_125 0 n16 ns125 0 -0.000120629116005
Gc8_126 0 n16 ns126 0 0.000505683514147
Gc8_127 0 n16 ns127 0 0.000122895161923
Gc8_128 0 n16 ns128 0 -0.000136089757118
Gc8_129 0 n16 ns129 0 -0.000193235232613
Gc8_130 0 n16 ns130 0 -0.000306043695485
Gc8_131 0 n16 ns131 0 -0.000895132163845
Gc8_132 0 n16 ns132 0 -0.000200642378928
Gc8_133 0 n16 ns133 0 0.000788400246025
Gc8_134 0 n16 ns134 0 0.000195357504394
Gc8_135 0 n16 ns135 0 -8.77796202155e-05
Gc8_136 0 n16 ns136 0 -0.000609219671008
Gc8_137 0 n16 ns137 0 0.000377806916777
Gc8_138 0 n16 ns138 0 0.000853138737361
Gc8_139 0 n16 ns139 0 0.000724528433156
Gc8_140 0 n16 ns140 0 -0.000411185232088
Gc8_141 0 n16 ns141 0 -0.000731134980378
Gc8_142 0 n16 ns142 0 -0.0012432968183
Gc8_143 0 n16 ns143 0 -6.63005772577e-06
Gc8_144 0 n16 ns144 0 0.000466252363112
Gc8_145 0 n16 ns145 0 0.00115905624657
Gc8_146 0 n16 ns146 0 0.000394761900871
Gc8_147 0 n16 ns147 0 -0.000589735934952
Gc8_148 0 n16 ns148 0 0.00907872804535
Gc8_149 0 n16 ns149 0 -0.00886024243479
Gc8_150 0 n16 ns150 0 0.000517403471044
Gc8_151 0 n16 ns151 0 -3.29600136396e-06
Gc8_152 0 n16 ns152 0 -2.60046567152e-05
Gc8_153 0 n16 ns153 0 -0.000610624739132
Gc8_154 0 n16 ns154 0 0.00147609990651
Gc8_155 0 n16 ns155 0 -0.0021941498942
Gc8_156 0 n16 ns156 0 -0.000163730414562
Gc8_157 0 n16 ns157 0 -0.000170193652338
Gc8_158 0 n16 ns158 0 -0.000154855696928
Gc8_159 0 n16 ns159 0 -0.000119909904045
Gc8_160 0 n16 ns160 0 -9.42693374765e-06
Gc8_161 0 n16 ns161 0 -1.91923355932e-05
Gc8_162 0 n16 ns162 0 -0.000507217849511
Gc8_163 0 n16 ns163 0 0.00137084105228
Gc8_164 0 n16 ns164 0 0.000227237973647
Gc8_165 0 n16 ns165 0 3.45527579406e-05
Gc8_166 0 n16 ns166 0 -8.25226890299e-05
Gc8_167 0 n16 ns167 0 -0.000376491258981
Gc8_168 0 n16 ns168 0 0.000740573244228
Gc8_169 0 n16 ns169 0 0.000524913618414
Gc8_170 0 n16 ns170 0 -0.000457547188277
Gc8_171 0 n16 ns171 0 0.000121298245542
Gc8_172 0 n16 ns172 0 0.000271263693955
Gc8_173 0 n16 ns173 0 -8.54564017969e-05
Gc8_174 0 n16 ns174 0 0.000951623567408
Gc8_175 0 n16 ns175 0 0.000551242938101
Gc8_176 0 n16 ns176 0 0.000301610336445
Gc8_177 0 n16 ns177 0 0.00103057021204
Gc8_178 0 n16 ns178 0 -3.42934908931e-05
Gc8_179 0 n16 ns179 0 -0.00110814456379
Gc8_180 0 n16 ns180 0 0.000636093229992
Gc8_181 0 n16 ns181 0 -0.000422260238765
Gc8_182 0 n16 ns182 0 -0.000384673810576
Gc8_183 0 n16 ns183 0 0.00152065037903
Gc8_184 0 n16 ns184 0 0.000821610037906
Gc8_185 0 n16 ns185 0 -0.000667642173947
Gc8_186 0 n16 ns186 0 0.0238471524544
Gc8_187 0 n16 ns187 0 -0.0219704077464
Gc8_188 0 n16 ns188 0 0.00116183978271
Gc8_189 0 n16 ns189 0 -6.17887134405e-06
Gc8_190 0 n16 ns190 0 -7.01965583337e-06
Gc8_191 0 n16 ns191 0 -0.00121584744188
Gc8_192 0 n16 ns192 0 0.000745625060142
Gc8_193 0 n16 ns193 0 -0.000225433780568
Gc8_194 0 n16 ns194 0 0.000538583021467
Gc8_195 0 n16 ns195 0 -0.000585921716504
Gc8_196 0 n16 ns196 0 0.00032649445646
Gc8_197 0 n16 ns197 0 -0.000154829681972
Gc8_198 0 n16 ns198 0 -3.88994169744e-05
Gc8_199 0 n16 ns199 0 3.41976167249e-05
Gc8_200 0 n16 ns200 0 -0.00199206494873
Gc8_201 0 n16 ns201 0 -0.000215294404367
Gc8_202 0 n16 ns202 0 0.000409478921315
Gc8_203 0 n16 ns203 0 3.04671884932e-05
Gc8_204 0 n16 ns204 0 0.000202807273951
Gc8_205 0 n16 ns205 0 -0.000485224922057
Gc8_206 0 n16 ns206 0 -0.00149441900496
Gc8_207 0 n16 ns207 0 0.000145870274114
Gc8_208 0 n16 ns208 0 -0.000376817036519
Gc8_209 0 n16 ns209 0 0.0002939215502
Gc8_210 0 n16 ns210 0 0.000471002997765
Gc8_211 0 n16 ns211 0 0.000134402243922
Gc8_212 0 n16 ns212 0 -0.000810308726427
Gc8_213 0 n16 ns213 0 0.00317963625018
Gc8_214 0 n16 ns214 0 0.000401444716946
Gc8_215 0 n16 ns215 0 0.00101334316053
Gc8_216 0 n16 ns216 0 0.000410964625527
Gc8_217 0 n16 ns217 0 -0.00146387151031
Gc8_218 0 n16 ns218 0 0.00149563023103
Gc8_219 0 n16 ns219 0 0.00172222423752
Gc8_220 0 n16 ns220 0 -0.00156533057636
Gc8_221 0 n16 ns221 0 0.000911545832351
Gc8_222 0 n16 ns222 0 0.00147320996508
Gc8_223 0 n16 ns223 0 -0.000422890115232
Gc8_224 0 n16 ns224 0 0.0411480004293
Gc8_225 0 n16 ns225 0 -0.0395528567075
Gc8_226 0 n16 ns226 0 0.00262805570654
Gc8_227 0 n16 ns227 0 -1.62005687507e-06
Gc8_228 0 n16 ns228 0 1.32705493053e-05
Gc8_229 0 n16 ns229 0 -0.00219425709097
Gc8_230 0 n16 ns230 0 -0.00113254427482
Gc8_231 0 n16 ns231 0 0.00287919515218
Gc8_232 0 n16 ns232 0 0.000343241856496
Gc8_233 0 n16 ns233 0 -0.000540659754303
Gc8_234 0 n16 ns234 0 0.000380764677743
Gc8_235 0 n16 ns235 0 0.000375141210812
Gc8_236 0 n16 ns236 0 -0.000184604592037
Gc8_237 0 n16 ns237 0 -6.25328302087e-05
Gc8_238 0 n16 ns238 0 -0.000705050665523
Gc8_239 0 n16 ns239 0 0.000133131883412
Gc8_240 0 n16 ns240 0 0.000537177470761
Gc8_241 0 n16 ns241 0 0.000137065674483
Gc8_242 0 n16 ns242 0 0.000498025797792
Gc8_243 0 n16 ns243 0 -0.000440428269292
Gc8_244 0 n16 ns244 0 0.00115057124841
Gc8_245 0 n16 ns245 0 -0.00169812082635
Gc8_246 0 n16 ns246 0 -0.000796481412215
Gc8_247 0 n16 ns247 0 -0.000527519967531
Gc8_248 0 n16 ns248 0 0.000289054813653
Gc8_249 0 n16 ns249 0 0.000358323817078
Gc8_250 0 n16 ns250 0 -0.00357810189739
Gc8_251 0 n16 ns251 0 -0.0018692690548
Gc8_252 0 n16 ns252 0 -4.55504206583e-05
Gc8_253 0 n16 ns253 0 0.00157369408943
Gc8_254 0 n16 ns254 0 0.0013602875825
Gc8_255 0 n16 ns255 0 -0.00141634652728
Gc8_256 0 n16 ns256 0 -0.00533764910334
Gc8_257 0 n16 ns257 0 -0.00145099192059
Gc8_258 0 n16 ns258 0 -0.00148547250769
Gc8_259 0 n16 ns259 0 0.000736712074041
Gc8_260 0 n16 ns260 0 0.00249798698654
Gc8_261 0 n16 ns261 0 0.000376736735239
Gc8_262 0 n16 ns262 0 0.0207304647006
Gc8_263 0 n16 ns263 0 -0.0284076898131
Gc8_264 0 n16 ns264 0 0.00551433534884
Gc8_265 0 n16 ns265 0 2.13212349564e-06
Gc8_266 0 n16 ns266 0 3.44584147962e-05
Gc8_267 0 n16 ns267 0 -0.00328678068659
Gc8_268 0 n16 ns268 0 -0.000553581274185
Gc8_269 0 n16 ns269 0 -0.00152799051611
Gc8_270 0 n16 ns270 0 0.000687885603408
Gc8_271 0 n16 ns271 0 -0.000480843134635
Gc8_272 0 n16 ns272 0 0.000436190343189
Gc8_273 0 n16 ns273 0 -0.000367353179955
Gc8_274 0 n16 ns274 0 -0.000207319415975
Gc8_275 0 n16 ns275 0 -0.000102257684541
Gc8_276 0 n16 ns276 0 -0.00460346721592
Gc8_277 0 n16 ns277 0 0.00173948460372
Gc8_278 0 n16 ns278 0 0.00120427236859
Gc8_279 0 n16 ns279 0 -0.000497490458004
Gc8_280 0 n16 ns280 0 0.00055049184735
Gc8_281 0 n16 ns281 0 -0.00040580056312
Gc8_282 0 n16 ns282 0 -0.000501180920911
Gc8_283 0 n16 ns283 0 0.00236610794045
Gc8_284 0 n16 ns284 0 0.000974224810927
Gc8_285 0 n16 ns285 0 -0.000256406892446
Gc8_286 0 n16 ns286 0 0.000448367151551
Gc8_287 0 n16 ns287 0 0.000266320799536
Gc8_288 0 n16 ns288 0 0.001188940213
Gc8_289 0 n16 ns289 0 0.00121675704074
Gc8_290 0 n16 ns290 0 0.000672598285827
Gc8_291 0 n16 ns291 0 0.00213348407015
Gc8_292 0 n16 ns292 0 0.00166893416518
Gc8_293 0 n16 ns293 0 -0.00159015066951
Gc8_294 0 n16 ns294 0 0.000531988206669
Gc8_295 0 n16 ns295 0 -0.00231736084622
Gc8_296 0 n16 ns296 0 0.00151422496332
Gc8_297 0 n16 ns297 0 0.00106198647894
Gc8_298 0 n16 ns298 0 0.00315845565632
Gc8_299 0 n16 ns299 0 0.000431214434197
Gc8_300 0 n16 ns300 0 -0.0239143696733
Gc8_301 0 n16 ns301 0 0.0236785593952
Gc8_302 0 n16 ns302 0 0.00699066192616
Gc8_303 0 n16 ns303 0 1.14502865992e-05
Gc8_304 0 n16 ns304 0 3.39192527449e-05
Gc8_305 0 n16 ns305 0 -0.00183044584943
Gc8_306 0 n16 ns306 0 -0.00304241687162
Gc8_307 0 n16 ns307 0 0.00640970791666
Gc8_308 0 n16 ns308 0 0.000688293741284
Gc8_309 0 n16 ns309 0 -0.000301988938964
Gc8_310 0 n16 ns310 0 0.000678365340982
Gc8_311 0 n16 ns311 0 0.000778608949414
Gc8_312 0 n16 ns312 0 -0.00016394802707
Gc8_313 0 n16 ns313 0 -9.58763912387e-05
Gc8_314 0 n16 ns314 0 -0.00086152061542
Gc8_315 0 n16 ns315 0 -0.00192655174653
Gc8_316 0 n16 ns316 0 0.00116253724921
Gc8_317 0 n16 ns317 0 7.38257135127e-05
Gc8_318 0 n16 ns318 0 0.000418686259836
Gc8_319 0 n16 ns319 0 -0.000180410034881
Gc8_320 0 n16 ns320 0 -0.000740639522031
Gc8_321 0 n16 ns321 0 -0.00329966615613
Gc8_322 0 n16 ns322 0 -0.000109241478853
Gc8_323 0 n16 ns323 0 0.000196240901983
Gc8_324 0 n16 ns324 0 0.000164262284442
Gc8_325 0 n16 ns325 0 0.000372208071738
Gc8_326 0 n16 ns326 0 -0.00573823212207
Gc8_327 0 n16 ns327 0 -0.00140622908315
Gc8_328 0 n16 ns328 0 0.000672629215079
Gc8_329 0 n16 ns329 0 0.000861124430385
Gc8_330 0 n16 ns330 0 0.00102324505514
Gc8_331 0 n16 ns331 0 -0.000848304279303
Gc8_332 0 n16 ns332 0 -0.00660839500837
Gc8_333 0 n16 ns333 0 -0.000271386417743
Gc8_334 0 n16 ns334 0 -0.000996433090037
Gc8_335 0 n16 ns335 0 -0.000579239487466
Gc8_336 0 n16 ns336 0 0.00203316835043
Gc8_337 0 n16 ns337 0 0.000788672176682
Gc8_338 0 n16 ns338 0 0.00414755950548
Gc8_339 0 n16 ns339 0 -0.0139916762516
Gc8_340 0 n16 ns340 0 0.00513968768035
Gc8_341 0 n16 ns341 0 1.48188984511e-06
Gc8_342 0 n16 ns342 0 3.03727810589e-05
Gc8_343 0 n16 ns343 0 1.07567131516e-05
Gc8_344 0 n16 ns344 0 -2.07522613287e-05
Gc8_345 0 n16 ns345 0 -0.00279799165881
Gc8_346 0 n16 ns346 0 -0.000172466960167
Gc8_347 0 n16 ns347 0 -0.000184653453778
Gc8_348 0 n16 ns348 0 -0.000123287471681
Gc8_349 0 n16 ns349 0 7.15508346494e-05
Gc8_350 0 n16 ns350 0 2.73776868379e-05
Gc8_351 0 n16 ns351 0 1.96449962072e-07
Gc8_352 0 n16 ns352 0 0.000256702292877
Gc8_353 0 n16 ns353 0 0.00103151592775
Gc8_354 0 n16 ns354 0 -0.000125203660133
Gc8_355 0 n16 ns355 0 -0.000465167898417
Gc8_356 0 n16 ns356 0 -0.000152578882972
Gc8_357 0 n16 ns357 0 7.6790312056e-05
Gc8_358 0 n16 ns358 0 -0.00044993031849
Gc8_359 0 n16 ns359 0 0.000879077578352
Gc8_360 0 n16 ns360 0 0.00067350347158
Gc8_361 0 n16 ns361 0 3.16025605114e-05
Gc8_362 0 n16 ns362 0 1.15608292932e-05
Gc8_363 0 n16 ns363 0 -0.000188191425559
Gc8_364 0 n16 ns364 0 0.00131374390914
Gc8_365 0 n16 ns365 0 0.00132412028078
Gc8_366 0 n16 ns366 0 0.000867398193361
Gc8_367 0 n16 ns367 0 -0.000631650157705
Gc8_368 0 n16 ns368 0 -0.000693125131827
Gc8_369 0 n16 ns369 0 1.12420559748e-05
Gc8_370 0 n16 ns370 0 0.00197604569119
Gc8_371 0 n16 ns371 0 0.00121483094388
Gc8_372 0 n16 ns372 0 0.000303135800628
Gc8_373 0 n16 ns373 0 -0.000352239629266
Gc8_374 0 n16 ns374 0 -0.000165921810274
Gc8_375 0 n16 ns375 0 -0.000272163677906
Gc8_376 0 n16 ns376 0 0.0202817937867
Gc8_377 0 n16 ns377 0 -0.0171685468801
Gc8_378 0 n16 ns378 0 0.000577572067003
Gc8_379 0 n16 ns379 0 -3.97422625209e-06
Gc8_380 0 n16 ns380 0 -3.11009465576e-05
Gc8_381 0 n16 ns381 0 9.88669450163e-05
Gc8_382 0 n16 ns382 0 -0.000278918385744
Gc8_383 0 n16 ns383 0 -8.38585930656e-05
Gc8_384 0 n16 ns384 0 -7.24569234622e-05
Gc8_385 0 n16 ns385 0 4.4401831226e-05
Gc8_386 0 n16 ns386 0 -2.75350632107e-05
Gc8_387 0 n16 ns387 0 4.03536508721e-05
Gc8_388 0 n16 ns388 0 1.1820479208e-05
Gc8_389 0 n16 ns389 0 3.03624965449e-05
Gc8_390 0 n16 ns390 0 2.19454222249e-05
Gc8_391 0 n16 ns391 0 0.000353307644039
Gc8_392 0 n16 ns392 0 0.000329489596838
Gc8_393 0 n16 ns393 0 -0.000200687569243
Gc8_394 0 n16 ns394 0 -0.000210527213491
Gc8_395 0 n16 ns395 0 -8.85442313973e-05
Gc8_396 0 n16 ns396 0 -0.00047578363837
Gc8_397 0 n16 ns397 0 -0.000466735619158
Gc8_398 0 n16 ns398 0 0.000144324013395
Gc8_399 0 n16 ns399 0 0.000622560092409
Gc8_400 0 n16 ns400 0 0.000128072115115
Gc8_401 0 n16 ns401 0 -0.000140560566567
Gc8_402 0 n16 ns402 0 -0.000173621921086
Gc8_403 0 n16 ns403 0 0.000684452429173
Gc8_404 0 n16 ns404 0 0.000970407014282
Gc8_405 0 n16 ns405 0 0.00032049159698
Gc8_406 0 n16 ns406 0 -0.000555638228678
Gc8_407 0 n16 ns407 0 -0.000517842597423
Gc8_408 0 n16 ns408 0 -0.000444893036276
Gc8_409 0 n16 ns409 0 0.000429443494276
Gc8_410 0 n16 ns410 0 0.000509073103347
Gc8_411 0 n16 ns411 0 0.000760883715367
Gc8_412 0 n16 ns412 0 0.000237455622923
Gc8_413 0 n16 ns413 0 -0.000530699324903
Gc8_414 0 n16 ns414 0 0.0130882866423
Gc8_415 0 n16 ns415 0 -0.0119652468974
Gc8_416 0 n16 ns416 0 0.000559021053227
Gc8_417 0 n16 ns417 0 -3.38534454162e-06
Gc8_418 0 n16 ns418 0 -3.25604121055e-05
Gc8_419 0 n16 ns419 0 -0.000405524763022
Gc8_420 0 n16 ns420 0 0.000850574559537
Gc8_421 0 n16 ns421 0 -0.00122024209846
Gc8_422 0 n16 ns422 0 -8.5076512218e-05
Gc8_423 0 n16 ns423 0 -4.01814025234e-05
Gc8_424 0 n16 ns424 0 -0.000110471272387
Gc8_425 0 n16 ns425 0 -3.43497694402e-05
Gc8_426 0 n16 ns426 0 -3.08331426665e-05
Gc8_427 0 n16 ns427 0 -2.05111936386e-05
Gc8_428 0 n16 ns428 0 -0.000373556037542
Gc8_429 0 n16 ns429 0 0.000921684562624
Gc8_430 0 n16 ns430 0 0.000400992868161
Gc8_431 0 n16 ns431 0 7.21444067382e-05
Gc8_432 0 n16 ns432 0 -0.000121662743563
Gc8_433 0 n16 ns433 0 -0.000320684112648
Gc8_434 0 n16 ns434 0 0.000583916709016
Gc8_435 0 n16 ns435 0 -0.000119425335921
Gc8_436 0 n16 ns436 0 -0.000415154822729
Gc8_437 0 n16 ns437 0 0.000378880934693
Gc8_438 0 n16 ns438 0 0.00022698896269
Gc8_439 0 n16 ns439 0 -9.38351517355e-05
Gc8_440 0 n16 ns440 0 0.000333964246552
Gc8_441 0 n16 ns441 0 0.000169603618594
Gc8_442 0 n16 ns442 0 0.000487802064169
Gc8_443 0 n16 ns443 0 0.00100074407418
Gc8_444 0 n16 ns444 0 -0.000172260247044
Gc8_445 0 n16 ns445 0 -0.000971826070161
Gc8_446 0 n16 ns446 0 -0.000287712243416
Gc8_447 0 n16 ns447 0 -0.000352436938097
Gc8_448 0 n16 ns448 0 5.92301456784e-05
Gc8_449 0 n16 ns449 0 0.00145236878886
Gc8_450 0 n16 ns450 0 0.00063485083089
Gc8_451 0 n16 ns451 0 -0.000674926310699
Gc8_452 0 n16 ns452 0 0.0177803985348
Gc8_453 0 n16 ns453 0 -0.0165354839717
Gc8_454 0 n16 ns454 0 0.000871478959452
Gc8_455 0 n16 ns455 0 -6.37215519604e-06
Gc8_456 0 n16 ns456 0 -1.83646004834e-05
Gc8_457 0 n16 ns457 0 -0.000886396164238
Gc8_458 0 n16 ns458 0 0.00179707914376
Gc8_459 0 n16 ns459 0 -0.00193316349241
Gc8_460 0 n16 ns460 0 0.000135762021747
Gc8_461 0 n16 ns461 0 -0.000267353438034
Gc8_462 0 n16 ns462 0 0.000173404603354
Gc8_463 0 n16 ns463 0 -0.000303638351386
Gc8_464 0 n16 ns464 0 -3.54365543453e-07
Gc8_465 0 n16 ns465 0 1.08163486265e-05
Gc8_466 0 n16 ns466 0 -0.00165071626908
Gc8_467 0 n16 ns467 0 0.000435701908315
Gc8_468 0 n16 ns468 0 0.000292228260116
Gc8_469 0 n16 ns469 0 6.3042610381e-05
Gc8_470 0 n16 ns470 0 7.26251148419e-05
Gc8_471 0 n16 ns471 0 -0.000429291217319
Gc8_472 0 n16 ns472 0 -0.000743527846888
Gc8_473 0 n16 ns473 0 0.00085084952847
Gc8_474 0 n16 ns474 0 -0.000277785137133
Gc8_475 0 n16 ns475 0 0.00020107206984
Gc8_476 0 n16 ns476 0 0.000402554990612
Gc8_477 0 n16 ns477 0 1.56386994232e-05
Gc8_478 0 n16 ns478 0 0.000632089781711
Gc8_479 0 n16 ns479 0 0.00252486068121
Gc8_480 0 n16 ns480 0 0.000318347546694
Gc8_481 0 n16 ns481 0 0.000888901319878
Gc8_482 0 n16 ns482 0 0.000186438759861
Gc8_483 0 n16 ns483 0 -0.00129114767719
Gc8_484 0 n16 ns484 0 0.00201424087412
Gc8_485 0 n16 ns485 0 0.00061663124154
Gc8_486 0 n16 ns486 0 -0.00129106634935
Gc8_487 0 n16 ns487 0 0.00123229918454
Gc8_488 0 n16 ns488 0 0.00120185894822
Gc8_489 0 n16 ns489 0 -0.000527021500826
Gc8_490 0 n16 ns490 0 0.0353117238853
Gc8_491 0 n16 ns491 0 -0.0329477459025
Gc8_492 0 n16 ns492 0 0.00189793259882
Gc8_493 0 n16 ns493 0 -4.59969049111e-06
Gc8_494 0 n16 ns494 0 2.29316864929e-06
Gc8_495 0 n16 ns495 0 -0.00196639124387
Gc8_496 0 n16 ns496 0 2.02506477638e-05
Gc8_497 0 n16 ns497 0 0.00204283623563
Gc8_498 0 n16 ns498 0 0.000653545172537
Gc8_499 0 n16 ns499 0 -0.000446623212627
Gc8_500 0 n16 ns500 0 0.000481389106391
Gc8_501 0 n16 ns501 0 0.000331484256946
Gc8_502 0 n16 ns502 0 -0.000170588763365
Gc8_503 0 n16 ns503 0 -4.07769046063e-06
Gc8_504 0 n16 ns504 0 -0.000640467783903
Gc8_505 0 n16 ns505 0 -0.000665554160123
Gc8_506 0 n16 ns506 0 0.000528463329933
Gc8_507 0 n16 ns507 0 8.61136875184e-05
Gc8_508 0 n16 ns508 0 0.000353839324843
Gc8_509 0 n16 ns509 0 -0.000498677633855
Gc8_510 0 n16 ns510 0 -0.000233096442424
Gc8_511 0 n16 ns511 0 -0.00219950665914
Gc8_512 0 n16 ns512 0 -0.000983464654341
Gc8_513 0 n16 ns513 0 -4.60654624564e-05
Gc8_514 0 n16 ns514 0 0.000339398436735
Gc8_515 0 n16 ns515 0 0.000332670962176
Gc8_516 0 n16 ns516 0 -0.00412469316809
Gc8_517 0 n16 ns517 0 0.000482455433178
Gc8_518 0 n16 ns518 0 0.000101770677049
Gc8_519 0 n16 ns519 0 0.00147668311287
Gc8_520 0 n16 ns520 0 0.00106721735231
Gc8_521 0 n16 ns521 0 -0.00147401474013
Gc8_522 0 n16 ns522 0 -0.00280263122668
Gc8_523 0 n16 ns523 0 0.0013798127924
Gc8_524 0 n16 ns524 0 -0.00180417660962
Gc8_525 0 n16 ns525 0 0.000542210467584
Gc8_526 0 n16 ns526 0 0.00209968767163
Gc8_527 0 n16 ns527 0 8.57756979623e-05
Gc8_528 0 n16 ns528 0 0.0381887177492
Gc8_529 0 n16 ns529 0 -0.0418786921695
Gc8_530 0 n16 ns530 0 0.00445754545423
Gc8_531 0 n16 ns531 0 3.19200589927e-06
Gc8_532 0 n16 ns532 0 2.56901304158e-05
Gc8_533 0 n16 ns533 0 -0.00464904437673
Gc8_534 0 n16 ns534 0 0.000376747197096
Gc8_535 0 n16 ns535 0 -0.00680082092219
Gc8_536 0 n16 ns536 0 -4.45284801346e-05
Gc8_537 0 n16 ns537 0 -0.00115320560851
Gc8_538 0 n16 ns538 0 -9.22361834019e-05
Gc8_539 0 n16 ns539 0 0.000165550351021
Gc8_540 0 n16 ns540 0 -0.000105773133274
Gc8_541 0 n16 ns541 0 -4.50946575303e-05
Gc8_542 0 n16 ns542 0 -0.00208396405849
Gc8_543 0 n16 ns543 0 0.00315756409511
Gc8_544 0 n16 ns544 0 0.000379926613345
Gc8_545 0 n16 ns545 0 -0.00063192023523
Gc8_546 0 n16 ns546 0 0.000400876583604
Gc8_547 0 n16 ns547 0 -0.00035722128207
Gc8_548 0 n16 ns548 0 0.000507314161298
Gc8_549 0 n16 ns549 0 0.00280720326592
Gc8_550 0 n16 ns550 0 0.000778263690164
Gc8_551 0 n16 ns551 0 -0.000707284323821
Gc8_552 0 n16 ns552 0 0.000398619713887
Gc8_553 0 n16 ns553 0 0.000181070778679
Gc8_554 0 n16 ns554 0 0.00275919206186
Gc8_555 0 n16 ns555 0 0.00154190831889
Gc8_556 0 n16 ns556 0 0.000432735194637
Gc8_557 0 n16 ns557 0 0.00193039598074
Gc8_558 0 n16 ns558 0 0.00159176613436
Gc8_559 0 n16 ns559 0 -0.00154324039277
Gc8_560 0 n16 ns560 0 0.00393403147195
Gc8_561 0 n16 ns561 0 -0.00149353462604
Gc8_562 0 n16 ns562 0 0.001246222356
Gc8_563 0 n16 ns563 0 0.000714407761057
Gc8_564 0 n16 ns564 0 0.00295666854466
Gc8_565 0 n16 ns565 0 0.000333684792888
Gc8_566 0 n16 ns566 0 -0.00982343778666
Gc8_567 0 n16 ns567 0 0.0135837801712
Gc8_568 0 n16 ns568 0 0.00706098853863
Gc8_569 0 n16 ns569 0 -1.27186559638e-06
Gc8_570 0 n16 ns570 0 3.20420097247e-05
Gc8_571 0 n16 ns571 0 -0.00441998005909
Gc8_572 0 n16 ns572 0 -0.0023208170341
Gc8_573 0 n16 ns573 0 -0.00122115324218
Gc8_574 0 n16 ns574 0 0.000758170634072
Gc8_575 0 n16 ns575 0 -0.00134279398238
Gc8_576 0 n16 ns576 0 1.8056615265e-06
Gc8_577 0 n16 ns577 0 0.000942111761
Gc8_578 0 n16 ns578 0 -9.42222597321e-05
Gc8_579 0 n16 ns579 0 -5.8170460433e-05
Gc8_580 0 n16 ns580 0 -0.000898324300723
Gc8_581 0 n16 ns581 0 0.000610984463698
Gc8_582 0 n16 ns582 0 0.000859160407179
Gc8_583 0 n16 ns583 0 -0.00055593546647
Gc8_584 0 n16 ns584 0 0.000338349985381
Gc8_585 0 n16 ns585 0 -0.000233738015068
Gc8_586 0 n16 ns586 0 -0.000825021576218
Gc8_587 0 n16 ns587 0 -0.00115784588738
Gc8_588 0 n16 ns588 0 0.000498123139865
Gc8_589 0 n16 ns589 0 -2.33047814811e-05
Gc8_590 0 n16 ns590 0 0.000274061622146
Gc8_591 0 n16 ns591 0 0.000289238423505
Gc8_592 0 n16 ns592 0 -0.00273422578282
Gc8_593 0 n16 ns593 0 0.00137005319139
Gc8_594 0 n16 ns594 0 0.00123271686921
Gc8_595 0 n16 ns595 0 0.00115424492845
Gc8_596 0 n16 ns596 0 0.00108087383157
Gc8_597 0 n16 ns597 0 -0.00125174297998
Gc8_598 0 n16 ns598 0 0.00041900327479
Gc8_599 0 n16 ns599 0 0.00208734108227
Gc8_600 0 n16 ns600 0 -2.24187935664e-05
Gc8_601 0 n16 ns601 0 -0.00128852419546
Gc8_602 0 n16 ns602 0 0.00223226615172
Gc8_603 0 n16 ns603 0 0.000644432535978
Gc8_604 0 n16 ns604 0 0.0168342214831
Gc8_605 0 n16 ns605 0 -0.0175119227949
Gc8_606 0 n16 ns606 0 0.00648940479227
Gc8_607 0 n16 ns607 0 -2.61196059208e-06
Gc8_608 0 n16 ns608 0 2.68853638396e-05
Gc8_609 0 n16 ns609 0 -2.98437905357e-05
Gc8_610 0 n16 ns610 0 -0.00010311222811
Gc8_611 0 n16 ns611 0 -0.00107714501206
Gc8_612 0 n16 ns612 0 -0.000183981779058
Gc8_613 0 n16 ns613 0 7.28424866016e-05
Gc8_614 0 n16 ns614 0 3.83439256914e-05
Gc8_615 0 n16 ns615 0 0.000162699912055
Gc8_616 0 n16 ns616 0 3.92274528933e-05
Gc8_617 0 n16 ns617 0 -1.6280434838e-05
Gc8_618 0 n16 ns618 0 -0.00039864277765
Gc8_619 0 n16 ns619 0 -7.37052864012e-05
Gc8_620 0 n16 ns620 0 0.000312698460484
Gc8_621 0 n16 ns621 0 0.000202839467908
Gc8_622 0 n16 ns622 0 5.04911261281e-05
Gc8_623 0 n16 ns623 0 -0.000132427104153
Gc8_624 0 n16 ns624 0 4.91687915123e-05
Gc8_625 0 n16 ns625 0 0.000789801112628
Gc8_626 0 n16 ns626 0 0.000397124631881
Gc8_627 0 n16 ns627 0 -0.000288993938668
Gc8_628 0 n16 ns628 0 -7.43188247827e-05
Gc8_629 0 n16 ns629 0 -0.000115779340349
Gc8_630 0 n16 ns630 0 0.000412424339955
Gc8_631 0 n16 ns631 0 -0.000123825301629
Gc8_632 0 n16 ns632 0 -0.000211023655716
Gc8_633 0 n16 ns633 0 9.17769326375e-05
Gc8_634 0 n16 ns634 0 0.000156585186091
Gc8_635 0 n16 ns635 0 -1.92096309725e-05
Gc8_636 0 n16 ns636 0 0.000544484932333
Gc8_637 0 n16 ns637 0 0.00103662440197
Gc8_638 0 n16 ns638 0 0.000330672171926
Gc8_639 0 n16 ns639 0 -0.000199205962369
Gc8_640 0 n16 ns640 0 -9.36153429188e-05
Gc8_641 0 n16 ns641 0 -0.000191364376695
Gc8_642 0 n16 ns642 0 0.010405235365
Gc8_643 0 n16 ns643 0 -0.00878654158191
Gc8_644 0 n16 ns644 0 0.00023431379254
Gc8_645 0 n16 ns645 0 5.6144107845e-06
Gc8_646 0 n16 ns646 0 -2.7161341871e-05
Gc8_647 0 n16 ns647 0 0.00014484460469
Gc8_648 0 n16 ns648 0 -0.000232019237845
Gc8_649 0 n16 ns649 0 -0.000626878531587
Gc8_650 0 n16 ns650 0 -0.000240983314119
Gc8_651 0 n16 ns651 0 0.000160353897679
Gc8_652 0 n16 ns652 0 8.32422996228e-05
Gc8_653 0 n16 ns653 0 0.000155800024178
Gc8_654 0 n16 ns654 0 2.97801575648e-05
Gc8_655 0 n16 ns655 0 -1.11594771982e-05
Gc8_656 0 n16 ns656 0 -0.000358118097266
Gc8_657 0 n16 ns657 0 -0.000374542175814
Gc8_658 0 n16 ns658 0 0.000283504497823
Gc8_659 0 n16 ns659 0 0.000355643948442
Gc8_660 0 n16 ns660 0 9.95774843939e-05
Gc8_661 0 n16 ns661 0 -0.000129716719599
Gc8_662 0 n16 ns662 0 -9.306599898e-05
Gc8_663 0 n16 ns663 0 0.000770489717329
Gc8_664 0 n16 ns664 0 0.000478195960727
Gc8_665 0 n16 ns665 0 -0.000235938668385
Gc8_666 0 n16 ns666 0 -7.27900641869e-05
Gc8_667 0 n16 ns667 0 -0.000144449969318
Gc8_668 0 n16 ns668 0 0.000351195330386
Gc8_669 0 n16 ns669 0 -0.000343272893614
Gc8_670 0 n16 ns670 0 -0.000397911447077
Gc8_671 0 n16 ns671 0 0.000146524928207
Gc8_672 0 n16 ns672 0 0.000277115611889
Gc8_673 0 n16 ns673 0 1.21072837848e-05
Gc8_674 0 n16 ns674 0 0.000138677447494
Gc8_675 0 n16 ns675 0 0.000941737153165
Gc8_676 0 n16 ns676 0 0.000397553088309
Gc8_677 0 n16 ns677 0 -6.33879173381e-05
Gc8_678 0 n16 ns678 0 -5.85666907752e-05
Gc8_679 0 n16 ns679 0 -0.0002336755782
Gc8_680 0 n16 ns680 0 0.00859022312862
Gc8_681 0 n16 ns681 0 -0.0072809913758
Gc8_682 0 n16 ns682 0 0.000183062056148
Gc8_683 0 n16 ns683 0 4.87655716879e-06
Gc8_684 0 n16 ns684 0 -2.96469964052e-05
Gc8_685 0 n16 ns685 0 0.00051997110531
Gc8_686 0 n16 ns686 0 -0.00105213150254
Gc8_687 0 n16 ns687 0 0.00193168750911
Gc8_688 0 n16 ns688 0 -0.000114848294677
Gc8_689 0 n16 ns689 0 0.000142269494332
Gc8_690 0 n16 ns690 0 2.78646638142e-05
Gc8_691 0 n16 ns691 0 3.69954237162e-05
Gc8_692 0 n16 ns692 0 -5.1079968154e-06
Gc8_693 0 n16 ns693 0 -4.58598894501e-07
Gc8_694 0 n16 ns694 0 0.000287529805299
Gc8_695 0 n16 ns695 0 -0.000900089953016
Gc8_696 0 n16 ns696 0 -0.000253497653552
Gc8_697 0 n16 ns697 0 0.000510097115906
Gc8_698 0 n16 ns698 0 0.000200808731387
Gc8_699 0 n16 ns699 0 3.51197994644e-05
Gc8_700 0 n16 ns700 0 -0.000649712649909
Gc8_701 0 n16 ns701 0 -5.66754397963e-05
Gc8_702 0 n16 ns702 0 0.000417413935834
Gc8_703 0 n16 ns703 0 0.000325917678047
Gc8_704 0 n16 ns704 0 3.19930562755e-05
Gc8_705 0 n16 ns705 0 -0.000166850810521
Gc8_706 0 n16 ns706 0 -2.6560794932e-05
Gc8_707 0 n16 ns707 0 -0.000931799148368
Gc8_708 0 n16 ns708 0 -0.00103967005364
Gc8_709 0 n16 ns709 0 7.5677276624e-05
Gc8_710 0 n16 ns710 0 0.000635033431719
Gc8_711 0 n16 ns711 0 0.000295704623428
Gc8_712 0 n16 ns712 0 -0.00198180425845
Gc8_713 0 n16 ns713 0 0.000358529321133
Gc8_714 0 n16 ns714 0 0.000693850335779
Gc8_715 0 n16 ns715 0 0.000678042330407
Gc8_716 0 n16 ns716 0 0.000160289453145
Gc8_717 0 n16 ns717 0 -0.0004318914336
Gc8_718 0 n16 ns718 0 -0.00033741380888
Gc8_719 0 n16 ns719 0 -2.23640082436e-05
Gc8_720 0 n16 ns720 0 -4.18206503707e-05
Gc8_721 0 n16 ns721 0 7.33065361948e-06
Gc8_722 0 n16 ns722 0 -3.41244483262e-05
Gc8_723 0 n16 ns723 0 0.000412896595292
Gc8_724 0 n16 ns724 0 -0.000546513376743
Gc8_725 0 n16 ns725 0 0.00318752710015
Gc8_726 0 n16 ns726 0 -0.000158892206197
Gc8_727 0 n16 ns727 0 0.000330579603705
Gc8_728 0 n16 ns728 0 0.000227443574255
Gc8_729 0 n16 ns729 0 6.58732460104e-06
Gc8_730 0 n16 ns730 0 9.06366226357e-06
Gc8_731 0 n16 ns731 0 -4.39788484247e-05
Gc8_732 0 n16 ns732 0 0.00067958452904
Gc8_733 0 n16 ns733 0 -0.000902202327974
Gc8_734 0 n16 ns734 0 -0.000519307465894
Gc8_735 0 n16 ns735 0 0.000143437158701
Gc8_736 0 n16 ns736 0 0.000189322167692
Gc8_737 0 n16 ns737 0 0.000225349457248
Gc8_738 0 n16 ns738 0 -0.000169797134361
Gc8_739 0 n16 ns739 0 -0.00130111199852
Gc8_740 0 n16 ns740 0 -0.000369158907303
Gc8_741 0 n16 ns741 0 0.000764276141195
Gc8_742 0 n16 ns742 0 0.000158810847376
Gc8_743 0 n16 ns743 0 -6.04623444344e-05
Gc8_744 0 n16 ns744 0 -0.000201298503873
Gc8_745 0 n16 ns745 0 -0.00139326405699
Gc8_746 0 n16 ns746 0 -0.00138974995607
Gc8_747 0 n16 ns747 0 -0.000701891388781
Gc8_748 0 n16 ns748 0 0.000641607218268
Gc8_749 0 n16 ns749 0 0.000959604091647
Gc8_750 0 n16 ns750 0 -0.00416815729697
Gc8_751 0 n16 ns751 0 -0.0013901823786
Gc8_752 0 n16 ns752 0 0.000594799758508
Gc8_753 0 n16 ns753 0 0.00188185557697
Gc8_754 0 n16 ns754 0 0.000615647095561
Gc8_755 0 n16 ns755 0 -0.000603811367647
Gc8_756 0 n16 ns756 0 -0.0120708717004
Gc8_757 0 n16 ns757 0 0.00965949983718
Gc8_758 0 n16 ns758 0 -0.000346783461579
Gc8_759 0 n16 ns759 0 2.59405110798e-06
Gc8_760 0 n16 ns760 0 -2.66859903036e-05
Gc8_761 0 n16 ns761 0 0.000266089535667
Gc8_762 0 n16 ns762 0 -0.000964949390063
Gc8_763 0 n16 ns763 0 0.0067286605614
Gc8_764 0 n16 ns764 0 0.00014777776241
Gc8_765 0 n16 ns765 0 0.000297273872433
Gc8_766 0 n16 ns766 0 0.000332703578552
Gc8_767 0 n16 ns767 0 6.83507460323e-05
Gc8_768 0 n16 ns768 0 -2.6537452011e-07
Gc8_769 0 n16 ns769 0 2.84133409074e-06
Gc8_770 0 n16 ns770 0 -0.000307186409169
Gc8_771 0 n16 ns771 0 -0.00210198119842
Gc8_772 0 n16 ns772 0 -1.06464198392e-05
Gc8_773 0 n16 ns773 0 0.000265099056055
Gc8_774 0 n16 ns774 0 0.000215834173639
Gc8_775 0 n16 ns775 0 0.000370814829753
Gc8_776 0 n16 ns776 0 0.000622514838816
Gc8_777 0 n16 ns777 0 -0.00113236467134
Gc8_778 0 n16 ns778 0 -0.00107092124623
Gc8_779 0 n16 ns779 0 0.000248172985253
Gc8_780 0 n16 ns780 0 0.00017427479848
Gc8_781 0 n16 ns781 0 4.83118140017e-05
Gc8_782 0 n16 ns782 0 -0.00123508184315
Gc8_783 0 n16 ns783 0 -0.00250984150944
Gc8_784 0 n16 ns784 0 -0.00117362258287
Gc8_785 0 n16 ns785 0 -0.00117344376334
Gc8_786 0 n16 ns786 0 0.000335458459867
Gc8_787 0 n16 ns787 0 0.00152110031192
Gc8_788 0 n16 ns788 0 -0.00695713678714
Gc8_789 0 n16 ns789 0 -0.00438936398317
Gc8_790 0 n16 ns790 0 -0.000237804493005
Gc8_791 0 n16 ns791 0 0.00359463034026
Gc8_792 0 n16 ns792 0 0.0014601843729
Gc8_793 0 n16 ns793 0 -0.000644011566535
Gc8_794 0 n16 ns794 0 -0.0383921298217
Gc8_795 0 n16 ns795 0 0.0322272271773
Gc8_796 0 n16 ns796 0 -0.00123571054261
Gc8_797 0 n16 ns797 0 -4.91577332881e-06
Gc8_798 0 n16 ns798 0 -7.62450199661e-06
Gc8_799 0 n16 ns799 0 0.000710841589503
Gc8_800 0 n16 ns800 0 -0.00100088801851
Gc8_801 0 n16 ns801 0 0.0115884342346
Gc8_802 0 n16 ns802 0 0.00032015082079
Gc8_803 0 n16 ns803 0 0.000589264203851
Gc8_804 0 n16 ns804 0 0.000423551285998
Gc8_805 0 n16 ns805 0 -0.00031078797284
Gc8_806 0 n16 ns806 0 -0.000121711046463
Gc8_807 0 n16 ns807 0 -3.37018858005e-05
Gc8_808 0 n16 ns808 0 3.42222068138e-05
Gc8_809 0 n16 ns809 0 -0.00373236058167
Gc8_810 0 n16 ns810 0 8.51718953379e-05
Gc8_811 0 n16 ns811 0 0.000615703234274
Gc8_812 0 n16 ns812 0 3.38830564481e-06
Gc8_813 0 n16 ns813 0 0.000517803543289
Gc8_814 0 n16 ns814 0 -0.000923581007905
Gc8_815 0 n16 ns815 0 -0.00138757615698
Gc8_816 0 n16 ns816 0 -0.000949204972445
Gc8_817 0 n16 ns817 0 0.000186323129879
Gc8_818 0 n16 ns818 0 0.00035833218088
Gc8_819 0 n16 ns819 0 0.000221479994541
Gc8_820 0 n16 ns820 0 -0.00263786613092
Gc8_821 0 n16 ns821 0 -0.00468588407412
Gc8_822 0 n16 ns822 0 -0.00128658208417
Gc8_823 0 n16 ns823 0 -0.000301595282172
Gc8_824 0 n16 ns824 0 0.000224104536375
Gc8_825 0 n16 ns825 0 0.00159232064784
Gc8_826 0 n16 ns826 0 -0.00973574745833
Gc8_827 0 n16 ns827 0 -0.00623419843643
Gc8_828 0 n16 ns828 0 -0.00177540530519
Gc8_829 0 n16 ns829 0 0.00421757107338
Gc8_830 0 n16 ns830 0 0.00246002885763
Gc8_831 0 n16 ns831 0 -0.000250534825291
Gc8_832 0 n16 ns832 0 -0.0780174615515
Gc8_833 0 n16 ns833 0 0.0677665710003
Gc8_834 0 n16 ns834 0 -0.00313334820156
Gc8_835 0 n16 ns835 0 -1.02753616039e-05
Gc8_836 0 n16 ns836 0 1.16054326355e-05
Gc8_837 0 n16 ns837 0 -0.00050329843814
Gc8_838 0 n16 ns838 0 0.000472458611988
Gc8_839 0 n16 ns839 0 0.0050517229686
Gc8_840 0 n16 ns840 0 -0.00128364882367
Gc8_841 0 n16 ns841 0 -0.000563326147122
Gc8_842 0 n16 ns842 0 0.00186786518916
Gc8_843 0 n16 ns843 0 0.000517522355731
Gc8_844 0 n16 ns844 0 -0.000159582540964
Gc8_845 0 n16 ns845 0 -0.000178770780051
Gc8_846 0 n16 ns846 0 0.00125502590862
Gc8_847 0 n16 ns847 0 -0.00135826494295
Gc8_848 0 n16 ns848 0 -8.61208500749e-05
Gc8_849 0 n16 ns849 0 0.00041629849023
Gc8_850 0 n16 ns850 0 -0.000327863198918
Gc8_851 0 n16 ns851 0 0.000352519727786
Gc8_852 0 n16 ns852 0 0.000528088165162
Gc8_853 0 n16 ns853 0 -0.00304202234558
Gc8_854 0 n16 ns854 0 -0.00132149558484
Gc8_855 0 n16 ns855 0 -0.000280639697936
Gc8_856 0 n16 ns856 0 0.000227511870868
Gc8_857 0 n16 ns857 0 0.000511445192002
Gc8_858 0 n16 ns858 0 0.000950642811343
Gc8_859 0 n16 ns859 0 -0.00461467910934
Gc8_860 0 n16 ns860 0 -0.00194566086271
Gc8_861 0 n16 ns861 0 -0.00110730202702
Gc8_862 0 n16 ns862 0 -0.000420951476313
Gc8_863 0 n16 ns863 0 0.00201574784164
Gc8_864 0 n16 ns864 0 -0.0110098128715
Gc8_865 0 n16 ns865 0 -0.00582399590075
Gc8_866 0 n16 ns866 0 -0.00152385417195
Gc8_867 0 n16 ns867 0 0.00270620621172
Gc8_868 0 n16 ns868 0 0.0030932016305
Gc8_869 0 n16 ns869 0 0.000478703737835
Gc8_870 0 n16 ns870 0 -0.0681060167974
Gc8_871 0 n16 ns871 0 0.0651092521358
Gc8_872 0 n16 ns872 0 -0.00643534310694
Gc8_873 0 n16 ns873 0 -1.31752355894e-05
Gc8_874 0 n16 ns874 0 3.16441434338e-05
Gc8_875 0 n16 ns875 0 -0.0172175583799
Gc8_876 0 n16 ns876 0 -0.00101838429947
Gc8_877 0 n16 ns877 0 0.0192606559222
Gc8_878 0 n16 ns878 0 0.00643253705716
Gc8_879 0 n16 ns879 0 0.00994506062643
Gc8_880 0 n16 ns880 0 0.00121160064366
Gc8_881 0 n16 ns881 0 -0.00331087704932
Gc8_882 0 n16 ns882 0 -0.000531509808596
Gc8_883 0 n16 ns883 0 7.5876945565e-05
Gc8_884 0 n16 ns884 0 -0.00185824036694
Gc8_885 0 n16 ns885 0 -0.0140545574946
Gc8_886 0 n16 ns886 0 0.00156205032339
Gc8_887 0 n16 ns887 0 0.002131850375
Gc8_888 0 n16 ns888 0 8.57389743741e-05
Gc8_889 0 n16 ns889 0 0.000142336876496
Gc8_890 0 n16 ns890 0 0.00026138169166
Gc8_891 0 n16 ns891 0 0.0018520666505
Gc8_892 0 n16 ns892 0 0.000465210412444
Gc8_893 0 n16 ns893 0 -0.000358925598641
Gc8_894 0 n16 ns894 0 0.000337643041304
Gc8_895 0 n16 ns895 0 0.000398427107181
Gc8_896 0 n16 ns896 0 -0.0118862974793
Gc8_897 0 n16 ns897 0 -0.0070971001416
Gc8_898 0 n16 ns898 0 -0.00240847624074
Gc8_899 0 n16 ns899 0 -0.000517517165409
Gc8_900 0 n16 ns900 0 -0.000465814537092
Gc8_901 0 n16 ns901 0 0.00170225016639
Gc8_902 0 n16 ns902 0 0.0110997818269
Gc8_903 0 n16 ns903 0 -0.0050282259199
Gc8_904 0 n16 ns904 0 0.000904082634754
Gc8_905 0 n16 ns905 0 0.000796519439875
Gc8_906 0 n16 ns906 0 0.00317216560025
Gc8_907 0 n16 ns907 0 0.000496087317076
Gc8_908 0 n16 ns908 0 -0.105048929636
Gc8_909 0 n16 ns909 0 0.0682637509592
Gc8_910 0 n16 ns910 0 -0.00887943612941
Gc8_911 0 n16 ns911 0 -1.35948302273e-05
Gc8_912 0 n16 ns912 0 2.63095647389e-05
Gc8_913 0 n16 ns913 0 -0.000521689071738
Gc8_914 0 n16 ns914 0 0.00057766469652
Gc8_915 0 n16 ns915 0 0.00183723534348
Gc8_916 0 n16 ns916 0 -0.00118751126417
Gc8_917 0 n16 ns917 0 -0.000848178476724
Gc8_918 0 n16 ns918 0 0.00157530035139
Gc8_919 0 n16 ns919 0 0.000211730726352
Gc8_920 0 n16 ns920 0 -0.000184839822536
Gc8_921 0 n16 ns921 0 -0.000186594781783
Gc8_922 0 n16 ns922 0 0.00243538831608
Gc8_923 0 n16 ns923 0 -0.000381710300793
Gc8_924 0 n16 ns924 0 -0.000898748760203
Gc8_925 0 n16 ns925 0 0.000628351826146
Gc8_926 0 n16 ns926 0 -0.000278367964503
Gc8_927 0 n16 ns927 0 0.000170080447576
Gc8_928 0 n16 ns928 0 -0.00121620830865
Gc8_929 0 n16 ns929 0 -0.00316118005756
Gc8_930 0 n16 ns930 0 -6.4631423357e-05
Gc8_931 0 n16 ns931 0 0.000291000620874
Gc8_932 0 n16 ns932 0 0.000175971502108
Gc8_933 0 n16 ns933 0 0.000383201339455
Gc8_934 0 n16 ns934 0 0.00196894636633
Gc8_935 0 n16 ns935 0 -0.00387613534224
Gc8_936 0 n16 ns936 0 -0.00221786351561
Gc8_937 0 n16 ns937 0 4.3260768142e-05
Gc8_938 0 n16 ns938 0 -0.000101000767001
Gc8_939 0 n16 ns939 0 0.00109804166756
Gc8_940 0 n16 ns940 0 -0.00838357250345
Gc8_941 0 n16 ns941 0 -0.00222247619859
Gc8_942 0 n16 ns942 0 -0.000860626507493
Gc8_943 0 n16 ns943 0 0.000315508397008
Gc8_944 0 n16 ns944 0 0.00230014604889
Gc8_945 0 n16 ns945 0 0.000771826416834
Gc8_946 0 n16 ns946 0 -0.0441195481724
Gc8_947 0 n16 ns947 0 0.0450879288909
Gc8_948 0 n16 ns948 0 -0.00595813360957
Gc8_949 0 n16 ns949 0 -5.61223026762e-06
Gc8_950 0 n16 ns950 0 2.85137001656e-05
Gc8_951 0 n16 ns951 0 0.000424808807216
Gc8_952 0 n16 ns952 0 -0.000782871009481
Gc8_953 0 n16 ns953 0 0.000885003975495
Gc8_954 0 n16 ns954 0 -0.000217544107067
Gc8_955 0 n16 ns955 0 0.000155801630808
Gc8_956 0 n16 ns956 0 4.84516398966e-05
Gc8_957 0 n16 ns957 0 0.000104805991697
Gc8_958 0 n16 ns958 0 1.01966737742e-05
Gc8_959 0 n16 ns959 0 3.45848350623e-06
Gc8_960 0 n16 ns960 0 3.10543751072e-05
Gc8_961 0 n16 ns961 0 -0.000756408307452
Gc8_962 0 n16 ns962 0 -9.98865259658e-06
Gc8_963 0 n16 ns963 0 0.00051343825226
Gc8_964 0 n16 ns964 0 0.000166480453388
Gc8_965 0 n16 ns965 0 -4.47690011182e-05
Gc8_966 0 n16 ns966 0 -0.000442814153354
Gc8_967 0 n16 ns967 0 0.000374620797276
Gc8_968 0 n16 ns968 0 0.000494062330204
Gc8_969 0 n16 ns969 0 5.34008614707e-05
Gc8_970 0 n16 ns970 0 -2.18548350534e-05
Gc8_971 0 n16 ns971 0 -0.000165035124746
Gc8_972 0 n16 ns972 0 0.000141608008866
Gc8_973 0 n16 ns973 0 -0.000704461035709
Gc8_974 0 n16 ns974 0 -0.000774324828008
Gc8_975 0 n16 ns975 0 0.000153313100279
Gc8_976 0 n16 ns976 0 0.000496944737213
Gc8_977 0 n16 ns977 0 0.000145705251283
Gc8_978 0 n16 ns978 0 -0.00102484119598
Gc8_979 0 n16 ns979 0 0.00062695867642
Gc8_980 0 n16 ns980 0 0.00056303971151
Gc8_981 0 n16 ns981 0 0.000334434649402
Gc8_982 0 n16 ns982 0 5.49256533457e-05
Gc8_983 0 n16 ns983 0 -0.000341650696228
Gc8_984 0 n16 ns984 0 0.00327833089661
Gc8_985 0 n16 ns985 0 -0.0029117126226
Gc8_986 0 n16 ns986 0 3.98961914735e-05
Gc8_987 0 n16 ns987 0 6.51495323341e-06
Gc8_988 0 n16 ns988 0 -3.21953585639e-05
Gc8_989 0 n16 ns989 0 0.000530970025945
Gc8_990 0 n16 ns990 0 -0.000619895993198
Gc8_991 0 n16 ns991 0 0.00272804957289
Gc8_992 0 n16 ns992 0 -0.000167518512029
Gc8_993 0 n16 ns993 0 0.000337584584255
Gc8_994 0 n16 ns994 0 0.000185763335421
Gc8_995 0 n16 ns995 0 -1.87671116558e-06
Gc8_996 0 n16 ns996 0 -1.25199181092e-05
Gc8_997 0 n16 ns997 0 -4.03396340416e-05
Gc8_998 0 n16 ns998 0 0.000710142562299
Gc8_999 0 n16 ns999 0 -0.000964465503232
Gc8_1000 0 n16 ns1000 0 -0.000495468162809
Gc8_1001 0 n16 ns1001 0 0.000316535367619
Gc8_1002 0 n16 ns1002 0 0.000192171020909
Gc8_1003 0 n16 ns1003 0 0.000151941777752
Gc8_1004 0 n16 ns1004 0 -0.000452578520986
Gc8_1005 0 n16 ns1005 0 -0.000968004934595
Gc8_1006 0 n16 ns1006 0 -3.98976726387e-05
Gc8_1007 0 n16 ns1007 0 0.000667715338103
Gc8_1008 0 n16 ns1008 0 0.00011111163498
Gc8_1009 0 n16 ns1009 0 -0.000104034779072
Gc8_1010 0 n16 ns1010 0 -0.000180654485462
Gc8_1011 0 n16 ns1011 0 -0.0013459557021
Gc8_1012 0 n16 ns1012 0 -0.00136805576999
Gc8_1013 0 n16 ns1013 0 -0.000338123058271
Gc8_1014 0 n16 ns1014 0 0.00071213307675
Gc8_1015 0 n16 ns1015 0 0.000694864026348
Gc8_1016 0 n16 ns1016 0 -0.00356030156387
Gc8_1017 0 n16 ns1017 0 -0.00070728663751
Gc8_1018 0 n16 ns1018 0 0.000689827903789
Gc8_1019 0 n16 ns1019 0 0.00145942640752
Gc8_1020 0 n16 ns1020 0 0.000454149368374
Gc8_1021 0 n16 ns1021 0 -0.000548645403912
Gc8_1022 0 n16 ns1022 0 -0.00764063732091
Gc8_1023 0 n16 ns1023 0 0.0059006765291
Gc8_1024 0 n16 ns1024 0 -0.000205868599834
Gc8_1025 0 n16 ns1025 0 5.54961286199e-06
Gc8_1026 0 n16 ns1026 0 -3.15852742319e-05
Gc8_1027 0 n16 ns1027 0 0.000249961294099
Gc8_1028 0 n16 ns1028 0 -0.000376949667142
Gc8_1029 0 n16 ns1029 0 0.00434353997423
Gc8_1030 0 n16 ns1030 0 -0.000227982139243
Gc8_1031 0 n16 ns1031 0 0.000435276246408
Gc8_1032 0 n16 ns1032 0 0.000378917507129
Gc8_1033 0 n16 ns1033 0 7.89025553846e-05
Gc8_1034 0 n16 ns1034 0 2.32009750945e-05
Gc8_1035 0 n16 ns1035 0 -1.68722276664e-05
Gc8_1036 0 n16 ns1036 0 0.000263185638564
Gc8_1037 0 n16 ns1037 0 -0.00134555291341
Gc8_1038 0 n16 ns1038 0 -0.000247789285643
Gc8_1039 0 n16 ns1039 0 0.000144628848682
Gc8_1040 0 n16 ns1040 0 0.00021245491956
Gc8_1041 0 n16 ns1041 0 0.000295940437135
Gc8_1042 0 n16 ns1042 0 0.000623416557979
Gc8_1043 0 n16 ns1043 0 -0.00125112194673
Gc8_1044 0 n16 ns1044 0 -0.000869782832994
Gc8_1045 0 n16 ns1045 0 0.000429064069792
Gc8_1046 0 n16 ns1046 0 0.000145584982378
Gc8_1047 0 n16 ns1047 0 4.14540154873e-06
Gc8_1048 0 n16 ns1048 0 -0.000472281409992
Gc8_1049 0 n16 ns1049 0 -0.00193052522022
Gc8_1050 0 n16 ns1050 0 -0.00125689669692
Gc8_1051 0 n16 ns1051 0 -0.00120001067809
Gc8_1052 0 n16 ns1052 0 0.000407595454059
Gc8_1053 0 n16 ns1053 0 0.00136855243723
Gc8_1054 0 n16 ns1054 0 -0.00552034708611
Gc8_1055 0 n16 ns1055 0 -0.00326188299583
Gc8_1056 0 n16 ns1056 0 0.000140914758374
Gc8_1057 0 n16 ns1057 0 0.00290380041029
Gc8_1058 0 n16 ns1058 0 0.00108030412603
Gc8_1059 0 n16 ns1059 0 -0.000654391405275
Gc8_1060 0 n16 ns1060 0 -0.0250920080924
Gc8_1061 0 n16 ns1061 0 0.0208821170294
Gc8_1062 0 n16 ns1062 0 -0.000795283193733
Gc8_1063 0 n16 ns1063 0 -1.74439905536e-06
Gc8_1064 0 n16 ns1064 0 -1.76895665782e-05
Gc8_1065 0 n16 ns1065 0 0.0006038069562
Gc8_1066 0 n16 ns1066 0 -0.00202051264169
Gc8_1067 0 n16 ns1067 0 0.0107601138858
Gc8_1068 0 n16 ns1068 0 0.00056689341485
Gc8_1069 0 n16 ns1069 0 8.10952503996e-05
Gc8_1070 0 n16 ns1070 0 6.73494747198e-05
Gc8_1071 0 n16 ns1071 0 -2.85566453801e-05
Gc8_1072 0 n16 ns1072 0 -4.81094216905e-05
Gc8_1073 0 n16 ns1073 0 8.83366151857e-06
Gc8_1074 0 n16 ns1074 0 -0.00027543392981
Gc8_1075 0 n16 ns1075 0 -0.00310520176479
Gc8_1076 0 n16 ns1076 0 -1.72415441837e-05
Gc8_1077 0 n16 ns1077 0 0.000505960141207
Gc8_1078 0 n16 ns1078 0 0.000120801693051
Gc8_1079 0 n16 ns1079 0 0.00050526383592
Gc8_1080 0 n16 ns1080 0 -0.000301915964445
Gc8_1081 0 n16 ns1081 0 -0.000829307187319
Gc8_1082 0 n16 ns1082 0 -0.00088445810401
Gc8_1083 0 n16 ns1083 0 9.38977512412e-05
Gc8_1084 0 n16 ns1084 0 0.000272325954587
Gc8_1085 0 n16 ns1085 0 9.45461959574e-05
Gc8_1086 0 n16 ns1086 0 -0.00236094921183
Gc8_1087 0 n16 ns1087 0 -0.00360818244187
Gc8_1088 0 n16 ns1088 0 -0.000981929564394
Gc8_1089 0 n16 ns1089 0 -0.000597598846024
Gc8_1090 0 n16 ns1090 0 0.000206966081166
Gc8_1091 0 n16 ns1091 0 0.00147450950054
Gc8_1092 0 n16 ns1092 0 -0.00839845416791
Gc8_1093 0 n16 ns1093 0 -0.00567281432215
Gc8_1094 0 n16 ns1094 0 -0.00129894079005
Gc8_1095 0 n16 ns1095 0 0.00414713162874
Gc8_1096 0 n16 ns1096 0 0.00209024423362
Gc8_1097 0 n16 ns1097 0 -0.000417808865872
Gc8_1098 0 n16 ns1098 0 -0.0622508918308
Gc8_1099 0 n16 ns1099 0 0.0533360256985
Gc8_1100 0 n16 ns1100 0 -0.00224618332366
Gc8_1101 0 n16 ns1101 0 -8.82273207432e-06
Gc8_1102 0 n16 ns1102 0 6.08053640666e-07
Gc8_1103 0 n16 ns1103 0 6.71259295902e-05
Gc8_1104 0 n16 ns1104 0 -0.000574154492174
Gc8_1105 0 n16 ns1105 0 0.00924614688549
Gc8_1106 0 n16 ns1106 0 -0.000218280151084
Gc8_1107 0 n16 ns1107 0 6.17809388986e-05
Gc8_1108 0 n16 ns1108 0 0.000556817287238
Gc8_1109 0 n16 ns1109 0 -0.000575507114806
Gc8_1110 0 n16 ns1110 0 -8.11295778564e-05
Gc8_1111 0 n16 ns1111 0 6.41715834602e-06
Gc8_1112 0 n16 ns1112 0 0.0013848871167
Gc8_1113 0 n16 ns1113 0 -0.00143082107415
Gc8_1114 0 n16 ns1114 0 -0.000183046097681
Gc8_1115 0 n16 ns1115 0 8.85367621586e-05
Gc8_1116 0 n16 ns1116 0 -0.000317927163456
Gc8_1117 0 n16 ns1117 0 0.000424442718768
Gc8_1118 0 n16 ns1118 0 -0.000506062841486
Gc8_1119 0 n16 ns1119 0 -0.00251450463325
Gc8_1120 0 n16 ns1120 0 -0.00117547859228
Gc8_1121 0 n16 ns1121 0 0.00012836028832
Gc8_1122 0 n16 ns1122 0 0.000332210974166
Gc8_1123 0 n16 ns1123 0 0.000437253545011
Gc8_1124 0 n16 ns1124 0 -0.000411174539732
Gc8_1125 0 n16 ns1125 0 -0.00577034038595
Gc8_1126 0 n16 ns1126 0 -0.00215171901073
Gc8_1127 0 n16 ns1127 0 -0.000644196929298
Gc8_1128 0 n16 ns1128 0 2.61118112522e-05
Gc8_1129 0 n16 ns1129 0 0.00198693042292
Gc8_1130 0 n16 ns1130 0 -0.0100800460581
Gc8_1131 0 n16 ns1131 0 -0.00595747398279
Gc8_1132 0 n16 ns1132 0 -0.00225917884932
Gc8_1133 0 n16 ns1133 0 0.00285466241281
Gc8_1134 0 n16 ns1134 0 0.00276621987838
Gc8_1135 0 n16 ns1135 0 0.00030451149173
Gc8_1136 0 n16 ns1136 0 -0.0912921579318
Gc8_1137 0 n16 ns1137 0 0.0832400048871
Gc8_1138 0 n16 ns1138 0 -0.00528832560668
Gc8_1139 0 n16 ns1139 0 -1.25962519481e-05
Gc8_1140 0 n16 ns1140 0 2.08522215341e-05
Gc8_1141 0 n16 ns1141 0 -0.00557085035292
Gc8_1142 0 n16 ns1142 0 -0.00412770082883
Gc8_1143 0 n16 ns1143 0 0.00640956676497
Gc8_1144 0 n16 ns1144 0 0.00236009488265
Gc8_1145 0 n16 ns1145 0 -0.0022124658833
Gc8_1146 0 n16 ns1146 0 0.000659681713504
Gc8_1147 0 n16 ns1147 0 0.00297526998073
Gc8_1148 0 n16 ns1148 0 1.09829326804e-05
Gc8_1149 0 n16 ns1149 0 -0.000278159834427
Gc8_1150 0 n16 ns1150 0 -0.00202960502629
Gc8_1151 0 n16 ns1151 0 -0.00117897301396
Gc8_1152 0 n16 ns1152 0 -3.98924878759e-05
Gc8_1153 0 n16 ns1153 0 0.000683743912858
Gc8_1154 0 n16 ns1154 0 -0.000253912226794
Gc8_1155 0 n16 ns1155 0 0.000284582180144
Gc8_1156 0 n16 ns1156 0 0.00327647703433
Gc8_1157 0 n16 ns1157 0 -0.000926191550857
Gc8_1158 0 n16 ns1158 0 -0.000519802534466
Gc8_1159 0 n16 ns1159 0 -0.00162590894108
Gc8_1160 0 n16 ns1160 0 -2.65809199549e-06
Gc8_1161 0 n16 ns1161 0 0.000200354222405
Gc8_1162 0 n16 ns1162 0 0.00245993259403
Gc8_1163 0 n16 ns1163 0 0.00200999386717
Gc8_1164 0 n16 ns1164 0 -6.28687963531e-05
Gc8_1165 0 n16 ns1165 0 -0.00212789402158
Gc8_1166 0 n16 ns1166 0 -0.0016773233462
Gc8_1167 0 n16 ns1167 0 0.00143908065522
Gc8_1168 0 n16 ns1168 0 -0.0116393025087
Gc8_1169 0 n16 ns1169 0 -0.00486530113444
Gc8_1170 0 n16 ns1170 0 0.00128181262913
Gc8_1171 0 n16 ns1171 0 0.00285570010455
Gc8_1172 0 n16 ns1172 0 0.00354348106435
Gc8_1173 0 n16 ns1173 0 0.000520181072792
Gc8_1174 0 n16 ns1174 0 0.0175679074403
Gc8_1175 0 n16 ns1175 0 -0.0077692208808
Gc8_1176 0 n16 ns1176 0 -0.00776808644732
Gc8_1177 0 n16 ns1177 0 -1.47612282969e-05
Gc8_1178 0 n16 ns1178 0 2.62159594006e-05
Gc8_1179 0 n16 ns1179 0 -0.00252990585192
Gc8_1180 0 n16 ns1180 0 -0.00229797951461
Gc8_1181 0 n16 ns1181 0 0.00509802738841
Gc8_1182 0 n16 ns1182 0 0.00114905526683
Gc8_1183 0 n16 ns1183 0 -0.00191477290721
Gc8_1184 0 n16 ns1184 0 0.000431182898841
Gc8_1185 0 n16 ns1185 0 0.0017578308434
Gc8_1186 0 n16 ns1186 0 -1.21808625197e-05
Gc8_1187 0 n16 ns1187 0 -0.00022986810081
Gc8_1188 0 n16 ns1188 0 0.000730928970962
Gc8_1189 0 n16 ns1189 0 -0.000489434193355
Gc8_1190 0 n16 ns1190 0 -0.000896645318177
Gc8_1191 0 n16 ns1191 0 0.000606334699161
Gc8_1192 0 n16 ns1192 0 -0.000330680950423
Gc8_1193 0 n16 ns1193 0 0.000223785588592
Gc8_1194 0 n16 ns1194 0 0.000458642138298
Gc8_1195 0 n16 ns1195 0 -0.00218337666917
Gc8_1196 0 n16 ns1196 0 0.000124372794422
Gc8_1197 0 n16 ns1197 0 -0.000396841518669
Gc8_1198 0 n16 ns1198 0 0.00014851653519
Gc8_1199 0 n16 ns1199 0 0.000290638155359
Gc8_1200 0 n16 ns1200 0 0.00223803240489
Gc8_1201 0 n16 ns1201 0 -0.00143213586728
Gc8_1202 0 n16 ns1202 0 -0.00176809241308
Gc8_1203 0 n16 ns1203 0 -0.000604151701483
Gc8_1204 0 n16 ns1204 0 -0.000622347933797
Gc8_1205 0 n16 ns1205 0 0.00125458505847
Gc8_1206 0 n16 ns1206 0 -0.00864890429929
Gc8_1207 0 n16 ns1207 0 -0.0027312585982
Gc8_1208 0 n16 ns1208 0 -0.000227920397216
Gc8_1209 0 n16 ns1209 0 0.000421860657592
Gc8_1210 0 n16 ns1210 0 0.00268752971811
Gc8_1211 0 n16 ns1211 0 0.000793246454451
Gc8_1212 0 n16 ns1212 0 -0.026632101282
Gc8_1213 0 n16 ns1213 0 0.0308073209283
Gc8_1214 0 n16 ns1214 0 -0.00704877858097
Gc8_1215 0 n16 ns1215 0 -8.38436610596e-06
Gc8_1216 0 n16 ns1216 0 2.67720653793e-05
Gd8_1 0 n16 ni1 0 -9.75473280109e-05
Gd8_2 0 n16 ni2 0 -9.44310749885e-05
Gd8_3 0 n16 ni3 0 -0.00010260942814
Gd8_4 0 n16 ni4 0 -2.59284838778e-06
Gd8_5 0 n16 ni5 0 0.000288386828226
Gd8_6 0 n16 ni6 0 -0.00028200124898
Gd8_7 0 n16 ni7 0 -0.00166847189468
Gd8_8 0 n16 ni8 0 0.000365756018528
Gd8_9 0 n16 ni9 0 -0.00203772843668
Gd8_10 0 n16 ni10 0 -0.000133075751567
Gd8_11 0 n16 ni11 0 2.89065555629e-05
Gd8_12 0 n16 ni12 0 0.000162512960967
Gd8_13 0 n16 ni13 0 0.000260596837988
Gd8_14 0 n16 ni14 0 -0.00102238760057
Gd8_15 0 n16 ni15 0 -0.000586798528644
Gd8_16 0 n16 ni16 0 -0.00277637356803
Gd8_17 0 n16 ni17 0 -9.95849107822e-05
Gd8_18 0 n16 ni18 0 -1.35949582826e-05
Gd8_19 0 n16 ni19 0 4.34817714258e-05
Gd8_20 0 n16 ni20 0 0.00020758172816
Gd8_21 0 n16 ni21 0 0.000106738765297
Gd8_22 0 n16 ni22 0 0.000519582356148
Gd8_23 0 n16 ni23 0 -0.000304342131536
Gd8_24 0 n16 ni24 0 -0.00683612786834
Gd8_25 0 n16 ni25 0 -0.000469003298944
Gd8_26 0 n16 ni26 0 3.10343361232e-05
Gd8_27 0 n16 ni27 0 0.000244706634769
Gd8_28 0 n16 ni28 0 0.000205302962799
Gd8_29 0 n16 ni29 0 0.000123052325207
Gd8_30 0 n16 ni30 0 -9.2332155396e-05
Gd8_31 0 n16 ni31 0 -0.00305388835481
Gd8_32 0 n16 ni32 0 -0.00151685811825
Gc9_1 0 n18 ns1 0 -0.000211842906234
Gc9_2 0 n18 ns2 0 0.00040794458276
Gc9_3 0 n18 ns3 0 -0.00206576306031
Gc9_4 0 n18 ns4 0 -0.000233791448679
Gc9_5 0 n18 ns5 0 -6.40704442776e-06
Gc9_6 0 n18 ns6 0 -0.000139354657215
Gc9_7 0 n18 ns7 0 0.000118083209952
Gc9_8 0 n18 ns8 0 2.04967905761e-05
Gc9_9 0 n18 ns9 0 2.97760275819e-05
Gc9_10 0 n18 ns10 0 0.00100308549261
Gc9_11 0 n18 ns11 0 0.000270018609038
Gc9_12 0 n18 ns12 0 -0.000393290548108
Gc9_13 0 n18 ns13 0 3.61456562685e-05
Gc9_14 0 n18 ns14 0 -1.35739814348e-06
Gc9_15 0 n18 ns15 0 9.08327092495e-05
Gc9_16 0 n18 ns16 0 0.00041971484047
Gc9_17 0 n18 ns17 0 0.000229838043752
Gc9_18 0 n18 ns18 0 1.71953466055e-05
Gc9_19 0 n18 ns19 0 -0.000238927736496
Gc9_20 0 n18 ns20 0 -5.52699549781e-05
Gc9_21 0 n18 ns21 0 -1.33416844702e-05
Gc9_22 0 n18 ns22 0 0.000620648409921
Gc9_23 0 n18 ns23 0 -1.48548084433e-05
Gc9_24 0 n18 ns24 0 1.56940658251e-05
Gc9_25 0 n18 ns25 0 -0.000285502426026
Gc9_26 0 n18 ns26 0 -0.000108777635932
Gc9_27 0 n18 ns27 0 0.00013502953138
Gc9_28 0 n18 ns28 0 0.000713663459167
Gc9_29 0 n18 ns29 0 0.000395070259046
Gc9_30 0 n18 ns30 0 0.000140793344786
Gc9_31 0 n18 ns31 0 -0.000169985373554
Gc9_32 0 n18 ns32 0 -7.53237480941e-05
Gc9_33 0 n18 ns33 0 -9.61256172439e-05
Gc9_34 0 n18 ns34 0 0.00824341690864
Gc9_35 0 n18 ns35 0 -0.00690727777559
Gc9_36 0 n18 ns36 0 0.000235779595118
Gc9_37 0 n18 ns37 0 -8.14565660525e-06
Gc9_38 0 n18 ns38 0 -1.99111005448e-05
Gc9_39 0 n18 ns39 0 -0.000188056573053
Gc9_40 0 n18 ns40 0 0.000758497138742
Gc9_41 0 n18 ns41 0 -0.00335642141889
Gc9_42 0 n18 ns42 0 -0.000315783456978
Gc9_43 0 n18 ns43 0 -9.57402639278e-05
Gc9_44 0 n18 ns44 0 -0.000208061601938
Gc9_45 0 n18 ns45 0 0.000115438493122
Gc9_46 0 n18 ns46 0 1.61934403063e-05
Gc9_47 0 n18 ns47 0 3.70396678402e-05
Gc9_48 0 n18 ns48 0 0.00118501759647
Gc9_49 0 n18 ns49 0 0.000713296252896
Gc9_50 0 n18 ns50 0 -0.000521553329916
Gc9_51 0 n18 ns51 0 -0.000102777800416
Gc9_52 0 n18 ns52 0 -3.14378100302e-05
Gc9_53 0 n18 ns53 0 0.000121987823384
Gc9_54 0 n18 ns54 0 0.000447926490061
Gc9_55 0 n18 ns55 0 0.000553281409021
Gc9_56 0 n18 ns56 0 0.000163277450154
Gc9_57 0 n18 ns57 0 -0.00032169877645
Gc9_58 0 n18 ns58 0 -6.49740911734e-05
Gc9_59 0 n18 ns59 0 -5.04250382661e-05
Gc9_60 0 n18 ns60 0 0.00108777539548
Gc9_61 0 n18 ns61 0 0.000300099713712
Gc9_62 0 n18 ns62 0 0.000164300632939
Gc9_63 0 n18 ns63 0 -0.000490906650586
Gc9_64 0 n18 ns64 0 -0.000248487112182
Gc9_65 0 n18 ns65 0 0.000176951886082
Gc9_66 0 n18 ns66 0 0.00146307573444
Gc9_67 0 n18 ns67 0 0.000751910431288
Gc9_68 0 n18 ns68 0 0.000155092538049
Gc9_69 0 n18 ns69 0 -0.000364638226731
Gc9_70 0 n18 ns70 0 -0.000141435194364
Gc9_71 0 n18 ns71 0 -0.000115753389602
Gc9_72 0 n18 ns72 0 0.0149234363479
Gc9_73 0 n18 ns73 0 -0.0126031815706
Gc9_74 0 n18 ns74 0 0.000439212219524
Gc9_75 0 n18 ns75 0 -8.18836255352e-06
Gc9_76 0 n18 ns76 0 -2.20314220924e-05
Gc9_77 0 n18 ns77 0 -6.93843279159e-06
Gc9_78 0 n18 ns78 0 -0.00016394026483
Gc9_79 0 n18 ns79 0 -0.00138692134727
Gc9_80 0 n18 ns80 0 -9.73352558643e-05
Gc9_81 0 n18 ns81 0 -0.000116210110756
Gc9_82 0 n18 ns82 0 -3.20205645334e-05
Gc9_83 0 n18 ns83 0 -3.59747611954e-05
Gc9_84 0 n18 ns84 0 -1.54088368852e-05
Gc9_85 0 n18 ns85 0 -1.99604746642e-05
Gc9_86 0 n18 ns86 0 3.87266289341e-05
Gc9_87 0 n18 ns87 0 0.00107137208322
Gc9_88 0 n18 ns88 0 -0.00011437000571
Gc9_89 0 n18 ns89 0 -0.00049854203548
Gc9_90 0 n18 ns90 0 -0.000127388540979
Gc9_91 0 n18 ns91 0 5.83199859087e-05
Gc9_92 0 n18 ns92 0 -0.000142613281799
Gc9_93 0 n18 ns93 0 0.000862827088889
Gc9_94 0 n18 ns94 0 0.000516456939365
Gc9_95 0 n18 ns95 0 -0.000164037983488
Gc9_96 0 n18 ns96 0 -3.75264594866e-05
Gc9_97 0 n18 ns97 0 -0.00014006793307
Gc9_98 0 n18 ns98 0 0.00103754962326
Gc9_99 0 n18 ns99 0 0.000659164801348
Gc9_100 0 n18 ns100 0 0.000432952572796
Gc9_101 0 n18 ns101 0 -0.000517688593007
Gc9_102 0 n18 ns102 0 -0.000420493870689
Gc9_103 0 n18 ns103 0 0.000108664115046
Gc9_104 0 n18 ns104 0 0.000988644092887
Gc9_105 0 n18 ns105 0 0.000488819676318
Gc9_106 0 n18 ns106 0 0.000186866417606
Gc9_107 0 n18 ns107 0 -7.13544228085e-05
Gc9_108 0 n18 ns108 0 -5.23183824611e-05
Gc9_109 0 n18 ns109 0 -0.000182618083169
Gc9_110 0 n18 ns110 0 0.0117652416888
Gc9_111 0 n18 ns111 0 -0.0100451538753
Gc9_112 0 n18 ns112 0 0.000364024074498
Gc9_113 0 n18 ns113 0 -7.69081204215e-06
Gc9_114 0 n18 ns114 0 -2.73474540903e-05
Gc9_115 0 n18 ns115 0 0.000395059327767
Gc9_116 0 n18 ns116 0 -0.00126338997603
Gc9_117 0 n18 ns117 0 0.00216609396402
Gc9_118 0 n18 ns118 0 0.000196760654982
Gc9_119 0 n18 ns119 0 -0.000144028065561
Gc9_120 0 n18 ns120 0 8.83855617895e-05
Gc9_121 0 n18 ns121 0 2.16252571298e-05
Gc9_122 0 n18 ns122 0 3.65278861132e-05
Gc9_123 0 n18 ns123 0 -3.60856267669e-05
Gc9_124 0 n18 ns124 0 -0.00136708912056
Gc9_125 0 n18 ns125 0 -4.40426119384e-05
Gc9_126 0 n18 ns126 0 0.000712808872922
Gc9_127 0 n18 ns127 0 -0.000253857975197
Gc9_128 0 n18 ns128 0 -0.000140785613441
Gc9_129 0 n18 ns129 0 -0.000128098602247
Gc9_130 0 n18 ns130 0 -0.00134652718195
Gc9_131 0 n18 ns131 0 -0.000140900843526
Gc9_132 0 n18 ns132 0 0.000460161585439
Gc9_133 0 n18 ns133 0 0.000740982882566
Gc9_134 0 n18 ns134 0 0.000154133571747
Gc9_135 0 n18 ns135 0 -0.000135540375832
Gc9_136 0 n18 ns136 0 -0.00043204947599
Gc9_137 0 n18 ns137 0 0.00129868722974
Gc9_138 0 n18 ns138 0 0.000975991144433
Gc9_139 0 n18 ns139 0 0.000137411188845
Gc9_140 0 n18 ns140 0 -0.000524217673718
Gc9_141 0 n18 ns141 0 -0.000379885250958
Gc9_142 0 n18 ns142 0 -0.00039051153517
Gc9_143 0 n18 ns143 0 0.00083185475364
Gc9_144 0 n18 ns144 0 0.000450690359856
Gc9_145 0 n18 ns145 0 0.000344846282091
Gc9_146 0 n18 ns146 0 8.93252235457e-05
Gc9_147 0 n18 ns147 0 -0.000354062653026
Gc9_148 0 n18 ns148 0 0.00685532617579
Gc9_149 0 n18 ns149 0 -0.00642720291105
Gc9_150 0 n18 ns150 0 0.000322579036812
Gc9_151 0 n18 ns151 0 -7.08859510422e-06
Gc9_152 0 n18 ns152 0 -2.33719814766e-05
Gc9_153 0 n18 ns153 0 -0.000137826462485
Gc9_154 0 n18 ns154 0 -0.000285884691498
Gc9_155 0 n18 ns155 0 0.00254878150252
Gc9_156 0 n18 ns156 0 8.01611289101e-05
Gc9_157 0 n18 ns157 0 9.53903474029e-06
Gc9_158 0 n18 ns158 0 -9.21709590303e-05
Gc9_159 0 n18 ns159 0 0.000183857691101
Gc9_160 0 n18 ns160 0 2.00864786764e-05
Gc9_161 0 n18 ns161 0 3.38872403792e-05
Gc9_162 0 n18 ns162 0 -9.18048466471e-05
Gc9_163 0 n18 ns163 0 -0.00102308808134
Gc9_164 0 n18 ns164 0 0.000528461336975
Gc9_165 0 n18 ns165 0 0.000662992089861
Gc9_166 0 n18 ns166 0 -2.30937785215e-06
Gc9_167 0 n18 ns167 0 -0.000255632881812
Gc9_168 0 n18 ns168 0 -9.79713699196e-05
Gc9_169 0 n18 ns169 0 -0.00183929761665
Gc9_170 0 n18 ns170 0 -0.000777897540846
Gc9_171 0 n18 ns171 0 0.000985818170375
Gc9_172 0 n18 ns172 0 0.00024091832701
Gc9_173 0 n18 ns173 0 5.78245547086e-05
Gc9_174 0 n18 ns174 0 -0.0018000847276
Gc9_175 0 n18 ns175 0 -0.000211601717204
Gc9_176 0 n18 ns176 0 0.000535517278778
Gc9_177 0 n18 ns177 0 0.00137006909805
Gc9_178 0 n18 ns178 0 -3.04008583644e-05
Gc9_179 0 n18 ns179 0 -0.000946254123112
Gc9_180 0 n18 ns180 0 -0.00243773128454
Gc9_181 0 n18 ns181 0 -0.000121884659618
Gc9_182 0 n18 ns182 0 0.000472411614248
Gc9_183 0 n18 ns183 0 0.00135439140035
Gc9_184 0 n18 ns184 0 0.000499988617145
Gc9_185 0 n18 ns185 0 -0.000558520943594
Gc9_186 0 n18 ns186 0 0.00127263801866
Gc9_187 0 n18 ns187 0 -0.00247396425654
Gc9_188 0 n18 ns188 0 0.000353465269211
Gc9_189 0 n18 ns189 0 -7.41379242287e-06
Gc9_190 0 n18 ns190 0 -7.11068624155e-06
Gc9_191 0 n18 ns191 0 -0.00127006200107
Gc9_192 0 n18 ns192 0 0.00273646591038
Gc9_193 0 n18 ns193 0 -0.0044410427758
Gc9_194 0 n18 ns194 0 -0.000190248222431
Gc9_195 0 n18 ns195 0 -0.000357519082606
Gc9_196 0 n18 ns196 0 -0.000444358913461
Gc9_197 0 n18 ns197 0 -0.000119674048274
Gc9_198 0 n18 ns198 0 -3.02787210538e-05
Gc9_199 0 n18 ns199 0 3.41639018243e-07
Gc9_200 0 n18 ns200 0 0.000729595386729
Gc9_201 0 n18 ns201 0 0.00192788580651
Gc9_202 0 n18 ns202 0 -0.000584372613878
Gc9_203 0 n18 ns203 0 0.000164559629993
Gc9_204 0 n18 ns204 0 6.51600732126e-05
Gc9_205 0 n18 ns205 0 -0.000248269673143
Gc9_206 0 n18 ns206 0 0.0022018603467
Gc9_207 0 n18 ns207 0 0.00100584458338
Gc9_208 0 n18 ns208 0 -0.000870079378002
Gc9_209 0 n18 ns209 0 -0.000724364763252
Gc9_210 0 n18 ns210 0 0.00012193499697
Gc9_211 0 n18 ns211 0 2.66445853119e-05
Gc9_212 0 n18 ns212 0 0.00163416375762
Gc9_213 0 n18 ns213 0 -0.000698198545013
Gc9_214 0 n18 ns214 0 -0.000667586606649
Gc9_215 0 n18 ns215 0 0.000953124180975
Gc9_216 0 n18 ns216 0 0.000472279393759
Gc9_217 0 n18 ns217 0 -0.000815745839517
Gc9_218 0 n18 ns218 0 0.000899464501144
Gc9_219 0 n18 ns219 0 -0.0010852395204
Gc9_220 0 n18 ns220 0 -0.000722285042082
Gc9_221 0 n18 ns221 0 0.00144972437484
Gc9_222 0 n18 ns222 0 0.000870223063823
Gc9_223 0 n18 ns223 0 -0.000506101911683
Gc9_224 0 n18 ns224 0 0.0225373861288
Gc9_225 0 n18 ns225 0 -0.0206673649335
Gc9_226 0 n18 ns226 0 0.00112982312963
Gc9_227 0 n18 ns227 0 -9.73377556e-06
Gc9_228 0 n18 ns228 0 1.4138881176e-05
Gc9_229 0 n18 ns229 0 -0.00116589838152
Gc9_230 0 n18 ns230 0 0.000771264427617
Gc9_231 0 n18 ns231 0 -0.00100196321041
Gc9_232 0 n18 ns232 0 0.00072687238747
Gc9_233 0 n18 ns233 0 -0.000682698370161
Gc9_234 0 n18 ns234 0 0.000506228984729
Gc9_235 0 n18 ns235 0 -0.000369860048774
Gc9_236 0 n18 ns236 0 -5.48346370719e-05
Gc9_237 0 n18 ns237 0 -1.22435736178e-05
Gc9_238 0 n18 ns238 0 -0.00275638706072
Gc9_239 0 n18 ns239 0 0.000400628495816
Gc9_240 0 n18 ns240 0 0.000110977628077
Gc9_241 0 n18 ns241 0 -0.000664891174163
Gc9_242 0 n18 ns242 0 0.000251128820384
Gc9_243 0 n18 ns243 0 -0.000245140983301
Gc9_244 0 n18 ns244 0 -0.00208115597118
Gc9_245 0 n18 ns245 0 0.00204596221451
Gc9_246 0 n18 ns246 0 0.000522369425567
Gc9_247 0 n18 ns247 0 -0.000530413956799
Gc9_248 0 n18 ns248 0 0.000289799450096
Gc9_249 0 n18 ns249 0 8.82137855993e-05
Gc9_250 0 n18 ns250 0 0.000679323321448
Gc9_251 0 n18 ns251 0 0.00388485350898
Gc9_252 0 n18 ns252 0 -9.55919064522e-05
Gc9_253 0 n18 ns253 0 -0.000241886595204
Gc9_254 0 n18 ns254 0 0.000483840098019
Gc9_255 0 n18 ns255 0 -0.000674805949901
Gc9_256 0 n18 ns256 0 0.00319582313301
Gc9_257 0 n18 ns257 0 0.00189329446813
Gc9_258 0 n18 ns258 0 -0.00212939159643
Gc9_259 0 n18 ns259 0 3.69557596197e-05
Gc9_260 0 n18 ns260 0 0.00131362915986
Gc9_261 0 n18 ns261 0 -3.56394099535e-05
Gc9_262 0 n18 ns262 0 0.0413926484808
Gc9_263 0 n18 ns263 0 -0.0392548184311
Gc9_264 0 n18 ns264 0 0.00261420220346
Gc9_265 0 n18 ns265 0 -2.40109300193e-06
Gc9_266 0 n18 ns266 0 2.27390787688e-05
Gc9_267 0 n18 ns267 0 -0.0018304455766
Gc9_268 0 n18 ns268 0 -0.00304241715188
Gc9_269 0 n18 ns269 0 0.00640970966135
Gc9_270 0 n18 ns270 0 0.000688293916126
Gc9_271 0 n18 ns271 0 -0.000301988715167
Gc9_272 0 n18 ns272 0 0.000678365527312
Gc9_273 0 n18 ns273 0 0.000778608736687
Gc9_274 0 n18 ns274 0 -0.000163948075409
Gc9_275 0 n18 ns275 0 -9.58763850479e-05
Gc9_276 0 n18 ns276 0 -0.000861521094801
Gc9_277 0 n18 ns277 0 -0.00192655210299
Gc9_278 0 n18 ns278 0 0.00116253742767
Gc9_279 0 n18 ns279 0 7.38257233893e-05
Gc9_280 0 n18 ns280 0 0.000418686270078
Gc9_281 0 n18 ns281 0 -0.000180410067407
Gc9_282 0 n18 ns282 0 -0.000740639602958
Gc9_283 0 n18 ns283 0 -0.00329966647441
Gc9_284 0 n18 ns284 0 -0.000109241604732
Gc9_285 0 n18 ns285 0 0.000196240981066
Gc9_286 0 n18 ns286 0 0.000164262287102
Gc9_287 0 n18 ns287 0 0.000372208104718
Gc9_288 0 n18 ns288 0 -0.00573823268523
Gc9_289 0 n18 ns289 0 -0.00140622958525
Gc9_290 0 n18 ns290 0 0.000672628987838
Gc9_291 0 n18 ns291 0 0.00086112463742
Gc9_292 0 n18 ns292 0 0.00102324522359
Gc9_293 0 n18 ns293 0 -0.00084830428721
Gc9_294 0 n18 ns294 0 -0.00660839642181
Gc9_295 0 n18 ns295 0 -0.000271387138701
Gc9_296 0 n18 ns296 0 -0.000996433073503
Gc9_297 0 n18 ns297 0 -0.000579239011102
Gc9_298 0 n18 ns298 0 0.00203316851231
Gc9_299 0 n18 ns299 0 0.000788672170864
Gc9_300 0 n18 ns300 0 0.00414755081639
Gc9_301 0 n18 ns301 0 -0.0139916691436
Gc9_302 0 n18 ns302 0 0.00513968748257
Gc9_303 0 n18 ns303 0 1.48189158557e-06
Gc9_304 0 n18 ns304 0 3.03727798781e-05
Gc9_305 0 n18 ns305 0 -0.0055971357438
Gc9_306 0 n18 ns306 0 -0.0033866519085
Gc9_307 0 n18 ns307 0 -0.00290076679366
Gc9_308 0 n18 ns308 0 0.000358286183194
Gc9_309 0 n18 ns309 0 -0.000717998983472
Gc9_310 0 n18 ns310 0 -0.000181679768395
Gc9_311 0 n18 ns311 0 0.000109476395363
Gc9_312 0 n18 ns312 0 -0.000168425672678
Gc9_313 0 n18 ns313 0 -0.000129667346919
Gc9_314 0 n18 ns314 0 -0.00189183330542
Gc9_315 0 n18 ns315 0 0.00169490911728
Gc9_316 0 n18 ns316 0 0.000981700396978
Gc9_317 0 n18 ns317 0 0.000123320564825
Gc9_318 0 n18 ns318 0 0.000266507656366
Gc9_319 0 n18 ns319 0 -0.000147673073353
Gc9_320 0 n18 ns320 0 0.00181420966643
Gc9_321 0 n18 ns321 0 0.00072022921653
Gc9_322 0 n18 ns322 0 0.000484830232416
Gc9_323 0 n18 ns323 0 0.00017612761219
Gc9_324 0 n18 ns324 0 0.000175435571102
Gc9_325 0 n18 ns325 0 0.000189491041216
Gc9_326 0 n18 ns326 0 0.00120601756146
Gc9_327 0 n18 ns327 0 -0.00205273707181
Gc9_328 0 n18 ns328 0 0.00101194337007
Gc9_329 0 n18 ns329 0 0.00259201391051
Gc9_330 0 n18 ns330 0 0.00131549867194
Gc9_331 0 n18 ns331 0 -0.00123168893496
Gc9_332 0 n18 ns332 0 -0.000702326417309
Gc9_333 0 n18 ns333 0 -0.0035848230887
Gc9_334 0 n18 ns334 0 0.00381154098761
Gc9_335 0 n18 ns335 0 0.000831093348763
Gc9_336 0 n18 ns336 0 0.00223699904135
Gc9_337 0 n18 ns337 0 0.000224825746477
Gc9_338 0 n18 ns338 0 -0.0618290192802
Gc9_339 0 n18 ns339 0 0.062258095607
Gc9_340 0 n18 ns340 0 0.00485485941126
Gc9_341 0 n18 ns341 0 7.14898727127e-06
Gc9_342 0 n18 ns342 0 2.56662608842e-05
Gc9_343 0 n18 ns343 0 -0.000143724561198
Gc9_344 0 n18 ns344 0 0.000320484634585
Gc9_345 0 n18 ns345 0 -0.00261348818044
Gc9_346 0 n18 ns346 0 -0.000191375148162
Gc9_347 0 n18 ns347 0 -0.000129284992804
Gc9_348 0 n18 ns348 0 -0.000137618246882
Gc9_349 0 n18 ns349 0 2.00744341051e-05
Gc9_350 0 n18 ns350 0 -8.02911355363e-06
Gc9_351 0 n18 ns351 0 9.37465055635e-06
Gc9_352 0 n18 ns352 0 0.00066041873371
Gc9_353 0 n18 ns353 0 0.00102871231601
Gc9_354 0 n18 ns354 0 -0.000370621675277
Gc9_355 0 n18 ns355 0 -0.000343951717231
Gc9_356 0 n18 ns356 0 -8.27410185695e-05
Gc9_357 0 n18 ns357 0 0.000100859209727
Gc9_358 0 n18 ns358 0 0.00021638158727
Gc9_359 0 n18 ns359 0 0.000810180374331
Gc9_360 0 n18 ns360 0 0.000365725934684
Gc9_361 0 n18 ns361 0 -0.000303725647495
Gc9_362 0 n18 ns362 0 -6.39892257596e-05
Gc9_363 0 n18 ns363 0 -0.000102017661529
Gc9_364 0 n18 ns364 0 0.00117297458327
Gc9_365 0 n18 ns365 0 0.000474067799626
Gc9_366 0 n18 ns366 0 0.00029209732306
Gc9_367 0 n18 ns367 0 -0.000546315068537
Gc9_368 0 n18 ns368 0 -0.000345058477981
Gc9_369 0 n18 ns369 0 0.000163921072069
Gc9_370 0 n18 ns370 0 0.00135434891696
Gc9_371 0 n18 ns371 0 0.000660175690583
Gc9_372 0 n18 ns372 0 0.000176631854229
Gc9_373 0 n18 ns373 0 -0.000255563449322
Gc9_374 0 n18 ns374 0 -0.000113147044753
Gc9_375 0 n18 ns375 0 -0.000153392872826
Gc9_376 0 n18 ns376 0 0.0141811216702
Gc9_377 0 n18 ns377 0 -0.0119875554412
Gc9_378 0 n18 ns378 0 0.000414188882765
Gc9_379 0 n18 ns379 0 -7.40163535419e-06
Gc9_380 0 n18 ns380 0 -2.49195942392e-05
Gc9_381 0 n18 ns381 0 0.00016168194103
Gc9_382 0 n18 ns382 0 -0.000749902307734
Gc9_383 0 n18 ns383 0 0.000380280433472
Gc9_384 0 n18 ns384 0 0.000108916101324
Gc9_385 0 n18 ns385 0 -0.000120043772247
Gc9_386 0 n18 ns386 0 8.53186818025e-05
Gc9_387 0 n18 ns387 0 -4.81369447116e-07
Gc9_388 0 n18 ns388 0 1.41572890141e-05
Gc9_389 0 n18 ns389 0 -5.52449011835e-05
Gc9_390 0 n18 ns390 0 -0.000936550577025
Gc9_391 0 n18 ns391 0 0.000477996212784
Gc9_392 0 n18 ns392 0 0.000399552578771
Gc9_393 0 n18 ns393 0 -0.000440757041269
Gc9_394 0 n18 ns394 0 -0.000144120370579
Gc9_395 0 n18 ns395 0 -4.07000725214e-05
Gc9_396 0 n18 ns396 0 -0.000931293285076
Gc9_397 0 n18 ns397 0 0.000457601343194
Gc9_398 0 n18 ns398 0 0.000592671149874
Gc9_399 0 n18 ns399 0 0.000327032004117
Gc9_400 0 n18 ns400 0 6.63772209327e-05
Gc9_401 0 n18 ns401 0 -0.000156710306771
Gc9_402 0 n18 ns402 0 0.000353852508348
Gc9_403 0 n18 ns403 0 0.00117081491637
Gc9_404 0 n18 ns404 0 0.000806345062213
Gc9_405 0 n18 ns405 0 -0.000237338542451
Gc9_406 0 n18 ns406 0 -0.000536937664568
Gc9_407 0 n18 ns407 0 -0.000145049050225
Gc9_408 0 n18 ns408 0 0.000482158439354
Gc9_409 0 n18 ns409 0 0.000724234384821
Gc9_410 0 n18 ns410 0 0.00029991011277
Gc9_411 0 n18 ns411 0 8.16681680778e-05
Gc9_412 0 n18 ns412 0 -2.84365691636e-07
Gc9_413 0 n18 ns413 0 -0.000262295044436
Gc9_414 0 n18 ns414 0 0.00962195129099
Gc9_415 0 n18 ns415 0 -0.00842774811576
Gc9_416 0 n18 ns416 0 0.000335270515673
Gc9_417 0 n18 ns417 0 -7.24736018081e-06
Gc9_418 0 n18 ns418 0 -2.70728455188e-05
Gc9_419 0 n18 ns419 0 0.000235994515688
Gc9_420 0 n18 ns420 0 -0.000348661430145
Gc9_421 0 n18 ns421 0 0.00264685441947
Gc9_422 0 n18 ns422 0 0.000140871308094
Gc9_423 0 n18 ns423 0 0.000161037758129
Gc9_424 0 n18 ns424 0 0.000112032727097
Gc9_425 0 n18 ns425 0 4.57111650944e-05
Gc9_426 0 n18 ns426 0 2.28400700189e-05
Gc9_427 0 n18 ns427 0 2.17983019275e-05
Gc9_428 0 n18 ns428 0 -0.000790304862223
Gc9_429 0 n18 ns429 0 -0.00101325821634
Gc9_430 0 n18 ns430 0 0.000765830263503
Gc9_431 0 n18 ns431 0 0.000296906254916
Gc9_432 0 n18 ns432 0 -8.41209329898e-05
Gc9_433 0 n18 ns433 0 -0.000208523914931
Gc9_434 0 n18 ns434 0 -0.000916110018552
Gc9_435 0 n18 ns435 0 -0.00152397766587
Gc9_436 0 n18 ns436 0 -0.000291361392933
Gc9_437 0 n18 ns437 0 0.00109655231376
Gc9_438 0 n18 ns438 0 0.00022641933439
Gc9_439 0 n18 ns439 0 -8.6027185215e-06
Gc9_440 0 n18 ns440 0 -0.00179390143539
Gc9_441 0 n18 ns441 0 0.000481516856656
Gc9_442 0 n18 ns442 0 0.000842689483492
Gc9_443 0 n18 ns443 0 0.00104610102346
Gc9_444 0 n18 ns444 0 -0.000237490953187
Gc9_445 0 n18 ns445 0 -0.000812584303837
Gc9_446 0 n18 ns446 0 -0.00219848355226
Gc9_447 0 n18 ns447 0 0.000717371607085
Gc9_448 0 n18 ns448 0 0.00076971138002
Gc9_449 0 n18 ns449 0 0.00105876292723
Gc9_450 0 n18 ns450 0 0.000353642376744
Gc9_451 0 n18 ns451 0 -0.000606544402168
Gc9_452 0 n18 ns452 0 0.00530450635899
Gc9_453 0 n18 ns453 0 -0.00582033367643
Gc9_454 0 n18 ns454 0 0.000420443938604
Gc9_455 0 n18 ns455 0 -7.94987540734e-06
Gc9_456 0 n18 ns456 0 -1.75299983289e-05
Gc9_457 0 n18 ns457 0 -0.000844032695304
Gc9_458 0 n18 ns458 0 0.00174515898757
Gc9_459 0 n18 ns459 0 -0.00163887839474
Gc9_460 0 n18 ns460 0 -7.24830586271e-05
Gc9_461 0 n18 ns461 0 -0.000137852846205
Gc9_462 0 n18 ns462 0 -0.000324153796246
Gc9_463 0 n18 ns463 0 2.43992956887e-05
Gc9_464 0 n18 ns464 0 -4.35018583799e-05
Gc9_465 0 n18 ns465 0 1.31122892497e-05
Gc9_466 0 n18 ns466 0 0.000576157485135
Gc9_467 0 n18 ns467 0 0.00066403605543
Gc9_468 0 n18 ns468 0 -7.98181728008e-05
Gc9_469 0 n18 ns469 0 0.000507153464698
Gc9_470 0 n18 ns470 0 4.32888675857e-05
Gc9_471 0 n18 ns471 0 -0.000284777281561
Gc9_472 0 n18 ns472 0 0.00168221892924
Gc9_473 0 n18 ns473 0 -0.000515366292221
Gc9_474 0 n18 ns474 0 -0.00106651463541
Gc9_475 0 n18 ns475 0 -3.14547796141e-07
Gc9_476 0 n18 ns476 0 0.000159675220684
Gc9_477 0 n18 ns477 0 6.35778533915e-05
Gc9_478 0 n18 ns478 0 -2.77693545026e-05
Gc9_479 0 n18 ns479 0 -0.00109648094457
Gc9_480 0 n18 ns480 0 -0.000304786597241
Gc9_481 0 n18 ns481 0 0.00136517094843
Gc9_482 0 n18 ns482 0 0.000361612702377
Gc9_483 0 n18 ns483 0 -0.000921993319941
Gc9_484 0 n18 ns484 0 -0.00112042275599
Gc9_485 0 n18 ns485 0 -0.000975656992439
Gc9_486 0 n18 ns486 0 -9.50127506331e-05
Gc9_487 0 n18 ns487 0 0.00164788536708
Gc9_488 0 n18 ns488 0 0.00075474384281
Gc9_489 0 n18 ns489 0 -0.000585352765314
Gc9_490 0 n18 ns490 0 0.0116470638576
Gc9_491 0 n18 ns491 0 -0.0114300802755
Gc9_492 0 n18 ns492 0 0.000747024443179
Gc9_493 0 n18 ns493 0 -9.82108500301e-06
Gc9_494 0 n18 ns494 0 3.58702970018e-06
Gc9_495 0 n18 ns495 0 -0.00119677241452
Gc9_496 0 n18 ns496 0 0.00259897619939
Gc9_497 0 n18 ns497 0 -0.0041592235028
Gc9_498 0 n18 ns498 0 0.000187857504211
Gc9_499 0 n18 ns499 0 -0.000478234846881
Gc9_500 0 n18 ns500 0 9.10060878422e-05
Gc9_501 0 n18 ns501 0 -0.000508856485133
Gc9_502 0 n18 ns502 0 -3.11103914815e-05
Gc9_503 0 n18 ns503 0 -1.37951029336e-05
Gc9_504 0 n18 ns504 0 -0.00153063852098
Gc9_505 0 n18 ns505 0 0.00164430817493
Gc9_506 0 n18 ns506 0 -0.000373573899797
Gc9_507 0 n18 ns507 0 -0.00042852835845
Gc9_508 0 n18 ns508 0 0.000152606471412
Gc9_509 0 n18 ns509 0 -0.00023351380528
Gc9_510 0 n18 ns510 0 -0.000135797730972
Gc9_511 0 n18 ns511 0 0.00267773459709
Gc9_512 0 n18 ns512 0 0.000129433120914
Gc9_513 0 n18 ns513 0 -0.000888855062888
Gc9_514 0 n18 ns514 0 0.000207155522195
Gc9_515 0 n18 ns515 0 9.89365077164e-06
Gc9_516 0 n18 ns516 0 0.00238387948352
Gc9_517 0 n18 ns517 0 0.00233389377325
Gc9_518 0 n18 ns518 0 -0.000514418792571
Gc9_519 0 n18 ns519 0 -2.39266255034e-06
Gc9_520 0 n18 ns520 0 0.000461222178087
Gc9_521 0 n18 ns521 0 -0.000642108500734
Gc9_522 0 n18 ns522 0 0.00363450329333
Gc9_523 0 n18 ns523 0 0.000271547290369
Gc9_524 0 n18 ns524 0 -0.00189643622772
Gc9_525 0 n18 ns525 0 0.000659022503259
Gc9_526 0 n18 ns526 0 0.00113006677868
Gc9_527 0 n18 ns527 0 -0.000208978233592
Gc9_528 0 n18 ns528 0 0.0369842801138
Gc9_529 0 n18 ns529 0 -0.0338659479746
Gc9_530 0 n18 ns530 0 0.00191148022916
Gc9_531 0 n18 ns531 0 -6.42860146701e-06
Gc9_532 0 n18 ns532 0 1.86537237179e-05
Gc9_533 0 n18 ns533 0 -0.001525116624
Gc9_534 0 n18 ns534 0 -0.00172156560207
Gc9_535 0 n18 ns535 0 0.0049811017485
Gc9_536 0 n18 ns536 0 0.00106047243645
Gc9_537 0 n18 ns537 0 -0.000449562752236
Gc9_538 0 n18 ns538 0 0.000821399268004
Gc9_539 0 n18 ns539 0 0.000501653403272
Gc9_540 0 n18 ns540 0 -0.000138805366528
Gc9_541 0 n18 ns541 0 -3.69889865994e-05
Gc9_542 0 n18 ns542 0 -0.00146536937817
Gc9_543 0 n18 ns543 0 -0.00198362519668
Gc9_544 0 n18 ns544 0 0.000837492831674
Gc9_545 0 n18 ns545 0 -0.000340155275992
Gc9_546 0 n18 ns546 0 0.000339518413088
Gc9_547 0 n18 ns547 0 -0.000227741047443
Gc9_548 0 n18 ns548 0 -0.00238570980383
Gc9_549 0 n18 ns549 0 -0.00232819120089
Gc9_550 0 n18 ns550 0 -3.03618516457e-05
Gc9_551 0 n18 ns551 0 0.000181959730038
Gc9_552 0 n18 ns552 0 0.00022505491565
Gc9_553 0 n18 ns553 0 0.000330604761711
Gc9_554 0 n18 ns554 0 -0.00507475499307
Gc9_555 0 n18 ns555 0 0.00186556036353
Gc9_556 0 n18 ns556 0 0.000486501282352
Gc9_557 0 n18 ns557 0 0.000416283305202
Gc9_558 0 n18 ns558 0 0.000838493923972
Gc9_559 0 n18 ns559 0 -0.0008197434923
Gc9_560 0 n18 ns560 0 -0.00259904260737
Gc9_561 0 n18 ns561 0 0.00269747384686
Gc9_562 0 n18 ns562 0 -0.00185852398189
Gc9_563 0 n18 ns563 0 -0.000770666585192
Gc9_564 0 n18 ns564 0 0.00176002888769
Gc9_565 0 n18 ns565 0 0.000529334140773
Gc9_566 0 n18 ns566 0 0.0298682961518
Gc9_567 0 n18 ns567 0 -0.0345933949037
Gc9_568 0 n18 ns568 0 0.00429206279362
Gc9_569 0 n18 ns569 0 2.66001067213e-06
Gc9_570 0 n18 ns570 0 2.81737549635e-05
Gc9_571 0 n18 ns571 0 -0.00555307823937
Gc9_572 0 n18 ns572 0 -0.00291845074678
Gc9_573 0 n18 ns573 0 -0.00444646284563
Gc9_574 0 n18 ns574 0 0.000152046166745
Gc9_575 0 n18 ns575 0 -0.00134499713731
Gc9_576 0 n18 ns576 0 -0.000667538621255
Gc9_577 0 n18 ns577 0 0.000817624785523
Gc9_578 0 n18 ns578 0 -2.74756501299e-05
Gc9_579 0 n18 ns579 0 -8.3582732897e-05
Gc9_580 0 n18 ns580 0 -0.000195511110002
Gc9_581 0 n18 ns581 0 0.00248675840933
Gc9_582 0 n18 ns582 0 0.000555203245435
Gc9_583 0 n18 ns583 0 -0.000201907838277
Gc9_584 0 n18 ns584 0 0.000202708824362
Gc9_585 0 n18 ns585 0 -9.05124518074e-05
Gc9_586 0 n18 ns586 0 0.0016172568585
Gc9_587 0 n18 ns587 0 0.00074782491375
Gc9_588 0 n18 ns588 0 0.000732433713416
Gc9_589 0 n18 ns589 0 -0.000117457705606
Gc9_590 0 n18 ns590 0 0.00017070575852
Gc9_591 0 n18 ns591 0 0.000132274392559
Gc9_592 0 n18 ns592 0 0.00135330502051
Gc9_593 0 n18 ns593 0 -0.00124467030011
Gc9_594 0 n18 ns594 0 0.00109321728945
Gc9_595 0 n18 ns595 0 0.0019815150395
Gc9_596 0 n18 ns596 0 0.00119443232085
Gc9_597 0 n18 ns597 0 -0.00110045799365
Gc9_598 0 n18 ns598 0 0.000958549053612
Gc9_599 0 n18 ns599 0 -0.00210379973995
Gc9_600 0 n18 ns600 0 0.00309815391401
Gc9_601 0 n18 ns601 0 -0.000112270786989
Gc9_602 0 n18 ns602 0 0.00218395333256
Gc9_603 0 n18 ns603 0 0.000433359742557
Gc9_604 0 n18 ns604 0 -0.0411271695837
Gc9_605 0 n18 ns605 0 0.0424474467333
Gc9_606 0 n18 ns606 0 0.00598353530454
Gc9_607 0 n18 ns607 0 -5.03528981736e-06
Gc9_608 0 n18 ns608 0 2.44196792083e-05
Gc9_609 0 n18 ns609 0 1.57600714267e-05
Gc9_610 0 n18 ns610 0 -0.000590114568659
Gc9_611 0 n18 ns611 0 -0.000334042123675
Gc9_612 0 n18 ns612 0 7.67670302961e-05
Gc9_613 0 n18 ns613 0 -0.00026860561911
Gc9_614 0 n18 ns614 0 -0.000177537577916
Gc9_615 0 n18 ns615 0 2.18603626115e-06
Gc9_616 0 n18 ns616 0 2.6827985319e-05
Gc9_617 0 n18 ns617 0 6.78349733781e-06
Gc9_618 0 n18 ns618 0 -0.000247233405536
Gc9_619 0 n18 ns619 0 0.000933785619487
Gc9_620 0 n18 ns620 0 0.000132359197996
Gc9_621 0 n18 ns621 0 -0.000314538852956
Gc9_622 0 n18 ns622 0 -0.000101460041378
Gc9_623 0 n18 ns623 0 -7.54322271328e-05
Gc9_624 0 n18 ns624 0 0.000287539786007
Gc9_625 0 n18 ns625 0 0.000478258747821
Gc9_626 0 n18 ns626 0 0.000108657107727
Gc9_627 0 n18 ns627 0 -0.000257741403813
Gc9_628 0 n18 ns628 0 -5.73418152497e-05
Gc9_629 0 n18 ns629 0 -2.8353855762e-05
Gc9_630 0 n18 ns630 0 0.000178344711333
Gc9_631 0 n18 ns631 0 0.000156533303698
Gc9_632 0 n18 ns632 0 5.93969389513e-05
Gc9_633 0 n18 ns633 0 7.63731752823e-05
Gc9_634 0 n18 ns634 0 4.76426410357e-06
Gc9_635 0 n18 ns635 0 -7.96658426642e-05
Gc9_636 0 n18 ns636 0 0.000623784501232
Gc9_637 0 n18 ns637 0 0.000842799952472
Gc9_638 0 n18 ns638 0 0.000182631156244
Gc9_639 0 n18 ns639 0 -0.000241994663877
Gc9_640 0 n18 ns640 0 -9.14115725906e-05
Gc9_641 0 n18 ns641 0 -0.00010143603306
Gc9_642 0 n18 ns642 0 0.00735354559669
Gc9_643 0 n18 ns643 0 -0.00611761668317
Gc9_644 0 n18 ns644 0 0.000136468691202
Gc9_645 0 n18 ns645 0 7.80162735453e-06
Gc9_646 0 n18 ns646 0 -2.4425762106e-05
Gc9_647 0 n18 ns647 0 6.49234674173e-05
Gc9_648 0 n18 ns648 0 -0.00041247653484
Gc9_649 0 n18 ns649 0 -0.000520784250458
Gc9_650 0 n18 ns650 0 -4.11743092398e-05
Gc9_651 0 n18 ns651 0 -9.74086511024e-05
Gc9_652 0 n18 ns652 0 -4.87970869594e-05
Gc9_653 0 n18 ns653 0 4.1214699874e-05
Gc9_654 0 n18 ns654 0 2.49079264463e-05
Gc9_655 0 n18 ns655 0 -1.06033779616e-05
Gc9_656 0 n18 ns656 0 -0.000425075569855
Gc9_657 0 n18 ns657 0 0.000688272595529
Gc9_658 0 n18 ns658 0 0.00027614894127
Gc9_659 0 n18 ns659 0 -0.000201167540481
Gc9_660 0 n18 ns660 0 -7.24464051848e-05
Gc9_661 0 n18 ns661 0 -0.000119748716849
Gc9_662 0 n18 ns662 0 0.000284224948646
Gc9_663 0 n18 ns663 0 0.00061219282874
Gc9_664 0 n18 ns664 0 0.000186008370304
Gc9_665 0 n18 ns665 0 -0.000318378814422
Gc9_666 0 n18 ns666 0 -7.78510125578e-05
Gc9_667 0 n18 ns667 0 -5.19935100038e-05
Gc9_668 0 n18 ns668 0 0.000175116585175
Gc9_669 0 n18 ns669 0 3.81035079925e-05
Gc9_670 0 n18 ns670 0 -2.26181789929e-05
Gc9_671 0 n18 ns671 0 0.00014654777368
Gc9_672 0 n18 ns672 0 7.08631793469e-05
Gc9_673 0 n18 ns673 0 -9.60765760313e-05
Gc9_674 0 n18 ns674 0 0.000550384952144
Gc9_675 0 n18 ns675 0 0.000995086362692
Gc9_676 0 n18 ns676 0 0.000273324880801
Gc9_677 0 n18 ns677 0 -0.000226152625952
Gc9_678 0 n18 ns678 0 -9.6923893861e-05
Gc9_679 0 n18 ns679 0 -0.000144183028419
Gc9_680 0 n18 ns680 0 0.00900221221135
Gc9_681 0 n18 ns681 0 -0.0076034214827
Gc9_682 0 n18 ns682 0 0.000197339963409
Gc9_683 0 n18 ns683 0 6.65168807493e-06
Gc9_684 0 n18 ns684 0 -2.62185960205e-05
Gc9_685 0 n18 ns685 0 -5.1329122726e-05
Gc9_686 0 n18 ns686 0 2.75088381315e-05
Gc9_687 0 n18 ns687 0 -0.000873377352922
Gc9_688 0 n18 ns688 0 -0.000232954093975
Gc9_689 0 n18 ns689 0 0.000174758267738
Gc9_690 0 n18 ns690 0 5.97596060859e-05
Gc9_691 0 n18 ns691 0 0.000202499510928
Gc9_692 0 n18 ns692 0 3.73410365829e-05
Gc9_693 0 n18 ns693 0 -5.82415011122e-06
Gc9_694 0 n18 ns694 0 -0.000169849979434
Gc9_695 0 n18 ns695 0 -0.000769787773672
Gc9_696 0 n18 ns696 0 0.000174817613119
Gc9_697 0 n18 ns697 0 0.000546155452875
Gc9_698 0 n18 ns698 0 0.000164175504469
Gc9_699 0 n18 ns699 0 -8.91316599681e-05
Gc9_700 0 n18 ns700 0 -0.000242797317059
Gc9_701 0 n18 ns701 0 0.000715947998238
Gc9_702 0 n18 ns702 0 0.00052130620757
Gc9_703 0 n18 ns703 0 -0.000156669166641
Gc9_704 0 n18 ns704 0 -5.2924300253e-05
Gc9_705 0 n18 ns705 0 -0.000157737439086
Gc9_706 0 n18 ns706 0 0.000451890874603
Gc9_707 0 n18 ns707 0 -0.000382801187538
Gc9_708 0 n18 ns708 0 -0.000450805221962
Gc9_709 0 n18 ns709 0 5.80494182249e-05
Gc9_710 0 n18 ns710 0 0.000274904979149
Gc9_711 0 n18 ns711 0 7.75147651821e-05
Gc9_712 0 n18 ns712 0 4.75059906062e-05
Gc9_713 0 n18 ns713 0 0.000814355861785
Gc9_714 0 n18 ns714 0 0.000383941645601
Gc9_715 0 n18 ns715 0 -1.49536086812e-05
Gc9_716 0 n18 ns716 0 -3.78204835155e-05
Gc9_717 0 n18 ns717 0 -0.00023027869588
Gc9_718 0 n18 ns718 0 0.0084176522721
Gc9_719 0 n18 ns719 0 -0.00717327063424
Gc9_720 0 n18 ns720 0 0.000187709825558
Gc9_721 0 n18 ns721 0 6.25358479468e-06
Gc9_722 0 n18 ns722 0 -2.74467412717e-05
Gc9_723 0 n18 ns723 0 0.000123476286804
Gc9_724 0 n18 ns724 0 -0.000923945629498
Gc9_725 0 n18 ns725 0 0.00255516371702
Gc9_726 0 n18 ns726 0 0.000104780965305
Gc9_727 0 n18 ns727 0 9.08491495255e-05
Gc9_728 0 n18 ns728 0 -3.73458851782e-05
Gc9_729 0 n18 ns729 0 -1.82837967089e-05
Gc9_730 0 n18 ns730 0 -2.62168420946e-05
Gc9_731 0 n18 ns731 0 1.32685267556e-05
Gc9_732 0 n18 ns732 0 0.000705273553649
Gc9_733 0 n18 ns733 0 -0.00145197472947
Gc9_734 0 n18 ns734 0 -0.00060357856271
Gc9_735 0 n18 ns735 0 0.00066784592327
Gc9_736 0 n18 ns736 0 0.000278227313647
Gc9_737 0 n18 ns737 0 0.000175063125015
Gc9_738 0 n18 ns738 0 -0.00102215314011
Gc9_739 0 n18 ns739 0 -0.000544283698423
Gc9_740 0 n18 ns740 0 0.000332455900152
Gc9_741 0 n18 ns741 0 0.000657016390029
Gc9_742 0 n18 ns742 0 0.00011599109767
Gc9_743 0 n18 ns743 0 -0.000144016297273
Gc9_744 0 n18 ns744 0 -1.22936639458e-05
Gc9_745 0 n18 ns745 0 -0.000990128596477
Gc9_746 0 n18 ns746 0 -0.00113537202143
Gc9_747 0 n18 ns747 0 -0.000182198872135
Gc9_748 0 n18 ns748 0 0.00059963641706
Gc9_749 0 n18 ns749 0 0.000486807410964
Gc9_750 0 n18 ns750 0 -0.002745369401
Gc9_751 0 n18 ns751 0 -0.000346220200416
Gc9_752 0 n18 ns752 0 0.00061934966203
Gc9_753 0 n18 ns753 0 0.000995118543129
Gc9_754 0 n18 ns754 0 0.0002799577415
Gc9_755 0 n18 ns755 0 -0.000406805613942
Gc9_756 0 n18 ns756 0 -0.00594519149154
Gc9_757 0 n18 ns757 0 0.00464207437174
Gc9_758 0 n18 ns758 0 -0.000184745270184
Gc9_759 0 n18 ns759 0 8.19464125414e-06
Gc9_760 0 n18 ns760 0 -2.11484256292e-05
Gc9_761 0 n18 ns761 0 0.000138453224539
Gc9_762 0 n18 ns762 0 -0.000580785654292
Gc9_763 0 n18 ns763 0 0.00436665531881
Gc9_764 0 n18 ns764 0 0.000191021750947
Gc9_765 0 n18 ns765 0 0.000176559456709
Gc9_766 0 n18 ns766 0 0.000217633259512
Gc9_767 0 n18 ns767 0 -0.000169101968391
Gc9_768 0 n18 ns768 0 -1.88900466599e-05
Gc9_769 0 n18 ns769 0 -7.09133180523e-05
Gc9_770 0 n18 ns770 0 0.000608460489148
Gc9_771 0 n18 ns771 0 -0.000252839638684
Gc9_772 0 n18 ns772 0 -0.000586670496363
Gc9_773 0 n18 ns773 0 -0.000432663367201
Gc9_774 0 n18 ns774 0 2.92547623783e-05
Gc9_775 0 n18 ns775 0 0.000304035518233
Gc9_776 0 n18 ns776 0 2.53718810755e-05
Gc9_777 0 n18 ns777 0 -0.00210062251761
Gc9_778 0 n18 ns778 0 -0.000917547937869
Gc9_779 0 n18 ns779 0 0.000989075971625
Gc9_780 0 n18 ns780 0 0.000229571625837
Gc9_781 0 n18 ns781 0 9.83326284593e-05
Gc9_782 0 n18 ns782 0 -0.000578887423671
Gc9_783 0 n18 ns783 0 -0.00114529234701
Gc9_784 0 n18 ns784 0 -0.00114341805714
Gc9_785 0 n18 ns785 0 -0.00094500013415
Gc9_786 0 n18 ns786 0 0.000434092305135
Gc9_787 0 n18 ns787 0 0.00106376895346
Gc9_788 0 n18 ns788 0 -0.0049598609664
Gc9_789 0 n18 ns789 0 -0.00218661311568
Gc9_790 0 n18 ns790 0 0.000434664583587
Gc9_791 0 n18 ns791 0 0.00224552763209
Gc9_792 0 n18 ns792 0 0.000774948337802
Gc9_793 0 n18 ns793 0 -0.000550585183612
Gc9_794 0 n18 ns794 0 -0.019094303819
Gc9_795 0 n18 ns795 0 0.0155012289837
Gc9_796 0 n18 ns796 0 -0.000532299826495
Gc9_797 0 n18 ns797 0 3.68136254572e-06
Gc9_798 0 n18 ns798 0 -5.94013810544e-06
Gc9_799 0 n18 ns799 0 4.99004582288e-06
Gc9_800 0 n18 ns800 0 3.50712399291e-05
Gc9_801 0 n18 ns801 0 0.00513240581577
Gc9_802 0 n18 ns802 0 9.25365616815e-05
Gc9_803 0 n18 ns803 0 0.00016796385368
Gc9_804 0 n18 ns804 0 0.000374700304222
Gc9_805 0 n18 ns805 0 0.000129876223485
Gc9_806 0 n18 ns806 0 3.63279938418e-05
Gc9_807 0 n18 ns807 0 -7.27995188612e-06
Gc9_808 0 n18 ns808 0 -0.00138657693998
Gc9_809 0 n18 ns809 0 -0.000922736938359
Gc9_810 0 n18 ns810 0 0.000797247027244
Gc9_811 0 n18 ns811 0 -0.000295830403547
Gc9_812 0 n18 ns812 0 -3.85257792505e-05
Gc9_813 0 n18 ns813 0 0.000158057477161
Gc9_814 0 n18 ns814 0 0.00169592690418
Gc9_815 0 n18 ns815 0 -0.000604298307118
Gc9_816 0 n18 ns816 0 -0.00149458239226
Gc9_817 0 n18 ns817 0 -0.00043962668947
Gc9_818 0 n18 ns818 0 5.88190844931e-05
Gc9_819 0 n18 ns819 0 0.000206347772396
Gc9_820 0 n18 ns820 0 -0.00143418657288
Gc9_821 0 n18 ns821 0 -0.00177464047168
Gc9_822 0 n18 ns822 0 -0.000212886997654
Gc9_823 0 n18 ns823 0 -0.00114101210888
Gc9_824 0 n18 ns824 0 -0.000196564997656
Gc9_825 0 n18 ns825 0 0.00123630465722
Gc9_826 0 n18 ns826 0 -0.0054434820162
Gc9_827 0 n18 ns827 0 -0.00419538448572
Gc9_828 0 n18 ns828 0 -0.000665651710638
Gc9_829 0 n18 ns829 0 0.00319162948248
Gc9_830 0 n18 ns830 0 0.00142768492667
Gc9_831 0 n18 ns831 0 -0.000466915249558
Gc9_832 0 n18 ns832 0 -0.0333166634819
Gc9_833 0 n18 ns833 0 0.0281188454596
Gc9_834 0 n18 ns834 0 -0.00113612376979
Gc9_835 0 n18 ns835 0 -4.4751411232e-06
Gc9_836 0 n18 ns836 0 1.21062717839e-05
Gc9_837 0 n18 ns837 0 0.00064654974237
Gc9_838 0 n18 ns838 0 -0.000597826710647
Gc9_839 0 n18 ns839 0 0.00929897732256
Gc9_840 0 n18 ns840 0 0.000323204552973
Gc9_841 0 n18 ns841 0 0.000221931260756
Gc9_842 0 n18 ns842 0 4.96944171968e-05
Gc9_843 0 n18 ns843 0 -0.000184638555526
Gc9_844 0 n18 ns844 0 -0.000114805749618
Gc9_845 0 n18 ns845 0 3.42418526339e-05
Gc9_846 0 n18 ns846 0 -0.00059406789177
Gc9_847 0 n18 ns847 0 -0.00373383783797
Gc9_848 0 n18 ns848 0 0.000605057814394
Gc9_849 0 n18 ns849 0 0.0011757406017
Gc9_850 0 n18 ns850 0 -1.81739443857e-05
Gc9_851 0 n18 ns851 0 0.000219808574329
Gc9_852 0 n18 ns852 0 -0.00119436727724
Gc9_853 0 n18 ns853 0 0.00056334163076
Gc9_854 0 n18 ns854 0 -6.3990131068e-05
Gc9_855 0 n18 ns855 0 -0.000769063727189
Gc9_856 0 n18 ns856 0 0.000148854783924
Gc9_857 0 n18 ns857 0 0.000144809629668
Gc9_858 0 n18 ns858 0 -0.00264606210223
Gc9_859 0 n18 ns859 0 -0.00410126763177
Gc9_860 0 n18 ns860 0 -0.000316067637356
Gc9_861 0 n18 ns861 0 0.000699971214776
Gc9_862 0 n18 ns862 0 -0.000121750970715
Gc9_863 0 n18 ns863 0 0.000695924630081
Gc9_864 0 n18 ns864 0 -0.00651779584401
Gc9_865 0 n18 ns865 0 -0.00454391779913
Gc9_866 0 n18 ns866 0 -0.00231271567697
Gc9_867 0 n18 ns867 0 0.00275263416784
Gc9_868 0 n18 ns868 0 0.00214008209431
Gc9_869 0 n18 ns869 0 0.000124398955283
Gc9_870 0 n18 ns870 0 -0.0655223401154
Gc9_871 0 n18 ns871 0 0.0577433568987
Gc9_872 0 n18 ns872 0 -0.00292329250511
Gc9_873 0 n18 ns873 0 -7.49791545356e-06
Gc9_874 0 n18 ns874 0 2.01473755101e-05
Gc9_875 0 n18 ns875 0 -0.000536675804526
Gc9_876 0 n18 ns876 0 0.000590868328437
Gc9_877 0 n18 ns877 0 0.00185836924741
Gc9_878 0 n18 ns878 0 -0.00117974955394
Gc9_879 0 n18 ns879 0 -0.000831279564013
Gc9_880 0 n18 ns880 0 0.00159061050274
Gc9_881 0 n18 ns881 0 0.000210579665885
Gc9_882 0 n18 ns882 0 -0.000187243928034
Gc9_883 0 n18 ns883 0 -0.000189541415657
Gc9_884 0 n18 ns884 0 0.00241940840069
Gc9_885 0 n18 ns885 0 -0.000421915783521
Gc9_886 0 n18 ns886 0 -0.000890421772643
Gc9_887 0 n18 ns887 0 0.000637137831471
Gc9_888 0 n18 ns888 0 -0.00027542482251
Gc9_889 0 n18 ns889 0 0.000169000035222
Gc9_890 0 n18 ns890 0 -0.00122308844603
Gc9_891 0 n18 ns891 0 -0.00317766362062
Gc9_892 0 n18 ns892 0 -6.93320098112e-05
Gc9_893 0 n18 ns893 0 0.000295858380065
Gc9_894 0 n18 ns894 0 0.000176307493825
Gc9_895 0 n18 ns895 0 0.000384943196463
Gc9_896 0 n18 ns896 0 0.00195039505392
Gc9_897 0 n18 ns897 0 -0.00389199966022
Gc9_898 0 n18 ns898 0 -0.0022234828416
Gc9_899 0 n18 ns899 0 4.90679237521e-05
Gc9_900 0 n18 ns900 0 -9.6986654295e-05
Gc9_901 0 n18 ns901 0 0.00109815074606
Gc9_902 0 n18 ns902 0 -0.00841771061773
Gc9_903 0 n18 ns903 0 -0.00224237576525
Gc9_904 0 n18 ns904 0 -0.000861524288649
Gc9_905 0 n18 ns905 0 0.000326387865942
Gc9_906 0 n18 ns906 0 0.00230386998159
Gc9_907 0 n18 ns907 0 0.000772165953257
Gc9_908 0 n18 ns908 0 -0.0443567456225
Gc9_909 0 n18 ns909 0 0.0452834737619
Gc9_910 0 n18 ns910 0 -0.00596294796698
Gc9_911 0 n18 ns911 0 -5.67319524249e-06
Gc9_912 0 n18 ns912 0 2.86171256829e-05
Gc9_913 0 n18 ns913 0 -0.0178446634303
Gc9_914 0 n18 ns914 0 -0.00329549476622
Gc9_915 0 n18 ns915 0 0.0152023686379
Gc9_916 0 n18 ns916 0 0.00884395963905
Gc9_917 0 n18 ns917 0 0.00852528530234
Gc9_918 0 n18 ns918 0 -0.000496461200856
Gc9_919 0 n18 ns919 0 -0.00316501367609
Gc9_920 0 n18 ns920 0 -0.000267555414751
Gc9_921 0 n18 ns921 0 0.000229107038394
Gc9_922 0 n18 ns922 0 -0.00376916679292
Gc9_923 0 n18 ns923 0 -0.00898574393117
Gc9_924 0 n18 ns924 0 0.00115167703003
Gc9_925 0 n18 ns925 0 0.000323257727094
Gc9_926 0 n18 ns926 0 4.51111077527e-05
Gc9_927 0 n18 ns927 0 -0.000158005664164
Gc9_928 0 n18 ns928 0 0.00186797401879
Gc9_929 0 n18 ns929 0 0.00189030812267
Gc9_930 0 n18 ns930 0 0.000721490185652
Gc9_931 0 n18 ns931 0 0.000241397087734
Gc9_932 0 n18 ns932 0 0.000219198944757
Gc9_933 0 n18 ns933 0 0.000207907936145
Gc9_934 0 n18 ns934 0 -0.0097597663368
Gc9_935 0 n18 ns935 0 -0.00163912248795
Gc9_936 0 n18 ns936 0 -0.00203936451283
Gc9_937 0 n18 ns937 0 -0.00127135795236
Gc9_938 0 n18 ns938 0 -0.000504483460417
Gc9_939 0 n18 ns939 0 0.00115375009977
Gc9_940 0 n18 ns940 0 0.0164851977465
Gc9_941 0 n18 ns941 0 -0.000491114242564
Gc9_942 0 n18 ns942 0 0.00344374802895
Gc9_943 0 n18 ns943 0 -0.00178886786955
Gc9_944 0 n18 ns944 0 0.00154564628732
Gc9_945 0 n18 ns945 0 0.000133239348074
Gc9_946 0 n18 ns946 0 -0.0361833273051
Gc9_947 0 n18 ns947 0 0.00666764328629
Gc9_948 0 n18 ns948 0 -0.00617160956136
Gc9_949 0 n18 ns949 0 -5.19746693576e-06
Gc9_950 0 n18 ns950 0 1.63166144972e-05
Gc9_951 0 n18 ns951 0 -3.15236771435e-05
Gc9_952 0 n18 ns952 0 -0.00010778030664
Gc9_953 0 n18 ns953 0 -0.00104011573585
Gc9_954 0 n18 ns954 0 -0.000181055938547
Gc9_955 0 n18 ns955 0 8.05802974889e-05
Gc9_956 0 n18 ns956 0 4.52307476062e-05
Gc9_957 0 n18 ns957 0 0.00016317173978
Gc9_958 0 n18 ns958 0 3.84029813098e-05
Gc9_959 0 n18 ns959 0 -1.75915044737e-05
Gc9_960 0 n18 ns960 0 -0.000403973201152
Gc9_961 0 n18 ns961 0 -9.92815502023e-05
Gc9_962 0 n18 ns962 0 0.000315562883025
Gc9_963 0 n18 ns963 0 0.000209704340744
Gc9_964 0 n18 ns964 0 5.27321874804e-05
Gc9_965 0 n18 ns965 0 -0.000132147802427
Gc9_966 0 n18 ns966 0 4.59541924761e-05
Gc9_967 0 n18 ns967 0 0.00077901202392
Gc9_968 0 n18 ns968 0 0.000393553595897
Gc9_969 0 n18 ns969 0 -0.000286264940948
Gc9_970 0 n18 ns970 0 -7.43059465221e-05
Gc9_971 0 n18 ns971 0 -0.000114726257334
Gc9_972 0 n18 ns972 0 0.000402986300698
Gc9_973 0 n18 ns973 0 -0.000136731782344
Gc9_974 0 n18 ns974 0 -0.000216284568884
Gc9_975 0 n18 ns975 0 9.14383043225e-05
Gc9_976 0 n18 ns976 0 0.000158655629026
Gc9_977 0 n18 ns977 0 -1.63997398452e-05
Gc9_978 0 n18 ns978 0 0.000510403247797
Gc9_979 0 n18 ns979 0 0.00100623901796
Gc9_980 0 n18 ns980 0 0.000327234296194
Gc9_981 0 n18 ns981 0 -0.000185608937071
Gc9_982 0 n18 ns982 0 -8.88707176852e-05
Gc9_983 0 n18 ns983 0 -0.000190148244824
Gc9_984 0 n18 ns984 0 0.0101060733986
Gc9_985 0 n18 ns985 0 -0.00853235554876
Gc9_986 0 n18 ns986 0 0.000225249575783
Gc9_987 0 n18 ns987 0 5.52285153878e-06
Gc9_988 0 n18 ns988 0 -2.71465125374e-05
Gc9_989 0 n18 ns989 0 5.770629053e-05
Gc9_990 0 n18 ns990 0 -0.0004392532039
Gc9_991 0 n18 ns991 0 0.000870620510707
Gc9_992 0 n18 ns992 0 -0.000126790803648
Gc9_993 0 n18 ns993 0 0.000167249261224
Gc9_994 0 n18 ns994 0 5.73185208645e-06
Gc9_995 0 n18 ns995 0 0.000127409345382
Gc9_996 0 n18 ns996 0 5.84841923051e-06
Gc9_997 0 n18 ns997 0 1.62113206397e-05
Gc9_998 0 n18 ns998 0 0.000435324720946
Gc9_999 0 n18 ns999 0 -0.00144215313469
Gc9_1000 0 n18 ns1000 0 -0.000285240307632
Gc9_1001 0 n18 ns1001 0 0.000797911475545
Gc9_1002 0 n18 ns1002 0 0.000271775823748
Gc9_1003 0 n18 ns1003 0 6.05028089795e-05
Gc9_1004 0 n18 ns1004 0 -0.000767802662101
Gc9_1005 0 n18 ns1005 0 9.82001649617e-05
Gc9_1006 0 n18 ns1006 0 0.000504879594312
Gc9_1007 0 n18 ns1007 0 0.000285159175875
Gc9_1008 0 n18 ns1008 0 3.61678340859e-05
Gc9_1009 0 n18 ns1009 0 -0.000170501654022
Gc9_1010 0 n18 ns1010 0 0.000257023179286
Gc9_1011 0 n18 ns1011 0 -0.000776912866832
Gc9_1012 0 n18 ns1012 0 -0.00087337999973
Gc9_1013 0 n18 ns1013 0 -4.96521339024e-05
Gc9_1014 0 n18 ns1014 0 0.000481066021854
Gc9_1015 0 n18 ns1015 0 0.000296223396065
Gc9_1016 0 n18 ns1016 0 -0.00141827486411
Gc9_1017 0 n18 ns1017 0 0.000158765283145
Gc9_1018 0 n18 ns1018 0 0.000495289150217
Gc9_1019 0 n18 ns1019 0 0.000511242639129
Gc9_1020 0 n18 ns1020 0 0.000125965781791
Gc9_1021 0 n18 ns1021 0 -0.000316347446288
Gc9_1022 0 n18 ns1022 0 0.000249470621918
Gc9_1023 0 n18 ns1023 0 -0.000377341798078
Gc9_1024 0 n18 ns1024 0 -3.8911436955e-05
Gc9_1025 0 n18 ns1025 0 7.56177072147e-06
Gc9_1026 0 n18 ns1026 0 -2.50374524785e-05
Gc9_1027 0 n18 ns1027 0 0.000219488297666
Gc9_1028 0 n18 ns1028 0 -0.000747479780891
Gc9_1029 0 n18 ns1029 0 0.00386605204636
Gc9_1030 0 n18 ns1030 0 0.00020257754745
Gc9_1031 0 n18 ns1031 0 0.000170528322886
Gc9_1032 0 n18 ns1032 0 0.000127533383903
Gc9_1033 0 n18 ns1033 0 -0.000187854112995
Gc9_1034 0 n18 ns1034 0 -5.42011842905e-05
Gc9_1035 0 n18 ns1035 0 -4.36921899957e-05
Gc9_1036 0 n18 ns1036 0 0.000824105442546
Gc9_1037 0 n18 ns1037 0 -0.000809163706698
Gc9_1038 0 n18 ns1038 0 -0.000759303872632
Gc9_1039 0 n18 ns1039 0 3.51918092143e-05
Gc9_1040 0 n18 ns1040 0 0.00014476919993
Gc9_1041 0 n18 ns1041 0 0.000280218942601
Gc9_1042 0 n18 ns1042 0 -0.000697469431495
Gc9_1043 0 n18 ns1043 0 -0.0016909645161
Gc9_1044 0 n18 ns1044 0 -0.000360612975881
Gc9_1045 0 n18 ns1045 0 0.00105383716865
Gc9_1046 0 n18 ns1046 0 0.000219423471392
Gc9_1047 0 n18 ns1047 0 -2.31289430051e-06
Gc9_1048 0 n18 ns1048 0 -0.000401413955707
Gc9_1049 0 n18 ns1049 0 -0.00104974251177
Gc9_1050 0 n18 ns1050 0 -0.00124687550041
Gc9_1051 0 n18 ns1051 0 -0.000619728535436
Gc9_1052 0 n18 ns1052 0 0.000568464892087
Gc9_1053 0 n18 ns1053 0 0.000845697171905
Gc9_1054 0 n18 ns1054 0 -0.00439194600165
Gc9_1055 0 n18 ns1055 0 -0.0011496455919
Gc9_1056 0 n18 ns1056 0 0.00070145965152
Gc9_1057 0 n18 ns1057 0 0.00177101431774
Gc9_1058 0 n18 ns1058 0 0.000574132116977
Gc9_1059 0 n18 ns1059 0 -0.00056261176024
Gc9_1060 0 n18 ns1060 0 -0.0121925362418
Gc9_1061 0 n18 ns1061 0 0.00958718758041
Gc9_1062 0 n18 ns1062 0 -0.000317138384833
Gc9_1063 0 n18 ns1063 0 6.5265258163e-06
Gc9_1064 0 n18 ns1064 0 -1.49677041905e-05
Gc9_1065 0 n18 ns1065 0 -1.97812739578e-05
Gc9_1066 0 n18 ns1066 0 0.000218430006576
Gc9_1067 0 n18 ns1067 0 0.00408366851018
Gc9_1068 0 n18 ns1068 0 -7.51820006394e-05
Gc9_1069 0 n18 ns1069 0 0.000296989326856
Gc9_1070 0 n18 ns1070 0 0.000422422494636
Gc9_1071 0 n18 ns1071 0 -1.06906992683e-05
Gc9_1072 0 n18 ns1072 0 3.39061223822e-05
Gc9_1073 0 n18 ns1073 0 -4.24028872528e-05
Gc9_1074 0 n18 ns1074 0 -0.000478773116719
Gc9_1075 0 n18 ns1075 0 -9.88687047716e-05
Gc9_1076 0 n18 ns1076 0 0.000222491872437
Gc9_1077 0 n18 ns1077 0 -0.000619155378998
Gc9_1078 0 n18 ns1078 0 -4.90666620456e-05
Gc9_1079 0 n18 ns1079 0 0.000204705899477
Gc9_1080 0 n18 ns1080 0 0.00146408157142
Gc9_1081 0 n18 ns1081 0 -0.0014459397148
Gc9_1082 0 n18 ns1082 0 -0.00148131463441
Gc9_1083 0 n18 ns1083 0 0.000153038397241
Gc9_1084 0 n18 ns1084 0 0.000114031896218
Gc9_1085 0 n18 ns1085 0 0.000191666786133
Gc9_1086 0 n18 ns1086 0 -0.000832204596747
Gc9_1087 0 n18 ns1087 0 -0.00137375531604
Gc9_1088 0 n18 ns1088 0 -0.000580977871445
Gc9_1089 0 n18 ns1089 0 -0.00131546363147
Gc9_1090 0 n18 ns1090 0 1.19002747945e-06
Gc9_1091 0 n18 ns1091 0 0.00126667266322
Gc9_1092 0 n18 ns1092 0 -0.00512264416398
Gc9_1093 0 n18 ns1093 0 -0.00356037671066
Gc9_1094 0 n18 ns1094 0 -0.000173479089331
Gc9_1095 0 n18 ns1095 0 0.00288777405539
Gc9_1096 0 n18 ns1096 0 0.00115203367544
Gc9_1097 0 n18 ns1097 0 -0.00053403809876
Gc9_1098 0 n18 ns1098 0 -0.0257173233666
Gc9_1099 0 n18 ns1099 0 0.0214200228906
Gc9_1100 0 n18 ns1100 0 -0.00082058583316
Gc9_1101 0 n18 ns1101 0 -1.19351959705e-06
Gc9_1102 0 n18 ns1102 0 3.62952699253e-06
Gc9_1103 0 n18 ns1103 0 0.000364485752318
Gc9_1104 0 n18 ns1104 0 -0.00122474315298
Gc9_1105 0 n18 ns1105 0 0.00842047285157
Gc9_1106 0 n18 ns1106 0 0.000497657298528
Gc9_1107 0 n18 ns1107 0 -0.000149996659003
Gc9_1108 0 n18 ns1108 0 -9.45741333673e-05
Gc9_1109 0 n18 ns1109 0 0.000174369713819
Gc9_1110 0 n18 ns1110 0 -1.0202647655e-05
Gc9_1111 0 n18 ns1111 0 4.84659057262e-05
Gc9_1112 0 n18 ns1112 0 -0.00135898965217
Gc9_1113 0 n18 ns1113 0 -0.00284907118725
Gc9_1114 0 n18 ns1114 0 0.000835192707977
Gc9_1115 0 n18 ns1115 0 0.000705672729008
Gc9_1116 0 n18 ns1116 0 2.13078323181e-05
Gc9_1117 0 n18 ns1117 0 0.000215064193019
Gc9_1118 0 n18 ns1118 0 0.000226650665677
Gc9_1119 0 n18 ns1119 0 0.000808493342691
Gc9_1120 0 n18 ns1120 0 -0.000568303921293
Gc9_1121 0 n18 ns1121 0 -0.000959732154511
Gc9_1122 0 n18 ns1122 0 6.5781198014e-05
Gc9_1123 0 n18 ns1123 0 0.000110666962821
Gc9_1124 0 n18 ns1124 0 -0.00246579268397
Gc9_1125 0 n18 ns1125 0 -0.00298385907272
Gc9_1126 0 n18 ns1126 0 9.63929009875e-05
Gc9_1127 0 n18 ns1127 0 -1.49487184281e-05
Gc9_1128 0 n18 ns1128 0 -0.000278412384535
Gc9_1129 0 n18 ns1129 0 0.000823026255351
Gc9_1130 0 n18 ns1130 0 -0.00567321711146
Gc9_1131 0 n18 ns1131 0 -0.0047256362712
Gc9_1132 0 n18 ns1132 0 -0.00189469058765
Gc9_1133 0 n18 ns1133 0 0.003136633604
Gc9_1134 0 n18 ns1134 0 0.00190688295113
Gc9_1135 0 n18 ns1135 0 -0.000105381922662
Gc9_1136 0 n18 ns1136 0 -0.0526182938329
Gc9_1137 0 n18 ns1137 0 0.0456310777414
Gc9_1138 0 n18 ns1138 0 -0.00207762922796
Gc9_1139 0 n18 ns1139 0 -7.42637200274e-06
Gc9_1140 0 n18 ns1140 0 1.65300178706e-05
Gc9_1141 0 n18 ns1141 0 0.000224987635569
Gc9_1142 0 n18 ns1142 0 -0.000306877181029
Gc9_1143 0 n18 ns1143 0 0.00738651659007
Gc9_1144 0 n18 ns1144 0 -9.56348013453e-05
Gc9_1145 0 n18 ns1145 0 -6.88941707796e-05
Gc9_1146 0 n18 ns1146 0 0.000250877022249
Gc9_1147 0 n18 ns1147 0 -0.000755507549654
Gc9_1148 0 n18 ns1148 0 -0.000132925942935
Gc9_1149 0 n18 ns1149 0 1.67254570361e-05
Gc9_1150 0 n18 ns1150 0 0.00188271411374
Gc9_1151 0 n18 ns1151 0 -0.00168474909699
Gc9_1152 0 n18 ns1152 0 -0.00045593792659
Gc9_1153 0 n18 ns1153 0 0.000752268971485
Gc9_1154 0 n18 ns1154 0 -0.000259424515945
Gc9_1155 0 n18 ns1155 0 0.000210655174616
Gc9_1156 0 n18 ns1156 0 -0.00223542808648
Gc9_1157 0 n18 ns1157 0 -0.0017496559238
Gc9_1158 0 n18 ns1158 0 0.000127454847972
Gc9_1159 0 n18 ns1159 0 0.000153428156129
Gc9_1160 0 n18 ns1160 0 0.000248879467312
Gc9_1161 0 n18 ns1161 0 0.000318450280534
Gc9_1162 0 n18 ns1162 0 -0.000263636133166
Gc9_1163 0 n18 ns1163 0 -0.00554785582339
Gc9_1164 0 n18 ns1164 0 -0.00204551895896
Gc9_1165 0 n18 ns1165 0 0.000795664212921
Gc9_1166 0 n18 ns1166 0 0.000211612215629
Gc9_1167 0 n18 ns1167 0 0.000990280055239
Gc9_1168 0 n18 ns1168 0 -0.00772330823288
Gc9_1169 0 n18 ns1169 0 -0.00315470967934
Gc9_1170 0 n18 ns1170 0 -0.00218631712177
Gc9_1171 0 n18 ns1171 0 0.00089369221295
Gc9_1172 0 n18 ns1172 0 0.00222668244824
Gc9_1173 0 n18 ns1173 0 0.000668272881827
Gc9_1174 0 n18 ns1174 0 -0.0773488980138
Gc9_1175 0 n18 ns1175 0 0.0718407844741
Gc9_1176 0 n18 ns1176 0 -0.00505926553894
Gc9_1177 0 n18 ns1177 0 -6.82201786396e-06
Gc9_1178 0 n18 ns1178 0 2.30458740766e-05
Gc9_1179 0 n18 ns1179 0 -0.00533595574494
Gc9_1180 0 n18 ns1180 0 -0.00344041338229
Gc9_1181 0 n18 ns1181 0 -0.00252791257264
Gc9_1182 0 n18 ns1182 0 0.00206919065105
Gc9_1183 0 n18 ns1183 0 -0.00350053942079
Gc9_1184 0 n18 ns1184 0 0.000328915545753
Gc9_1185 0 n18 ns1185 0 0.00329524927504
Gc9_1186 0 n18 ns1186 0 0.000137972726453
Gc9_1187 0 n18 ns1187 0 -0.00030584394178
Gc9_1188 0 n18 ns1188 0 -0.00115781223649
Gc9_1189 0 n18 ns1189 0 0.00292098477519
Gc9_1190 0 n18 ns1190 0 -0.000971244926404
Gc9_1191 0 n18 ns1191 0 -0.000281592290771
Gc9_1192 0 n18 ns1192 0 -0.000278030674104
Gc9_1193 0 n18 ns1193 0 6.11576855532e-05
Gc9_1194 0 n18 ns1194 0 0.00347081535164
Gc9_1195 0 n18 ns1195 0 -0.0016832180193
Gc9_1196 0 n18 ns1196 0 -8.46305940139e-06
Gc9_1197 0 n18 ns1197 0 -0.000806450750068
Gc9_1198 0 n18 ns1198 0 -9.45838952245e-05
Gc9_1199 0 n18 ns1199 0 9.07889091622e-05
Gc9_1200 0 n18 ns1200 0 0.00535095821099
Gc9_1201 0 n18 ns1201 0 0.0056270412139
Gc9_1202 0 n18 ns1202 0 -3.69730273027e-05
Gc9_1203 0 n18 ns1203 0 -0.00240200776466
Gc9_1204 0 n18 ns1204 0 -0.00165384791089
Gc9_1205 0 n18 ns1205 0 0.000796060986125
Gc9_1206 0 n18 ns1206 0 -0.00704167378859
Gc9_1207 0 n18 ns1207 0 0.000727961623025
Gc9_1208 0 n18 ns1208 0 0.00354664928174
Gc9_1209 0 n18 ns1209 0 -0.000171128340331
Gc9_1210 0 n18 ns1210 0 0.00212600725346
Gc9_1211 0 n18 ns1211 0 0.00040767084188
Gc9_1212 0 n18 ns1212 0 0.0850386778099
Gc9_1213 0 n18 ns1213 0 -0.0659545389884
Gc9_1214 0 n18 ns1214 0 -0.00595872055233
Gc9_1215 0 n18 ns1215 0 -6.29923612231e-06
Gc9_1216 0 n18 ns1216 0 2.36587170179e-05
Gd9_1 0 n18 ni1 0 -8.51431019381e-05
Gd9_2 0 n18 ni2 0 -1.18907807619e-05
Gd9_3 0 n18 ni3 0 -9.71909854459e-05
Gd9_4 0 n18 ni4 0 -4.96345116823e-05
Gd9_5 0 n18 ni5 0 4.88807339316e-05
Gd9_6 0 n18 ni6 0 0.000241825332629
Gd9_7 0 n18 ni7 0 -0.000224787255229
Gd9_8 0 n18 ni8 0 -0.00203772830285
Gd9_9 0 n18 ni9 0 -0.00289144209288
Gd9_10 0 n18 ni10 0 -8.91915334047e-05
Gd9_11 0 n18 ni11 0 -0.000111039895936
Gd9_12 0 n18 ni12 0 0.000234864612825
Gd9_13 0 n18 ni13 0 0.00020967072534
Gd9_14 0 n18 ni14 0 0.000306168715197
Gd9_15 0 n18 ni15 0 -0.00122715917474
Gd9_16 0 n18 ni16 0 -0.00247619808188
Gd9_17 0 n18 ni17 0 -0.00022978663055
Gd9_18 0 n18 ni18 0 -0.000124651195362
Gd9_19 0 n18 ni19 0 -5.64624299081e-05
Gd9_20 0 n18 ni20 0 -0.000135304518695
Gd9_21 0 n18 ni21 0 7.98459414156e-05
Gd9_22 0 n18 ni22 0 0.000270606603611
Gd9_23 0 n18 ni23 0 0.00055696262676
Gd9_24 0 n18 ni24 0 -0.000472112657395
Gd9_25 0 n18 ni25 0 -0.00755734337462
Gd9_26 0 n18 ni26 0 -0.000100587378579
Gd9_27 0 n18 ni27 0 -8.31926275586e-05
Gd9_28 0 n18 ni28 0 4.48620177354e-05
Gd9_29 0 n18 ni29 0 0.00026745888156
Gd9_30 0 n18 ni30 0 0.000197797860459
Gd9_31 0 n18 ni31 0 1.16548513056e-05
Gd9_32 0 n18 ni32 0 -0.00317950275189
Gc10_1 0 n20 ns1 0 -0.00182686257256
Gc10_2 0 n20 ns2 0 -0.00303491011349
Gc10_3 0 n20 ns3 0 0.00644549147626
Gc10_4 0 n20 ns4 0 0.000688183201074
Gc10_5 0 n20 ns5 0 -0.000296634044357
Gc10_6 0 n20 ns6 0 0.000686869541731
Gc10_7 0 n20 ns7 0 0.000776449135246
Gc10_8 0 n20 ns8 0 -0.000164955381092
Gc10_9 0 n20 ns9 0 -9.6733799716e-05
Gc10_10 0 n20 ns10 0 -0.000880822995198
Gc10_11 0 n20 ns11 0 -0.00194241907163
Gc10_12 0 n20 ns12 0 0.00116831454991
Gc10_13 0 n20 ns13 0 7.51689270747e-05
Gc10_14 0 n20 ns14 0 0.000421197516085
Gc10_15 0 n20 ns15 0 -0.000181821478187
Gc10_16 0 n20 ns16 0 -0.000750735138777
Gc10_17 0 n20 ns17 0 -0.00330121201162
Gc10_18 0 n20 ns18 0 -0.000110184686243
Gc10_19 0 n20 ns19 0 0.000196316107016
Gc10_20 0 n20 ns20 0 0.000165357536531
Gc10_21 0 n20 ns21 0 0.000373213758054
Gc10_22 0 n20 ns22 0 -0.00574595304304
Gc10_23 0 n20 ns23 0 -0.00140934184817
Gc10_24 0 n20 ns24 0 0.000665081785316
Gc10_25 0 n20 ns25 0 0.000862082917727
Gc10_26 0 n20 ns26 0 0.00102733050592
Gc10_27 0 n20 ns27 0 -0.000848209745582
Gc10_28 0 n20 ns28 0 -0.00663751284375
Gc10_29 0 n20 ns29 0 -0.000294756273569
Gc10_30 0 n20 ns30 0 -0.00100219425144
Gc10_31 0 n20 ns31 0 -0.000563253230617
Gc10_32 0 n20 ns32 0 0.00203926398246
Gc10_33 0 n20 ns33 0 0.000788088810299
Gc10_34 0 n20 ns34 0 0.00394070091864
Gc10_35 0 n20 ns35 0 -0.013823294442
Gc10_36 0 n20 ns36 0 0.0051340820855
Gc10_37 0 n20 ns37 0 1.53303131254e-06
Gc10_38 0 n20 ns38 0 3.07531009503e-05
Gc10_39 0 n20 ns39 0 -0.00438905298831
Gc10_40 0 n20 ns40 0 -0.00231493588727
Gc10_41 0 n20 ns41 0 -0.00111675374572
Gc10_42 0 n20 ns42 0 0.000753936765772
Gc10_43 0 n20 ns43 0 -0.00132299211653
Gc10_44 0 n20 ns44 0 1.12551452588e-05
Gc10_45 0 n20 ns45 0 0.000928986316849
Gc10_46 0 n20 ns46 0 -9.60985891047e-05
Gc10_47 0 n20 ns47 0 -5.73418764607e-05
Gc10_48 0 n20 ns48 0 -0.000910487578952
Gc10_49 0 n20 ns49 0 0.000593629297957
Gc10_50 0 n20 ns50 0 0.000861455939118
Gc10_51 0 n20 ns51 0 -0.000551253906558
Gc10_52 0 n20 ns52 0 0.000339273249486
Gc10_53 0 n20 ns53 0 -0.000233909779505
Gc10_54 0 n20 ns54 0 -0.000820333249066
Gc10_55 0 n20 ns55 0 -0.00116900628081
Gc10_56 0 n20 ns56 0 0.000489169395495
Gc10_57 0 n20 ns57 0 -2.25614139669e-05
Gc10_58 0 n20 ns58 0 0.000272640262158
Gc10_59 0 n20 ns59 0 0.000290935841794
Gc10_60 0 n20 ns60 0 -0.00275715161067
Gc10_61 0 n20 ns61 0 0.00133527057297
Gc10_62 0 n20 ns62 0 0.00121405663032
Gc10_63 0 n20 ns63 0 0.00116371592403
Gc10_64 0 n20 ns64 0 0.00109083729861
Gc10_65 0 n20 ns65 0 -0.00124736647924
Gc10_66 0 n20 ns66 0 0.000340214477624
Gc10_67 0 n20 ns67 0 0.00203500887811
Gc10_68 0 n20 ns68 0 -2.51276321137e-05
Gc10_69 0 n20 ns69 0 -0.00125831301838
Gc10_70 0 n20 ns70 0 0.00224100679053
Gc10_71 0 n20 ns71 0 0.000647783214542
Gc10_72 0 n20 ns72 0 0.0162669200177
Gc10_73 0 n20 ns73 0 -0.017042100916
Gc10_74 0 n20 ns74 0 0.0064769846212
Gc10_75 0 n20 ns75 0 -2.44624020892e-06
Gc10_76 0 n20 ns76 0 2.684762617e-05
Gc10_77 0 n20 ns77 0 -0.00465183419026
Gc10_78 0 n20 ns78 0 0.000414282318368
Gc10_79 0 n20 ns79 0 -0.00685507428509
Gc10_80 0 n20 ns80 0 -6.26193288103e-05
Gc10_81 0 n20 ns81 0 -0.00114267707423
Gc10_82 0 n20 ns82 0 -9.74200714456e-05
Gc10_83 0 n20 ns83 0 0.000173610054123
Gc10_84 0 n20 ns84 0 -0.000103446474047
Gc10_85 0 n20 ns85 0 -4.48760964174e-05
Gc10_86 0 n20 ns86 0 -0.00203497316006
Gc10_87 0 n20 ns87 0 0.00316500437301
Gc10_88 0 n20 ns88 0 0.000368406872523
Gc10_89 0 n20 ns89 0 -0.000629063655887
Gc10_90 0 n20 ns90 0 0.000399711697407
Gc10_91 0 n20 ns91 0 -0.000354836160475
Gc10_92 0 n20 ns92 0 0.000532216515172
Gc10_93 0 n20 ns93 0 0.00280536659633
Gc10_94 0 n20 ns94 0 0.000774459962192
Gc10_95 0 n20 ns95 0 -0.000717312010149
Gc10_96 0 n20 ns96 0 0.000395875565551
Gc10_97 0 n20 ns97 0 0.000180269880624
Gc10_98 0 n20 ns98 0 0.0027738500392
Gc10_99 0 n20 ns99 0 0.00152127582696
Gc10_100 0 n20 ns100 0 0.00042380343647
Gc10_101 0 n20 ns101 0 0.00192629475247
Gc10_102 0 n20 ns102 0 0.00159352373975
Gc10_103 0 n20 ns103 0 -0.00153840202957
Gc10_104 0 n20 ns104 0 0.00395065445442
Gc10_105 0 n20 ns105 0 -0.00152047391167
Gc10_106 0 n20 ns106 0 0.00123625255501
Gc10_107 0 n20 ns107 0 0.000719983838507
Gc10_108 0 n20 ns108 0 0.00295886213909
Gc10_109 0 n20 ns109 0 0.000337118618193
Gc10_110 0 n20 ns110 0 -0.0099811411923
Gc10_111 0 n20 ns111 0 0.0137510366939
Gc10_112 0 n20 ns112 0 0.00705267589937
Gc10_113 0 n20 ns113 0 -1.27764168867e-06
Gc10_114 0 n20 ns114 0 3.23048635179e-05
Gc10_115 0 n20 ns115 0 -0.00197416964176
Gc10_116 0 n20 ns116 0 2.56396888316e-05
Gc10_117 0 n20 ns117 0 0.0020000579521
Gc10_118 0 n20 ns118 0 0.000655177185625
Gc10_119 0 n20 ns119 0 -0.000446944746231
Gc10_120 0 n20 ns120 0 0.00047849552894
Gc10_121 0 n20 ns121 0 0.000335149595434
Gc10_122 0 n20 ns122 0 -0.000169721781868
Gc10_123 0 n20 ns123 0 -4.43068636207e-06
Gc10_124 0 n20 ns124 0 -0.000629875726138
Gc10_125 0 n20 ns125 0 -0.000667624688814
Gc10_126 0 n20 ns126 0 0.000525679763564
Gc10_127 0 n20 ns127 0 8.72443257434e-05
Gc10_128 0 n20 ns128 0 0.000354060238464
Gc10_129 0 n20 ns129 0 -0.000496638701143
Gc10_130 0 n20 ns130 0 -0.000230199326258
Gc10_131 0 n20 ns131 0 -0.00219781598034
Gc10_132 0 n20 ns132 0 -0.000980704700587
Gc10_133 0 n20 ns133 0 -4.82282264044e-05
Gc10_134 0 n20 ns134 0 0.000338102075345
Gc10_135 0 n20 ns135 0 0.000332585802871
Gc10_136 0 n20 ns136 0 -0.00411813867262
Gc10_137 0 n20 ns137 0 0.000485691493864
Gc10_138 0 n20 ns138 0 0.00010437130279
Gc10_139 0 n20 ns139 0 0.00147118781772
Gc10_140 0 n20 ns140 0 0.0010655366777
Gc10_141 0 n20 ns141 0 -0.00147091258543
Gc10_142 0 n20 ns142 0 -0.00277734736295
Gc10_143 0 n20 ns143 0 0.0013941383245
Gc10_144 0 n20 ns144 0 -0.00180469242109
Gc10_145 0 n20 ns145 0 0.000528860029937
Gc10_146 0 n20 ns146 0 0.00209603709936
Gc10_147 0 n20 ns147 0 8.81217684248e-05
Gc10_148 0 n20 ns148 0 0.0383327928015
Gc10_149 0 n20 ns149 0 -0.0419954799845
Gc10_150 0 n20 ns150 0 0.00446135853252
Gc10_151 0 n20 ns151 0 3.19221059193e-06
Gc10_152 0 n20 ns152 0 2.52445387913e-05
Gc10_153 0 n20 ns153 0 -0.00088632893993
Gc10_154 0 n20 ns154 0 0.00179440190102
Gc10_155 0 n20 ns155 0 -0.00193515065704
Gc10_156 0 n20 ns156 0 0.000138418809068
Gc10_157 0 n20 ns157 0 -0.000269051350447
Gc10_158 0 n20 ns158 0 0.000173553672166
Gc10_159 0 n20 ns159 0 -0.000304953576822
Gc10_160 0 n20 ns160 0 -4.18432697783e-07
Gc10_161 0 n20 ns161 0 1.09738784575e-05
Gc10_162 0 n20 ns162 0 -0.00165665091775
Gc10_163 0 n20 ns163 0 0.00043524668529
Gc10_164 0 n20 ns164 0 0.000291810907212
Gc10_165 0 n20 ns165 0 6.15670941766e-05
Gc10_166 0 n20 ns166 0 7.33883423498e-05
Gc10_167 0 n20 ns167 0 -0.000428663566498
Gc10_168 0 n20 ns168 0 -0.000749094904565
Gc10_169 0 n20 ns169 0 0.000856452995514
Gc10_170 0 n20 ns170 0 -0.000274653946543
Gc10_171 0 n20 ns171 0 0.000199634593154
Gc10_172 0 n20 ns172 0 0.000402413378319
Gc10_173 0 n20 ns173 0 1.58238327565e-05
Gc10_174 0 n20 ns174 0 0.000635696069386
Gc10_175 0 n20 ns175 0 0.00253198256647
Gc10_176 0 n20 ns176 0 0.000317669643847
Gc10_177 0 n20 ns177 0 0.000884769884152
Gc10_178 0 n20 ns178 0 0.000186650158805
Gc10_179 0 n20 ns179 0 -0.00128908041063
Gc10_180 0 n20 ns180 0 0.00202279948326
Gc10_181 0 n20 ns181 0 0.000620603689826
Gc10_182 0 n20 ns182 0 -0.00129385408996
Gc10_183 0 n20 ns183 0 0.00122899360972
Gc10_184 0 n20 ns184 0 0.00120179635002
Gc10_185 0 n20 ns185 0 -0.000525779704149
Gc10_186 0 n20 ns186 0 0.0353448041614
Gc10_187 0 n20 ns187 0 -0.0329755382846
Gc10_188 0 n20 ns188 0 0.00189873023038
Gc10_189 0 n20 ns189 0 -4.54015298992e-06
Gc10_190 0 n20 ns190 0 1.94209907324e-06
Gc10_191 0 n20 ns191 0 -0.000413545364248
Gc10_192 0 n20 ns192 0 0.000864996229368
Gc10_193 0 n20 ns193 0 -0.00122516506037
Gc10_194 0 n20 ns194 0 -8.2004857638e-05
Gc10_195 0 n20 ns195 0 -4.12369346322e-05
Gc10_196 0 n20 ns196 0 -0.000110337985443
Gc10_197 0 n20 ns197 0 -3.73673845211e-05
Gc10_198 0 n20 ns198 0 -3.14884805923e-05
Gc10_199 0 n20 ns199 0 -2.03493551016e-05
Gc10_200 0 n20 ns200 0 -0.000381814584863
Gc10_201 0 n20 ns201 0 0.000923948351209
Gc10_202 0 n20 ns202 0 0.00040214844526
Gc10_203 0 n20 ns203 0 7.15168778334e-05
Gc10_204 0 n20 ns204 0 -0.000121153715609
Gc10_205 0 n20 ns205 0 -0.00032133310358
Gc10_206 0 n20 ns206 0 0.000583724450051
Gc10_207 0 n20 ns207 0 -0.00011714963014
Gc10_208 0 n20 ns208 0 -0.000415431775102
Gc10_209 0 n20 ns209 0 0.000378432926805
Gc10_210 0 n20 ns210 0 0.000227206133273
Gc10_211 0 n20 ns211 0 -9.36715771142e-05
Gc10_212 0 n20 ns212 0 0.000333381776898
Gc10_213 0 n20 ns213 0 0.000169299090876
Gc10_214 0 n20 ns214 0 0.000486532304804
Gc10_215 0 n20 ns215 0 0.0010018799034
Gc10_216 0 n20 ns216 0 -0.000171368548466
Gc10_217 0 n20 ns217 0 -0.000972229342353
Gc10_218 0 n20 ns218 0 -0.000294108778225
Gc10_219 0 n20 ns219 0 -0.000346914306766
Gc10_220 0 n20 ns220 0 6.35799326085e-05
Gc10_221 0 n20 ns221 0 0.00145441584366
Gc10_222 0 n20 ns222 0 0.000635117619731
Gc10_223 0 n20 ns223 0 -0.000677188361774
Gc10_224 0 n20 ns224 0 0.0178394230928
Gc10_225 0 n20 ns225 0 -0.0165908868883
Gc10_226 0 n20 ns226 0 0.000874224007471
Gc10_227 0 n20 ns227 0 -6.42727246881e-06
Gc10_228 0 n20 ns228 0 -1.87589906479e-05
Gc10_229 0 n20 ns229 0 8.53039221819e-05
Gc10_230 0 n20 ns230 0 -0.000282270876483
Gc10_231 0 n20 ns231 0 -5.60490867673e-05
Gc10_232 0 n20 ns232 0 -6.5785428869e-05
Gc10_233 0 n20 ns233 0 4.2859267835e-05
Gc10_234 0 n20 ns234 0 -2.56800922212e-05
Gc10_235 0 n20 ns235 0 4.23942717012e-05
Gc10_236 0 n20 ns236 0 1.21808104446e-05
Gc10_237 0 n20 ns237 0 3.00424143862e-05
Gc10_238 0 n20 ns238 0 1.85040525581e-05
Gc10_239 0 n20 ns239 0 0.00032026002625
Gc10_240 0 n20 ns240 0 0.000329770867748
Gc10_241 0 n20 ns241 0 -0.000189058333013
Gc10_242 0 n20 ns242 0 -0.000206496103604
Gc10_243 0 n20 ns243 0 -8.73925080082e-05
Gc10_244 0 n20 ns244 0 -0.000484058364176
Gc10_245 0 n20 ns245 0 -0.000478036965895
Gc10_246 0 n20 ns246 0 0.000141244274844
Gc10_247 0 n20 ns247 0 0.000627766355902
Gc10_248 0 n20 ns248 0 0.000129210415625
Gc10_249 0 n20 ns249 0 -0.000139029946674
Gc10_250 0 n20 ns250 0 -0.000171425133085
Gc10_251 0 n20 ns251 0 0.000680884463189
Gc10_252 0 n20 ns252 0 0.000969919247388
Gc10_253 0 n20 ns253 0 0.000315075310744
Gc10_254 0 n20 ns254 0 -0.000557152874289
Gc10_255 0 n20 ns255 0 -0.00051510404104
Gc10_256 0 n20 ns256 0 -0.000411882883178
Gc10_257 0 n20 ns257 0 0.000350166679325
Gc10_258 0 n20 ns258 0 0.000470924836177
Gc10_259 0 n20 ns259 0 0.000746818883436
Gc10_260 0 n20 ns260 0 0.000229678298438
Gc10_261 0 n20 ns261 0 -0.000510077834881
Gc10_262 0 n20 ns262 0 0.012090108755
Gc10_263 0 n20 ns263 0 -0.0110619322706
Gc10_264 0 n20 ns264 0 0.000522217828318
Gc10_265 0 n20 ns265 0 -3.13360452147e-06
Gc10_266 0 n20 ns266 0 -3.27280148564e-05
Gc10_267 0 n20 ns267 0 1.07572541355e-05
Gc10_268 0 n20 ns268 0 -2.07526803615e-05
Gc10_269 0 n20 ns269 0 -0.0027979870261
Gc10_270 0 n20 ns270 0 -0.000172466705241
Gc10_271 0 n20 ns271 0 -0.000184652651484
Gc10_272 0 n20 ns272 0 -0.00012328683752
Gc10_273 0 n20 ns273 0 7.15505077911e-05
Gc10_274 0 n20 ns274 0 2.73775855907e-05
Gc10_275 0 n20 ns275 0 1.96405699476e-07
Gc10_276 0 n20 ns276 0 0.000256701322106
Gc10_277 0 n20 ns277 0 0.0010315143278
Gc10_278 0 n20 ns278 0 -0.000125203181756
Gc10_279 0 n20 ns279 0 -0.000465167616549
Gc10_280 0 n20 ns280 0 -0.000152578799826
Gc10_281 0 n20 ns281 0 7.67902419009e-05
Gc10_282 0 n20 ns282 0 -0.000449930407668
Gc10_283 0 n20 ns283 0 0.000879076550213
Gc10_284 0 n20 ns284 0 0.000673503050604
Gc10_285 0 n20 ns285 0 3.16027376202e-05
Gc10_286 0 n20 ns286 0 1.15608146056e-05
Gc10_287 0 n20 ns287 0 -0.000188191324127
Gc10_288 0 n20 ns288 0 0.00131374238742
Gc10_289 0 n20 ns289 0 0.00132411857536
Gc10_290 0 n20 ns290 0 0.00086739748811
Gc10_291 0 n20 ns291 0 -0.000631649624919
Gc10_292 0 n20 ns292 0 -0.000693124660949
Gc10_293 0 n20 ns293 0 1.12420845025e-05
Gc10_294 0 n20 ns294 0 0.00197604148037
Gc10_295 0 n20 ns295 0 0.00121482821396
Gc10_296 0 n20 ns296 0 0.000303135691643
Gc10_297 0 n20 ns297 0 -0.000352238050278
Gc10_298 0 n20 ns298 0 -0.000165921266612
Gc10_299 0 n20 ns299 0 -0.00027216366122
Gc10_300 0 n20 ns300 0 0.020281765645
Gc10_301 0 n20 ns301 0 -0.0171685236633
Gc10_302 0 n20 ns302 0 0.000577571393178
Gc10_303 0 n20 ns303 0 -3.9742180445e-06
Gc10_304 0 n20 ns304 0 -3.11009476387e-05
Gc10_305 0 n20 ns305 0 -0.000143724702515
Gc10_306 0 n20 ns306 0 0.000320484828353
Gc10_307 0 n20 ns307 0 -0.00261348904468
Gc10_308 0 n20 ns308 0 -0.000191375199442
Gc10_309 0 n20 ns309 0 -0.000129284986285
Gc10_310 0 n20 ns310 0 -0.000137618233724
Gc10_311 0 n20 ns311 0 2.00745158234e-05
Gc10_312 0 n20 ns312 0 -8.02910836226e-06
Gc10_313 0 n20 ns313 0 9.37463335105e-06
Gc10_314 0 n20 ns314 0 0.000660418851917
Gc10_315 0 n20 ns315 0 0.00102871230121
Gc10_316 0 n20 ns316 0 -0.000370621696366
Gc10_317 0 n20 ns317 0 -0.000343951691477
Gc10_318 0 n20 ns318 0 -8.2741014193e-05
Gc10_319 0 n20 ns319 0 0.000100859214932
Gc10_320 0 n20 ns320 0 0.000216381618763
Gc10_321 0 n20 ns321 0 0.00081018045913
Gc10_322 0 n20 ns322 0 0.000365725968103
Gc10_323 0 n20 ns323 0 -0.000303725673803
Gc10_324 0 n20 ns324 0 -6.3989227599e-05
Gc10_325 0 n20 ns325 0 -0.000102017670592
Gc10_326 0 n20 ns326 0 0.00117297477296
Gc10_327 0 n20 ns327 0 0.000474067955164
Gc10_328 0 n20 ns328 0 0.000292097400986
Gc10_329 0 n20 ns329 0 -0.000546315134777
Gc10_330 0 n20 ns330 0 -0.000345058535046
Gc10_331 0 n20 ns331 0 0.000163921072853
Gc10_332 0 n20 ns332 0 0.00135434945401
Gc10_333 0 n20 ns333 0 0.000660175984739
Gc10_334 0 n20 ns334 0 0.000176631861208
Gc10_335 0 n20 ns335 0 -0.000255563643091
Gc10_336 0 n20 ns336 0 -0.000113147112556
Gc10_337 0 n20 ns337 0 -0.000153392873458
Gc10_338 0 n20 ns338 0 0.014181125138
Gc10_339 0 n20 ns339 0 -0.0119875582685
Gc10_340 0 n20 ns340 0 0.000414188959744
Gc10_341 0 n20 ns341 0 -7.40163746397e-06
Gc10_342 0 n20 ns342 0 -2.49195967299e-05
Gc10_343 0 n20 ns343 0 -0.00327776117839
Gc10_344 0 n20 ns344 0 -0.000571726949623
Gc10_345 0 n20 ns345 0 -0.00144598292452
Gc10_346 0 n20 ns346 0 0.000705401357512
Gc10_347 0 n20 ns347 0 -0.000485155674467
Gc10_348 0 n20 ns348 0 0.000448787620521
Gc10_349 0 n20 ns349 0 -0.000378743048188
Gc10_350 0 n20 ns350 0 -0.000211168133677
Gc10_351 0 n20 ns351 0 -0.000103293141997
Gc10_352 0 n20 ns352 0 -0.00466817414245
Gc10_353 0 n20 ns353 0 0.00170597023302
Gc10_354 0 n20 ns354 0 0.00122123252356
Gc10_355 0 n20 ns355 0 -0.00049080460861
Gc10_356 0 n20 ns356 0 0.000554692213004
Gc10_357 0 n20 ns357 0 -0.000408778602705
Gc10_358 0 n20 ns358 0 -0.000525531893489
Gc10_359 0 n20 ns359 0 0.00235335814333
Gc10_360 0 n20 ns360 0 0.000969662611672
Gc10_361 0 n20 ns361 0 -0.00024243739242
Gc10_362 0 n20 ns362 0 0.000450626280159
Gc10_363 0 n20 ns363 0 0.000269446495064
Gc10_364 0 n20 ns364 0 0.00114980562128
Gc10_365 0 n20 ns365 0 0.00122071284746
Gc10_366 0 n20 ns366 0 0.000675308629148
Gc10_367 0 n20 ns367 0 0.0021460481796
Gc10_368 0 n20 ns368 0 0.00167184860347
Gc10_369 0 n20 ns369 0 -0.00159430411169
Gc10_370 0 n20 ns370 0 0.000474839037926
Gc10_371 0 n20 ns371 0 -0.00229564248116
Gc10_372 0 n20 ns372 0 0.00152915034735
Gc10_373 0 n20 ns373 0 0.00106215153542
Gc10_374 0 n20 ns374 0 0.00315642152396
Gc10_375 0 n20 ns375 0 0.000428456301795
Gc10_376 0 n20 ns376 0 -0.0239349763968
Gc10_377 0 n20 ns377 0 0.0236464028394
Gc10_378 0 n20 ns378 0 0.00699692001265
Gc10_379 0 n20 ns379 0 1.13920584772e-05
Gc10_380 0 n20 ns380 0 3.35383187092e-05
Gc10_381 0 n20 ns381 0 -0.00219641769258
Gc10_382 0 n20 ns382 0 -0.00116651125847
Gc10_383 0 n20 ns383 0 0.00292768203967
Gc10_384 0 n20 ns384 0 0.000356610595926
Gc10_385 0 n20 ns385 0 -0.000548531872706
Gc10_386 0 n20 ns386 0 0.000381207565569
Gc10_387 0 n20 ns387 0 0.00037230862943
Gc10_388 0 n20 ns388 0 -0.000185727408336
Gc10_389 0 n20 ns389 0 -6.24090638979e-05
Gc10_390 0 n20 ns390 0 -0.000729622006431
Gc10_391 0 n20 ns391 0 0.000126102448698
Gc10_392 0 n20 ns392 0 0.000544367193826
Gc10_393 0 n20 ns393 0 0.000136593860752
Gc10_394 0 n20 ns394 0 0.000499010235409
Gc10_395 0 n20 ns395 0 -0.000441878964849
Gc10_396 0 n20 ns396 0 0.00113806833228
Gc10_397 0 n20 ns397 0 -0.0017038933699
Gc10_398 0 n20 ns398 0 -0.000796523662808
Gc10_399 0 n20 ns399 0 -0.000522057619099
Gc10_400 0 n20 ns400 0 0.00028996969078
Gc10_401 0 n20 ns401 0 0.000359423966358
Gc10_402 0 n20 ns402 0 -0.0035952284012
Gc10_403 0 n20 ns403 0 -0.00186208630961
Gc10_404 0 n20 ns404 0 -4.3197869117e-05
Gc10_405 0 n20 ns405 0 0.00157865247657
Gc10_406 0 n20 ns406 0 0.00136193672197
Gc10_407 0 n20 ns407 0 -0.00141874227251
Gc10_408 0 n20 ns408 0 -0.00535133346779
Gc10_409 0 n20 ns409 0 -0.00143990029012
Gc10_410 0 n20 ns410 0 -0.00148109052254
Gc10_411 0 n20 ns411 0 0.000735907426492
Gc10_412 0 n20 ns412 0 0.0024983676309
Gc10_413 0 n20 ns413 0 0.000375828436964
Gc10_414 0 n20 ns414 0 0.0206615045425
Gc10_415 0 n20 ns415 0 -0.0283509367531
Gc10_416 0 n20 ns416 0 0.00551290026378
Gc10_417 0 n20 ns417 0 2.11259646063e-06
Gc10_418 0 n20 ns418 0 3.42404436089e-05
Gc10_419 0 n20 ns419 0 -0.00121341016102
Gc10_420 0 n20 ns420 0 0.000735775347787
Gc10_421 0 n20 ns421 0 -0.000232826722518
Gc10_422 0 n20 ns422 0 0.000540516513062
Gc10_423 0 n20 ns423 0 -0.000591493989555
Gc10_424 0 n20 ns424 0 0.000322335956217
Gc10_425 0 n20 ns425 0 -0.000153178845029
Gc10_426 0 n20 ns426 0 -3.80133087104e-05
Gc10_427 0 n20 ns427 0 3.45015834369e-05
Gc10_428 0 n20 ns428 0 -0.0019906419479
Gc10_429 0 n20 ns429 0 -0.000209415021652
Gc10_430 0 n20 ns430 0 0.000407299635801
Gc10_431 0 n20 ns431 0 2.80101557853e-05
Gc10_432 0 n20 ns432 0 0.000202924882523
Gc10_433 0 n20 ns433 0 -0.000484295432653
Gc10_434 0 n20 ns434 0 -0.00149830104417
Gc10_435 0 n20 ns435 0 0.000151848026641
Gc10_436 0 n20 ns436 0 -0.000372717513252
Gc10_437 0 n20 ns437 0 0.000292073551672
Gc10_438 0 n20 ns438 0 0.000470584962867
Gc10_439 0 n20 ns439 0 0.000134248616433
Gc10_440 0 n20 ns440 0 -0.000806063658936
Gc10_441 0 n20 ns441 0 0.00318965599277
Gc10_442 0 n20 ns442 0 0.000403231332262
Gc10_443 0 n20 ns443 0 0.00100846537739
Gc10_444 0 n20 ns444 0 0.000410077215465
Gc10_445 0 n20 ns445 0 -0.00146186617728
Gc10_446 0 n20 ns446 0 0.00151389871569
Gc10_447 0 n20 ns447 0 0.00173651145551
Gc10_448 0 n20 ns448 0 -0.00156724237556
Gc10_449 0 n20 ns449 0 0.000902322434433
Gc10_450 0 n20 ns450 0 0.00147148066934
Gc10_451 0 n20 ns451 0 -0.000421241224709
Gc10_452 0 n20 ns452 0 0.041261454686
Gc10_453 0 n20 ns453 0 -0.0396491072573
Gc10_454 0 n20 ns454 0 0.002631579557
Gc10_455 0 n20 ns455 0 -1.56518197882e-06
Gc10_456 0 n20 ns456 0 1.29430030728e-05
Gc10_457 0 n20 ns457 0 -0.000620695195513
Gc10_458 0 n20 ns458 0 0.00149114592584
Gc10_459 0 n20 ns459 0 -0.00221020567464
Gc10_460 0 n20 ns460 0 -0.000163799091902
Gc10_461 0 n20 ns461 0 -0.000169288086919
Gc10_462 0 n20 ns462 0 -0.000153862359793
Gc10_463 0 n20 ns463 0 -0.000119142494274
Gc10_464 0 n20 ns464 0 -9.47767886938e-06
Gc10_465 0 n20 ns465 0 -1.97925217473e-05
Gc10_466 0 n20 ns466 0 -0.00050585956353
Gc10_467 0 n20 ns467 0 0.00136861059343
Gc10_468 0 n20 ns468 0 0.000225916030724
Gc10_469 0 n20 ns469 0 3.56528104567e-05
Gc10_470 0 n20 ns470 0 -8.17650400381e-05
Gc10_471 0 n20 ns471 0 -0.000376268555328
Gc10_472 0 n20 ns472 0 0.000743999139112
Gc10_473 0 n20 ns473 0 0.000526920159138
Gc10_474 0 n20 ns474 0 -0.000458514532481
Gc10_475 0 n20 ns475 0 0.000118861688827
Gc10_476 0 n20 ns476 0 0.00027097670637
Gc10_477 0 n20 ns477 0 -8.51943362605e-05
Gc10_478 0 n20 ns478 0 0.000955354267194
Gc10_479 0 n20 ns479 0 0.000547789422693
Gc10_480 0 n20 ns480 0 0.000298805443895
Gc10_481 0 n20 ns481 0 0.00102989722229
Gc10_482 0 n20 ns482 0 -3.31011159868e-05
Gc10_483 0 n20 ns483 0 -0.00110732919324
Gc10_484 0 n20 ns484 0 0.000638921411072
Gc10_485 0 n20 ns485 0 -0.000427478523004
Gc10_486 0 n20 ns486 0 -0.000387450117783
Gc10_487 0 n20 ns487 0 0.00152152473637
Gc10_488 0 n20 ns488 0 0.00082242626765
Gc10_489 0 n20 ns489 0 -0.000667034438346
Gc10_490 0 n20 ns490 0 0.0238426384371
Gc10_491 0 n20 ns491 0 -0.0219654115568
Gc10_492 0 n20 ns492 0 0.00116165287396
Gc10_493 0 n20 ns493 0 -6.16481684205e-06
Gc10_494 0 n20 ns494 0 -7.34902198694e-06
Gc10_495 0 n20 ns495 0 -1.76068230125e-05
Gc10_496 0 n20 ns496 0 -0.000378545208438
Gc10_497 0 n20 ns497 0 0.00100627259444
Gc10_498 0 n20 ns498 0 -4.31614561453e-05
Gc10_499 0 n20 ns499 0 0.00014534022656
Gc10_500 0 n20 ns500 0 5.5613170302e-05
Gc10_501 0 n20 ns501 0 4.66893983115e-05
Gc10_502 0 n20 ns502 0 -1.47828978119e-05
Gc10_503 0 n20 ns503 0 7.74435818386e-06
Gc10_504 0 n20 ns504 0 -0.000246221894561
Gc10_505 0 n20 ns505 0 -0.000121260847551
Gc10_506 0 n20 ns506 0 0.00050650782145
Gc10_507 0 n20 ns507 0 0.000122550756289
Gc10_508 0 n20 ns508 0 -0.000136653024456
Gc10_509 0 n20 ns509 0 -0.000193504786862
Gc10_510 0 n20 ns510 0 -0.000304598155926
Gc10_511 0 n20 ns511 0 -0.000898813601623
Gc10_512 0 n20 ns512 0 -0.000202038602735
Gc10_513 0 n20 ns513 0 0.000789055666576
Gc10_514 0 n20 ns514 0 0.000195224352829
Gc10_515 0 n20 ns515 0 -8.77652119786e-05
Gc10_516 0 n20 ns516 0 -0.000613450888593
Gc10_517 0 n20 ns517 0 0.000373054674955
Gc10_518 0 n20 ns518 0 0.000852751379731
Gc10_519 0 n20 ns519 0 0.000726462447501
Gc10_520 0 n20 ns520 0 -0.000410873345949
Gc10_521 0 n20 ns521 0 -0.000731701168293
Gc10_522 0 n20 ns522 0 -0.00125355695683
Gc10_523 0 n20 ns523 0 -1.19378105653e-05
Gc10_524 0 n20 ns524 0 0.000466984325291
Gc10_525 0 n20 ns525 0 0.00116321475386
Gc10_526 0 n20 ns526 0 0.000395993431859
Gc10_527 0 n20 ns527 0 -0.000590290721846
Gc10_528 0 n20 ns528 0 0.00903735205063
Gc10_529 0 n20 ns529 0 -0.00882799593413
Gc10_530 0 n20 ns530 0 0.00051685478478
Gc10_531 0 n20 ns531 0 -3.32201872896e-06
Gc10_532 0 n20 ns532 0 -2.64800902345e-05
Gc10_533 0 n20 ns533 0 0.000172596168179
Gc10_534 0 n20 ns534 0 -0.000408065176896
Gc10_535 0 n20 ns535 0 -0.00147495221277
Gc10_536 0 n20 ns536 0 -0.000108692954211
Gc10_537 0 n20 ns537 0 -0.00013396726964
Gc10_538 0 n20 ns538 0 -6.39762548331e-05
Gc10_539 0 n20 ns539 0 5.52030192287e-05
Gc10_540 0 n20 ns540 0 3.1291460124e-05
Gc10_541 0 n20 ns541 0 9.04694550046e-06
Gc10_542 0 n20 ns542 0 -0.000100717633484
Gc10_543 0 n20 ns543 0 0.000679070781779
Gc10_544 0 n20 ns544 0 0.0001321370308
Gc10_545 0 n20 ns545 0 -0.000384602343556
Gc10_546 0 n20 ns546 0 -0.000171014295125
Gc10_547 0 n20 ns547 0 1.52900365635e-05
Gc10_548 0 n20 ns548 0 -0.000780770007889
Gc10_549 0 n20 ns549 0 0.000458402004931
Gc10_550 0 n20 ns550 0 0.000614225089429
Gc10_551 0 n20 ns551 0 0.000345694987966
Gc10_552 0 n20 ns552 0 7.40076478206e-05
Gc10_553 0 n20 ns553 0 -0.000188120223245
Gc10_554 0 n20 ns554 0 0.000803643908351
Gc10_555 0 n20 ns555 0 0.00140661878901
Gc10_556 0 n20 ns556 0 0.00102906015516
Gc10_557 0 n20 ns557 0 -0.000402579982486
Gc10_558 0 n20 ns558 0 -0.000731069118872
Gc10_559 0 n20 ns559 0 -0.000148921828389
Gc10_560 0 n20 ns560 0 0.00123588402085
Gc10_561 0 n20 ns561 0 0.00113124423105
Gc10_562 0 n20 ns562 0 0.000416835280851
Gc10_563 0 n20 ns563 0 -6.36042551794e-05
Gc10_564 0 n20 ns564 0 -7.4579381275e-05
Gc10_565 0 n20 ns565 0 -0.000358722797154
Gc10_566 0 n20 ns566 0 0.0178752995833
Gc10_567 0 n20 ns567 0 -0.0153978317794
Gc10_568 0 n20 ns568 0 0.000560034693555
Gc10_569 0 n20 ns569 0 -3.64890046332e-06
Gc10_570 0 n20 ns570 0 -3.37915963731e-05
Gc10_571 0 n20 ns571 0 -5.11793739519e-05
Gc10_572 0 n20 ns572 0 0.000209928354682
Gc10_573 0 n20 ns573 0 -0.00300050419616
Gc10_574 0 n20 ns574 0 -0.000235214003132
Gc10_575 0 n20 ns575 0 -0.000196032110121
Gc10_576 0 n20 ns576 0 -0.000174731560333
Gc10_577 0 n20 ns577 0 1.80181967519e-05
Gc10_578 0 n20 ns578 0 1.35595222376e-06
Gc10_579 0 n20 ns579 0 1.42291528884e-05
Gc10_580 0 n20 ns580 0 0.00064047441862
Gc10_581 0 n20 ns581 0 0.0013237086483
Gc10_582 0 n20 ns582 0 -0.000372344284436
Gc10_583 0 n20 ns583 0 -0.000481444051935
Gc10_584 0 n20 ns584 0 -0.000126858512296
Gc10_585 0 n20 ns585 0 0.000111661828017
Gc10_586 0 n20 ns586 0 6.57679888672e-05
Gc10_587 0 n20 ns587 0 0.0010250281509
Gc10_588 0 n20 ns588 0 0.000537399901176
Gc10_589 0 n20 ns589 0 -0.000276286093788
Gc10_590 0 n20 ns590 0 -5.46487970149e-05
Gc10_591 0 n20 ns591 0 -0.000148834601128
Gc10_592 0 n20 ns592 0 0.00146024073718
Gc10_593 0 n20 ns593 0 0.00080336108712
Gc10_594 0 n20 ns594 0 0.000490729425119
Gc10_595 0 n20 ns595 0 -0.000683840749038
Gc10_596 0 n20 ns596 0 -0.000498489726987
Gc10_597 0 n20 ns597 0 0.000161576008998
Gc10_598 0 n20 ns598 0 0.0018080193099
Gc10_599 0 n20 ns599 0 0.00086017909759
Gc10_600 0 n20 ns600 0 0.000197485615193
Gc10_601 0 n20 ns601 0 -0.000340311323088
Gc10_602 0 n20 ns602 0 -0.000150534970262
Gc10_603 0 n20 ns603 0 -0.000187387165154
Gc10_604 0 n20 ns604 0 0.0176501173529
Gc10_605 0 n20 ns605 0 -0.0148933575577
Gc10_606 0 n20 ns606 0 0.000502992635341
Gc10_607 0 n20 ns607 0 -5.24641206814e-06
Gc10_608 0 n20 ns608 0 -2.80818473769e-05
Gc10_609 0 n20 ns609 0 -0.00049470089634
Gc10_610 0 n20 ns610 0 0.000599517689834
Gc10_611 0 n20 ns611 0 0.00185356022841
Gc10_612 0 n20 ns612 0 -0.0012044679159
Gc10_613 0 n20 ns613 0 -0.000843392985562
Gc10_614 0 n20 ns614 0 0.00158248024021
Gc10_615 0 n20 ns615 0 0.000213794705581
Gc10_616 0 n20 ns616 0 -0.000185684584168
Gc10_617 0 n20 ns617 0 -0.000187182191464
Gc10_618 0 n20 ns618 0 0.00243819567525
Gc10_619 0 n20 ns619 0 -0.000397724513701
Gc10_620 0 n20 ns620 0 -0.00089712139208
Gc10_621 0 n20 ns621 0 0.000634609726009
Gc10_622 0 n20 ns622 0 -0.00027822591245
Gc10_623 0 n20 ns623 0 0.000170857774693
Gc10_624 0 n20 ns624 0 -0.00122096282499
Gc10_625 0 n20 ns625 0 -0.00316163388156
Gc10_626 0 n20 ns626 0 -6.61049248515e-05
Gc10_627 0 n20 ns627 0 0.000289806057617
Gc10_628 0 n20 ns628 0 0.00017689963754
Gc10_629 0 n20 ns629 0 0.000383961740187
Gc10_630 0 n20 ns630 0 0.00195710399341
Gc10_631 0 n20 ns631 0 -0.00388800025817
Gc10_632 0 n20 ns632 0 -0.00221981924947
Gc10_633 0 n20 ns633 0 4.42778424941e-05
Gc10_634 0 n20 ns634 0 -9.98002391368e-05
Gc10_635 0 n20 ns635 0 0.00110128361661
Gc10_636 0 n20 ns636 0 -0.00841133147204
Gc10_637 0 n20 ns637 0 -0.00224024201671
Gc10_638 0 n20 ns638 0 -0.000863089734841
Gc10_639 0 n20 ns639 0 0.000330010988133
Gc10_640 0 n20 ns640 0 0.00230501141195
Gc10_641 0 n20 ns641 0 0.00076993835717
Gc10_642 0 n20 ns642 0 -0.0443035430965
Gc10_643 0 n20 ns643 0 0.0452360435356
Gc10_644 0 n20 ns644 0 -0.00596033008263
Gc10_645 0 n20 ns645 0 -5.54778211644e-06
Gc10_646 0 n20 ns646 0 2.8664052774e-05
Gc10_647 0 n20 ns647 0 -0.00253268549036
Gc10_648 0 n20 ns648 0 -0.00230317706389
Gc10_649 0 n20 ns649 0 0.00516761433537
Gc10_650 0 n20 ns650 0 0.00115606950814
Gc10_651 0 n20 ns651 0 -0.00190685078518
Gc10_652 0 n20 ns652 0 0.00042813005509
Gc10_653 0 n20 ns653 0 0.00174998088977
Gc10_654 0 n20 ns654 0 -1.23060916473e-05
Gc10_655 0 n20 ns655 0 -0.000228137454318
Gc10_656 0 n20 ns656 0 0.000717118413046
Gc10_657 0 n20 ns657 0 -0.000488521596059
Gc10_658 0 n20 ns658 0 -0.000892070802365
Gc10_659 0 n20 ns659 0 0.000602417518713
Gc10_660 0 n20 ns660 0 -0.000330599428543
Gc10_661 0 n20 ns661 0 0.000222910400786
Gc10_662 0 n20 ns662 0 0.000463562198111
Gc10_663 0 n20 ns663 0 -0.00218494887133
Gc10_664 0 n20 ns664 0 0.000119760351805
Gc10_665 0 n20 ns665 0 -0.000396694101869
Gc10_666 0 n20 ns666 0 0.000147753897156
Gc10_667 0 n20 ns667 0 0.000291273389578
Gc10_668 0 n20 ns668 0 0.002226301698
Gc10_669 0 n20 ns669 0 -0.00143724634652
Gc10_670 0 n20 ns670 0 -0.00176811971075
Gc10_671 0 n20 ns671 0 -0.00060354308656
Gc10_672 0 n20 ns672 0 -0.000621281677131
Gc10_673 0 n20 ns673 0 0.00125315795392
Gc10_674 0 n20 ns674 0 -0.00868240099061
Gc10_675 0 n20 ns675 0 -0.00276667813341
Gc10_676 0 n20 ns676 0 -0.000233153354228
Gc10_677 0 n20 ns677 0 0.000438239922383
Gc10_678 0 n20 ns678 0 0.00269216541214
Gc10_679 0 n20 ns679 0 0.000797289914422
Gc10_680 0 n20 ns680 0 -0.0269464213401
Gc10_681 0 n20 ns681 0 0.0310733603353
Gc10_682 0 n20 ns682 0 -0.0070585877751
Gc10_683 0 n20 ns683 0 -8.38875849528e-06
Gc10_684 0 n20 ns684 0 2.68002254492e-05
Gc10_685 0 n20 ns685 0 -0.00565745044956
Gc10_686 0 n20 ns686 0 -0.00427662381118
Gc10_687 0 n20 ns687 0 0.00658199690166
Gc10_688 0 n20 ns688 0 0.00243046803368
Gc10_689 0 n20 ns689 0 -0.00223000136542
Gc10_690 0 n20 ns690 0 0.000620049023069
Gc10_691 0 n20 ns691 0 0.00296855110726
Gc10_692 0 n20 ns692 0 1.56264316633e-05
Gc10_693 0 n20 ns693 0 -0.000274744776029
Gc10_694 0 n20 ns694 0 -0.00203230748426
Gc10_695 0 n20 ns695 0 -0.00115725138049
Gc10_696 0 n20 ns696 0 -4.71212735497e-05
Gc10_697 0 n20 ns697 0 0.000673302036338
Gc10_698 0 n20 ns698 0 -0.00025680588253
Gc10_699 0 n20 ns699 0 0.00028565779384
Gc10_700 0 n20 ns700 0 0.00329085377811
Gc10_701 0 n20 ns701 0 -0.000926894304343
Gc10_702 0 n20 ns702 0 -0.000523010437263
Gc10_703 0 n20 ns703 0 -0.00163014285339
Gc10_704 0 n20 ns704 0 -4.00356540011e-06
Gc10_705 0 n20 ns705 0 0.00020067969004
Gc10_706 0 n20 ns706 0 0.00244757689386
Gc10_707 0 n20 ns707 0 0.00201131269784
Gc10_708 0 n20 ns708 0 -6.44345433846e-05
Gc10_709 0 n20 ns709 0 -0.00212564850009
Gc10_710 0 n20 ns710 0 -0.00167576733429
Gc10_711 0 n20 ns711 0 0.00143900252655
Gc10_712 0 n20 ns712 0 -0.0116469144679
Gc10_713 0 n20 ns713 0 -0.0048812357232
Gc10_714 0 n20 ns714 0 0.00127899575704
Gc10_715 0 n20 ns715 0 0.0028585901791
Gc10_716 0 n20 ns716 0 0.00354500324708
Gc10_717 0 n20 ns717 0 0.000521768081531
Gc10_718 0 n20 ns718 0 0.0173793803603
Gc10_719 0 n20 ns719 0 -0.00761575456775
Gc10_720 0 n20 ns720 0 -0.00777339143159
Gc10_721 0 n20 ns721 0 -1.47707222159e-05
Gc10_722 0 n20 ns722 0 2.60113345516e-05
Gc10_723 0 n20 ns723 0 5.84265139604e-05
Gc10_724 0 n20 ns724 0 -0.000591574228233
Gc10_725 0 n20 ns725 0 0.00924899903287
Gc10_726 0 n20 ns726 0 -0.000209332796495
Gc10_727 0 n20 ns727 0 5.75420988834e-05
Gc10_728 0 n20 ns728 0 0.000553944727961
Gc10_729 0 n20 ns729 0 -0.000579622154052
Gc10_730 0 n20 ns730 0 -8.1562821448e-05
Gc10_731 0 n20 ns731 0 7.07837449176e-06
Gc10_732 0 n20 ns732 0 0.00137980955766
Gc10_733 0 n20 ns733 0 -0.00141747403739
Gc10_734 0 n20 ns734 0 -0.000182865620099
Gc10_735 0 n20 ns735 0 8.45285898847e-05
Gc10_736 0 n20 ns736 0 -0.000318869240093
Gc10_737 0 n20 ns737 0 0.000422760544896
Gc10_738 0 n20 ns738 0 -0.000507503961077
Gc10_739 0 n20 ns739 0 -0.00251287953617
Gc10_740 0 n20 ns740 0 -0.00117282677171
Gc10_741 0 n20 ns741 0 0.000128251221039
Gc10_742 0 n20 ns742 0 0.000331519834935
Gc10_743 0 n20 ns743 0 0.000437360695349
Gc10_744 0 n20 ns744 0 -0.000405528395131
Gc10_745 0 n20 ns745 0 -0.00576202168167
Gc10_746 0 n20 ns746 0 -0.00214733872199
Gc10_747 0 n20 ns747 0 -0.000642361787629
Gc10_748 0 n20 ns748 0 2.35118148919e-05
Gc10_749 0 n20 ns749 0 0.00198264351846
Gc10_750 0 n20 ns750 0 -0.0100653903263
Gc10_751 0 n20 ns751 0 -0.00595454885832
Gc10_752 0 n20 ns752 0 -0.00226247724916
Gc10_753 0 n20 ns753 0 0.00284735659159
Gc10_754 0 n20 ns754 0 0.00276511778851
Gc10_755 0 n20 ns755 0 0.000307716512296
Gc10_756 0 n20 ns756 0 -0.0912551725411
Gc10_757 0 n20 ns757 0 0.0832135195772
Gc10_758 0 n20 ns758 0 -0.00528893857199
Gc10_759 0 n20 ns759 0 -1.25787890971e-05
Gc10_760 0 n20 ns760 0 2.04798636698e-05
Gc10_761 0 n20 ns761 0 0.000599638572871
Gc10_762 0 n20 ns762 0 -0.00201914261209
Gc10_763 0 n20 ns763 0 0.0107609867648
Gc10_764 0 n20 ns764 0 0.00056775842162
Gc10_765 0 n20 ns765 0 8.29395914681e-05
Gc10_766 0 n20 ns766 0 6.89391580658e-05
Gc10_767 0 n20 ns767 0 -2.8197704112e-05
Gc10_768 0 n20 ns768 0 -4.85693159157e-05
Gc10_769 0 n20 ns769 0 8.36423574462e-06
Gc10_770 0 n20 ns770 0 -0.000278831183843
Gc10_771 0 n20 ns771 0 -0.00310956055627
Gc10_772 0 n20 ns772 0 -1.41197632563e-05
Gc10_773 0 n20 ns773 0 0.000507671985662
Gc10_774 0 n20 ns774 0 0.000120409077467
Gc10_775 0 n20 ns775 0 0.00050428964027
Gc10_776 0 n20 ns776 0 -0.000303117894565
Gc10_777 0 n20 ns777 0 -0.000826207347754
Gc10_778 0 n20 ns778 0 -0.000883182524345
Gc10_779 0 n20 ns779 0 9.16002940761e-05
Gc10_780 0 n20 ns780 0 0.000271942728603
Gc10_781 0 n20 ns781 0 9.48614697794e-05
Gc10_782 0 n20 ns782 0 -0.00236136460298
Gc10_783 0 n20 ns783 0 -0.00360844511628
Gc10_784 0 n20 ns784 0 -0.000978826640257
Gc10_785 0 n20 ns785 0 -0.000595875623765
Gc10_786 0 n20 ns786 0 0.000205083808474
Gc10_787 0 n20 ns787 0 0.00147271040091
Gc10_788 0 n20 ns788 0 -0.00839362395522
Gc10_789 0 n20 ns789 0 -0.0056793314131
Gc10_790 0 n20 ns790 0 -0.0013040973058
Gc10_791 0 n20 ns791 0 0.00414658223068
Gc10_792 0 n20 ns792 0 0.00209106499251
Gc10_793 0 n20 ns793 0 -0.000415720900259
Gc10_794 0 n20 ns794 0 -0.0623065391478
Gc10_795 0 n20 ns795 0 0.0533871824693
Gc10_796 0 n20 ns796 0 -0.00224861761526
Gc10_797 0 n20 ns797 0 -8.73222369858e-06
Gc10_798 0 n20 ns798 0 2.56283961229e-07
Gc10_799 0 n20 ns799 0 0.000242122529471
Gc10_800 0 n20 ns800 0 -0.000371495210818
Gc10_801 0 n20 ns801 0 0.0043647426861
Gc10_802 0 n20 ns802 0 -0.000222129460248
Gc10_803 0 n20 ns803 0 0.000433915150782
Gc10_804 0 n20 ns804 0 0.000380361775681
Gc10_805 0 n20 ns805 0 7.52772553946e-05
Gc10_806 0 n20 ns806 0 2.2413294147e-05
Gc10_807 0 n20 ns807 0 -1.66283068652e-05
Gc10_808 0 n20 ns808 0 0.000246582272208
Gc10_809 0 n20 ns809 0 -0.0013464776626
Gc10_810 0 n20 ns810 0 -0.000242234824106
Gc10_811 0 n20 ns811 0 0.000143038659103
Gc10_812 0 n20 ns812 0 0.000212488224218
Gc10_813 0 n20 ns813 0 0.000294699354061
Gc10_814 0 n20 ns814 0 0.00062159819391
Gc10_815 0 n20 ns815 0 -0.0012528707576
Gc10_816 0 n20 ns816 0 -0.000871639906155
Gc10_817 0 n20 ns817 0 0.000429529948765
Gc10_818 0 n20 ns818 0 0.000145601111649
Gc10_819 0 n20 ns819 0 4.88553663391e-06
Gc10_820 0 n20 ns820 0 -0.000484338785052
Gc10_821 0 n20 ns821 0 -0.00193082760215
Gc10_822 0 n20 ns822 0 -0.00125655492473
Gc10_823 0 n20 ns823 0 -0.00119572024351
Gc10_824 0 n20 ns824 0 0.00040903649702
Gc10_825 0 n20 ns825 0 0.0013668925668
Gc10_826 0 n20 ns826 0 -0.00553464978237
Gc10_827 0 n20 ns827 0 -0.00325743851424
Gc10_828 0 n20 ns828 0 0.000144735094527
Gc10_829 0 n20 ns829 0 0.00290706148991
Gc10_830 0 n20 ns830 0 0.00108111419964
Gc10_831 0 n20 ns831 0 -0.000656292070412
Gc10_832 0 n20 ns832 0 -0.0251287951358
Gc10_833 0 n20 ns833 0 0.0209089497713
Gc10_834 0 n20 ns834 0 -0.000795560789605
Gc10_835 0 n20 ns835 0 -1.71180569678e-06
Gc10_836 0 n20 ns836 0 -1.79197694996e-05
Gc10_837 0 n20 ns837 0 0.000525834823944
Gc10_838 0 n20 ns838 0 -0.000610390498139
Gc10_839 0 n20 ns839 0 0.0027261409193
Gc10_840 0 n20 ns840 0 -0.000167101071187
Gc10_841 0 n20 ns841 0 0.000338768421716
Gc10_842 0 n20 ns842 0 0.000186706299548
Gc10_843 0 n20 ns843 0 -2.50681177303e-06
Gc10_844 0 n20 ns844 0 -1.27357394169e-05
Gc10_845 0 n20 ns845 0 -4.04305546583e-05
Gc10_846 0 n20 ns846 0 0.000709502868658
Gc10_847 0 n20 ns847 0 -0.000965544178881
Gc10_848 0 n20 ns848 0 -0.000495008118971
Gc10_849 0 n20 ns849 0 0.000316213848157
Gc10_850 0 n20 ns850 0 0.00019198775123
Gc10_851 0 n20 ns851 0 0.00015192301018
Gc10_852 0 n20 ns852 0 -0.000452214156379
Gc10_853 0 n20 ns853 0 -0.000970151719813
Gc10_854 0 n20 ns854 0 -4.11827173336e-05
Gc10_855 0 n20 ns855 0 0.000668085566319
Gc10_856 0 n20 ns856 0 0.000111192204479
Gc10_857 0 n20 ns857 0 -0.00010360385349
Gc10_858 0 n20 ns858 0 -0.000181188760452
Gc10_859 0 n20 ns859 0 -0.00134628504412
Gc10_860 0 n20 ns860 0 -0.00136765393426
Gc10_861 0 n20 ns861 0 -0.000338748549639
Gc10_862 0 n20 ns862 0 0.000711643346843
Gc10_863 0 n20 ns863 0 0.000695115432045
Gc10_864 0 n20 ns864 0 -0.00356136737325
Gc10_865 0 n20 ns865 0 -0.000713769149398
Gc10_866 0 n20 ns866 0 0.000687736971423
Gc10_867 0 n20 ns867 0 0.00146060148975
Gc10_868 0 n20 ns868 0 0.000454546589996
Gc10_869 0 n20 ns869 0 -0.000547752898808
Gc10_870 0 n20 ns870 0 -0.00769255569234
Gc10_871 0 n20 ns871 0 0.00594613072065
Gc10_872 0 n20 ns872 0 -0.000207517406352
Gc10_873 0 n20 ns873 0 5.5505095315e-06
Gc10_874 0 n20 ns874 0 -3.18044445837e-05
Gc10_875 0 n20 ns875 0 0.000424559200363
Gc10_876 0 n20 ns876 0 -0.000785021444553
Gc10_877 0 n20 ns877 0 0.000890001464093
Gc10_878 0 n20 ns878 0 -0.000217983843887
Gc10_879 0 n20 ns879 0 0.000154399766211
Gc10_880 0 n20 ns880 0 4.73313978673e-05
Gc10_881 0 n20 ns881 0 0.000105174955428
Gc10_882 0 n20 ns882 0 1.04295797416e-05
Gc10_883 0 n20 ns883 0 3.65541861852e-06
Gc10_884 0 n20 ns884 0 3.23385081485e-05
Gc10_885 0 n20 ns885 0 -0.000755897185874
Gc10_886 0 n20 ns886 0 -1.0797028698e-05
Gc10_887 0 n20 ns887 0 0.000513854670856
Gc10_888 0 n20 ns888 0 0.000166629669592
Gc10_889 0 n20 ns889 0 -4.4622182746e-05
Gc10_890 0 n20 ns890 0 -0.000443166500241
Gc10_891 0 n20 ns891 0 0.00037501346637
Gc10_892 0 n20 ns892 0 0.000494380983187
Gc10_893 0 n20 ns893 0 5.34616064751e-05
Gc10_894 0 n20 ns894 0 -2.1831424408e-05
Gc10_895 0 n20 ns895 0 -0.000165118548252
Gc10_896 0 n20 ns896 0 0.000142090212813
Gc10_897 0 n20 ns897 0 -0.000704385097621
Gc10_898 0 n20 ns898 0 -0.000774343528326
Gc10_899 0 n20 ns899 0 0.000152984222803
Gc10_900 0 n20 ns900 0 0.000496837704989
Gc10_901 0 n20 ns901 0 0.000145860943407
Gc10_902 0 n20 ns902 0 -0.00102467040209
Gc10_903 0 n20 ns903 0 0.000624340789833
Gc10_904 0 n20 ns904 0 0.000562021149131
Gc10_905 0 n20 ns905 0 0.00033459413534
Gc10_906 0 n20 ns906 0 5.49452763047e-05
Gc10_907 0 n20 ns907 0 -0.000341228858377
Gc10_908 0 n20 ns908 0 0.00324522451585
Gc10_909 0 n20 ns909 0 -0.00288190076243
Gc10_910 0 n20 ns910 0 3.86130824891e-05
Gc10_911 0 n20 ns911 0 6.51152937402e-06
Gc10_912 0 n20 ns912 0 -3.21527173572e-05
Gc10_913 0 n20 ns913 0 -2.61219398544e-05
Gc10_914 0 n20 ns914 0 -0.000112583373131
Gc10_915 0 n20 ns915 0 -0.00105509243773
Gc10_916 0 n20 ns916 0 -0.000181662939658
Gc10_917 0 n20 ns917 0 7.48973858711e-05
Gc10_918 0 n20 ns918 0 4.01292801492e-05
Gc10_919 0 n20 ns919 0 0.000161749601531
Gc10_920 0 n20 ns920 0 3.87794945313e-05
Gc10_921 0 n20 ns921 0 -1.64526068012e-05
Gc10_922 0 n20 ns922 0 -0.000401085103593
Gc10_923 0 n20 ns923 0 -8.1448029573e-05
Gc10_924 0 n20 ns924 0 0.000313144762806
Gc10_925 0 n20 ns925 0 0.000204699308806
Gc10_926 0 n20 ns926 0 5.12416420386e-05
Gc10_927 0 n20 ns927 0 -0.00013217116137
Gc10_928 0 n20 ns928 0 4.70185911035e-05
Gc10_929 0 n20 ns929 0 0.000786217343998
Gc10_930 0 n20 ns930 0 0.000396351775309
Gc10_931 0 n20 ns931 0 -0.000287517190379
Gc10_932 0 n20 ns932 0 -7.41344734719e-05
Gc10_933 0 n20 ns933 0 -0.000115596760654
Gc10_934 0 n20 ns934 0 0.000409677826533
Gc10_935 0 n20 ns935 0 -0.000129028856091
Gc10_936 0 n20 ns936 0 -0.000213361346703
Gc10_937 0 n20 ns937 0 9.11700033289e-05
Gc10_938 0 n20 ns938 0 0.000157363618385
Gc10_939 0 n20 ns939 0 -1.7802860332e-05
Gc10_940 0 n20 ns940 0 0.000530454877024
Gc10_941 0 n20 ns941 0 0.00102012742915
Gc10_942 0 n20 ns942 0 0.000326991249312
Gc10_943 0 n20 ns943 0 -0.000192944212389
Gc10_944 0 n20 ns944 0 -9.10784261199e-05
Gc10_945 0 n20 ns945 0 -0.000189818909768
Gc10_946 0 n20 ns946 0 0.010268271594
Gc10_947 0 n20 ns947 0 -0.00867343125511
Gc10_948 0 n20 ns948 0 0.000231458656519
Gc10_949 0 n20 ns949 0 5.52569080638e-06
Gc10_950 0 n20 ns950 0 -2.70212015812e-05
Gc10_951 0 n20 ns951 0 -0.0171404081627
Gc10_952 0 n20 ns952 0 -0.000893350515081
Gc10_953 0 n20 ns953 0 0.0191621611151
Gc10_954 0 n20 ns954 0 0.00637301855342
Gc10_955 0 n20 ns955 0 0.00996052464821
Gc10_956 0 n20 ns956 0 0.0012494806557
Gc10_957 0 n20 ns957 0 -0.00331134052313
Gc10_958 0 n20 ns958 0 -0.000536682673394
Gc10_959 0 n20 ns959 0 7.31859596135e-05
Gc10_960 0 n20 ns960 0 -0.00186384185591
Gc10_961 0 n20 ns961 0 -0.0140675446419
Gc10_962 0 n20 ns962 0 0.00157132534526
Gc10_963 0 n20 ns963 0 0.00213428867918
Gc10_964 0 n20 ns964 0 8.71629239271e-05
Gc10_965 0 n20 ns965 0 0.000140658472373
Gc10_966 0 n20 ns966 0 0.000250651483385
Gc10_967 0 n20 ns967 0 0.00183882853903
Gc10_968 0 n20 ns968 0 0.00045959984139
Gc10_969 0 n20 ns969 0 -0.000351137565256
Gc10_970 0 n20 ns970 0 0.000338595407218
Gc10_971 0 n20 ns971 0 0.000400234396253
Gc10_972 0 n20 ns972 0 -0.0118884044389
Gc10_973 0 n20 ns973 0 -0.00710922216054
Gc10_974 0 n20 ns974 0 -0.00241056998469
Gc10_975 0 n20 ns975 0 -0.000517120672476
Gc10_976 0 n20 ns976 0 -0.000464145176397
Gc10_977 0 n20 ns977 0 0.00170137286188
Gc10_978 0 n20 ns978 0 0.0110699381389
Gc10_979 0 n20 ns979 0 -0.00504237443366
Gc10_980 0 n20 ns980 0 0.000904438953425
Gc10_981 0 n20 ns981 0 0.000807872214515
Gc10_982 0 n20 ns982 0 0.0031738922476
Gc10_983 0 n20 ns983 0 0.000496483392009
Gc10_984 0 n20 ns984 0 -0.105253251914
Gc10_985 0 n20 ns985 0 0.0684496110046
Gc10_986 0 n20 ns986 0 -0.00888604845951
Gc10_987 0 n20 ns987 0 -1.34935985596e-05
Gc10_988 0 n20 ns988 0 2.64063050346e-05
Gc10_989 0 n20 ns989 0 -0.000508829048551
Gc10_990 0 n20 ns990 0 0.000497810367612
Gc10_991 0 n20 ns991 0 0.00501103227255
Gc10_992 0 n20 ns992 0 -0.00128820854537
Gc10_993 0 n20 ns993 0 -0.000556317612264
Gc10_994 0 n20 ns994 0 0.00187520240598
Gc10_995 0 n20 ns995 0 0.000523008606658
Gc10_996 0 n20 ns996 0 -0.000159643551449
Gc10_997 0 n20 ns997 0 -0.000180777787749
Gc10_998 0 n20 ns998 0 0.00126288384385
Gc10_999 0 n20 ns999 0 -0.00137463686979
Gc10_1000 0 n20 ns1000 0 -8.62495249504e-05
Gc10_1001 0 n20 ns1001 0 0.000421383966504
Gc10_1002 0 n20 ns1002 0 -0.000326984436898
Gc10_1003 0 n20 ns1003 0 0.000352927011161
Gc10_1004 0 n20 ns1004 0 0.000529948252907
Gc10_1005 0 n20 ns1005 0 -0.00305132701584
Gc10_1006 0 n20 ns1006 0 -0.00132432108716
Gc10_1007 0 n20 ns1007 0 -0.000279453695445
Gc10_1008 0 n20 ns1008 0 0.000227335723451
Gc10_1009 0 n20 ns1009 0 0.000512382995348
Gc10_1010 0 n20 ns1010 0 0.000951774188484
Gc10_1011 0 n20 ns1011 0 -0.00461808921563
Gc10_1012 0 n20 ns1012 0 -0.00194710143537
Gc10_1013 0 n20 ns1013 0 -0.00110652479628
Gc10_1014 0 n20 ns1014 0 -0.000420626625799
Gc10_1015 0 n20 ns1015 0 0.00201557399992
Gc10_1016 0 n20 ns1016 0 -0.0110077705355
Gc10_1017 0 n20 ns1017 0 -0.00582747591177
Gc10_1018 0 n20 ns1018 0 -0.001524522002
Gc10_1019 0 n20 ns1019 0 0.00270576590355
Gc10_1020 0 n20 ns1020 0 0.00309358148436
Gc10_1021 0 n20 ns1021 0 0.000479038683523
Gc10_1022 0 n20 ns1022 0 -0.0680506843268
Gc10_1023 0 n20 ns1023 0 0.0650594894054
Gc10_1024 0 n20 ns1024 0 -0.00643325435789
Gc10_1025 0 n20 ns1025 0 -1.32143769364e-05
Gc10_1026 0 n20 ns1026 0 3.15182186851e-05
Gc10_1027 0 n20 ns1027 0 0.00069843986659
Gc10_1028 0 n20 ns1028 0 -0.00100270540014
Gc10_1029 0 n20 ns1029 0 0.0115818719093
Gc10_1030 0 n20 ns1030 0 0.000323192110988
Gc10_1031 0 n20 ns1031 0 0.000588099633704
Gc10_1032 0 n20 ns1032 0 0.000420693083046
Gc10_1033 0 n20 ns1033 0 -0.000309531136445
Gc10_1034 0 n20 ns1034 0 -0.000121348411888
Gc10_1035 0 n20 ns1035 0 -3.38422176957e-05
Gc10_1036 0 n20 ns1036 0 4.04518627532e-05
Gc10_1037 0 n20 ns1037 0 -0.00373218607948
Gc10_1038 0 n20 ns1038 0 8.43043957811e-05
Gc10_1039 0 n20 ns1039 0 0.000617091109938
Gc10_1040 0 n20 ns1040 0 2.55907066144e-06
Gc10_1041 0 n20 ns1041 0 0.000517416644737
Gc10_1042 0 n20 ns1042 0 -0.000923380316252
Gc10_1043 0 n20 ns1043 0 -0.00138535190247
Gc10_1044 0 n20 ns1044 0 -0.00094760003903
Gc10_1045 0 n20 ns1045 0 0.000183823436649
Gc10_1046 0 n20 ns1046 0 0.000357737140856
Gc10_1047 0 n20 ns1047 0 0.000221794086305
Gc10_1048 0 n20 ns1048 0 -0.00263426210734
Gc10_1049 0 n20 ns1049 0 -0.0046865744353
Gc10_1050 0 n20 ns1050 0 -0.00128395128564
Gc10_1051 0 n20 ns1051 0 -0.000299728660951
Gc10_1052 0 n20 ns1052 0 0.000222102025777
Gc10_1053 0 n20 ns1053 0 0.00159010433935
Gc10_1054 0 n20 ns1054 0 -0.00972332869496
Gc10_1055 0 n20 ns1055 0 -0.00623758783472
Gc10_1056 0 n20 ns1056 0 -0.00178143071908
Gc10_1057 0 n20 ns1057 0 0.00421315543372
Gc10_1058 0 n20 ns1058 0 0.00246002836955
Gc10_1059 0 n20 ns1059 0 -0.000247534850652
Gc10_1060 0 n20 ns1060 0 -0.0780417817024
Gc10_1061 0 n20 ns1061 0 0.0677948512765
Gc10_1062 0 n20 ns1062 0 -0.00313594641872
Gc10_1063 0 n20 ns1063 0 -1.02940393334e-05
Gc10_1064 0 n20 ns1064 0 1.14564334518e-05
Gc10_1065 0 n20 ns1065 0 0.000257225116814
Gc10_1066 0 n20 ns1066 0 -0.000955251120531
Gc10_1067 0 n20 ns1067 0 0.00672045220822
Gc10_1068 0 n20 ns1068 0 0.000148187783699
Gc10_1069 0 n20 ns1069 0 0.000296829996032
Gc10_1070 0 n20 ns1070 0 0.0003328245127
Gc10_1071 0 n20 ns1071 0 6.93587225397e-05
Gc10_1072 0 n20 ns1072 0 -1.21842312554e-07
Gc10_1073 0 n20 ns1073 0 2.702047692e-06
Gc10_1074 0 n20 ns1074 0 -0.000311260289978
Gc10_1075 0 n20 ns1075 0 -0.00210278849953
Gc10_1076 0 n20 ns1076 0 -7.87632402285e-06
Gc10_1077 0 n20 ns1077 0 0.000265365487951
Gc10_1078 0 n20 ns1078 0 0.000215655822617
Gc10_1079 0 n20 ns1079 0 0.000370313611886
Gc10_1080 0 n20 ns1080 0 0.000624133276152
Gc10_1081 0 n20 ns1081 0 -0.00112890729768
Gc10_1082 0 n20 ns1082 0 -0.00107095068697
Gc10_1083 0 n20 ns1083 0 0.000246070748622
Gc10_1084 0 n20 ns1084 0 0.000174054337723
Gc10_1085 0 n20 ns1085 0 4.84052369203e-05
Gc10_1086 0 n20 ns1086 0 -0.00123358843592
Gc10_1087 0 n20 ns1087 0 -0.00250778677496
Gc10_1088 0 n20 ns1088 0 -0.00117113347444
Gc10_1089 0 n20 ns1089 0 -0.00117503884711
Gc10_1090 0 n20 ns1090 0 0.000333645215546
Gc10_1091 0 n20 ns1091 0 0.00152140072856
Gc10_1092 0 n20 ns1092 0 -0.00695179179008
Gc10_1093 0 n20 ns1093 0 -0.00439133085606
Gc10_1094 0 n20 ns1094 0 -0.000239854161401
Gc10_1095 0 n20 ns1095 0 0.00359449231342
Gc10_1096 0 n20 ns1096 0 0.00146036170327
Gc10_1097 0 n20 ns1097 0 -0.000643674111073
Gc10_1098 0 n20 ns1098 0 -0.0383847741449
Gc10_1099 0 n20 ns1099 0 0.0322224368907
Gc10_1100 0 n20 ns1100 0 -0.00123572885343
Gc10_1101 0 n20 ns1101 0 -4.91537227244e-06
Gc10_1102 0 n20 ns1102 0 -8.00087748716e-06
Gc10_1103 0 n20 ns1103 0 0.000405376706863
Gc10_1104 0 n20 ns1104 0 -0.000535488862234
Gc10_1105 0 n20 ns1105 0 0.00317594443828
Gc10_1106 0 n20 ns1106 0 -0.000160366346897
Gc10_1107 0 n20 ns1107 0 0.000329033687292
Gc10_1108 0 n20 ns1108 0 0.000226492055137
Gc10_1109 0 n20 ns1109 0 7.21071406424e-06
Gc10_1110 0 n20 ns1110 0 9.30888484199e-06
Gc10_1111 0 n20 ns1111 0 -4.39809749996e-05
Gc10_1112 0 n20 ns1112 0 0.000682476284533
Gc10_1113 0 n20 ns1113 0 -0.000898006944536
Gc10_1114 0 n20 ns1114 0 -0.00052089585782
Gc10_1115 0 n20 ns1115 0 0.000142174792949
Gc10_1116 0 n20 ns1116 0 0.000189146181865
Gc10_1117 0 n20 ns1117 0 0.000225675707633
Gc10_1118 0 n20 ns1118 0 -0.000169471141631
Gc10_1119 0 n20 ns1119 0 -0.001300513798
Gc10_1120 0 n20 ns1120 0 -0.000368643569517
Gc10_1121 0 n20 ns1121 0 0.000764948990915
Gc10_1122 0 n20 ns1122 0 0.000159077591383
Gc10_1123 0 n20 ns1123 0 -6.08094245858e-05
Gc10_1124 0 n20 ns1124 0 -0.000196326901031
Gc10_1125 0 n20 ns1125 0 -0.00139199991405
Gc10_1126 0 n20 ns1126 0 -0.0013907844248
Gc10_1127 0 n20 ns1127 0 -0.000704758511345
Gc10_1128 0 n20 ns1128 0 0.000641527850663
Gc10_1129 0 n20 ns1129 0 0.000961211520507
Gc10_1130 0 n20 ns1130 0 -0.00416616115334
Gc10_1131 0 n20 ns1131 0 -0.00138866693049
Gc10_1132 0 n20 ns1132 0 0.000596238784524
Gc10_1133 0 n20 ns1133 0 0.00188237122013
Gc10_1134 0 n20 ns1134 0 0.000615529441245
Gc10_1135 0 n20 ns1135 0 -0.000604857021205
Gc10_1136 0 n20 ns1136 0 -0.0120211558623
Gc10_1137 0 n20 ns1137 0 0.00961674631279
Gc10_1138 0 n20 ns1138 0 -0.000345295015284
Gc10_1139 0 n20 ns1139 0 2.55668602111e-06
Gc10_1140 0 n20 ns1140 0 -2.70439357856e-05
Gc10_1141 0 n20 ns1141 0 0.000517262883447
Gc10_1142 0 n20 ns1142 0 -0.00105025238039
Gc10_1143 0 n20 ns1143 0 0.00193424816171
Gc10_1144 0 n20 ns1144 0 -0.000114426947859
Gc10_1145 0 n20 ns1145 0 0.000140890766478
Gc10_1146 0 n20 ns1146 0 2.69720519057e-05
Gc10_1147 0 n20 ns1147 0 3.64152365051e-05
Gc10_1148 0 n20 ns1148 0 -5.16057581918e-06
Gc10_1149 0 n20 ns1149 0 -2.40972114793e-07
Gc10_1150 0 n20 ns1150 0 0.000288383938756
Gc10_1151 0 n20 ns1151 0 -0.000897118505355
Gc10_1152 0 n20 ns1152 0 -0.000254459146091
Gc10_1153 0 n20 ns1153 0 0.000508921553869
Gc10_1154 0 n20 ns1154 0 0.000200522358833
Gc10_1155 0 n20 ns1155 0 3.53497457001e-05
Gc10_1156 0 n20 ns1156 0 -0.000649647688737
Gc10_1157 0 n20 ns1157 0 -5.70845718068e-05
Gc10_1158 0 n20 ns1158 0 0.000417139069612
Gc10_1159 0 n20 ns1159 0 0.000326204990861
Gc10_1160 0 n20 ns1160 0 3.20951934723e-05
Gc10_1161 0 n20 ns1161 0 -0.000166770175386
Gc10_1162 0 n20 ns1162 0 -2.60350036862e-05
Gc10_1163 0 n20 ns1163 0 -0.00093139256116
Gc10_1164 0 n20 ns1164 0 -0.00103961495927
Gc10_1165 0 n20 ns1165 0 7.47902310026e-05
Gc10_1166 0 n20 ns1166 0 0.000634729675874
Gc10_1167 0 n20 ns1167 0 0.000296188435315
Gc10_1168 0 n20 ns1168 0 -0.00198337663516
Gc10_1169 0 n20 ns1169 0 0.000356767044015
Gc10_1170 0 n20 ns1170 0 0.000693650706048
Gc10_1171 0 n20 ns1171 0 0.000679132912257
Gc10_1172 0 n20 ns1172 0 0.000160745290788
Gc10_1173 0 n20 ns1173 0 -0.000431978908522
Gc10_1174 0 n20 ns1174 0 -0.000350452621427
Gc10_1175 0 n20 ns1175 0 -1.0905608481e-05
Gc10_1176 0 n20 ns1176 0 -4.24314337441e-05
Gc10_1177 0 n20 ns1177 0 7.30590731002e-06
Gc10_1178 0 n20 ns1178 0 -3.4177983722e-05
Gc10_1179 0 n20 ns1179 0 0.000151091783278
Gc10_1180 0 n20 ns1180 0 -0.000235569059456
Gc10_1181 0 n20 ns1181 0 -0.000619212428073
Gc10_1182 0 n20 ns1182 0 -0.000242541290953
Gc10_1183 0 n20 ns1183 0 0.000161202386744
Gc10_1184 0 n20 ns1184 0 8.36599856904e-05
Gc10_1185 0 n20 ns1185 0 0.00015583277949
Gc10_1186 0 n20 ns1186 0 2.98430367548e-05
Gc10_1187 0 n20 ns1187 0 -1.11211575922e-05
Gc10_1188 0 n20 ns1188 0 -0.000358826655761
Gc10_1189 0 n20 ns1189 0 -0.000375525596839
Gc10_1190 0 n20 ns1190 0 0.000284027265522
Gc10_1191 0 n20 ns1191 0 0.000356325113306
Gc10_1192 0 n20 ns1192 0 9.97615029664e-05
Gc10_1193 0 n20 ns1193 0 -0.000129913075186
Gc10_1194 0 n20 ns1194 0 -9.30427338175e-05
Gc10_1195 0 n20 ns1195 0 0.000770798469666
Gc10_1196 0 n20 ns1196 0 0.00047829488073
Gc10_1197 0 n20 ns1197 0 -0.000236248604675
Gc10_1198 0 n20 ns1198 0 -7.29086082021e-05
Gc10_1199 0 n20 ns1199 0 -0.000144488717836
Gc10_1200 0 n20 ns1200 0 0.000349406694627
Gc10_1201 0 n20 ns1201 0 -0.000344697248505
Gc10_1202 0 n20 ns1202 0 -0.000398435647751
Gc10_1203 0 n20 ns1203 0 0.000147774419893
Gc10_1204 0 n20 ns1204 0 0.000277733234309
Gc10_1205 0 n20 ns1205 0 1.16455968046e-05
Gc10_1206 0 n20 ns1206 0 0.000135713470439
Gc10_1207 0 n20 ns1207 0 0.000939421306516
Gc10_1208 0 n20 ns1208 0 0.000396808943937
Gc10_1209 0 n20 ns1209 0 -6.25538099331e-05
Gc10_1210 0 n20 ns1210 0 -5.82310420065e-05
Gc10_1211 0 n20 ns1211 0 -0.000233178917422
Gc10_1212 0 n20 ns1212 0 0.00856447576157
Gc10_1213 0 n20 ns1213 0 -0.00726118525637
Gc10_1214 0 n20 ns1214 0 0.000182978632096
Gc10_1215 0 n20 ns1215 0 4.90496708046e-06
Gc10_1216 0 n20 ns1216 0 -2.94957960879e-05
Gd10_1 0 n20 ni1 0 -0.00203272548823
Gd10_2 0 n20 ni2 0 -0.00274371473585
Gd10_3 0 n20 ni3 0 -0.000570531772167
Gd10_4 0 n20 ni4 0 -0.00102759111626
Gd10_5 0 n20 ni5 0 0.000258576515674
Gd10_6 0 n20 ni6 0 0.000162224803777
Gd10_7 0 n20 ni7 0 1.47058780562e-05
Gd10_8 0 n20 ni8 0 -0.000133075385688
Gd10_9 0 n20 ni9 0 -8.91916000336e-05
Gd10_10 0 n20 ni10 0 0.000356908453836
Gd10_11 0 n20 ni11 0 -0.00168289402217
Gd10_12 0 n20 ni12 0 -0.000284564372522
Gd10_13 0 n20 ni13 0 0.000286571988839
Gd10_14 0 n20 ni14 0 -1.18072060591e-06
Gd10_15 0 n20 ni15 0 -0.000102175430115
Gd10_16 0 n20 ni16 0 -9.34614812768e-05
Gd10_17 0 n20 ni17 0 -0.0004464935243
Gd10_18 0 n20 ni18 0 -0.00151246351884
Gd10_19 0 n20 ni19 0 -0.00313526380878
Gd10_20 0 n20 ni20 0 -0.000103079883007
Gd10_21 0 n20 ni21 0 0.000121259277769
Gd10_22 0 n20 ni22 0 0.000203594841895
Gd10_23 0 n20 ni23 0 0.000244904839621
Gd10_24 0 n20 ni24 0 3.04354413247e-05
Gd10_25 0 n20 ni25 0 -9.97046387791e-05
Gd10_26 0 n20 ni26 0 -0.0067649952588
Gd10_27 0 n20 ni27 0 -0.000301588950143
Gd10_28 0 n20 ni28 0 0.000512034189613
Gd10_29 0 n20 ni29 0 0.000104539284108
Gd10_30 0 n20 ni30 0 0.000206164046581
Gd10_31 0 n20 ni31 0 4.27947984065e-05
Gd10_32 0 n20 ni32 0 -1.04610172473e-05
Gc11_1 0 n22 ns1 0 -0.00116211257875
Gc11_2 0 n22 ns2 0 0.000759200921754
Gc11_3 0 n22 ns3 0 -0.000956185966398
Gc11_4 0 n22 ns4 0 0.000731609623833
Gc11_5 0 n22 ns5 0 -0.000690629530488
Gc11_6 0 n22 ns6 0 0.000503144263283
Gc11_7 0 n22 ns7 0 -0.000378546895746
Gc11_8 0 n22 ns8 0 -5.58721884791e-05
Gc11_9 0 n22 ns9 0 -1.04081770151e-05
Gc11_10 0 n22 ns10 0 -0.00277112892725
Gc11_11 0 n22 ns11 0 0.000417758455975
Gc11_12 0 n22 ns12 0 0.000109846909915
Gc11_13 0 n22 ns13 0 -0.000669347112636
Gc11_14 0 n22 ns14 0 0.000251698375794
Gc11_15 0 n22 ns15 0 -0.000246921593249
Gc11_16 0 n22 ns16 0 -0.00207805151506
Gc11_17 0 n22 ns17 0 0.00205144589041
Gc11_18 0 n22 ns18 0 0.000518842947762
Gc11_19 0 n22 ns19 0 -0.000532886163711
Gc11_20 0 n22 ns20 0 0.000290748256833
Gc11_21 0 n22 ns21 0 8.88857740982e-05
Gc11_22 0 n22 ns22 0 0.000675559298187
Gc11_23 0 n22 ns23 0 0.00387971135509
Gc11_24 0 n22 ns24 0 -0.00010147471784
Gc11_25 0 n22 ns25 0 -0.000236146899879
Gc11_26 0 n22 ns26 0 0.000487849209486
Gc11_27 0 n22 ns27 0 -0.000677427491312
Gc11_28 0 n22 ns28 0 0.00317328690142
Gc11_29 0 n22 ns29 0 0.00188320742218
Gc11_30 0 n22 ns30 0 -0.00212898074893
Gc11_31 0 n22 ns31 0 4.74567859017e-05
Gc11_32 0 n22 ns32 0 0.00131709037004
Gc11_33 0 n22 ns33 0 -3.77621743062e-05
Gc11_34 0 n22 ns34 0 0.0412584979719
Gc11_35 0 n22 ns35 0 -0.0391450067308
Gc11_36 0 n22 ns36 0 0.0026106767759
Gc11_37 0 n22 ns37 0 -2.33051967891e-06
Gc11_38 0 n22 ns38 0 2.28856010678e-05
Gc11_39 0 n22 ns39 0 -0.00154256740975
Gc11_40 0 n22 ns40 0 0.00091645943575
Gc11_41 0 n22 ns41 0 -0.00141758375078
Gc11_42 0 n22 ns42 0 0.000685377808128
Gc11_43 0 n22 ns43 0 -0.000755716234727
Gc11_44 0 n22 ns44 0 0.000549103670585
Gc11_45 0 n22 ns45 0 -0.00013296784397
Gc11_46 0 n22 ns46 0 -0.000123082406434
Gc11_47 0 n22 ns47 0 -1.78452765105e-05
Gc11_48 0 n22 ns48 0 -0.00241677681305
Gc11_49 0 n22 ns49 0 0.000418658917101
Gc11_50 0 n22 ns50 0 0.000333862468641
Gc11_51 0 n22 ns51 0 -0.000587618621729
Gc11_52 0 n22 ns52 0 0.00033815157576
Gc11_53 0 n22 ns53 0 -0.000369356046399
Gc11_54 0 n22 ns54 0 -0.00164547337316
Gc11_55 0 n22 ns55 0 0.00102893548777
Gc11_56 0 n22 ns56 0 0.000246061152945
Gc11_57 0 n22 ns57 0 -0.000534503070315
Gc11_58 0 n22 ns58 0 0.000338925586413
Gc11_59 0 n22 ns59 0 0.000163970543419
Gc11_60 0 n22 ns60 0 -0.000567742698856
Gc11_61 0 n22 ns61 0 0.00322949891578
Gc11_62 0 n22 ns62 0 3.29408222045e-05
Gc11_63 0 n22 ns63 0 0.00011743198783
Gc11_64 0 n22 ns64 0 0.000693842735134
Gc11_65 0 n22 ns65 0 -0.000964239509315
Gc11_66 0 n22 ns66 0 0.00206331800287
Gc11_67 0 n22 ns67 0 0.00198381209069
Gc11_68 0 n22 ns68 0 -0.00230001090464
Gc11_69 0 n22 ns69 0 -5.22469145175e-05
Gc11_70 0 n22 ns70 0 0.00166715931517
Gc11_71 0 n22 ns71 0 6.20798770878e-05
Gc11_72 0 n22 ns72 0 0.0471047797342
Gc11_73 0 n22 ns73 0 -0.0462655912672
Gc11_74 0 n22 ns74 0 0.00365363624556
Gc11_75 0 n22 ns75 0 -4.32231616704e-07
Gc11_76 0 n22 ns76 0 2.78869900374e-05
Gc11_77 0 n22 ns77 0 -0.00489722884429
Gc11_78 0 n22 ns78 0 -0.000520139746238
Gc11_79 0 n22 ns79 0 -0.00426715743219
Gc11_80 0 n22 ns80 0 0.000240498952861
Gc11_81 0 n22 ns81 0 -0.00130981839821
Gc11_82 0 n22 ns82 0 -0.000271237209665
Gc11_83 0 n22 ns83 0 0.000828752110136
Gc11_84 0 n22 ns84 0 -0.000130011682585
Gc11_85 0 n22 ns85 0 -2.80324016169e-05
Gc11_86 0 n22 ns86 0 1.90777300665e-05
Gc11_87 0 n22 ns87 0 0.00190189478197
Gc11_88 0 n22 ns88 0 0.000524589173408
Gc11_89 0 n22 ns89 0 -0.000134582143771
Gc11_90 0 n22 ns90 0 0.000367648066706
Gc11_91 0 n22 ns91 0 -0.000502850731884
Gc11_92 0 n22 ns92 0 0.00130883509648
Gc11_93 0 n22 ns93 0 -0.00096754895545
Gc11_94 0 n22 ns94 0 -0.000444512035931
Gc11_95 0 n22 ns95 0 -0.000296949618761
Gc11_96 0 n22 ns96 0 0.00039872176508
Gc11_97 0 n22 ns97 0 0.000292755632633
Gc11_98 0 n22 ns98 0 -0.00166595349059
Gc11_99 0 n22 ns99 0 5.49447767208e-05
Gc11_100 0 n22 ns100 0 0.000853397160241
Gc11_101 0 n22 ns101 0 0.00218956619528
Gc11_102 0 n22 ns102 0 0.00129373346261
Gc11_103 0 n22 ns103 0 -0.00193330761759
Gc11_104 0 n22 ns104 0 0.000252551972837
Gc11_105 0 n22 ns105 0 0.000703509277338
Gc11_106 0 n22 ns106 0 9.51177560231e-05
Gc11_107 0 n22 ns107 0 7.61281986938e-05
Gc11_108 0 n22 ns108 0 0.00255852236554
Gc11_109 0 n22 ns109 0 0.000150641361793
Gc11_110 0 n22 ns110 0 0.0245608018399
Gc11_111 0 n22 ns111 0 -0.0240859641791
Gc11_112 0 n22 ns112 0 0.00660293821286
Gc11_113 0 n22 ns113 0 -3.42304196915e-06
Gc11_114 0 n22 ns114 0 2.98106953785e-05
Gc11_115 0 n22 ns115 0 -0.00454042343337
Gc11_116 0 n22 ns116 0 -0.000324218111252
Gc11_117 0 n22 ns117 0 -0.00404548952542
Gc11_118 0 n22 ns118 0 -4.61652384714e-05
Gc11_119 0 n22 ns119 0 -0.00086895896625
Gc11_120 0 n22 ns120 0 5.47245454418e-05
Gc11_121 0 n22 ns121 0 0.000335662375689
Gc11_122 0 n22 ns122 0 -9.04284955586e-05
Gc11_123 0 n22 ns123 0 -2.84918237642e-05
Gc11_124 0 n22 ns124 0 -0.0022371204083
Gc11_125 0 n22 ns125 0 0.00188572941894
Gc11_126 0 n22 ns126 0 0.00104528330682
Gc11_127 0 n22 ns127 0 -0.000137142043361
Gc11_128 0 n22 ns128 0 0.000326263634117
Gc11_129 0 n22 ns129 0 -0.000561217746218
Gc11_130 0 n22 ns130 0 1.77309366303e-05
Gc11_131 0 n22 ns131 0 0.000950515643982
Gc11_132 0 n22 ns132 0 0.000301532283726
Gc11_133 0 n22 ns133 0 0.000328733458912
Gc11_134 0 n22 ns134 0 0.000583740080799
Gc11_135 0 n22 ns135 0 0.000193672479876
Gc11_136 0 n22 ns136 0 0.000980174465798
Gc11_137 0 n22 ns137 0 0.00145780143877
Gc11_138 0 n22 ns138 0 0.00117305760692
Gc11_139 0 n22 ns139 0 0.00284028082267
Gc11_140 0 n22 ns140 0 0.00134308461283
Gc11_141 0 n22 ns141 0 -0.00217329801233
Gc11_142 0 n22 ns142 0 0.00185180045195
Gc11_143 0 n22 ns143 0 -0.0017039693637
Gc11_144 0 n22 ns144 0 0.00182705701518
Gc11_145 0 n22 ns145 0 0.00147469139285
Gc11_146 0 n22 ns146 0 0.00306704385947
Gc11_147 0 n22 ns147 0 4.2323463575e-05
Gc11_148 0 n22 ns148 0 -0.0169642748779
Gc11_149 0 n22 ns149 0 0.0192770990203
Gc11_150 0 n22 ns150 0 0.00688734520485
Gc11_151 0 n22 ns151 0 2.13018920554e-07
Gc11_152 0 n22 ns152 0 1.94528814726e-05
Gc11_153 0 n22 ns153 0 -0.00184865326669
Gc11_154 0 n22 ns154 0 -0.00062691472844
Gc11_155 0 n22 ns155 0 0.00241814650837
Gc11_156 0 n22 ns156 0 0.000655052148177
Gc11_157 0 n22 ns157 0 -0.000334723499141
Gc11_158 0 n22 ns158 0 0.000699107182299
Gc11_159 0 n22 ns159 0 0.000346954032019
Gc11_160 0 n22 ns160 0 -0.00015384298183
Gc11_161 0 n22 ns161 0 -5.55505624847e-05
Gc11_162 0 n22 ns162 0 -0.00142966952396
Gc11_163 0 n22 ns163 0 -0.000522397028925
Gc11_164 0 n22 ns164 0 0.000993648997135
Gc11_165 0 n22 ns165 0 -0.000290883008691
Gc11_166 0 n22 ns166 0 0.000190581862954
Gc11_167 0 n22 ns167 0 -0.000535771024177
Gc11_168 0 n22 ns168 0 -0.00118642389102
Gc11_169 0 n22 ns169 0 -0.00192495651523
Gc11_170 0 n22 ns170 0 -0.000411480471752
Gc11_171 0 n22 ns171 0 0.000316778568093
Gc11_172 0 n22 ns172 0 0.000398174667828
Gc11_173 0 n22 ns173 0 0.000180789598911
Gc11_174 0 n22 ns174 0 -0.00379070734028
Gc11_175 0 n22 ns175 0 0.00151762053614
Gc11_176 0 n22 ns176 0 0.000846226118487
Gc11_177 0 n22 ns177 0 0.00113290435956
Gc11_178 0 n22 ns178 0 0.000547243386362
Gc11_179 0 n22 ns179 0 -0.00151656344508
Gc11_180 0 n22 ns180 0 -0.00217606447538
Gc11_181 0 n22 ns181 0 0.0016692864021
Gc11_182 0 n22 ns182 0 -0.00168237900504
Gc11_183 0 n22 ns183 0 0.000427216515838
Gc11_184 0 n22 ns184 0 0.0019993679636
Gc11_185 0 n22 ns185 0 1.92175330362e-05
Gc11_186 0 n22 ns186 0 0.0415818476445
Gc11_187 0 n22 ns187 0 -0.0445770971803
Gc11_188 0 n22 ns188 0 0.00450128390157
Gc11_189 0 n22 ns189 0 3.1200834212e-06
Gc11_190 0 n22 ns190 0 3.31753671932e-06
Gc11_191 0 n22 ns191 0 -0.00116831204066
Gc11_192 0 n22 ns192 0 0.00223994164909
Gc11_193 0 n22 ns193 0 -0.0048000949513
Gc11_194 0 n22 ns194 0 -5.8094889099e-05
Gc11_195 0 n22 ns195 0 -0.000256871115014
Gc11_196 0 n22 ns196 0 0.000116002521974
Gc11_197 0 n22 ns197 0 -0.000338130527782
Gc11_198 0 n22 ns198 0 -1.81769419592e-05
Gc11_199 0 n22 ns199 0 1.53101984973e-05
Gc11_200 0 n22 ns200 0 -0.000980801725786
Gc11_201 0 n22 ns201 0 0.00150211378731
Gc11_202 0 n22 ns202 0 -7.00066925672e-05
Gc11_203 0 n22 ns203 0 -0.000357515305617
Gc11_204 0 n22 ns204 0 -3.2926921865e-05
Gc11_205 0 n22 ns205 0 -0.000316403664532
Gc11_206 0 n22 ns206 0 -0.000452013866459
Gc11_207 0 n22 ns207 0 0.00176125927519
Gc11_208 0 n22 ns208 0 0.000127282845368
Gc11_209 0 n22 ns209 0 -0.000176124359627
Gc11_210 0 n22 ns210 0 0.000322251403964
Gc11_211 0 n22 ns211 0 -0.000100442813554
Gc11_212 0 n22 ns212 0 0.00202485273494
Gc11_213 0 n22 ns213 0 0.00285542861228
Gc11_214 0 n22 ns214 0 0.000502621038243
Gc11_215 0 n22 ns215 0 0.00024766468994
Gc11_216 0 n22 ns216 0 -0.000125871621291
Gc11_217 0 n22 ns217 0 -0.00105129186665
Gc11_218 0 n22 ns218 0 0.00365998691163
Gc11_219 0 n22 ns219 0 0.000811969180714
Gc11_220 0 n22 ns220 0 -0.00134151965384
Gc11_221 0 n22 ns221 0 0.000870612442984
Gc11_222 0 n22 ns222 0 0.00104743290082
Gc11_223 0 n22 ns223 0 -0.000531892248292
Gc11_224 0 n22 ns224 0 0.0454115383931
Gc11_225 0 n22 ns225 0 -0.0411048175555
Gc11_226 0 n22 ns226 0 0.00210294189825
Gc11_227 0 n22 ns227 0 -5.27276248121e-06
Gc11_228 0 n22 ns228 0 -1.9992416532e-05
Gc11_229 0 n22 ns229 0 -0.00069015227391
Gc11_230 0 n22 ns230 0 0.00162417481612
Gc11_231 0 n22 ns231 0 -0.0044590287567
Gc11_232 0 n22 ns232 0 -0.000315346537755
Gc11_233 0 n22 ns233 0 -0.000138574896899
Gc11_234 0 n22 ns234 0 -0.000345651178037
Gc11_235 0 n22 ns235 0 3.9697251349e-05
Gc11_236 0 n22 ns236 0 -1.31005390318e-05
Gc11_237 0 n22 ns237 0 3.30411874276e-05
Gc11_238 0 n22 ns238 0 0.000792373841577
Gc11_239 0 n22 ns239 0 0.00152996734046
Gc11_240 0 n22 ns240 0 -0.000117179959864
Gc11_241 0 n22 ns241 0 1.85922482073e-05
Gc11_242 0 n22 ns242 0 -0.000138277025119
Gc11_243 0 n22 ns243 0 -0.000203880002245
Gc11_244 0 n22 ns244 0 0.00106496429021
Gc11_245 0 n22 ns245 0 0.000335274407325
Gc11_246 0 n22 ns246 0 -0.000316486861082
Gc11_247 0 n22 ns247 0 7.13993883189e-05
Gc11_248 0 n22 ns248 0 0.000168071418944
Gc11_249 0 n22 ns249 0 -0.000129533783722
Gc11_250 0 n22 ns250 0 0.0013174953568
Gc11_251 0 n22 ns251 0 0.000341197772136
Gc11_252 0 n22 ns252 0 0.000560137255759
Gc11_253 0 n22 ns253 0 0.000598004682135
Gc11_254 0 n22 ns254 0 -0.000336980385098
Gc11_255 0 n22 ns255 0 -0.000815681831322
Gc11_256 0 n22 ns256 0 0.00126275733926
Gc11_257 0 n22 ns257 0 0.000196276381775
Gc11_258 0 n22 ns258 0 8.19193894011e-05
Gc11_259 0 n22 ns259 0 0.000983704485741
Gc11_260 0 n22 ns260 0 0.000453595691024
Gc11_261 0 n22 ns261 0 -0.000688065391706
Gc11_262 0 n22 ns262 0 0.0287119915184
Gc11_263 0 n22 ns263 0 -0.0254609090654
Gc11_264 0 n22 ns264 0 0.00111421951527
Gc11_265 0 n22 ns265 0 -6.6876634832e-06
Gc11_266 0 n22 ns266 0 -3.11465988627e-05
Gc11_267 0 n22 ns267 0 9.88670171682e-05
Gc11_268 0 n22 ns268 0 -0.00027891847268
Gc11_269 0 n22 ns269 0 -8.38590173732e-05
Gc11_270 0 n22 ns270 0 -7.24569696091e-05
Gc11_271 0 n22 ns271 0 4.4401766197e-05
Gc11_272 0 n22 ns272 0 -2.75351414986e-05
Gc11_273 0 n22 ns273 0 4.03536810548e-05
Gc11_274 0 n22 ns274 0 1.18204917584e-05
Gc11_275 0 n22 ns275 0 3.0362507424e-05
Gc11_276 0 n22 ns276 0 2.19456305908e-05
Gc11_277 0 n22 ns277 0 0.000353307798042
Gc11_278 0 n22 ns278 0 0.000329489499486
Gc11_279 0 n22 ns279 0 -0.0002006875884
Gc11_280 0 n22 ns280 0 -0.000210527219545
Gc11_281 0 n22 ns281 0 -8.85442091999e-05
Gc11_282 0 n22 ns282 0 -0.000475783612238
Gc11_283 0 n22 ns283 0 -0.000466735536985
Gc11_284 0 n22 ns284 0 0.00014432404653
Gc11_285 0 n22 ns285 0 0.000622560079861
Gc11_286 0 n22 ns286 0 0.000128072119664
Gc11_287 0 n22 ns287 0 -0.000140560576863
Gc11_288 0 n22 ns288 0 -0.000173621718979
Gc11_289 0 n22 ns289 0 0.000684452571738
Gc11_290 0 n22 ns290 0 0.000970407075229
Gc11_291 0 n22 ns291 0 0.000320491509293
Gc11_292 0 n22 ns292 0 -0.000555638284495
Gc11_293 0 n22 ns293 0 -0.000517842577314
Gc11_294 0 n22 ns294 0 -0.000444892519046
Gc11_295 0 n22 ns295 0 0.000429443609348
Gc11_296 0 n22 ns296 0 0.000509073023559
Gc11_297 0 n22 ns297 0 0.000760883525822
Gc11_298 0 n22 ns298 0 0.000237455564205
Gc11_299 0 n22 ns299 0 -0.000530699281784
Gc11_300 0 n22 ns300 0 0.0130882872919
Gc11_301 0 n22 ns301 0 -0.0119652471449
Gc11_302 0 n22 ns302 0 0.000559020980563
Gc11_303 0 n22 ns303 0 -3.38534653311e-06
Gc11_304 0 n22 ns304 0 -3.25604106114e-05
Gc11_305 0 n22 ns305 0 0.000161682125197
Gc11_306 0 n22 ns306 0 -0.000749902498004
Gc11_307 0 n22 ns307 0 0.000380281443065
Gc11_308 0 n22 ns308 0 0.000108916144884
Gc11_309 0 n22 ns309 0 -0.000120043597458
Gc11_310 0 n22 ns310 0 8.53188068304e-05
Gc11_311 0 n22 ns311 0 -4.81422509647e-07
Gc11_312 0 n22 ns312 0 1.41572732022e-05
Gc11_313 0 n22 ns313 0 -5.52449104071e-05
Gc11_314 0 n22 ns314 0 -0.00093655069927
Gc11_315 0 n22 ns315 0 0.000477995842714
Gc11_316 0 n22 ns316 0 0.0003995526562
Gc11_317 0 n22 ns317 0 -0.000440756970205
Gc11_318 0 n22 ns318 0 -0.000144120354617
Gc11_319 0 n22 ns319 0 -4.07000787174e-05
Gc11_320 0 n22 ns320 0 -0.000931293274823
Gc11_321 0 n22 ns321 0 0.00045760108619
Gc11_322 0 n22 ns322 0 0.000592671040162
Gc11_323 0 n22 ns323 0 0.000327032034802
Gc11_324 0 n22 ns324 0 6.63772128961e-05
Gc11_325 0 n22 ns325 0 -0.000156710281297
Gc11_326 0 n22 ns326 0 0.000353852122594
Gc11_327 0 n22 ns327 0 0.00117081449073
Gc11_328 0 n22 ns328 0 0.000806344876993
Gc11_329 0 n22 ns329 0 -0.000237338382925
Gc11_330 0 n22 ns330 0 -0.000536937530985
Gc11_331 0 n22 ns331 0 -0.000145049055025
Gc11_332 0 n22 ns332 0 0.000482157500303
Gc11_333 0 n22 ns333 0 0.000724233882798
Gc11_334 0 n22 ns334 0 0.000299910112893
Gc11_335 0 n22 ns335 0 8.16684871537e-05
Gc11_336 0 n22 ns336 0 -2.84253379977e-07
Gc11_337 0 n22 ns337 0 -0.000262295044676
Gc11_338 0 n22 ns338 0 0.00962194565964
Gc11_339 0 n22 ns339 0 -0.00842774351727
Gc11_340 0 n22 ns340 0 0.000335270389974
Gc11_341 0 n22 ns341 0 -7.24736024884e-06
Gc11_342 0 n22 ns342 0 -2.70728452825e-05
Gc11_343 0 n22 ns343 0 -0.00219641745925
Gc11_344 0 n22 ns344 0 -0.0011665116077
Gc11_345 0 n22 ns345 0 0.00292768260926
Gc11_346 0 n22 ns346 0 0.000356610660078
Gc11_347 0 n22 ns347 0 -0.000548531941606
Gc11_348 0 n22 ns348 0 0.000381207492404
Gc11_349 0 n22 ns349 0 0.000372308497726
Gc11_350 0 n22 ns350 0 -0.000185727417341
Gc11_351 0 n22 ns351 0 -6.24090266513e-05
Gc11_352 0 n22 ns352 0 -0.000729622103368
Gc11_353 0 n22 ns353 0 0.000126102763984
Gc11_354 0 n22 ns354 0 0.000544367183021
Gc11_355 0 n22 ns355 0 0.000136593740824
Gc11_356 0 n22 ns356 0 0.000499010204164
Gc11_357 0 n22 ns357 0 -0.000441878972785
Gc11_358 0 n22 ns358 0 0.00113806831709
Gc11_359 0 n22 ns359 0 -0.0017038933318
Gc11_360 0 n22 ns360 0 -0.000796523650187
Gc11_361 0 n22 ns361 0 -0.000522057612535
Gc11_362 0 n22 ns362 0 0.000289969695607
Gc11_363 0 n22 ns363 0 0.000359423963525
Gc11_364 0 n22 ns364 0 -0.00359522842913
Gc11_365 0 n22 ns365 0 -0.00186208629037
Gc11_366 0 n22 ns366 0 -4.3197879715e-05
Gc11_367 0 n22 ns367 0 0.00157865249946
Gc11_368 0 n22 ns368 0 0.00136193673745
Gc11_369 0 n22 ns369 0 -0.00141874228475
Gc11_370 0 n22 ns370 0 -0.00535133357894
Gc11_371 0 n22 ns371 0 -0.00143990036858
Gc11_372 0 n22 ns372 0 -0.00148109054008
Gc11_373 0 n22 ns373 0 0.000735907472069
Gc11_374 0 n22 ns374 0 0.00249836764643
Gc11_375 0 n22 ns375 0 0.000375828443307
Gc11_376 0 n22 ns376 0 0.0206615031344
Gc11_377 0 n22 ns377 0 -0.0283509355571
Gc11_378 0 n22 ns378 0 0.00551290021724
Gc11_379 0 n22 ns379 0 2.11259858189e-06
Gc11_380 0 n22 ns380 0 3.42404398084e-05
Gc11_381 0 n22 ns381 0 -0.00359994466632
Gc11_382 0 n22 ns382 0 -0.000434491474048
Gc11_383 0 n22 ns383 0 -0.000627459465319
Gc11_384 0 n22 ns384 0 0.000558160988812
Gc11_385 0 n22 ns385 0 -0.000379609317107
Gc11_386 0 n22 ns386 0 0.000317593764644
Gc11_387 0 n22 ns387 0 -0.000151282980768
Gc11_388 0 n22 ns388 0 -0.000199940065382
Gc11_389 0 n22 ns389 0 -6.6773686775e-05
Gc11_390 0 n22 ns390 0 -0.0039133976164
Gc11_391 0 n22 ns391 0 0.00102706859925
Gc11_392 0 n22 ns392 0 0.00150745958729
Gc11_393 0 n22 ns393 0 0.00020612301351
Gc11_394 0 n22 ns394 0 0.000520038890143
Gc11_395 0 n22 ns395 0 -0.000650631436505
Gc11_396 0 n22 ns396 0 0.000127038598629
Gc11_397 0 n22 ns397 0 0.000486156239487
Gc11_398 0 n22 ns398 0 4.39391170121e-05
Gc11_399 0 n22 ns399 0 0.000526091674822
Gc11_400 0 n22 ns400 0 0.000631318184744
Gc11_401 0 n22 ns401 0 0.000318189032372
Gc11_402 0 n22 ns402 0 -0.000248776551396
Gc11_403 0 n22 ns403 0 0.000365848904003
Gc11_404 0 n22 ns404 0 0.00113331888113
Gc11_405 0 n22 ns405 0 0.00337697233035
Gc11_406 0 n22 ns406 0 0.00159131322104
Gc11_407 0 n22 ns407 0 -0.00237716291262
Gc11_408 0 n22 ns408 0 -0.00146563224189
Gc11_409 0 n22 ns409 0 -0.00283132813562
Gc11_410 0 n22 ns410 0 0.00214264291562
Gc11_411 0 n22 ns411 0 0.00204463777274
Gc11_412 0 n22 ns412 0 0.00330927582599
Gc11_413 0 n22 ns413 0 2.03330937788e-05
Gc11_414 0 n22 ns414 0 -0.0274675427957
Gc11_415 0 n22 ns415 0 0.0263154126884
Gc11_416 0 n22 ns416 0 0.00689288688314
Gc11_417 0 n22 ns417 0 1.14749928763e-05
Gc11_418 0 n22 ns418 0 2.82286446604e-05
Gc11_419 0 n22 ns419 0 -0.00187618822671
Gc11_420 0 n22 ns420 0 -0.00222949611036
Gc11_421 0 n22 ns421 0 0.00510056047048
Gc11_422 0 n22 ns422 0 0.000387983736792
Gc11_423 0 n22 ns423 0 -0.000394227116964
Gc11_424 0 n22 ns424 0 0.000636428001787
Gc11_425 0 n22 ns425 0 0.000447228372286
Gc11_426 0 n22 ns426 0 -0.000156248351075
Gc11_427 0 n22 ns427 0 -9.53278624048e-05
Gc11_428 0 n22 ns428 0 -0.00174485843146
Gc11_429 0 n22 ns429 0 -0.000405704802266
Gc11_430 0 n22 ns430 0 0.00129868214961
Gc11_431 0 n22 ns431 0 3.47504070583e-05
Gc11_432 0 n22 ns432 0 0.000347520430297
Gc11_433 0 n22 ns433 0 -0.000570552406973
Gc11_434 0 n22 ns434 0 -0.000114854966165
Gc11_435 0 n22 ns435 0 -0.00223235898096
Gc11_436 0 n22 ns436 0 -0.000457905714908
Gc11_437 0 n22 ns437 0 0.000268587760667
Gc11_438 0 n22 ns438 0 0.000429460069568
Gc11_439 0 n22 ns439 0 0.000246356976039
Gc11_440 0 n22 ns440 0 -0.00420483033666
Gc11_441 0 n22 ns441 0 -0.000857512322945
Gc11_442 0 n22 ns442 0 0.000875712049084
Gc11_443 0 n22 ns443 0 0.0016528735863
Gc11_444 0 n22 ns444 0 0.000856682184493
Gc11_445 0 n22 ns445 0 -0.00169948939647
Gc11_446 0 n22 ns446 0 -0.00575301451042
Gc11_447 0 n22 ns447 0 -0.0011746403859
Gc11_448 0 n22 ns448 0 -0.0011883620956
Gc11_449 0 n22 ns449 0 0.000883373905165
Gc11_450 0 n22 ns450 0 0.00246202733948
Gc11_451 0 n22 ns451 0 0.000239522887226
Gc11_452 0 n22 ns452 0 0.0189678517543
Gc11_453 0 n22 ns453 0 -0.0269548091177
Gc11_454 0 n22 ns454 0 0.00544400476927
Gc11_455 0 n22 ns455 0 2.68707554969e-06
Gc11_456 0 n22 ns456 0 1.6329075476e-05
Gc11_457 0 n22 ns457 0 -0.00132782442369
Gc11_458 0 n22 ns458 0 0.000765696679202
Gc11_459 0 n22 ns459 0 -0.00184978443009
Gc11_460 0 n22 ns460 0 0.000400934904018
Gc11_461 0 n22 ns461 0 -0.000484679884487
Gc11_462 0 n22 ns462 0 0.000435529855807
Gc11_463 0 n22 ns463 0 -0.000212686777859
Gc11_464 0 n22 ns464 0 -5.9005980739e-05
Gc11_465 0 n22 ns465 0 4.32326872818e-08
Gc11_466 0 n22 ns466 0 -0.00199515120683
Gc11_467 0 n22 ns467 0 0.000685124228817
Gc11_468 0 n22 ns468 0 0.000371919100908
Gc11_469 0 n22 ns469 0 -0.000489496866523
Gc11_470 0 n22 ns470 0 5.84360636999e-05
Gc11_471 0 n22 ns471 0 -0.000423359379758
Gc11_472 0 n22 ns472 0 -0.00164299118058
Gc11_473 0 n22 ns473 0 0.00103321735338
Gc11_474 0 n22 ns474 0 0.000177033027567
Gc11_475 0 n22 ns475 0 0.000101174267823
Gc11_476 0 n22 ns476 0 0.000423011418373
Gc11_477 0 n22 ns477 0 -1.40600625426e-05
Gc11_478 0 n22 ns478 0 0.000379859730036
Gc11_479 0 n22 ns479 0 0.00373496911734
Gc11_480 0 n22 ns480 0 0.00074030826038
Gc11_481 0 n22 ns481 0 0.000387362948485
Gc11_482 0 n22 ns482 0 2.00206704242e-05
Gc11_483 0 n22 ns483 0 -0.00126734797495
Gc11_484 0 n22 ns484 0 0.00278040655873
Gc11_485 0 n22 ns485 0 0.00177701055436
Gc11_486 0 n22 ns486 0 -0.00160928952065
Gc11_487 0 n22 ns487 0 0.000684029154094
Gc11_488 0 n22 ns488 0 0.00136019022288
Gc11_489 0 n22 ns489 0 -0.000432708566408
Gc11_490 0 n22 ns490 0 0.0483153205743
Gc11_491 0 n22 ns491 0 -0.0453085767514
Gc11_492 0 n22 ns492 0 0.00276481609986
Gc11_493 0 n22 ns493 0 -1.88542535826e-06
Gc11_494 0 n22 ns494 0 -9.70028245665e-06
Gc11_495 0 n22 ns495 0 -0.000966717812889
Gc11_496 0 n22 ns496 0 0.00230027533003
Gc11_497 0 n22 ns497 0 -0.00582032444373
Gc11_498 0 n22 ns498 0 -0.000431498063451
Gc11_499 0 n22 ns499 0 -0.00021639262456
Gc11_500 0 n22 ns500 0 -0.000356077047852
Gc11_501 0 n22 ns501 0 -6.48065983192e-05
Gc11_502 0 n22 ns502 0 -4.31477269077e-06
Gc11_503 0 n22 ns503 0 2.4634623935e-05
Gc11_504 0 n22 ns504 0 0.000770382988333
Gc11_505 0 n22 ns505 0 0.00218590173993
Gc11_506 0 n22 ns506 0 -0.000352472532088
Gc11_507 0 n22 ns507 0 -0.000128867540312
Gc11_508 0 n22 ns508 0 -0.000126578177624
Gc11_509 0 n22 ns509 0 -0.000235085609967
Gc11_510 0 n22 ns510 0 0.00131177815305
Gc11_511 0 n22 ns511 0 0.00115931715485
Gc11_512 0 n22 ns512 0 -0.000281044842013
Gc11_513 0 n22 ns513 0 -0.000281471586653
Gc11_514 0 n22 ns514 0 0.000188563653823
Gc11_515 0 n22 ns515 0 -0.000146551742929
Gc11_516 0 n22 ns516 0 0.00221467580105
Gc11_517 0 n22 ns517 0 0.000676491077922
Gc11_518 0 n22 ns518 0 0.000364505217925
Gc11_519 0 n22 ns519 0 0.000493440477409
Gc11_520 0 n22 ns520 0 -0.000245112185592
Gc11_521 0 n22 ns521 0 -0.000883842211941
Gc11_522 0 n22 ns522 0 0.00233913902135
Gc11_523 0 n22 ns523 0 -5.39109197752e-05
Gc11_524 0 n22 ns524 0 -0.000405777557246
Gc11_525 0 n22 ns525 0 0.00107360842216
Gc11_526 0 n22 ns526 0 0.000643164696191
Gc11_527 0 n22 ns527 0 -0.000673469865309
Gc11_528 0 n22 ns528 0 0.0353020545793
Gc11_529 0 n22 ns529 0 -0.0312815390038
Gc11_530 0 n22 ns530 0 0.001410015179
Gc11_531 0 n22 ns531 0 -7.01910998942e-06
Gc11_532 0 n22 ns532 0 -2.53410181562e-05
Gc11_533 0 n22 ns533 0 -0.000169598751018
Gc11_534 0 n22 ns534 0 3.78141245574e-05
Gc11_535 0 n22 ns535 0 -0.000737162520187
Gc11_536 0 n22 ns536 0 -0.00015494565529
Gc11_537 0 n22 ns537 0 6.69748099742e-05
Gc11_538 0 n22 ns538 0 -8.92163388542e-05
Gc11_539 0 n22 ns539 0 0.000116023488675
Gc11_540 0 n22 ns540 0 3.64754837613e-06
Gc11_541 0 n22 ns541 0 3.60634848359e-05
Gc11_542 0 n22 ns542 0 0.000384345960044
Gc11_543 0 n22 ns543 0 0.000120579776075
Gc11_544 0 n22 ns544 0 0.000241122777836
Gc11_545 0 n22 ns545 0 0.000136626519857
Gc11_546 0 n22 ns546 0 -0.000137673146478
Gc11_547 0 n22 ns547 0 -0.000135370746984
Gc11_548 0 n22 ns548 0 -7.30658196534e-05
Gc11_549 0 n22 ns549 0 -0.00072049385563
Gc11_550 0 n22 ns550 0 -0.00017255463921
Gc11_551 0 n22 ns551 0 0.000658638441194
Gc11_552 0 n22 ns552 0 0.000171791746133
Gc11_553 0 n22 ns553 0 -0.000100511042757
Gc11_554 0 n22 ns554 0 -0.00014821785725
Gc11_555 0 n22 ns555 0 0.000485685488966
Gc11_556 0 n22 ns556 0 0.000901512243307
Gc11_557 0 n22 ns557 0 0.000539606839585
Gc11_558 0 n22 ns558 0 -0.000493115706541
Gc11_559 0 n22 ns559 0 -0.000665122321251
Gc11_560 0 n22 ns560 0 -0.000410764474057
Gc11_561 0 n22 ns561 0 0.000339717086241
Gc11_562 0 n22 ns562 0 0.000483283377004
Gc11_563 0 n22 ns563 0 0.000888266055563
Gc11_564 0 n22 ns564 0 0.000292221614391
Gc11_565 0 n22 ns565 0 -0.000596033179089
Gc11_566 0 n22 ns566 0 0.014931007978
Gc11_567 0 n22 ns567 0 -0.013636695258
Gc11_568 0 n22 ns568 0 0.000646188081552
Gc11_569 0 n22 ns569 0 -3.94571757274e-06
Gc11_570 0 n22 ns570 0 -3.33591040077e-05
Gc11_571 0 n22 ns571 0 0.000346355615072
Gc11_572 0 n22 ns572 0 -0.000997507760257
Gc11_573 0 n22 ns573 0 0.000873693950041
Gc11_574 0 n22 ns574 0 9.23909632093e-05
Gc11_575 0 n22 ns575 0 -9.3637401667e-05
Gc11_576 0 n22 ns576 0 7.79459268079e-05
Gc11_577 0 n22 ns577 0 -4.53582441852e-05
Gc11_578 0 n22 ns578 0 1.27625357486e-05
Gc11_579 0 n22 ns579 0 -2.14330773501e-05
Gc11_580 0 n22 ns580 0 -0.000959946754067
Gc11_581 0 n22 ns581 0 0.000409389440176
Gc11_582 0 n22 ns582 0 0.000480254911339
Gc11_583 0 n22 ns583 0 -0.000416685836486
Gc11_584 0 n22 ns584 0 -0.000173181553336
Gc11_585 0 n22 ns585 0 -6.34699217371e-05
Gc11_586 0 n22 ns586 0 -0.00110818902412
Gc11_587 0 n22 ns587 0 0.000212636729614
Gc11_588 0 n22 ns588 0 0.000573282552518
Gc11_589 0 n22 ns589 0 0.000533030163965
Gc11_590 0 n22 ns590 0 0.000109221781227
Gc11_591 0 n22 ns591 0 -0.000169568636884
Gc11_592 0 n22 ns592 0 0.000152697877408
Gc11_593 0 n22 ns593 0 0.0012904488011
Gc11_594 0 n22 ns594 0 0.000976311552864
Gc11_595 0 n22 ns595 0 -0.000131690450993
Gc11_596 0 n22 ns596 0 -0.000618826455466
Gc11_597 0 n22 ns597 0 -0.000253475925547
Gc11_598 0 n22 ns598 0 0.00015077396482
Gc11_599 0 n22 ns599 0 0.000753508565623
Gc11_600 0 n22 ns600 0 0.000410201952158
Gc11_601 0 n22 ns601 0 0.000265594187109
Gc11_602 0 n22 ns602 0 5.07245465325e-05
Gc11_603 0 n22 ns603 0 -0.000353037551001
Gc11_604 0 n22 ns604 0 0.010323475105
Gc11_605 0 n22 ns605 0 -0.00923948005697
Gc11_606 0 n22 ns606 0 0.000394801823792
Gc11_607 0 n22 ns607 0 -3.92042733568e-06
Gc11_608 0 n22 ns608 0 -3.04784402785e-05
Gc11_609 0 n22 ns609 0 0.00065037823728
Gc11_610 0 n22 ns610 0 -0.000590813538167
Gc11_611 0 n22 ns611 0 0.00931830805657
Gc11_612 0 n22 ns612 0 0.000328954324167
Gc11_613 0 n22 ns613 0 0.000222356797473
Gc11_614 0 n22 ns614 0 5.67809812767e-05
Gc11_615 0 n22 ns615 0 -0.000185890812479
Gc11_616 0 n22 ns616 0 -0.000116592303466
Gc11_617 0 n22 ns617 0 3.3065858496e-05
Gc11_618 0 n22 ns618 0 -0.000622334597819
Gc11_619 0 n22 ns619 0 -0.00374847586219
Gc11_620 0 n22 ns620 0 0.000616985718112
Gc11_621 0 n22 ns621 0 0.00117638653137
Gc11_622 0 n22 ns622 0 -1.76971172457e-05
Gc11_623 0 n22 ns623 0 0.00021872451398
Gc11_624 0 n22 ns624 0 -0.00119722049976
Gc11_625 0 n22 ns625 0 0.000562035650061
Gc11_626 0 n22 ns626 0 -6.85383806435e-05
Gc11_627 0 n22 ns627 0 -0.000769042712464
Gc11_628 0 n22 ns628 0 0.000149646049503
Gc11_629 0 n22 ns629 0 0.000146011028779
Gc11_630 0 n22 ns630 0 -0.00266246108396
Gc11_631 0 n22 ns631 0 -0.00410323160549
Gc11_632 0 n22 ns632 0 -0.000315978839029
Gc11_633 0 n22 ns633 0 0.000700002062135
Gc11_634 0 n22 ns634 0 -0.000120780605612
Gc11_635 0 n22 ns635 0 0.000698507475045
Gc11_636 0 n22 ns636 0 -0.00654330153996
Gc11_637 0 n22 ns637 0 -0.00454197124929
Gc11_638 0 n22 ns638 0 -0.00230724570827
Gc11_639 0 n22 ns639 0 0.00276090762121
Gc11_640 0 n22 ns640 0 0.00214226302591
Gc11_641 0 n22 ns641 0 0.000120641159776
Gc11_642 0 n22 ns642 0 -0.0655910284694
Gc11_643 0 n22 ns643 0 0.0577952482821
Gc11_644 0 n22 ns644 0 -0.00292429361345
Gc11_645 0 n22 ns645 0 -7.31956874923e-06
Gc11_646 0 n22 ns646 0 2.00869153761e-05
Gc11_647 0 n22 ns647 0 -7.86619302758e-05
Gc11_648 0 n22 ns648 0 -0.00084865327451
Gc11_649 0 n22 ns649 0 0.00948346550929
Gc11_650 0 n22 ns650 0 0.000123646154566
Gc11_651 0 n22 ns651 0 0.000162232278496
Gc11_652 0 n22 ns652 0 0.000390776615441
Gc11_653 0 n22 ns653 0 -0.000377149373847
Gc11_654 0 n22 ns654 0 -0.000139988205343
Gc11_655 0 n22 ns655 0 2.69388452966e-05
Gc11_656 0 n22 ns656 0 0.000105501685863
Gc11_657 0 n22 ns657 0 -0.00316977444539
Gc11_658 0 n22 ns658 0 0.00039366095067
Gc11_659 0 n22 ns659 0 0.000975506165468
Gc11_660 0 n22 ns660 0 -0.000156178062524
Gc11_661 0 n22 ns661 0 0.000291701811181
Gc11_662 0 n22 ns662 0 -0.00105449806971
Gc11_663 0 n22 ns663 0 -0.000289545232615
Gc11_664 0 n22 ns664 0 -0.000314926687816
Gc11_665 0 n22 ns665 0 -0.000682747478832
Gc11_666 0 n22 ns666 0 0.000208498440549
Gc11_667 0 n22 ns667 0 0.000245667045323
Gc11_668 0 n22 ns668 0 -0.0017611633923
Gc11_669 0 n22 ns669 0 -0.00494528947958
Gc11_670 0 n22 ns670 0 -0.000894977417591
Gc11_671 0 n22 ns671 0 0.000300959106646
Gc11_672 0 n22 ns672 0 -0.000183265895581
Gc11_673 0 n22 ns673 0 0.00117060582563
Gc11_674 0 n22 ns674 0 -0.00775602524456
Gc11_675 0 n22 ns675 0 -0.00536054110866
Gc11_676 0 n22 ns676 0 -0.00259248508575
Gc11_677 0 n22 ns677 0 0.00280269089197
Gc11_678 0 n22 ns678 0 0.00252697824634
Gc11_679 0 n22 ns679 0 0.000260913923804
Gc11_680 0 n22 ns680 0 -0.0779975588045
Gc11_681 0 n22 ns681 0 0.0701222051359
Gc11_682 0 n22 ns682 0 -0.00408306165223
Gc11_683 0 n22 ns683 0 -1.02670233075e-05
Gc11_684 0 n22 ns684 0 2.31485249605e-05
Gc11_685 0 n22 ns685 0 -0.00262026763964
Gc11_686 0 n22 ns686 0 -0.00256198042325
Gc11_687 0 n22 ns687 0 0.00686566756057
Gc11_688 0 n22 ns688 0 0.000999823392118
Gc11_689 0 n22 ns689 0 -0.00184326682783
Gc11_690 0 n22 ns690 0 0.00070319740581
Gc11_691 0 n22 ns691 0 0.00192246258131
Gc11_692 0 n22 ns692 0 3.63451105516e-05
Gc11_693 0 n22 ns693 0 -0.000236387431475
Gc11_694 0 n22 ns694 0 0.000308500471505
Gc11_695 0 n22 ns695 0 -0.000194414218119
Gc11_696 0 n22 ns696 0 -0.000647766110187
Gc11_697 0 n22 ns697 0 -4.9114061133e-05
Gc11_698 0 n22 ns698 0 -0.000409441852068
Gc11_699 0 n22 ns699 0 0.000449799764827
Gc11_700 0 n22 ns700 0 0.00211304930496
Gc11_701 0 n22 ns701 0 -0.00289366956603
Gc11_702 0 n22 ns702 0 -0.00115867640918
Gc11_703 0 n22 ns703 0 -0.000446911529744
Gc11_704 0 n22 ns704 0 0.000246942756503
Gc11_705 0 n22 ns705 0 0.000407456258511
Gc11_706 0 n22 ns706 0 0.00200656609785
Gc11_707 0 n22 ns707 0 -0.00162339390239
Gc11_708 0 n22 ns708 0 -0.00185832140671
Gc11_709 0 n22 ns709 0 -0.00200877166209
Gc11_710 0 n22 ns710 0 -0.000792415127007
Gc11_711 0 n22 ns711 0 0.00226496451009
Gc11_712 0 n22 ns712 0 -0.011075614941
Gc11_713 0 n22 ns713 0 -0.0051872282308
Gc11_714 0 n22 ns714 0 -0.000127586130143
Gc11_715 0 n22 ns715 0 0.00237384381511
Gc11_716 0 n22 ns716 0 0.00319741763368
Gc11_717 0 n22 ns717 0 0.000345073361733
Gc11_718 0 n22 ns718 0 -0.0367943173762
Gc11_719 0 n22 ns719 0 0.0386671837272
Gc11_720 0 n22 ns720 0 -0.00709632666849
Gc11_721 0 n22 ns721 0 -1.32290420337e-05
Gc11_722 0 n22 ns722 0 2.90935767293e-05
Gc11_723 0 n22 ns723 0 -0.00546324229102
Gc11_724 0 n22 ns724 0 -0.00514551701257
Gc11_725 0 n22 ns725 0 0.00924492557485
Gc11_726 0 n22 ns726 0 0.00262746827791
Gc11_727 0 n22 ns727 0 -0.00211929199122
Gc11_728 0 n22 ns728 0 0.000659135391099
Gc11_729 0 n22 ns729 0 0.00279512311594
Gc11_730 0 n22 ns730 0 -1.61573616248e-06
Gc11_731 0 n22 ns731 0 -0.000307575553024
Gc11_732 0 n22 ns732 0 -0.00100834102501
Gc11_733 0 n22 ns733 0 -0.00145151375913
Gc11_734 0 n22 ns734 0 -0.000881564979564
Gc11_735 0 n22 ns735 0 0.000483350721575
Gc11_736 0 n22 ns736 0 -0.000157599690515
Gc11_737 0 n22 ns737 0 0.000583612052205
Gc11_738 0 n22 ns738 0 0.00278230946228
Gc11_739 0 n22 ns739 0 -0.00258094114531
Gc11_740 0 n22 ns740 0 -0.000892600675063
Gc11_741 0 n22 ns741 0 -0.000590275719318
Gc11_742 0 n22 ns742 0 0.000202424433688
Gc11_743 0 n22 ns743 0 0.000194981322022
Gc11_744 0 n22 ns744 0 0.00238146788649
Gc11_745 0 n22 ns745 0 0.00135002538692
Gc11_746 0 n22 ns746 0 -0.00116515873918
Gc11_747 0 n22 ns747 0 -0.0026810683809
Gc11_748 0 n22 ns748 0 -0.00115710360716
Gc11_749 0 n22 ns749 0 0.00210186295339
Gc11_750 0 n22 ns750 0 -0.0147193375611
Gc11_751 0 n22 ns751 0 -0.00568421168865
Gc11_752 0 n22 ns752 0 0.00202370142099
Gc11_753 0 n22 ns753 0 0.00390785693968
Gc11_754 0 n22 ns754 0 0.00372254315548
Gc11_755 0 n22 ns755 0 0.000172898311031
Gc11_756 0 n22 ns756 0 0.00883061009012
Gc11_757 0 n22 ns757 0 -0.00107909880037
Gc11_758 0 n22 ns758 0 -0.00787549975644
Gc11_759 0 n22 ns759 0 -1.31513295566e-05
Gc11_760 0 n22 ns760 0 1.55030484748e-05
Gc11_761 0 n22 ns761 0 0.000215481382882
Gc11_762 0 n22 ns762 0 -0.00110229994674
Gc11_763 0 n22 ns763 0 0.00990209616319
Gc11_764 0 n22 ns764 0 -0.000245605889677
Gc11_765 0 n22 ns765 0 0.00017435450525
Gc11_766 0 n22 ns766 0 0.000488306294318
Gc11_767 0 n22 ns767 0 -0.000517912248825
Gc11_768 0 n22 ns768 0 -8.52067105471e-05
Gc11_769 0 n22 ns769 0 3.42865311015e-05
Gc11_770 0 n22 ns770 0 0.0020071821357
Gc11_771 0 n22 ns771 0 -0.00275990609222
Gc11_772 0 n22 ns772 0 -0.000628818328212
Gc11_773 0 n22 ns773 0 0.000844010046752
Gc11_774 0 n22 ns774 0 -4.90517861867e-05
Gc11_775 0 n22 ns775 0 0.000520824075338
Gc11_776 0 n22 ns776 0 -0.0013544569585
Gc11_777 0 n22 ns777 0 -0.00245103556034
Gc11_778 0 n22 ns778 0 -0.00062914956889
Gc11_779 0 n22 ns779 0 0.000442309773288
Gc11_780 0 n22 ns780 0 0.000366276462396
Gc11_781 0 n22 ns781 0 0.000262713503605
Gc11_782 0 n22 ns782 0 -0.000257072103815
Gc11_783 0 n22 ns783 0 -0.00646274661635
Gc11_784 0 n22 ns784 0 -0.00291757279198
Gc11_785 0 n22 ns785 0 -0.000475704169736
Gc11_786 0 n22 ns786 0 0.00050053342134
Gc11_787 0 n22 ns787 0 0.00210504541492
Gc11_788 0 n22 ns788 0 -0.0109308880965
Gc11_789 0 n22 ns789 0 -0.00562927166325
Gc11_790 0 n22 ns790 0 -0.00184843980219
Gc11_791 0 n22 ns791 0 0.00293710110475
Gc11_792 0 n22 ns792 0 0.00271326872924
Gc11_793 0 n22 ns793 0 0.000165482879684
Gc11_794 0 n22 ns794 0 -0.091521091484
Gc11_795 0 n22 ns795 0 0.083264622917
Gc11_796 0 n22 ns796 0 -0.00526775897671
Gc11_797 0 n22 ns797 0 -1.00291770626e-05
Gc11_798 0 n22 ns798 0 -5.89436929632e-07
Gc11_799 0 n22 ns799 0 0.000717292918728
Gc11_800 0 n22 ns800 0 -0.00169869264108
Gc11_801 0 n22 ns801 0 0.0092046112071
Gc11_802 0 n22 ns802 0 0.00022571458147
Gc11_803 0 n22 ns803 0 0.00026330700904
Gc11_804 0 n22 ns804 0 0.000148488191877
Gc11_805 0 n22 ns805 0 0.000152388141857
Gc11_806 0 n22 ns806 0 -1.08837705486e-05
Gc11_807 0 n22 ns807 0 5.42888844683e-06
Gc11_808 0 n22 ns808 0 -0.000473464586831
Gc11_809 0 n22 ns809 0 -0.00336754941042
Gc11_810 0 n22 ns810 0 0.000251235528183
Gc11_811 0 n22 ns811 0 0.000824435577568
Gc11_812 0 n22 ns812 0 0.000192546847378
Gc11_813 0 n22 ns813 0 0.000381167879225
Gc11_814 0 n22 ns814 0 -0.000193406997704
Gc11_815 0 n22 ns815 0 -7.71150908725e-05
Gc11_816 0 n22 ns816 0 -0.000518979021969
Gc11_817 0 n22 ns817 0 -0.000231628746796
Gc11_818 0 n22 ns818 0 0.000184524102986
Gc11_819 0 n22 ns819 0 -1.20493952151e-05
Gc11_820 0 n22 ns820 0 -0.00205723053328
Gc11_821 0 n22 ns821 0 -0.00371119682993
Gc11_822 0 n22 ns822 0 -0.00106205436198
Gc11_823 0 n22 ns823 0 -0.000380168945671
Gc11_824 0 n22 ns824 0 0.000319948374887
Gc11_825 0 n22 ns825 0 0.00134153359407
Gc11_826 0 n22 ns826 0 -0.00743494112689
Gc11_827 0 n22 ns827 0 -0.00478425722645
Gc11_828 0 n22 ns828 0 -0.00115747256827
Gc11_829 0 n22 ns829 0 0.00373602423335
Gc11_830 0 n22 ns830 0 0.00192856759525
Gc11_831 0 n22 ns831 0 -0.000462681363487
Gc11_832 0 n22 ns832 0 -0.053293380246
Gc11_833 0 n22 ns833 0 0.0457853731141
Gc11_834 0 n22 ns834 0 -0.00199550345787
Gc11_835 0 n22 ns835 0 -8.35677163005e-06
Gc11_836 0 n22 ns836 0 -2.36577905521e-05
Gc11_837 0 n22 ns837 0 0.000521920551528
Gc11_838 0 n22 ns838 0 -0.000609159563653
Gc11_839 0 n22 ns839 0 0.00423521772441
Gc11_840 0 n22 ns840 0 -0.000332149743119
Gc11_841 0 n22 ns841 0 0.000451372246856
Gc11_842 0 n22 ns842 0 0.000428640181109
Gc11_843 0 n22 ns843 0 7.07346977991e-05
Gc11_844 0 n22 ns844 0 2.99488650614e-05
Gc11_845 0 n22 ns845 0 -2.95606912619e-05
Gc11_846 0 n22 ns846 0 -8.53869890449e-05
Gc11_847 0 n22 ns847 0 -0.000754664513822
Gc11_848 0 n22 ns848 0 1.38506482615e-05
Gc11_849 0 n22 ns849 0 -9.31301121242e-05
Gc11_850 0 n22 ns850 0 0.00011907430717
Gc11_851 0 n22 ns851 0 0.000194628591687
Gc11_852 0 n22 ns852 0 0.000954108670463
Gc11_853 0 n22 ns853 0 -0.000982496279409
Gc11_854 0 n22 ns854 0 -0.000876436069255
Gc11_855 0 n22 ns855 0 0.0001911512275
Gc11_856 0 n22 ns856 0 8.32909082457e-05
Gc11_857 0 n22 ns857 0 6.82785331956e-06
Gc11_858 0 n22 ns858 0 -0.000584765747642
Gc11_859 0 n22 ns859 0 -0.0019090147987
Gc11_860 0 n22 ns860 0 -0.00118270482721
Gc11_861 0 n22 ns861 0 -0.000992704528764
Gc11_862 0 n22 ns862 0 0.000436052778771
Gc11_863 0 n22 ns863 0 0.00122361930106
Gc11_864 0 n22 ns864 0 -0.00518751756686
Gc11_865 0 n22 ns865 0 -0.00278503222635
Gc11_866 0 n22 ns866 0 0.000228553879491
Gc11_867 0 n22 ns867 0 0.00274630666914
Gc11_868 0 n22 ns868 0 0.00101861656571
Gc11_869 0 n22 ns869 0 -0.000687378269714
Gc11_870 0 n22 ns870 0 -0.0213659300909
Gc11_871 0 n22 ns871 0 0.0176810250085
Gc11_872 0 n22 ns872 0 -0.000682952103023
Gc11_873 0 n22 ns873 0 -1.02338354423e-06
Gc11_874 0 n22 ns874 0 -3.2949457894e-05
Gc11_875 0 n22 ns875 0 0.000532636438707
Gc11_876 0 n22 ns876 0 -0.000622018512799
Gc11_877 0 n22 ns877 0 0.00273190087265
Gc11_878 0 n22 ns878 0 -0.000168162469241
Gc11_879 0 n22 ns879 0 0.000338423378542
Gc11_880 0 n22 ns880 0 0.000186031387325
Gc11_881 0 n22 ns881 0 -1.71624354421e-06
Gc11_882 0 n22 ns882 0 -1.2514413114e-05
Gc11_883 0 n22 ns883 0 -4.03886206621e-05
Gc11_884 0 n22 ns884 0 0.000712643990352
Gc11_885 0 n22 ns885 0 -0.000965246329226
Gc11_886 0 n22 ns886 0 -0.000496273772387
Gc11_887 0 n22 ns887 0 0.000316589154549
Gc11_888 0 n22 ns888 0 0.000192080436816
Gc11_889 0 n22 ns889 0 0.000152260557734
Gc11_890 0 n22 ns890 0 -0.000451598912284
Gc11_891 0 n22 ns891 0 -0.00096949852792
Gc11_892 0 n22 ns892 0 -4.06846591829e-05
Gc11_893 0 n22 ns893 0 0.000667666214994
Gc11_894 0 n22 ns894 0 0.000111023841371
Gc11_895 0 n22 ns895 0 -0.000103888638872
Gc11_896 0 n22 ns896 0 -0.000181084229031
Gc11_897 0 n22 ns897 0 -0.00134817827087
Gc11_898 0 n22 ns898 0 -0.0013689078338
Gc11_899 0 n22 ns899 0 -0.000338379818575
Gc11_900 0 n22 ns900 0 0.000712392021099
Gc11_901 0 n22 ns901 0 0.000695354006573
Gc11_902 0 n22 ns902 0 -0.00356464623202
Gc11_903 0 n22 ns903 0 -0.000711609869887
Gc11_904 0 n22 ns904 0 0.000689342933935
Gc11_905 0 n22 ns905 0 0.00146147670462
Gc11_906 0 n22 ns906 0 0.00045486590537
Gc11_907 0 n22 ns907 0 -0.000548510841473
Gc11_908 0 n22 ns908 0 -0.00766490275417
Gc11_909 0 n22 ns909 0 0.0059195109753
Gc11_910 0 n22 ns910 0 -0.000206081115468
Gc11_911 0 n22 ns911 0 5.57636344398e-06
Gc11_912 0 n22 ns912 0 -3.17694956456e-05
Gc11_913 0 n22 ns913 0 5.55781244107e-05
Gc11_914 0 n22 ns914 0 -0.000434070544076
Gc11_915 0 n22 ns915 0 0.000851545506534
Gc11_916 0 n22 ns916 0 -0.000123371515016
Gc11_917 0 n22 ns917 0 0.000171376340502
Gc11_918 0 n22 ns918 0 1.02053428211e-05
Gc11_919 0 n22 ns919 0 0.000126458697964
Gc11_920 0 n22 ns920 0 4.8512430113e-06
Gc11_921 0 n22 ns921 0 1.53990788597e-05
Gc11_922 0 n22 ns922 0 0.0004282405131
Gc11_923 0 n22 ns923 0 -0.00144863418126
Gc11_924 0 n22 ns924 0 -0.000281935065029
Gc11_925 0 n22 ns925 0 0.000798405862764
Gc11_926 0 n22 ns926 0 0.000272109629896
Gc11_927 0 n22 ns927 0 5.99269454183e-05
Gc11_928 0 n22 ns928 0 -0.000769760365836
Gc11_929 0 n22 ns929 0 9.77947487999e-05
Gc11_930 0 n22 ns930 0 0.000505342821731
Gc11_931 0 n22 ns931 0 0.000286154771543
Gc11_932 0 n22 ns932 0 3.6496872331e-05
Gc11_933 0 n22 ns933 0 -0.000170650207601
Gc11_934 0 n22 ns934 0 0.000257811941386
Gc11_935 0 n22 ns935 0 -0.000775402230953
Gc11_936 0 n22 ns936 0 -0.000872528619124
Gc11_937 0 n22 ns937 0 -4.87804916937e-05
Gc11_938 0 n22 ns938 0 0.000480995037944
Gc11_939 0 n22 ns939 0 0.00029522750802
Gc11_940 0 n22 ns940 0 -0.0014079723499
Gc11_941 0 n22 ns941 0 0.000159696288472
Gc11_942 0 n22 ns942 0 0.000492558580304
Gc11_943 0 n22 ns943 0 0.000507704865928
Gc11_944 0 n22 ns944 0 0.000125052698073
Gc11_945 0 n22 ns945 0 -0.000314968506603
Gc11_946 0 n22 ns946 0 0.000278103282464
Gc11_947 0 n22 ns947 0 -0.000401125601886
Gc11_948 0 n22 ns948 0 -3.74808911841e-05
Gc11_949 0 n22 ns949 0 7.49200729193e-06
Gc11_950 0 n22 ns950 0 -2.50789125755e-05
Gc11_951 0 n22 ns951 0 -0.000520775684318
Gc11_952 0 n22 ns952 0 0.000509645061842
Gc11_953 0 n22 ns953 0 0.00498373964411
Gc11_954 0 n22 ns954 0 -0.00129713692522
Gc11_955 0 n22 ns955 0 -0.00055285949792
Gc11_956 0 n22 ns956 0 0.001875851118
Gc11_957 0 n22 ns957 0 0.000532275255615
Gc11_958 0 n22 ns958 0 -0.000157998762105
Gc11_959 0 n22 ns959 0 -0.000182334695156
Gc11_960 0 n22 ns960 0 0.00128393321574
Gc11_961 0 n22 ns961 0 -0.00138181098384
Gc11_962 0 n22 ns962 0 -9.01899410888e-05
Gc11_963 0 n22 ns963 0 0.000425716886313
Gc11_964 0 n22 ns964 0 -0.00032679602907
Gc11_965 0 n22 ns965 0 0.000353890740592
Gc11_966 0 n22 ns966 0 0.000537621032573
Gc11_967 0 n22 ns967 0 -0.00305415518928
Gc11_968 0 n22 ns968 0 -0.00132621995225
Gc11_969 0 n22 ns969 0 -0.000281986595519
Gc11_970 0 n22 ns970 0 0.000226505051978
Gc11_971 0 n22 ns971 0 0.000512867738299
Gc11_972 0 n22 ns972 0 0.000959396152399
Gc11_973 0 n22 ns973 0 -0.00462329624065
Gc11_974 0 n22 ns974 0 -0.00194795303839
Gc11_975 0 n22 ns975 0 -0.00110916198604
Gc11_976 0 n22 ns976 0 -0.00042182063678
Gc11_977 0 n22 ns977 0 0.00201708369119
Gc11_978 0 n22 ns978 0 -0.0109975328586
Gc11_979 0 n22 ns979 0 -0.00583331622379
Gc11_980 0 n22 ns980 0 -0.00152824548113
Gc11_981 0 n22 ns981 0 0.0027043923096
Gc11_982 0 n22 ns982 0 0.00309370870576
Gc11_983 0 n22 ns983 0 0.000480184443981
Gc11_984 0 n22 ns984 0 -0.0680315219793
Gc11_985 0 n22 ns985 0 0.0650481669935
Gc11_986 0 n22 ns986 0 -0.00643340530364
Gc11_987 0 n22 ns987 0 -1.32200986267e-05
Gc11_988 0 n22 ns988 0 3.19164771714e-05
Gc11_989 0 n22 ns989 0 -0.0169748295312
Gc11_990 0 n22 ns990 0 -0.00116163949877
Gc11_991 0 n22 ns991 0 0.0212030682955
Gc11_992 0 n22 ns992 0 0.00639889246694
Gc11_993 0 n22 ns993 0 0.0102021283012
Gc11_994 0 n22 ns994 0 0.00156039855788
Gc11_995 0 n22 ns995 0 -0.00341796779608
Gc11_996 0 n22 ns996 0 -0.000538674214795
Gc11_997 0 n22 ns997 0 6.92019335301e-06
Gc11_998 0 n22 ns998 0 -0.00134325751194
Gc11_999 0 n22 ns999 0 -0.0140364593131
Gc11_1000 0 n22 ns1000 0 0.00109735308489
Gc11_1001 0 n22 ns1001 0 0.00157657438251
Gc11_1002 0 n22 ns1002 0 9.9881945547e-05
Gc11_1003 0 n22 ns1003 0 0.000433573919238
Gc11_1004 0 n22 ns1004 0 0.000453491432559
Gc11_1005 0 n22 ns1005 0 -5.95887377658e-05
Gc11_1006 0 n22 ns1006 0 -0.000432587318722
Gc11_1007 0 n22 ns1007 0 0.000600357873752
Gc11_1008 0 n22 ns1008 0 0.00056094984996
Gc11_1009 0 n22 ns1009 0 0.00048180245066
Gc11_1010 0 n22 ns1010 0 -0.0120007820855
Gc11_1011 0 n22 ns1011 0 -0.0075513365668
Gc11_1012 0 n22 ns1012 0 -0.00331484888824
Gc11_1013 0 n22 ns1013 0 -0.00148918336377
Gc11_1014 0 n22 ns1014 0 -0.000126447850133
Gc11_1015 0 n22 ns1015 0 0.00258331777852
Gc11_1016 0 n22 ns1016 0 0.00778815578118
Gc11_1017 0 n22 ns1017 0 -0.00616809497547
Gc11_1018 0 n22 ns1018 0 0.00169791593444
Gc11_1019 0 n22 ns1019 0 0.002183754251
Gc11_1020 0 n22 ns1020 0 0.00343174497548
Gc11_1021 0 n22 ns1021 0 3.04096703175e-05
Gc11_1022 0 n22 ns1022 0 -0.113009029697
Gc11_1023 0 n22 ns1023 0 0.0741769798642
Gc11_1024 0 n22 ns1024 0 -0.00891730469901
Gc11_1025 0 n22 ns1025 0 -1.30545053829e-05
Gc11_1026 0 n22 ns1026 0 2.416776063e-05
Gc11_1027 0 n22 ns1027 0 -0.000319782044072
Gc11_1028 0 n22 ns1028 0 -0.000423942915743
Gc11_1029 0 n22 ns1029 0 0.00698416650612
Gc11_1030 0 n22 ns1030 0 -0.00111429032274
Gc11_1031 0 n22 ns1031 0 -0.000483080748366
Gc11_1032 0 n22 ns1032 0 0.0018017987353
Gc11_1033 0 n22 ns1033 0 0.00046431918646
Gc11_1034 0 n22 ns1034 0 -0.000184270515116
Gc11_1035 0 n22 ns1035 0 -0.00017239804868
Gc11_1036 0 n22 ns1036 0 0.00220055133369
Gc11_1037 0 n22 ns1037 0 -0.00268476820184
Gc11_1038 0 n22 ns1038 0 -0.000847158690691
Gc11_1039 0 n22 ns1039 0 0.00099207988732
Gc11_1040 0 n22 ns1040 0 -6.41270145667e-05
Gc11_1041 0 n22 ns1041 0 0.000571021303148
Gc11_1042 0 n22 ns1042 0 -0.000542055085772
Gc11_1043 0 n22 ns1043 0 -0.00371832239403
Gc11_1044 0 n22 ns1044 0 -0.000988895883182
Gc11_1045 0 n22 ns1045 0 0.000439413624531
Gc11_1046 0 n22 ns1046 0 0.00034662345693
Gc11_1047 0 n22 ns1047 0 0.00037331162735
Gc11_1048 0 n22 ns1048 0 0.000889244996316
Gc11_1049 0 n22 ns1049 0 -0.00548658966197
Gc11_1050 0 n22 ns1050 0 -0.00299489332245
Gc11_1051 0 n22 ns1051 0 -0.00107357805379
Gc11_1052 0 n22 ns1052 0 0.000185998885638
Gc11_1053 0 n22 ns1053 0 0.00231691510417
Gc11_1054 0 n22 ns1054 0 -0.0130247324298
Gc11_1055 0 n22 ns1055 0 -0.00589961125386
Gc11_1056 0 n22 ns1056 0 -0.00094956767275
Gc11_1057 0 n22 ns1057 0 0.0031678096423
Gc11_1058 0 n22 ns1058 0 0.00313467407859
Gc11_1059 0 n22 ns1059 0 0.000264058761316
Gc11_1060 0 n22 ns1060 0 -0.0734839127194
Gc11_1061 0 n22 ns1061 0 0.0692711322379
Gc11_1062 0 n22 ns1062 0 -0.00651703605085
Gc11_1063 0 n22 ns1063 0 -9.89875122742e-06
Gc11_1064 0 n22 ns1064 0 1.5617670159e-05
Gc11_1065 0 n22 ns1065 0 0.000787626750844
Gc11_1066 0 n22 ns1066 0 -0.000790686067925
Gc11_1067 0 n22 ns1067 0 0.0102739175688
Gc11_1068 0 n22 ns1068 0 1.3751137281e-05
Gc11_1069 0 n22 ns1069 0 0.000742054188385
Gc11_1070 0 n22 ns1070 0 0.000418120462535
Gc11_1071 0 n22 ns1071 0 -0.000126533025527
Gc11_1072 0 n22 ns1072 0 -8.63666629612e-05
Gc11_1073 0 n22 ns1073 0 -1.11345915968e-05
Gc11_1074 0 n22 ns1074 0 0.000143892087479
Gc11_1075 0 n22 ns1075 0 -0.00446210286645
Gc11_1076 0 n22 ns1076 0 0.000120791294512
Gc11_1077 0 n22 ns1077 0 0.00121254620607
Gc11_1078 0 n22 ns1078 0 0.000176660170933
Gc11_1079 0 n22 ns1079 0 0.000453801154379
Gc11_1080 0 n22 ns1080 0 -0.0011498350976
Gc11_1081 0 n22 ns1081 0 -0.00063589295154
Gc11_1082 0 n22 ns1082 0 -0.00040368046946
Gc11_1083 0 n22 ns1083 0 -5.04952330639e-06
Gc11_1084 0 n22 ns1084 0 0.000293792348823
Gc11_1085 0 n22 ns1085 0 6.06506842509e-05
Gc11_1086 0 n22 ns1086 0 -0.00223867518754
Gc11_1087 0 n22 ns1087 0 -0.0049595362107
Gc11_1088 0 n22 ns1088 0 -0.00157075755099
Gc11_1089 0 n22 ns1089 0 -9.15209210001e-05
Gc11_1090 0 n22 ns1090 0 0.000443586790604
Gc11_1091 0 n22 ns1091 0 0.00151957613069
Gc11_1092 0 n22 ns1092 0 -0.00903501983578
Gc11_1093 0 n22 ns1093 0 -0.00540216451396
Gc11_1094 0 n22 ns1094 0 -0.00157315599358
Gc11_1095 0 n22 ns1095 0 0.00386146453086
Gc11_1096 0 n22 ns1096 0 0.0023023076197
Gc11_1097 0 n22 ns1097 0 -0.000313534579885
Gc11_1098 0 n22 ns1098 0 -0.0701678718671
Gc11_1099 0 n22 ns1099 0 0.0611359648109
Gc11_1100 0 n22 ns1100 0 -0.00291237541969
Gc11_1101 0 n22 ns1101 0 -9.66775294112e-06
Gc11_1102 0 n22 ns1102 0 -1.31821323607e-05
Gc11_1103 0 n22 ns1103 0 0.000513818640174
Gc11_1104 0 n22 ns1104 0 -0.000947738187917
Gc11_1105 0 n22 ns1105 0 0.00581202266697
Gc11_1106 0 n22 ns1106 0 -7.94288597011e-05
Gc11_1107 0 n22 ns1107 0 0.000339718199894
Gc11_1108 0 n22 ns1108 0 0.00037315432114
Gc11_1109 0 n22 ns1109 0 0.000140485459918
Gc11_1110 0 n22 ns1110 0 2.65937507804e-05
Gc11_1111 0 n22 ns1111 0 -7.15924643334e-06
Gc11_1112 0 n22 ns1112 0 -0.000630488362306
Gc11_1113 0 n22 ns1113 0 -0.00157551999023
Gc11_1114 0 n22 ns1114 0 0.000296101376806
Gc11_1115 0 n22 ns1115 0 0.000137986891186
Gc11_1116 0 n22 ns1116 0 0.000148450636285
Gc11_1117 0 n22 ns1117 0 0.000241390236393
Gc11_1118 0 n22 ns1118 0 0.000989504695149
Gc11_1119 0 n22 ns1119 0 -0.000611799706713
Gc11_1120 0 n22 ns1120 0 -0.000957945069848
Gc11_1121 0 n22 ns1121 0 -8.58078281217e-05
Gc11_1122 0 n22 ns1122 0 9.00216950628e-05
Gc11_1123 0 n22 ns1123 0 1.53855046032e-05
Gc11_1124 0 n22 ns1124 0 -0.00116225578909
Gc11_1125 0 n22 ns1125 0 -0.00244396266286
Gc11_1126 0 n22 ns1126 0 -0.00108527814523
Gc11_1127 0 n22 ns1127 0 -0.000951688549428
Gc11_1128 0 n22 ns1128 0 0.00036346973577
Gc11_1129 0 n22 ns1129 0 0.00134807474508
Gc11_1130 0 n22 ns1130 0 -0.00613137925257
Gc11_1131 0 n22 ns1131 0 -0.00360019631737
Gc11_1132 0 n22 ns1132 0 -0.000131923235468
Gc11_1133 0 n22 ns1133 0 0.00325601148319
Gc11_1134 0 n22 ns1134 0 0.00133342276641
Gc11_1135 0 n22 ns1135 0 -0.000681335412675
Gc11_1136 0 n22 ns1136 0 -0.0310330656347
Gc11_1137 0 n22 ns1137 0 0.0260113587619
Gc11_1138 0 n22 ns1138 0 -0.0010318721883
Gc11_1139 0 n22 ns1139 0 -4.08384820516e-06
Gc11_1140 0 n22 ns1140 0 -2.91011481467e-05
Gc11_1141 0 n22 ns1141 0 0.000597361287249
Gc11_1142 0 n22 ns1142 0 -0.000755000995248
Gc11_1143 0 n22 ns1143 0 0.00340679300717
Gc11_1144 0 n22 ns1144 0 -0.000176863413095
Gc11_1145 0 n22 ns1145 0 0.000334241032804
Gc11_1146 0 n22 ns1146 0 0.000255727095201
Gc11_1147 0 n22 ns1147 0 -3.72346558543e-05
Gc11_1148 0 n22 ns1148 0 4.0107581589e-06
Gc11_1149 0 n22 ns1149 0 -4.83323723668e-05
Gc11_1150 0 n22 ns1150 0 0.00049246478222
Gc11_1151 0 n22 ns1151 0 -0.000554714188534
Gc11_1152 0 n22 ns1152 0 -0.000404140498574
Gc11_1153 0 n22 ns1153 0 -2.2646221831e-05
Gc11_1154 0 n22 ns1154 0 0.000131369108924
Gc11_1155 0 n22 ns1155 0 0.000182316441024
Gc11_1156 0 n22 ns1156 0 -1.22289366347e-05
Gc11_1157 0 n22 ns1157 0 -0.00124079810548
Gc11_1158 0 n22 ns1158 0 -0.000406617418427
Gc11_1159 0 n22 ns1159 0 0.000674192858841
Gc11_1160 0 n22 ns1160 0 0.00013383405679
Gc11_1161 0 n22 ns1161 0 -5.00527587383e-05
Gc11_1162 0 n22 ns1162 0 -0.000317780798501
Gc11_1163 0 n22 ns1163 0 -0.00140572017217
Gc11_1164 0 n22 ns1164 0 -0.00136330237877
Gc11_1165 0 n22 ns1165 0 -0.000596383988443
Gc11_1166 0 n22 ns1166 0 0.000661548687867
Gc11_1167 0 n22 ns1167 0 0.00089379491805
Gc11_1168 0 n22 ns1168 0 -0.00416637803932
Gc11_1169 0 n22 ns1169 0 -0.00125817675164
Gc11_1170 0 n22 ns1170 0 0.000633984010197
Gc11_1171 0 n22 ns1171 0 0.00186529702244
Gc11_1172 0 n22 ns1172 0 0.000605820843071
Gc11_1173 0 n22 ns1173 0 -0.000620313599649
Gc11_1174 0 n22 ns1174 0 -0.0114941071624
Gc11_1175 0 n22 ns1175 0 0.00913715079231
Gc11_1176 0 n22 ns1176 0 -0.000325594006036
Gc11_1177 0 n22 ns1177 0 3.57317677083e-06
Gc11_1178 0 n22 ns1178 0 -3.46687201538e-05
Gc11_1179 0 n22 ns1179 0 0.000210479248726
Gc11_1180 0 n22 ns1180 0 -0.000619366271105
Gc11_1181 0 n22 ns1181 0 0.00147141480682
Gc11_1182 0 n22 ns1182 0 -0.000108144673232
Gc11_1183 0 n22 ns1183 0 0.000202653964055
Gc11_1184 0 n22 ns1184 0 3.7003539827e-05
Gc11_1185 0 n22 ns1185 0 9.94216991874e-05
Gc11_1186 0 n22 ns1186 0 -3.73049899894e-06
Gc11_1187 0 n22 ns1187 0 -2.01470491614e-06
Gc11_1188 0 n22 ns1188 0 0.000572555144922
Gc11_1189 0 n22 ns1189 0 -0.0014679417242
Gc11_1190 0 n22 ns1190 0 -0.000410184933297
Gc11_1191 0 n22 ns1191 0 0.000756655288436
Gc11_1192 0 n22 ns1192 0 0.000284769349137
Gc11_1193 0 n22 ns1193 0 9.83069758917e-05
Gc11_1194 0 n22 ns1194 0 -0.000854064043853
Gc11_1195 0 n22 ns1195 0 -0.000181862773898
Gc11_1196 0 n22 ns1196 0 0.000452768053398
Gc11_1197 0 n22 ns1197 0 0.000458789898574
Gc11_1198 0 n22 ns1198 0 6.80492821195e-05
Gc11_1199 0 n22 ns1199 0 -0.000179465670406
Gc11_1200 0 n22 ns1200 0 0.000168261090085
Gc11_1201 0 n22 ns1201 0 -0.000965455543041
Gc11_1202 0 n22 ns1202 0 -0.00109393337792
Gc11_1203 0 n22 ns1203 0 -0.000104105648348
Gc11_1204 0 n22 ns1204 0 0.000602155499138
Gc11_1205 0 n22 ns1205 0 0.000410715062145
Gc11_1206 0 n22 ns1206 0 -0.0020575270317
Gc11_1207 0 n22 ns1207 0 4.98331173781e-05
Gc11_1208 0 n22 ns1208 0 0.00062890228314
Gc11_1209 0 n22 ns1209 0 0.000750815385081
Gc11_1210 0 n22 ns1210 0 0.000190534382088
Gc11_1211 0 n22 ns1211 0 -0.000408310042679
Gc11_1212 0 n22 ns1212 0 -0.00155474037737
Gc11_1213 0 n22 ns1213 0 0.00105291444979
Gc11_1214 0 n22 ns1214 0 -8.23372216314e-05
Gc11_1215 0 n22 ns1215 0 6.14973896803e-06
Gc11_1216 0 n22 ns1216 0 -2.8202428239e-05
Gd11_1 0 n22 ni1 0 -0.000225403859782
Gd11_2 0 n22 ni2 0 -0.000608834218954
Gd11_3 0 n22 ni3 0 -0.00253823994475
Gd11_4 0 n22 ni4 0 -0.000614659202495
Gd11_5 0 n22 ni5 0 -0.00114556925731
Gd11_6 0 n22 ni6 0 0.000104421705182
Gd11_7 0 n22 ni7 0 7.64266670144e-05
Gd11_8 0 n22 ni8 0 2.8906540742e-05
Gd11_9 0 n22 ni9 0 -0.000111039819094
Gd11_10 0 n22 ni10 0 -0.00168289398228
Gd11_11 0 n22 ni11 0 0.000230157810264
Gd11_12 0 n22 ni12 0 -0.00172873488254
Gd11_13 0 n22 ni13 0 -0.000402319496249
Gd11_14 0 n22 ni14 0 0.000158105121593
Gd11_15 0 n22 ni15 0 -5.60282362837e-05
Gd11_16 0 n22 ni16 0 -7.05070136202e-05
Gd11_17 0 n22 ni17 0 0.000560699391479
Gd11_18 0 n22 ni18 0 -6.66929459587e-05
Gd11_19 0 n22 ni19 0 -0.0015843279831
Gd11_20 0 n22 ni20 0 -0.00323329561211
Gd11_21 0 n22 ni21 0 -0.00018056441357
Gd11_22 0 n22 ni22 0 0.000238414661285
Gd11_23 0 n22 ni23 0 0.000288513451444
Gd11_24 0 n22 ni24 0 0.000244906338362
Gd11_25 0 n22 ni25 0 -8.44890649586e-05
Gd11_26 0 n22 ni26 0 -0.00030441989536
Gd11_27 0 n22 ni27 0 -0.00671811808893
Gd11_28 0 n22 ni28 0 -0.000463273668644
Gd11_29 0 n22 ni29 0 0.000581387152669
Gd11_30 0 n22 ni30 0 0.000227650245046
Gd11_31 0 n22 ni31 0 0.000251796969254
Gd11_32 0 n22 ni32 0 -2.23527480769e-05
Gc12_1 0 n24 ns1 0 -0.00127929969604
Gc12_2 0 n24 ns2 0 0.00275528682994
Gc12_3 0 n24 ns3 0 -0.004456967314
Gc12_4 0 n24 ns4 0 -0.000192773121996
Gc12_5 0 n24 ns5 0 -0.000355905360658
Gc12_6 0 n24 ns6 0 -0.000444088649131
Gc12_7 0 n24 ns7 0 -0.00011884400781
Gc12_8 0 n24 ns8 0 -3.0268069744e-05
Gc12_9 0 n24 ns9 0 3.85753118155e-07
Gc12_10 0 n24 ns10 0 0.000736511632668
Gc12_11 0 n24 ns11 0 0.00192447939925
Gc12_12 0 n24 ns12 0 -0.000586285876662
Gc12_13 0 n24 ns13 0 0.000168178631221
Gc12_14 0 n24 ns14 0 6.59074873576e-05
Gc12_15 0 n24 ns15 0 -0.000248625828575
Gc12_16 0 n24 ns16 0 0.00220865008965
Gc12_17 0 n24 ns17 0 0.00100132468589
Gc12_18 0 n24 ns18 0 -0.000874877193953
Gc12_19 0 n24 ns19 0 -0.000724943766559
Gc12_20 0 n24 ns20 0 0.000122053928131
Gc12_21 0 n24 ns21 0 2.73248668242e-05
Gc12_22 0 n24 ns22 0 0.00163133151977
Gc12_23 0 n24 ns23 0 -0.000704519883033
Gc12_24 0 n24 ns24 0 -0.000669808974453
Gc12_25 0 n24 ns25 0 0.000957368046948
Gc12_26 0 n24 ns26 0 0.000474233927766
Gc12_27 0 n24 ns27 0 -0.000817569783714
Gc12_28 0 n24 ns28 0 0.000897585130291
Gc12_29 0 n24 ns29 0 -0.00108519240129
Gc12_30 0 n24 ns30 0 -0.000721700460837
Gc12_31 0 n24 ns31 0 0.00145077439467
Gc12_32 0 n24 ns32 0 0.000870509637214
Gc12_33 0 n24 ns33 0 -0.000506887554417
Gc12_34 0 n24 ns34 0 0.0225486099076
Gc12_35 0 n24 ns35 0 -0.0206770414191
Gc12_36 0 n24 ns36 0 0.00113013808809
Gc12_37 0 n24 ns37 0 -9.77523106715e-06
Gc12_38 0 n24 ns38 0 1.4035445718e-05
Gc12_39 0 n24 ns39 0 -0.00129067342273
Gc12_40 0 n24 ns40 0 0.00261966307877
Gc12_41 0 n24 ns41 0 -0.00366617567686
Gc12_42 0 n24 ns42 0 -6.24775824847e-05
Gc12_43 0 n24 ns43 0 -0.000316833735766
Gc12_44 0 n24 ns44 0 -0.000160003313564
Gc12_45 0 n24 ns45 0 -0.000231236408316
Gc12_46 0 n24 ns46 0 -3.59518122467e-05
Gc12_47 0 n24 ns47 0 5.6411778892e-06
Gc12_48 0 n24 ns48 0 -0.000166801251795
Gc12_49 0 n24 ns49 0 0.0014246691455
Gc12_50 0 n24 ns50 0 -0.000348447170501
Gc12_51 0 n24 ns51 0 0.000161430930219
Gc12_52 0 n24 ns52 0 0.000124857968997
Gc12_53 0 n24 ns53 0 -0.000353090535461
Gc12_54 0 n24 ns54 0 0.00137547651731
Gc12_55 0 n24 ns55 0 0.00107988820358
Gc12_56 0 n24 ns56 0 -0.000801611705665
Gc12_57 0 n24 ns57 0 -0.000567072592953
Gc12_58 0 n24 ns58 0 0.000233222825876
Gc12_59 0 n24 ns59 0 5.09743206865e-05
Gc12_60 0 n24 ns60 0 0.00131565217466
Gc12_61 0 n24 ns61 0 0.000250251495477
Gc12_62 0 n24 ns62 0 -0.000545356430839
Gc12_63 0 n24 ns63 0 0.00105687059046
Gc12_64 0 n24 ns64 0 0.000530286164738
Gc12_65 0 n24 ns65 0 -0.00105526416785
Gc12_66 0 n24 ns66 0 0.00107037972514
Gc12_67 0 n24 ns67 0 -0.000682137060655
Gc12_68 0 n24 ns68 0 -0.00101932667911
Gc12_69 0 n24 ns69 0 0.00158156530734
Gc12_70 0 n24 ns70 0 0.00112132581558
Gc12_71 0 n24 ns71 0 -0.00055525055978
Gc12_72 0 n24 ns72 0 0.027893608393
Gc12_73 0 n24 ns73 0 -0.0260309115197
Gc12_74 0 n24 ns74 0 0.00152500699152
Gc12_75 0 n24 ns75 0 -7.25206434111e-06
Gc12_76 0 n24 ns76 0 1.56125551804e-05
Gc12_77 0 n24 ns77 0 -0.00136739468909
Gc12_78 0 n24 ns78 0 -8.32116437891e-06
Gc12_79 0 n24 ns79 0 0.00152101124037
Gc12_80 0 n24 ns80 0 0.000735775985001
Gc12_81 0 n24 ns81 0 -0.000535058951975
Gc12_82 0 n24 ns82 0 0.000683359304721
Gc12_83 0 n24 ns83 0 -2.11470281308e-05
Gc12_84 0 n24 ns84 0 -0.00012036430246
Gc12_85 0 n24 ns85 0 1.02773704802e-05
Gc12_86 0 n24 ns86 0 -0.00271250247808
Gc12_87 0 n24 ns87 0 -0.000705029371065
Gc12_88 0 n24 ns88 0 0.00102286204609
Gc12_89 0 n24 ns89 0 -0.00014949164475
Gc12_90 0 n24 ns90 0 0.000256471717977
Gc12_91 0 n24 ns91 0 -0.000589175824744
Gc12_92 0 n24 ns92 0 -0.00217645116706
Gc12_93 0 n24 ns93 0 -0.000798198826416
Gc12_94 0 n24 ns94 0 -0.000219472988743
Gc12_95 0 n24 ns95 0 0.00052315471209
Gc12_96 0 n24 ns96 0 0.000537200680995
Gc12_97 0 n24 ns97 0 0.000174006163905
Gc12_98 0 n24 ns98 0 -0.00237674597935
Gc12_99 0 n24 ns99 0 0.00322972176457
Gc12_100 0 n24 ns100 0 0.000803822026827
Gc12_101 0 n24 ns101 0 0.00105168736773
Gc12_102 0 n24 ns102 0 0.000440997556961
Gc12_103 0 n24 ns103 0 -0.00162377423032
Gc12_104 0 n24 ns104 0 -8.501056427e-06
Gc12_105 0 n24 ns105 0 0.00193164565053
Gc12_106 0 n24 ns106 0 -0.00168791846445
Gc12_107 0 n24 ns107 0 0.000699381433991
Gc12_108 0 n24 ns108 0 0.00178005662175
Gc12_109 0 n24 ns109 0 -0.00026210601119
Gc12_110 0 n24 ns110 0 0.0410213635898
Gc12_111 0 n24 ns111 0 -0.0415242177429
Gc12_112 0 n24 ns112 0 0.00350217082464
Gc12_113 0 n24 ns113 0 9.5251154294e-08
Gc12_114 0 n24 ns114 0 1.28122195815e-05
Gc12_115 0 n24 ns115 0 -0.00481109733758
Gc12_116 0 n24 ns116 0 -0.00106871411078
Gc12_117 0 n24 ns117 0 -0.00382182238401
Gc12_118 0 n24 ns118 0 0.0002663456441
Gc12_119 0 n24 ns119 0 -0.00117005393721
Gc12_120 0 n24 ns120 0 -2.79472105361e-05
Gc12_121 0 n24 ns121 0 0.000828344152235
Gc12_122 0 n24 ns122 0 -0.000117432578558
Gc12_123 0 n24 ns123 0 -8.24417841101e-05
Gc12_124 0 n24 ns124 0 -0.000822865836765
Gc12_125 0 n24 ns125 0 0.00197032809015
Gc12_126 0 n24 ns126 0 0.00100822328705
Gc12_127 0 n24 ns127 0 -0.000499205928741
Gc12_128 0 n24 ns128 0 0.000208051564756
Gc12_129 0 n24 ns129 0 -0.000541310662123
Gc12_130 0 n24 ns130 0 0.000349573793228
Gc12_131 0 n24 ns131 0 -0.000721945963486
Gc12_132 0 n24 ns132 0 0.000114197927418
Gc12_133 0 n24 ns133 0 6.97751276546e-05
Gc12_134 0 n24 ns134 0 0.0004547600937
Gc12_135 0 n24 ns135 0 0.000144159265382
Gc12_136 0 n24 ns136 0 -0.00137644871147
Gc12_137 0 n24 ns137 0 0.0010270139661
Gc12_138 0 n24 ns138 0 0.00157314156921
Gc12_139 0 n24 ns139 0 0.00185727721867
Gc12_140 0 n24 ns140 0 0.000786751918853
Gc12_141 0 n24 ns141 0 -0.00196894478095
Gc12_142 0 n24 ns142 0 0.000748870986136
Gc12_143 0 n24 ns143 0 0.000877061374202
Gc12_144 0 n24 ns144 0 0.00020289126616
Gc12_145 0 n24 ns145 0 4.96635046544e-06
Gc12_146 0 n24 ns146 0 0.00247263932399
Gc12_147 0 n24 ns147 0 9.4994109184e-05
Gc12_148 0 n24 ns148 0 0.0268741032978
Gc12_149 0 n24 ns149 0 -0.025894429249
Gc12_150 0 n24 ns150 0 0.00662627820109
Gc12_151 0 n24 ns151 0 -3.38933692405e-06
Gc12_152 0 n24 ns152 0 8.09939002174e-06
Gc12_153 0 n24 ns153 0 -0.00496106569604
Gc12_154 0 n24 ns154 0 0.000305714777342
Gc12_155 0 n24 ns155 0 -0.00706884053867
Gc12_156 0 n24 ns156 0 -0.000228444974794
Gc12_157 0 n24 ns157 0 -0.000855231753217
Gc12_158 0 n24 ns158 0 4.75996524254e-06
Gc12_159 0 n24 ns159 0 0.000327104787314
Gc12_160 0 n24 ns160 0 -0.000106050395379
Gc12_161 0 n24 ns161 0 -3.19145313713e-05
Gc12_162 0 n24 ns162 0 -0.0015419028652
Gc12_163 0 n24 ns163 0 0.00288712767837
Gc12_164 0 n24 ns164 0 0.000687792806949
Gc12_165 0 n24 ns165 0 -0.000539973565269
Gc12_166 0 n24 ns166 0 0.000223709348434
Gc12_167 0 n24 ns167 0 -0.000447790281884
Gc12_168 0 n24 ns168 0 0.00032797615907
Gc12_169 0 n24 ns169 0 0.00182169377858
Gc12_170 0 n24 ns170 0 0.000690439448436
Gc12_171 0 n24 ns171 0 -4.99878106175e-05
Gc12_172 0 n24 ns172 0 0.000502611253674
Gc12_173 0 n24 ns173 0 8.01874796706e-05
Gc12_174 0 n24 ns174 0 0.00236514850563
Gc12_175 0 n24 ns175 0 0.0017283902214
Gc12_176 0 n24 ns176 0 0.00134077737742
Gc12_177 0 n24 ns177 0 0.00219843817742
Gc12_178 0 n24 ns178 0 0.00103745555131
Gc12_179 0 n24 ns179 0 -0.0019294035035
Gc12_180 0 n24 ns180 0 0.00344055324681
Gc12_181 0 n24 ns181 0 -0.00159661733642
Gc12_182 0 n24 ns182 0 0.00176231075452
Gc12_183 0 n24 ns183 0 0.00114153175461
Gc12_184 0 n24 ns184 0 0.00292601414445
Gc12_185 0 n24 ns185 0 3.96110478667e-05
Gc12_186 0 n24 ns186 0 -0.00722362736485
Gc12_187 0 n24 ns187 0 0.0114070462632
Gc12_188 0 n24 ns188 0 0.00709071662591
Gc12_189 0 n24 ns189 0 -1.1697363761e-06
Gc12_190 0 n24 ns190 0 -1.91047327e-06
Gc12_191 0 n24 ns191 0 -0.00219284014878
Gc12_192 0 n24 ns192 0 0.000219719576998
Gc12_193 0 n24 ns193 0 -0.000826974934263
Gc12_194 0 n24 ns194 0 0.000426093274134
Gc12_195 0 n24 ns195 0 -0.000418402481105
Gc12_196 0 n24 ns196 0 0.000480148620699
Gc12_197 0 n24 ns197 0 0.000417680812276
Gc12_198 0 n24 ns198 0 -0.000139189772459
Gc12_199 0 n24 ns199 0 -3.25013611669e-06
Gc12_200 0 n24 ns200 0 -0.000255911016102
Gc12_201 0 n24 ns201 0 6.96252530307e-05
Gc12_202 0 n24 ns202 0 0.000475732090279
Gc12_203 0 n24 ns203 0 -0.000346348968499
Gc12_204 0 n24 ns204 0 0.000171888985278
Gc12_205 0 n24 ns205 0 -0.000420140041622
Gc12_206 0 n24 ns206 0 -0.000692864465183
Gc12_207 0 n24 ns207 0 -0.00148679236364
Gc12_208 0 n24 ns208 0 -0.000324690243989
Gc12_209 0 n24 ns209 0 7.04114349974e-06
Gc12_210 0 n24 ns210 0 0.00033914186331
Gc12_211 0 n24 ns211 0 0.000145930090786
Gc12_212 0 n24 ns212 0 -0.00280245844129
Gc12_213 0 n24 ns213 0 0.00164639583762
Gc12_214 0 n24 ns214 0 0.000896838659283
Gc12_215 0 n24 ns215 0 0.000727097232484
Gc12_216 0 n24 ns216 0 0.000389306982942
Gc12_217 0 n24 ns217 0 -0.00135359019884
Gc12_218 0 n24 ns218 0 -0.000682461412274
Gc12_219 0 n24 ns219 0 0.00213219217016
Gc12_220 0 n24 ns220 0 -0.00167587331386
Gc12_221 0 n24 ns221 0 -8.79679473531e-06
Gc12_222 0 n24 ns222 0 0.00182999182013
Gc12_223 0 n24 ns223 0 9.19419391782e-06
Gc12_224 0 n24 ns224 0 0.0519573614607
Gc12_225 0 n24 ns225 0 -0.0530349047545
Gc12_226 0 n24 ns226 0 0.00473095743558
Gc12_227 0 n24 ns227 0 1.58105083156e-06
Gc12_228 0 n24 ns228 0 -1.09654084041e-05
Gc12_229 0 n24 ns229 0 -0.00116634209454
Gc12_230 0 n24 ns230 0 0.00223782397937
Gc12_231 0 n24 ns231 0 -0.00479797970813
Gc12_232 0 n24 ns232 0 -6.1025820749e-05
Gc12_233 0 n24 ns233 0 -0.000252948762003
Gc12_234 0 n24 ns234 0 0.000117634037559
Gc12_235 0 n24 ns235 0 -0.000337540788421
Gc12_236 0 n24 ns236 0 -1.85069308645e-05
Gc12_237 0 n24 ns237 0 1.5082170718e-05
Gc12_238 0 n24 ns238 0 -0.000974079859657
Gc12_239 0 n24 ns239 0 0.00149856067918
Gc12_240 0 n24 ns240 0 -7.08666001602e-05
Gc12_241 0 n24 ns241 0 -0.000355562106441
Gc12_242 0 n24 ns242 0 -3.29998921447e-05
Gc12_243 0 n24 ns243 0 -0.000315953649493
Gc12_244 0 n24 ns244 0 -0.000446883977663
Gc12_245 0 n24 ns245 0 0.00175702637553
Gc12_246 0 n24 ns246 0 0.000125033156151
Gc12_247 0 n24 ns247 0 -0.000176375258208
Gc12_248 0 n24 ns248 0 0.000321760037264
Gc12_249 0 n24 ns249 0 -0.00010022087736
Gc12_250 0 n24 ns250 0 0.00202324307048
Gc12_251 0 n24 ns251 0 0.00284718140146
Gc12_252 0 n24 ns252 0 0.000500581306736
Gc12_253 0 n24 ns253 0 0.000248615744477
Gc12_254 0 n24 ns254 0 -0.000124947528247
Gc12_255 0 n24 ns255 0 -0.00105044724967
Gc12_256 0 n24 ns256 0 0.00365341754782
Gc12_257 0 n24 ns257 0 0.000804241601941
Gc12_258 0 n24 ns258 0 -0.0013420279106
Gc12_259 0 n24 ns259 0 0.000872287099329
Gc12_260 0 n24 ns260 0 0.00104769271125
Gc12_261 0 n24 ns261 0 -0.000530832564432
Gc12_262 0 n24 ns262 0 0.0453491688272
Gc12_263 0 n24 ns263 0 -0.0410514550489
Gc12_264 0 n24 ns264 0 0.00210112401728
Gc12_265 0 n24 ns265 0 -5.33296520645e-06
Gc12_266 0 n24 ns266 0 -1.97005238592e-05
Gc12_267 0 n24 ns267 0 -0.000405525028478
Gc12_268 0 n24 ns268 0 0.000850574617599
Gc12_269 0 n24 ns269 0 -0.00122024400559
Gc12_270 0 n24 ns270 0 -8.50763989201e-05
Gc12_271 0 n24 ns271 0 -4.01818041329e-05
Gc12_272 0 n24 ns272 0 -0.000110471528758
Gc12_273 0 n24 ns273 0 -3.43497641375e-05
Gc12_274 0 n24 ns274 0 -3.08331303625e-05
Gc12_275 0 n24 ns275 0 -2.05111604515e-05
Gc12_276 0 n24 ns276 0 -0.00037355607279
Gc12_277 0 n24 ns277 0 0.000921685339272
Gc12_278 0 n24 ns278 0 0.000400992782876
Gc12_279 0 n24 ns279 0 7.21442209738e-05
Gc12_280 0 n24 ns280 0 -0.000121662777242
Gc12_281 0 n24 ns281 0 -0.000320684119976
Gc12_282 0 n24 ns282 0 0.000583916633084
Gc12_283 0 n24 ns283 0 -0.000119424799303
Gc12_284 0 n24 ns284 0 -0.000415154586717
Gc12_285 0 n24 ns285 0 0.000378880868557
Gc12_286 0 n24 ns286 0 0.000226988971392
Gc12_287 0 n24 ns287 0 -9.38352019529e-05
Gc12_288 0 n24 ns288 0 0.00033396479356
Gc12_289 0 n24 ns289 0 0.000169604466203
Gc12_290 0 n24 ns290 0 0.000487802394907
Gc12_291 0 n24 ns291 0 0.00100074391177
Gc12_292 0 n24 ns292 0 -0.000172260433782
Gc12_293 0 n24 ns293 0 -0.000971826124982
Gc12_294 0 n24 ns294 0 -0.000287710427347
Gc12_295 0 n24 ns295 0 -0.000352435368027
Gc12_296 0 n24 ns296 0 5.92303121863e-05
Gc12_297 0 n24 ns297 0 0.00145236803136
Gc12_298 0 n24 ns298 0 0.000634850565003
Gc12_299 0 n24 ns299 0 -0.000674926359374
Gc12_300 0 n24 ns300 0 0.0177804132653
Gc12_301 0 n24 ns301 0 -0.0165354963722
Gc12_302 0 n24 ns302 0 0.000871479381746
Gc12_303 0 n24 ns303 0 -6.37216029175e-06
Gc12_304 0 n24 ns304 0 -1.83646065316e-05
Gc12_305 0 n24 ns305 0 0.000235994649129
Gc12_306 0 n24 ns306 0 -0.000348661595338
Gc12_307 0 n24 ns307 0 0.00264685506812
Gc12_308 0 n24 ns308 0 0.000140871285323
Gc12_309 0 n24 ns309 0 0.000161037820073
Gc12_310 0 n24 ns310 0 0.000112032752413
Gc12_311 0 n24 ns311 0 4.5711166687e-05
Gc12_312 0 n24 ns312 0 2.2840076858e-05
Gc12_313 0 n24 ns313 0 2.17983006401e-05
Gc12_314 0 n24 ns314 0 -0.00079030485076
Gc12_315 0 n24 ns315 0 -0.00101325838137
Gc12_316 0 n24 ns316 0 0.000765830282211
Gc12_317 0 n24 ns317 0 0.000296906303523
Gc12_318 0 n24 ns318 0 -8.4120924678e-05
Gc12_319 0 n24 ns319 0 -0.000208523915321
Gc12_320 0 n24 ns320 0 -0.000916109990017
Gc12_321 0 n24 ns321 0 -0.00152397779823
Gc12_322 0 n24 ns322 0 -0.000291361455092
Gc12_323 0 n24 ns323 0 0.00109655232125
Gc12_324 0 n24 ns324 0 0.000226419327791
Gc12_325 0 n24 ns325 0 -8.6027055327e-06
Gc12_326 0 n24 ns326 0 -0.0017939016579
Gc12_327 0 n24 ns327 0 0.000481516623896
Gc12_328 0 n24 ns328 0 0.000842689387849
Gc12_329 0 n24 ns329 0 0.00104610112948
Gc12_330 0 n24 ns330 0 -0.000237490877593
Gc12_331 0 n24 ns331 0 -0.00081258431867
Gc12_332 0 n24 ns332 0 -0.00219848404401
Gc12_333 0 n24 ns333 0 0.000717371351372
Gc12_334 0 n24 ns334 0 0.000769711377518
Gc12_335 0 n24 ns335 0 0.00105876309004
Gc12_336 0 n24 ns336 0 0.000353642434341
Gc12_337 0 n24 ns337 0 -0.000606544400987
Gc12_338 0 n24 ns338 0 0.00530450315891
Gc12_339 0 n24 ns339 0 -0.00582033103818
Gc12_340 0 n24 ns340 0 0.00042044386097
Gc12_341 0 n24 ns341 0 -7.94987389782e-06
Gc12_342 0 n24 ns342 0 -1.75300000927e-05
Gc12_343 0 n24 ns343 0 -0.00121341076163
Gc12_344 0 n24 ns344 0 0.000735775880061
Gc12_345 0 n24 ns345 0 -0.000232831490133
Gc12_346 0 n24 ns346 0 0.000540516337157
Gc12_347 0 n24 ns347 0 -0.000591494726323
Gc12_348 0 n24 ns348 0 0.000322335381383
Gc12_349 0 n24 ns349 0 -0.000153178562401
Gc12_350 0 n24 ns350 0 -3.80132224674e-05
Gc12_351 0 n24 ns351 0 3.45016255446e-05
Gc12_352 0 n24 ns352 0 -0.00199064110413
Gc12_353 0 n24 ns353 0 -0.000209413530028
Gc12_354 0 n24 ns354 0 0.000407299213816
Gc12_355 0 n24 ns355 0 2.80098853231e-05
Gc12_356 0 n24 ns356 0 0.000202924805199
Gc12_357 0 n24 ns357 0 -0.000484295374739
Gc12_358 0 n24 ns358 0 -0.00149830094155
Gc12_359 0 n24 ns359 0 0.000151849035478
Gc12_360 0 n24 ns360 0 -0.000372717100423
Gc12_361 0 n24 ns361 0 0.000292073357489
Gc12_362 0 n24 ns362 0 0.000470584967716
Gc12_363 0 n24 ns363 0 0.000134248516447
Gc12_364 0 n24 ns364 0 -0.000806062201104
Gc12_365 0 n24 ns365 0 0.00318965759629
Gc12_366 0 n24 ns366 0 0.000403231996241
Gc12_367 0 n24 ns367 0 0.00100846489096
Gc12_368 0 n24 ns368 0 0.000410076778021
Gc12_369 0 n24 ns369 0 -0.00146186621719
Gc12_370 0 n24 ns370 0 0.00151390277019
Gc12_371 0 n24 ns371 0 0.00173651413761
Gc12_372 0 n24 ns372 0 -0.00156724223803
Gc12_373 0 n24 ns373 0 0.000902320923977
Gc12_374 0 n24 ns374 0 0.00147148014625
Gc12_375 0 n24 ns375 0 -0.000421241259776
Gc12_376 0 n24 ns376 0 0.0412614831149
Gc12_377 0 n24 ns377 0 -0.039649130844
Gc12_378 0 n24 ns378 0 0.00263158028102
Gc12_379 0 n24 ns379 0 -1.56518944013e-06
Gc12_380 0 n24 ns380 0 1.29430004689e-05
Gc12_381 0 n24 ns381 0 -0.00187618835097
Gc12_382 0 n24 ns382 0 -0.00222949636586
Gc12_383 0 n24 ns383 0 0.00510055951012
Gc12_384 0 n24 ns384 0 0.000387983866605
Gc12_385 0 n24 ns385 0 -0.000394227655694
Gc12_386 0 n24 ns386 0 0.000636427645925
Gc12_387 0 n24 ns387 0 0.000447228322041
Gc12_388 0 n24 ns388 0 -0.000156248326798
Gc12_389 0 n24 ns389 0 -9.53278043418e-05
Gc12_390 0 n24 ns390 0 -0.00174485859206
Gc12_391 0 n24 ns391 0 -0.000405703779622
Gc12_392 0 n24 ns392 0 0.00129868208013
Gc12_393 0 n24 ns393 0 3.47501444884e-05
Gc12_394 0 n24 ns394 0 0.000347520375925
Gc12_395 0 n24 ns395 0 -0.000570552429242
Gc12_396 0 n24 ns396 0 -0.000114855075358
Gc12_397 0 n24 ns397 0 -0.00223235843961
Gc12_398 0 n24 ns398 0 -0.000457905483431
Gc12_399 0 n24 ns399 0 0.000268587706209
Gc12_400 0 n24 ns400 0 0.000429460079764
Gc12_401 0 n24 ns401 0 0.000246356929744
Gc12_402 0 n24 ns402 0 -0.00420482998396
Gc12_403 0 n24 ns403 0 -0.000857511484933
Gc12_404 0 n24 ns404 0 0.000875712363374
Gc12_405 0 n24 ns405 0 0.00165287351643
Gc12_406 0 n24 ns406 0 0.000856682036664
Gc12_407 0 n24 ns407 0 -0.00169948948814
Gc12_408 0 n24 ns408 0 -0.00575301308923
Gc12_409 0 n24 ns409 0 -0.00117463873861
Gc12_410 0 n24 ns410 0 -0.00118836184258
Gc12_411 0 n24 ns411 0 0.000883373241235
Gc12_412 0 n24 ns412 0 0.00246202710469
Gc12_413 0 n24 ns413 0 0.00023952280659
Gc12_414 0 n24 ns414 0 0.0189678659363
Gc12_415 0 n24 ns415 0 -0.0269548212862
Gc12_416 0 n24 ns416 0 0.00544400523511
Gc12_417 0 n24 ns417 0 2.6870711814e-06
Gc12_418 0 n24 ns418 0 1.63290709579e-05
Gc12_419 0 n24 ns419 0 -0.00371697166991
Gc12_420 0 n24 ns420 0 -0.000579444762419
Gc12_421 0 n24 ns421 0 -0.00206314670872
Gc12_422 0 n24 ns422 0 0.000436373121874
Gc12_423 0 n24 ns423 0 -0.000380936400038
Gc12_424 0 n24 ns424 0 0.00035646322691
Gc12_425 0 n24 ns425 0 -0.000220124215156
Gc12_426 0 n24 ns426 0 -0.000219296504774
Gc12_427 0 n24 ns427 0 -8.87935692934e-05
Gc12_428 0 n24 ns428 0 -0.0039050129726
Gc12_429 0 n24 ns429 0 0.00215519327913
Gc12_430 0 n24 ns430 0 0.00144749050273
Gc12_431 0 n24 ns431 0 -0.00037645896664
Gc12_432 0 n24 ns432 0 0.000359053929891
Gc12_433 0 n24 ns433 0 -0.00059296690169
Gc12_434 0 n24 ns434 0 1.9568880977e-06
Gc12_435 0 n24 ns435 0 0.00143587563837
Gc12_436 0 n24 ns436 0 0.000619823098463
Gc12_437 0 n24 ns437 0 0.000315118120283
Gc12_438 0 n24 ns438 0 0.000583927297272
Gc12_439 0 n24 ns439 0 0.000162363921253
Gc12_440 0 n24 ns440 0 0.000991497698653
Gc12_441 0 n24 ns441 0 0.000958310952672
Gc12_442 0 n24 ns442 0 0.00149295968849
Gc12_443 0 n24 ns443 0 0.0027349176983
Gc12_444 0 n24 ns444 0 0.00118649110371
Gc12_445 0 n24 ns445 0 -0.00218591166279
Gc12_446 0 n24 ns446 0 -0.000119309141299
Gc12_447 0 n24 ns447 0 -0.00280623721216
Gc12_448 0 n24 ns448 0 0.00206522997701
Gc12_449 0 n24 ns449 0 0.00180359366973
Gc12_450 0 n24 ns450 0 0.00319988481428
Gc12_451 0 n24 ns451 0 2.26108469813e-05
Gc12_452 0 n24 ns452 0 -0.0205686641917
Gc12_453 0 n24 ns453 0 0.0208090842176
Gc12_454 0 n24 ns454 0 0.00702181179565
Gc12_455 0 n24 ns455 0 1.05887606365e-05
Gc12_456 0 n24 ns456 0 6.57794160821e-06
Gc12_457 0 n24 ns457 0 -0.00232952294687
Gc12_458 0 n24 ns458 0 -0.00126018367897
Gc12_459 0 n24 ns459 0 0.00147469752234
Gc12_460 0 n24 ns460 0 0.000130732218808
Gc12_461 0 n24 ns461 0 -0.000398565526635
Gc12_462 0 n24 ns462 0 0.000473367172668
Gc12_463 0 n24 ns463 0 0.000499506780685
Gc12_464 0 n24 ns464 0 -0.000155935065833
Gc12_465 0 n24 ns465 0 -5.73239378058e-05
Gc12_466 0 n24 ns466 0 -0.000489424080261
Gc12_467 0 n24 ns467 0 0.000308912739314
Gc12_468 0 n24 ns468 0 0.00073612942328
Gc12_469 0 n24 ns469 0 -0.000109521214177
Gc12_470 0 n24 ns470 0 0.000308638565768
Gc12_471 0 n24 ns471 0 -0.000430368489651
Gc12_472 0 n24 ns472 0 0.000457370179118
Gc12_473 0 n24 ns473 0 -0.00164653957284
Gc12_474 0 n24 ns474 0 -0.000302894145918
Gc12_475 0 n24 ns475 0 -0.000130942267903
Gc12_476 0 n24 ns476 0 0.000345585267209
Gc12_477 0 n24 ns477 0 0.000190318267858
Gc12_478 0 n24 ns478 0 -0.0029852954094
Gc12_479 0 n24 ns479 0 -0.000805007030949
Gc12_480 0 n24 ns480 0 0.000905934141679
Gc12_481 0 n24 ns481 0 0.00112766151638
Gc12_482 0 n24 ns482 0 0.000663369531965
Gc12_483 0 n24 ns483 0 -0.00147026826477
Gc12_484 0 n24 ns484 0 -0.00418625830226
Gc12_485 0 n24 ns485 0 -0.000914574919143
Gc12_486 0 n24 ns486 0 -0.0012189054981
Gc12_487 0 n24 ns487 0 0.000491086618086
Gc12_488 0 n24 ns488 0 0.00230367105097
Gc12_489 0 n24 ns489 0 0.000235212568911
Gc12_490 0 n24 ns490 0 0.0295902977544
Gc12_491 0 n24 ns491 0 -0.0355884889446
Gc12_492 0 n24 ns492 0 0.00567666976357
Gc12_493 0 n24 ns493 0 1.12498566771e-06
Gc12_494 0 n24 ns494 0 -2.72878602094e-06
Gc12_495 0 n24 ns495 0 -0.00147200154137
Gc12_496 0 n24 ns496 0 0.00114166109871
Gc12_497 0 n24 ns497 0 -0.00346029193086
Gc12_498 0 n24 ns498 0 0.000311815251067
Gc12_499 0 n24 ns499 0 -0.000590163029331
Gc12_500 0 n24 ns500 0 0.000273282915438
Gc12_501 0 n24 ns501 0 -0.00018138314538
Gc12_502 0 n24 ns502 0 -4.51643032678e-05
Gc12_503 0 n24 ns503 0 3.72932040213e-05
Gc12_504 0 n24 ns504 0 -0.00140858606317
Gc12_505 0 n24 ns505 0 0.00102287127094
Gc12_506 0 n24 ns506 0 0.000105025775892
Gc12_507 0 n24 ns507 0 -0.000509988127823
Gc12_508 0 n24 ns508 0 4.96295751099e-05
Gc12_509 0 n24 ns509 0 -0.000369243064261
Gc12_510 0 n24 ns510 0 -0.00140961101596
Gc12_511 0 n24 ns511 0 0.00123445921558
Gc12_512 0 n24 ns512 0 0.000209695165193
Gc12_513 0 n24 ns513 0 -3.25008136515e-05
Gc12_514 0 n24 ns514 0 0.000400445750369
Gc12_515 0 n24 ns515 0 -2.80822595406e-05
Gc12_516 0 n24 ns516 0 0.00084158426799
Gc12_517 0 n24 ns517 0 0.00384928855437
Gc12_518 0 n24 ns518 0 0.00078507180493
Gc12_519 0 n24 ns519 0 0.000207121743438
Gc12_520 0 n24 ns520 0 -5.9116211621e-05
Gc12_521 0 n24 ns521 0 -0.00120353186768
Gc12_522 0 n24 ns522 0 0.00358463573304
Gc12_523 0 n24 ns523 0 0.00212749425026
Gc12_524 0 n24 ns524 0 -0.0015857381124
Gc12_525 0 n24 ns525 0 0.000420143064223
Gc12_526 0 n24 ns526 0 0.00125882054939
Gc12_527 0 n24 ns527 0 -0.00044144723307
Gc12_528 0 n24 ns528 0 0.0540121151155
Gc12_529 0 n24 ns529 0 -0.0499607340186
Gc12_530 0 n24 ns530 0 0.00288977863092
Gc12_531 0 n24 ns531 0 -2.98804079289e-06
Gc12_532 0 n24 ns532 0 -1.81851767102e-05
Gc12_533 0 n24 ns533 0 -0.000780687908027
Gc12_534 0 n24 ns534 0 0.00174148964636
Gc12_535 0 n24 ns535 0 -0.00352312797009
Gc12_536 0 n24 ns536 0 -0.000250823306849
Gc12_537 0 n24 ns537 0 -0.000134577955633
Gc12_538 0 n24 ns538 0 -0.000179671219279
Gc12_539 0 n24 ns539 0 -0.000146149711059
Gc12_540 0 n24 ns540 0 -2.50117336953e-05
Gc12_541 0 n24 ns541 0 -1.42884572997e-05
Gc12_542 0 n24 ns542 0 -6.70637012677e-05
Gc12_543 0 n24 ns543 0 0.00182904910165
Gc12_544 0 n24 ns544 0 3.47690773878e-06
Gc12_545 0 n24 ns545 0 -0.000133624384829
Gc12_546 0 n24 ns546 0 -0.000123408949928
Gc12_547 0 n24 ns547 0 -0.000313209740436
Gc12_548 0 n24 ns548 0 0.000997954893431
Gc12_549 0 n24 ns549 0 0.000883454307042
Gc12_550 0 n24 ns550 0 -0.000333892892837
Gc12_551 0 n24 ns551 0 -9.2927736175e-05
Gc12_552 0 n24 ns552 0 0.000221964018649
Gc12_553 0 n24 ns553 0 -0.000127143653292
Gc12_554 0 n24 ns554 0 0.00156348215217
Gc12_555 0 n24 ns555 0 0.000515408456976
Gc12_556 0 n24 ns556 0 0.000300829506086
Gc12_557 0 n24 ns557 0 0.000755100472526
Gc12_558 0 n24 ns558 0 -0.000133323941465
Gc12_559 0 n24 ns559 0 -0.000977989960623
Gc12_560 0 n24 ns560 0 0.00119829729714
Gc12_561 0 n24 ns561 0 -0.000520948979599
Gc12_562 0 n24 ns562 0 -0.000423787692525
Gc12_563 0 n24 ns563 0 0.00143921084417
Gc12_564 0 n24 ns564 0 0.000779880338023
Gc12_565 0 n24 ns565 0 -0.000666744613834
Gc12_566 0 n24 ns566 0 0.0272742456386
Gc12_567 0 n24 ns567 0 -0.0247129930403
Gc12_568 0 n24 ns568 0 0.00122744880552
Gc12_569 0 n24 ns569 0 -6.96833544969e-06
Gc12_570 0 n24 ns570 0 -1.90790265505e-05
Gc12_571 0 n24 ns571 0 0.000109850291374
Gc12_572 0 n24 ns572 0 -0.000745412293928
Gc12_573 0 n24 ns573 0 0.00268549760486
Gc12_574 0 n24 ns574 0 0.000117418397812
Gc12_575 0 n24 ns575 0 9.74160579009e-06
Gc12_576 0 n24 ns576 0 -7.42936511209e-07
Gc12_577 0 n24 ns577 0 9.52948832074e-05
Gc12_578 0 n24 ns578 0 1.73345494147e-05
Gc12_579 0 n24 ns579 0 1.24883312478e-05
Gc12_580 0 n24 ns580 0 -0.000682874840237
Gc12_581 0 n24 ns581 0 -0.000634482712335
Gc12_582 0 n24 ns582 0 0.000739988512755
Gc12_583 0 n24 ns583 0 0.000335416737011
Gc12_584 0 n24 ns584 0 -9.14583706498e-05
Gc12_585 0 n24 ns585 0 -0.000267866855287
Gc12_586 0 n24 ns586 0 -0.000564194280139
Gc12_587 0 n24 ns587 0 -0.00141726328595
Gc12_588 0 n24 ns588 0 -0.000406589242329
Gc12_589 0 n24 ns589 0 0.00105847333811
Gc12_590 0 n24 ns590 0 0.000256335607239
Gc12_591 0 n24 ns591 0 -2.64040403871e-05
Gc12_592 0 n24 ns592 0 -0.00143869644496
Gc12_593 0 n24 ns593 0 0.000361896849569
Gc12_594 0 n24 ns594 0 0.000828517249947
Gc12_595 0 n24 ns595 0 0.00112013056335
Gc12_596 0 n24 ns596 0 -0.000258139942712
Gc12_597 0 n24 ns597 0 -0.000912723644845
Gc12_598 0 n24 ns598 0 -0.0019589694974
Gc12_599 0 n24 ns599 0 0.000109435273045
Gc12_600 0 n24 ns600 0 0.000498398463582
Gc12_601 0 n24 ns601 0 0.00125380974338
Gc12_602 0 n24 ns602 0 0.000449460097214
Gc12_603 0 n24 ns603 0 -0.000583012347949
Gc12_604 0 n24 ns604 0 0.00441092061921
Gc12_605 0 n24 ns605 0 -0.0051006946654
Gc12_606 0 n24 ns606 0 0.000425707279349
Gc12_607 0 n24 ns607 0 -4.97570588051e-06
Gc12_608 0 n24 ns608 0 -1.83441089289e-05
Gc12_609 0 n24 ns609 0 -4.30224449974e-06
Gc12_610 0 n24 ns610 0 4.13558921592e-05
Gc12_611 0 n24 ns611 0 0.00510887331143
Gc12_612 0 n24 ns612 0 9.76736310503e-05
Gc12_613 0 n24 ns613 0 0.000158629625335
Gc12_614 0 n24 ns614 0 0.000368676540087
Gc12_615 0 n24 ns615 0 0.000128370965731
Gc12_616 0 n24 ns616 0 3.68160730802e-05
Gc12_617 0 n24 ns617 0 -6.14283460904e-06
Gc12_618 0 n24 ns618 0 -0.00138968035534
Gc12_619 0 n24 ns619 0 -0.000904489090298
Gc12_620 0 n24 ns620 0 0.000796664046877
Gc12_621 0 n24 ns621 0 -0.00030303597528
Gc12_622 0 n24 ns622 0 -4.02727272504e-05
Gc12_623 0 n24 ns623 0 0.000158385946964
Gc12_624 0 n24 ns624 0 0.00169864311203
Gc12_625 0 n24 ns625 0 -0.000599044972741
Gc12_626 0 n24 ns626 0 -0.00149451955925
Gc12_627 0 n24 ns627 0 -0.000440402641467
Gc12_628 0 n24 ns628 0 5.92781350975e-05
Gc12_629 0 n24 ns629 0 0.000205965934051
Gc12_630 0 n24 ns630 0 -0.00142958554671
Gc12_631 0 n24 ns631 0 -0.00176465028305
Gc12_632 0 n24 ns632 0 -0.000209032351681
Gc12_633 0 n24 ns633 0 -0.00114343376497
Gc12_634 0 n24 ns634 0 -0.000198403603044
Gc12_635 0 n24 ns635 0 0.00123631123091
Gc12_636 0 n24 ns636 0 -0.00542261886644
Gc12_637 0 n24 ns637 0 -0.00417837896326
Gc12_638 0 n24 ns638 0 -0.000664263027472
Gc12_639 0 n24 ns639 0 0.00318448407202
Gc12_640 0 n24 ns640 0 0.00142518150037
Gc12_641 0 n24 ns641 0 -0.000468075048984
Gc12_642 0 n24 ns642 0 -0.0331561941734
Gc12_643 0 n24 ns643 0 0.0279844319218
Gc12_644 0 n24 ns644 0 -0.00113157354604
Gc12_645 0 n24 ns645 0 -4.55310235622e-06
Gc12_646 0 n24 ns646 0 1.19677546418e-05
Gc12_647 0 n24 ns647 0 0.00038241146472
Gc12_648 0 n24 ns648 0 -0.000907186125306
Gc12_649 0 n24 ns649 0 0.00747724868828
Gc12_650 0 n24 ns650 0 0.000285406978383
Gc12_651 0 n24 ns651 0 -0.000147655300577
Gc12_652 0 n24 ns652 0 8.71348333304e-05
Gc12_653 0 n24 ns653 0 6.63033970521e-05
Gc12_654 0 n24 ns654 0 1.97282121067e-05
Gc12_655 0 n24 ns655 0 2.7854551951e-05
Gc12_656 0 n24 ns656 0 -0.00114697019898
Gc12_657 0 n24 ns657 0 -0.00124575315988
Gc12_658 0 n24 ns658 0 0.000598492357899
Gc12_659 0 n24 ns659 0 -0.000199838861269
Gc12_660 0 n24 ns660 0 -6.94478396031e-05
Gc12_661 0 n24 ns661 0 0.000295467971233
Gc12_662 0 n24 ns662 0 0.00111919909975
Gc12_663 0 n24 ns663 0 -0.000424694890286
Gc12_664 0 n24 ns664 0 -0.0013646097972
Gc12_665 0 n24 ns665 0 -0.000404469356697
Gc12_666 0 n24 ns666 0 0.000157337878616
Gc12_667 0 n24 ns667 0 0.000189960835299
Gc12_668 0 n24 ns668 0 -0.00178153319987
Gc12_669 0 n24 ns669 0 -0.00226658042833
Gc12_670 0 n24 ns670 0 -0.000263111378315
Gc12_671 0 n24 ns671 0 -0.00108438650194
Gc12_672 0 n24 ns672 0 -0.000216339004716
Gc12_673 0 n24 ns673 0 0.00139885217111
Gc12_674 0 n24 ns674 0 -0.00641731872277
Gc12_675 0 n24 ns675 0 -0.00476129474043
Gc12_676 0 n24 ns676 0 -0.00102432496369
Gc12_677 0 n24 ns677 0 0.00361904038889
Gc12_678 0 n24 ns678 0 0.00175872986625
Gc12_679 0 n24 ns679 0 -0.0004704313166
Gc12_680 0 n24 ns680 0 -0.043952720737
Gc12_681 0 n24 ns681 0 0.0374731833598
Gc12_682 0 n24 ns682 0 -0.00158960811719
Gc12_683 0 n24 ns683 0 -8.54083238048e-06
Gc12_684 0 n24 ns684 0 1.02292611496e-05
Gc12_685 0 n24 ns685 0 0.000220793246064
Gc12_686 0 n24 ns686 0 -0.00151144057373
Gc12_687 0 n24 ns687 0 0.0116526534593
Gc12_688 0 n24 ns688 0 0.000160089303439
Gc12_689 0 n24 ns689 0 0.000360454853827
Gc12_690 0 n24 ns690 0 0.000521131765911
Gc12_691 0 n24 ns691 0 -0.000469638256422
Gc12_692 0 n24 ns692 0 -0.000155132627574
Gc12_693 0 n24 ns693 0 -2.66304339195e-05
Gc12_694 0 n24 ns694 0 0.00129152074804
Gc12_695 0 n24 ns695 0 -0.00363566557124
Gc12_696 0 n24 ns696 0 -0.00045667329949
Gc12_697 0 n24 ns697 0 0.000851687064393
Gc12_698 0 n24 ns698 0 -4.73295484837e-05
Gc12_699 0 n24 ns699 0 0.000605768347928
Gc12_700 0 n24 ns700 0 -0.00152362525362
Gc12_701 0 n24 ns701 0 -0.00199198947664
Gc12_702 0 n24 ns702 0 -0.000710787427783
Gc12_703 0 n24 ns703 0 0.000356346181432
Gc12_704 0 n24 ns704 0 0.0004182949614
Gc12_705 0 n24 ns705 0 0.000241292132117
Gc12_706 0 n24 ns706 0 -0.00177867614493
Gc12_707 0 n24 ns707 0 -0.00566206557236
Gc12_708 0 n24 ns708 0 -0.00202270902759
Gc12_709 0 n24 ns709 0 -0.000271283266781
Gc12_710 0 n24 ns710 0 0.000344017002133
Gc12_711 0 n24 ns711 0 0.00185581440418
Gc12_712 0 n24 ns712 0 -0.0106932018535
Gc12_713 0 n24 ns713 0 -0.00615912562053
Gc12_714 0 n24 ns714 0 -0.0018777147902
Gc12_715 0 n24 ns715 0 0.00382921213348
Gc12_716 0 n24 ns716 0 0.00270029994906
Gc12_717 0 n24 ns717 0 -9.43854647068e-05
Gc12_718 0 n24 ns718 0 -0.0862513322859
Gc12_719 0 n24 ns719 0 0.0764792755887
Gc12_720 0 n24 ns720 0 -0.0041791929732
Gc12_721 0 n24 ns721 0 -9.55346627991e-06
Gc12_722 0 n24 ns722 0 1.24447748687e-05
Gc12_723 0 n24 ns723 0 -0.00256780227107
Gc12_724 0 n24 ns724 0 -0.00296336952509
Gc12_725 0 n24 ns725 0 0.00738952535376
Gc12_726 0 n24 ns726 0 0.00098605796963
Gc12_727 0 n24 ns727 0 -0.00171902583936
Gc12_728 0 n24 ns728 0 0.000637930618937
Gc12_729 0 n24 ns729 0 0.00198997430384
Gc12_730 0 n24 ns730 0 3.42386017033e-05
Gc12_731 0 n24 ns731 0 -0.000211424544655
Gc12_732 0 n24 ns732 0 0.000930377258345
Gc12_733 0 n24 ns733 0 -0.001576709454
Gc12_734 0 n24 ns734 0 -0.00108751413617
Gc12_735 0 n24 ns735 0 0.000722639555299
Gc12_736 0 n24 ns736 0 -0.000135508483655
Gc12_737 0 n24 ns737 0 0.000546537309497
Gc12_738 0 n24 ns738 0 0.00127109780425
Gc12_739 0 n24 ns739 0 -0.00283949908245
Gc12_740 0 n24 ns740 0 -0.000617916532058
Gc12_741 0 n24 ns741 0 -0.000134378290311
Gc12_742 0 n24 ns742 0 0.000278843586052
Gc12_743 0 n24 ns743 0 0.000233917907254
Gc12_744 0 n24 ns744 0 0.0021545132017
Gc12_745 0 n24 ns745 0 -0.00232496541589
Gc12_746 0 n24 ns746 0 -0.00262150441715
Gc12_747 0 n24 ns747 0 -0.00183564104238
Gc12_748 0 n24 ns748 0 -0.000318370809429
Gc12_749 0 n24 ns749 0 0.00237808055698
Gc12_750 0 n24 ns750 0 -0.0119217817174
Gc12_751 0 n24 ns751 0 -0.00484723070154
Gc12_752 0 n24 ns752 0 0.000289911737111
Gc12_753 0 n24 ns753 0 0.00245001792211
Gc12_754 0 n24 ns754 0 0.00314174178099
Gc12_755 0 n24 ns755 0 0.000207156444554
Gc12_756 0 n24 ns756 0 -0.036742430929
Gc12_757 0 n24 ns757 0 0.0384506713805
Gc12_758 0 n24 ns758 0 -0.00706898942121
Gc12_759 0 n24 ns759 0 -9.87468129733e-06
Gc12_760 0 n24 ns760 0 8.5029174308e-06
Gc12_761 0 n24 ns761 0 -0.00536647781635
Gc12_762 0 n24 ns762 0 -0.00436927675989
Gc12_763 0 n24 ns763 0 0.00722447941249
Gc12_764 0 n24 ns764 0 0.00220189283157
Gc12_765 0 n24 ns765 0 -0.00188792730996
Gc12_766 0 n24 ns766 0 0.000821476896455
Gc12_767 0 n24 ns767 0 0.00299178721026
Gc12_768 0 n24 ns768 0 2.7844764198e-05
Gc12_769 0 n24 ns769 0 -0.00032296389441
Gc12_770 0 n24 ns770 0 -0.00120432477494
Gc12_771 0 n24 ns771 0 -0.0018200119103
Gc12_772 0 n24 ns772 0 -0.000595900668593
Gc12_773 0 n24 ns773 0 0.000832340501752
Gc12_774 0 n24 ns774 0 -7.80258693431e-05
Gc12_775 0 n24 ns775 0 0.000460232108513
Gc12_776 0 n24 ns776 0 0.00287542557679
Gc12_777 0 n24 ns777 0 -0.00186856708295
Gc12_778 0 n24 ns778 0 -0.000537530413285
Gc12_779 0 n24 ns779 0 -0.000905203183349
Gc12_780 0 n24 ns780 0 0.000116604789168
Gc12_781 0 n24 ns781 0 9.12056953798e-05
Gc12_782 0 n24 ns782 0 0.00268433075378
Gc12_783 0 n24 ns783 0 0.00119805169551
Gc12_784 0 n24 ns784 0 -0.00126498600024
Gc12_785 0 n24 ns785 0 -0.00246514983648
Gc12_786 0 n24 ns786 0 -0.00103765131656
Gc12_787 0 n24 ns787 0 0.00198014701873
Gc12_788 0 n24 ns788 0 -0.0138033579681
Gc12_789 0 n24 ns789 0 -0.00473160983233
Gc12_790 0 n24 ns790 0 0.00220341847907
Gc12_791 0 n24 ns791 0 0.00349467073417
Gc12_792 0 n24 ns792 0 0.00355913400668
Gc12_793 0 n24 ns793 0 0.000111868961795
Gc12_794 0 n24 ns794 0 0.018491234649
Gc12_795 0 n24 ns795 0 -0.00924040392498
Gc12_796 0 n24 ns796 0 -0.00760207017213
Gc12_797 0 n24 ns797 0 -1.14235763798e-05
Gc12_798 0 n24 ns798 0 -7.80684040534e-06
Gc12_799 0 n24 ns799 0 0.00043970506632
Gc12_800 0 n24 ns800 0 -0.00126567930381
Gc12_801 0 n24 ns801 0 0.00974278752549
Gc12_802 0 n24 ns802 0 -0.000330979920567
Gc12_803 0 n24 ns803 0 0.000171793831597
Gc12_804 0 n24 ns804 0 0.000521538196078
Gc12_805 0 n24 ns805 0 -0.000533967887463
Gc12_806 0 n24 ns806 0 -7.92885879226e-05
Gc12_807 0 n24 ns807 0 2.39385760771e-05
Gc12_808 0 n24 ns808 0 0.00165656437984
Gc12_809 0 n24 ns809 0 -0.00213752473634
Gc12_810 0 n24 ns810 0 -0.000372623038303
Gc12_811 0 n24 ns811 0 0.000592630951153
Gc12_812 0 n24 ns812 0 -0.000146441831162
Gc12_813 0 n24 ns813 0 0.00042187494455
Gc12_814 0 n24 ns814 0 -0.00102254406623
Gc12_815 0 n24 ns815 0 -0.0021713334388
Gc12_816 0 n24 ns816 0 -0.000634024047256
Gc12_817 0 n24 ns817 0 0.000201492697712
Gc12_818 0 n24 ns818 0 0.000304803614242
Gc12_819 0 n24 ns819 0 0.000263142426
Gc12_820 0 n24 ns820 0 -0.000380485023555
Gc12_821 0 n24 ns821 0 -0.00644085136855
Gc12_822 0 n24 ns822 0 -0.00283982167203
Gc12_823 0 n24 ns823 0 -0.000264560637445
Gc12_824 0 n24 ns824 0 0.000529985831784
Gc12_825 0 n24 ns825 0 0.00196022747841
Gc12_826 0 n24 ns826 0 -0.010578546274
Gc12_827 0 n24 ns827 0 -0.00511025711508
Gc12_828 0 n24 ns828 0 -0.00175515254112
Gc12_829 0 n24 ns829 0 0.00276733537122
Gc12_830 0 n24 ns830 0 0.00264817262974
Gc12_831 0 n24 ns831 0 0.000128953108681
Gc12_832 0 n24 ns832 0 -0.0875476134606
Gc12_833 0 n24 ns833 0 0.0798578197073
Gc12_834 0 n24 ns834 0 -0.00515063521831
Gc12_835 0 n24 ns835 0 -8.34256256889e-06
Gc12_836 0 n24 ns836 0 -1.74111519796e-05
Gc12_837 0 n24 ns837 0 0.000717755302176
Gc12_838 0 n24 ns838 0 -0.00168985757074
Gc12_839 0 n24 ns839 0 0.00918055664233
Gc12_840 0 n24 ns840 0 0.000224729938178
Gc12_841 0 n24 ns841 0 0.000266788554489
Gc12_842 0 n24 ns842 0 0.000151069089818
Gc12_843 0 n24 ns843 0 0.000151034263868
Gc12_844 0 n24 ns844 0 -1.12795379883e-05
Gc12_845 0 n24 ns845 0 5.57866450417e-06
Gc12_846 0 n24 ns846 0 -0.000474280614159
Gc12_847 0 n24 ns847 0 -0.00336384853165
Gc12_848 0 n24 ns848 0 0.00025159810988
Gc12_849 0 n24 ns849 0 0.000822507483587
Gc12_850 0 n24 ns850 0 0.000192633604598
Gc12_851 0 n24 ns851 0 0.000380922453787
Gc12_852 0 n24 ns852 0 -0.000188790544186
Gc12_853 0 n24 ns853 0 -7.64573553949e-05
Gc12_854 0 n24 ns854 0 -0.000519454197879
Gc12_855 0 n24 ns855 0 -0.000232443360382
Gc12_856 0 n24 ns856 0 0.000184072080712
Gc12_857 0 n24 ns857 0 -1.22732812586e-05
Gc12_858 0 n24 ns858 0 -0.00204999781266
Gc12_859 0 n24 ns859 0 -0.00370916211912
Gc12_860 0 n24 ns860 0 -0.00106156820521
Gc12_861 0 n24 ns861 0 -0.000383492270457
Gc12_862 0 n24 ns862 0 0.00031870148571
Gc12_863 0 n24 ns863 0 0.00134222174386
Gc12_864 0 n24 ns864 0 -0.00742663647753
Gc12_865 0 n24 ns865 0 -0.00478773464336
Gc12_866 0 n24 ns866 0 -0.00115855183884
Gc12_867 0 n24 ns867 0 0.00373472390034
Gc12_868 0 n24 ns868 0 0.00192781805236
Gc12_869 0 n24 ns869 0 -0.000461872210505
Gc12_870 0 n24 ns870 0 -0.0532477507415
Gc12_871 0 n24 ns871 0 0.0457473143808
Gc12_872 0 n24 ns872 0 -0.00199396286981
Gc12_873 0 n24 ns873 0 -8.46251943925e-06
Gc12_874 0 n24 ns874 0 -2.36634801321e-05
Gc12_875 0 n24 ns875 0 0.000246944273076
Gc12_876 0 n24 ns876 0 -0.00037183330973
Gc12_877 0 n24 ns877 0 0.00433242928113
Gc12_878 0 n24 ns878 0 -0.00022982844642
Gc12_879 0 n24 ns879 0 0.000438014697858
Gc12_880 0 n24 ns880 0 0.000380634573159
Gc12_881 0 n24 ns881 0 8.11206677206e-05
Gc12_882 0 n24 ns882 0 2.33889457565e-05
Gc12_883 0 n24 ns883 0 -1.75235551207e-05
Gc12_884 0 n24 ns884 0 0.000268151964984
Gc12_885 0 n24 ns885 0 -0.00135140540077
Gc12_886 0 n24 ns886 0 -0.000248569611476
Gc12_887 0 n24 ns887 0 0.00014658518721
Gc12_888 0 n24 ns888 0 0.0002128808786
Gc12_889 0 n24 ns889 0 0.000296380646368
Gc12_890 0 n24 ns890 0 0.000625501404269
Gc12_891 0 n24 ns891 0 -0.00125360313024
Gc12_892 0 n24 ns892 0 -0.000871092485059
Gc12_893 0 n24 ns893 0 0.000428878521921
Gc12_894 0 n24 ns894 0 0.000145403374113
Gc12_895 0 n24 ns895 0 4.34779442518e-06
Gc12_896 0 n24 ns896 0 -0.000471499070548
Gc12_897 0 n24 ns897 0 -0.00193302202087
Gc12_898 0 n24 ns898 0 -0.00125780012187
Gc12_899 0 n24 ns899 0 -0.00120048570075
Gc12_900 0 n24 ns900 0 0.000407841042341
Gc12_901 0 n24 ns901 0 0.00136906588292
Gc12_902 0 n24 ns902 0 -0.00552039380727
Gc12_903 0 n24 ns903 0 -0.00326384529029
Gc12_904 0 n24 ns904 0 0.000140920075604
Gc12_905 0 n24 ns905 0 0.0029043511155
Gc12_906 0 n24 ns906 0 0.00108040319172
Gc12_907 0 n24 ns907 0 -0.000654455453484
Gc12_908 0 n24 ns908 0 -0.0250798394159
Gc12_909 0 n24 ns909 0 0.0208713611336
Gc12_910 0 n24 ns910 0 -0.000794749714435
Gc12_911 0 n24 ns911 0 -1.70096527244e-06
Gc12_912 0 n24 ns912 0 -1.77706491011e-05
Gc12_913 0 n24 ns913 0 0.000216216381155
Gc12_914 0 n24 ns914 0 -0.000747297987297
Gc12_915 0 n24 ns915 0 0.00383250761586
Gc12_916 0 n24 ns916 0 0.000203956688659
Gc12_917 0 n24 ns917 0 0.000165947144695
Gc12_918 0 n24 ns918 0 0.000124305670759
Gc12_919 0 n24 ns919 0 -0.000187468515276
Gc12_920 0 n24 ns920 0 -5.40363348943e-05
Gc12_921 0 n24 ns921 0 -4.33060286963e-05
Gc12_922 0 n24 ns922 0 0.000825688226469
Gc12_923 0 n24 ns923 0 -0.000798620672797
Gc12_924 0 n24 ns924 0 -0.000760714670891
Gc12_925 0 n24 ns925 0 3.27986522377e-05
Gc12_926 0 n24 ns926 0 0.000144188113791
Gc12_927 0 n24 ns927 0 0.000280093987452
Gc12_928 0 n24 ns928 0 -0.000697549014226
Gc12_929 0 n24 ns929 0 -0.00168294114242
Gc12_930 0 n24 ns930 0 -0.000356929978913
Gc12_931 0 n24 ns931 0 0.00105273349658
Gc12_932 0 n24 ns932 0 0.0002196516615
Gc12_933 0 n24 ns933 0 -3.33925567494e-06
Gc12_934 0 n24 ns934 0 -0.000389999554384
Gc12_935 0 n24 ns935 0 -0.00103951223899
Gc12_936 0 n24 ns936 0 -0.00124253140126
Gc12_937 0 n24 ns937 0 -0.000622414575642
Gc12_938 0 n24 ns938 0 0.00056568949673
Gc12_939 0 n24 ns939 0 0.000844850875204
Gc12_940 0 n24 ns940 0 -0.00436163784855
Gc12_941 0 n24 ns941 0 -0.00113697235087
Gc12_942 0 n24 ns942 0 0.00069972006004
Gc12_943 0 n24 ns943 0 0.00176135695491
Gc12_944 0 n24 ns944 0 0.000570989598398
Gc12_945 0 n24 ns945 0 -0.000561908648423
Gc12_946 0 n24 ns946 0 -0.0120300532432
Gc12_947 0 n24 ns947 0 0.00945442373618
Gc12_948 0 n24 ns948 0 -0.00031313475569
Gc12_949 0 n24 ns949 0 6.47863329269e-06
Gc12_950 0 n24 ns950 0 -1.50498044378e-05
Gc12_951 0 n24 ns951 0 0.000702370270587
Gc12_952 0 n24 ns952 0 -0.00100135972725
Gc12_953 0 n24 ns953 0 0.0115855950091
Gc12_954 0 n24 ns954 0 0.000324356323163
Gc12_955 0 n24 ns955 0 0.00058885226544
Gc12_956 0 n24 ns956 0 0.000424072014758
Gc12_957 0 n24 ns957 0 -0.000310507350763
Gc12_958 0 n24 ns958 0 -0.000122247404086
Gc12_959 0 n24 ns959 0 -3.4699673411e-05
Gc12_960 0 n24 ns960 0 3.14301705735e-05
Gc12_961 0 n24 ns961 0 -0.00373351308659
Gc12_962 0 n24 ns962 0 8.73656094854e-05
Gc12_963 0 n24 ns963 0 0.000616261531609
Gc12_964 0 n24 ns964 0 2.63047654851e-06
Gc12_965 0 n24 ns965 0 0.000516409274019
Gc12_966 0 n24 ns966 0 -0.000927199260219
Gc12_967 0 n24 ns967 0 -0.00138665128074
Gc12_968 0 n24 ns968 0 -0.000947437967796
Gc12_969 0 n24 ns969 0 0.000185279001943
Gc12_970 0 n24 ns970 0 0.000358036339568
Gc12_971 0 n24 ns971 0 0.000222201215242
Gc12_972 0 n24 ns972 0 -0.00263813592671
Gc12_973 0 n24 ns973 0 -0.00468419114714
Gc12_974 0 n24 ns974 0 -0.0012828497125
Gc12_975 0 n24 ns975 0 -0.000298465618702
Gc12_976 0 n24 ns976 0 0.000221931355462
Gc12_977 0 n24 ns977 0 0.00158935635728
Gc12_978 0 n24 ns978 0 -0.00972679902057
Gc12_979 0 n24 ns979 0 -0.00623290580801
Gc12_980 0 n24 ns980 0 -0.00177976254132
Gc12_981 0 n24 ns981 0 0.00421308349315
Gc12_982 0 n24 ns982 0 0.00246007370383
Gc12_983 0 n24 ns983 0 -0.000248177586639
Gc12_984 0 n24 ns984 0 -0.0780303499082
Gc12_985 0 n24 ns985 0 0.0677827496749
Gc12_986 0 n24 ns986 0 -0.00313516981713
Gc12_987 0 n24 ns987 0 -1.02743748176e-05
Gc12_988 0 n24 ns988 0 1.16603060001e-05
Gc12_989 0 n24 ns989 0 -0.000320512976985
Gc12_990 0 n24 ns990 0 -0.000425629367579
Gc12_991 0 n24 ns991 0 0.0069817565822
Gc12_992 0 n24 ns992 0 -0.00111243398716
Gc12_993 0 n24 ns993 0 -0.000483937280355
Gc12_994 0 n24 ns994 0 0.00180029877061
Gc12_995 0 n24 ns995 0 0.000463033992538
Gc12_996 0 n24 ns996 0 -0.000184127736962
Gc12_997 0 n24 ns997 0 -0.000171990281526
Gc12_998 0 n24 ns998 0 0.00219752412305
Gc12_999 0 n24 ns999 0 -0.00268146243889
Gc12_1000 0 n24 ns1000 0 -0.000846431032272
Gc12_1001 0 n24 ns1001 0 0.000991109036434
Gc12_1002 0 n24 ns1002 0 -6.40912584457e-05
Gc12_1003 0 n24 ns1003 0 0.0005706681063
Gc12_1004 0 n24 ns1004 0 -0.000542282641514
Gc12_1005 0 n24 ns1005 0 -0.00371541173753
Gc12_1006 0 n24 ns1006 0 -0.000987636143294
Gc12_1007 0 n24 ns1007 0 0.000439064936487
Gc12_1008 0 n24 ns1008 0 0.0003465837521
Gc12_1009 0 n24 ns1009 0 0.000372909314208
Gc12_1010 0 n24 ns1010 0 0.000891748054876
Gc12_1011 0 n24 ns1011 0 -0.00548447375254
Gc12_1012 0 n24 ns1012 0 -0.00299413451893
Gc12_1013 0 n24 ns1013 0 -0.0010742952084
Gc12_1014 0 n24 ns1014 0 0.000185452559894
Gc12_1015 0 n24 ns1015 0 0.00231679180198
Gc12_1016 0 n24 ns1016 0 -0.0130195260445
Gc12_1017 0 n24 ns1017 0 -0.00589785273392
Gc12_1018 0 n24 ns1018 0 -0.000950181347718
Gc12_1019 0 n24 ns1019 0 0.00316613082375
Gc12_1020 0 n24 ns1020 0 0.00313423705676
Gc12_1021 0 n24 ns1021 0 0.000264357768145
Gc12_1022 0 n24 ns1022 0 -0.0734662934519
Gc12_1023 0 n24 ns1023 0 0.0692578896325
Gc12_1024 0 n24 ns1024 0 -0.00651684144652
Gc12_1025 0 n24 ns1025 0 -9.89116224416e-06
Gc12_1026 0 n24 ns1026 0 1.56067789422e-05
Gc12_1027 0 n24 ns1027 0 -0.0170957212437
Gc12_1028 0 n24 ns1028 0 -0.00135977204017
Gc12_1029 0 n24 ns1029 0 0.0205039874425
Gc12_1030 0 n24 ns1030 0 0.00626818665722
Gc12_1031 0 n24 ns1031 0 0.0102905756256
Gc12_1032 0 n24 ns1032 0 0.00147654307552
Gc12_1033 0 n24 ns1033 0 -0.00323161965565
Gc12_1034 0 n24 ns1034 0 -0.000492789566431
Gc12_1035 0 n24 ns1035 0 3.25873854057e-05
Gc12_1036 0 n24 ns1036 0 -0.00127811972397
Gc12_1037 0 n24 ns1037 0 -0.0147836725305
Gc12_1038 0 n24 ns1038 0 0.00112955342738
Gc12_1039 0 n24 ns1039 0 0.00217122404107
Gc12_1040 0 n24 ns1040 0 0.000272780626315
Gc12_1041 0 n24 ns1041 0 0.000372648827366
Gc12_1042 0 n24 ns1042 0 0.000260460476726
Gc12_1043 0 n24 ns1043 0 0.000661465924729
Gc12_1044 0 n24 ns1044 0 9.5487367063e-05
Gc12_1045 0 n24 ns1045 0 0.000394331007338
Gc12_1046 0 n24 ns1046 0 0.000490278593712
Gc12_1047 0 n24 ns1047 0 0.000323916789428
Gc12_1048 0 n24 ns1048 0 -0.0117085146968
Gc12_1049 0 n24 ns1049 0 -0.00792273036425
Gc12_1050 0 n24 ns1050 0 -0.00367272183145
Gc12_1051 0 n24 ns1051 0 -0.00123920029681
Gc12_1052 0 n24 ns1052 0 0.000144572417468
Gc12_1053 0 n24 ns1053 0 0.00252450049336
Gc12_1054 0 n24 ns1054 0 0.00834538821721
Gc12_1055 0 n24 ns1055 0 -0.0053949925872
Gc12_1056 0 n24 ns1056 0 0.001902863378
Gc12_1057 0 n24 ns1057 0 0.00182853605372
Gc12_1058 0 n24 ns1058 0 0.00327393725922
Gc12_1059 0 n24 ns1059 0 -2.62932352911e-05
Gc12_1060 0 n24 ns1060 0 -0.107294224676
Gc12_1061 0 n24 ns1061 0 0.0694264855074
Gc12_1062 0 n24 ns1062 0 -0.00878035094437
Gc12_1063 0 n24 ns1063 0 -1.11660645052e-05
Gc12_1064 0 n24 ns1064 0 6.60095744651e-07
Gc12_1065 0 n24 ns1065 0 -0.000155344042784
Gc12_1066 0 n24 ns1066 0 -0.000260505071093
Gc12_1067 0 n24 ns1067 0 0.00599334138509
Gc12_1068 0 n24 ns1068 0 -0.00132388459121
Gc12_1069 0 n24 ns1069 0 -0.000422698326128
Gc12_1070 0 n24 ns1070 0 0.00185844696596
Gc12_1071 0 n24 ns1071 0 0.000523822683847
Gc12_1072 0 n24 ns1072 0 -0.000162129954902
Gc12_1073 0 n24 ns1073 0 -0.000184562423638
Gc12_1074 0 n24 ns1074 0 0.00184686428098
Gc12_1075 0 n24 ns1075 0 -0.00219832287974
Gc12_1076 0 n24 ns1076 0 -0.00052912997949
Gc12_1077 0 n24 ns1077 0 0.000868750792276
Gc12_1078 0 n24 ns1078 0 -0.000129791453932
Gc12_1079 0 n24 ns1079 0 0.000441510017139
Gc12_1080 0 n24 ns1080 0 -0.000186365209358
Gc12_1081 0 n24 ns1081 0 -0.00321353736554
Gc12_1082 0 n24 ns1082 0 -0.000881939615393
Gc12_1083 0 n24 ns1083 0 0.000110273574409
Gc12_1084 0 n24 ns1084 0 0.000263477224461
Gc12_1085 0 n24 ns1085 0 0.000341945432601
Gc12_1086 0 n24 ns1086 0 0.000933004815614
Gc12_1087 0 n24 ns1087 0 -0.00543744455403
Gc12_1088 0 n24 ns1088 0 -0.00290807635908
Gc12_1089 0 n24 ns1089 0 -0.000846427448882
Gc12_1090 0 n24 ns1090 0 0.000216057675583
Gc12_1091 0 n24 ns1091 0 0.00214567705446
Gc12_1092 0 n24 ns1092 0 -0.0122417113322
Gc12_1093 0 n24 ns1093 0 -0.00509246688139
Gc12_1094 0 n24 ns1094 0 -0.000827939890927
Gc12_1095 0 n24 ns1095 0 0.00283693109976
Gc12_1096 0 n24 ns1096 0 0.00301014500353
Gc12_1097 0 n24 ns1097 0 0.000219038927374
Gc12_1098 0 n24 ns1098 0 -0.0660574039627
Gc12_1099 0 n24 ns1099 0 0.0629858090694
Gc12_1100 0 n24 ns1100 0 -0.00630953848234
Gc12_1101 0 n24 ns1101 0 -8.37710706864e-06
Gc12_1102 0 n24 ns1102 0 -6.8713237371e-06
Gc12_1103 0 n24 ns1103 0 0.000920244685219
Gc12_1104 0 n24 ns1104 0 -0.000919758044584
Gc12_1105 0 n24 ns1105 0 0.0103696899622
Gc12_1106 0 n24 ns1106 0 -1.32409745177e-05
Gc12_1107 0 n24 ns1107 0 0.000761580521079
Gc12_1108 0 n24 ns1108 0 0.000456040139369
Gc12_1109 0 n24 ns1109 0 -0.000146777785076
Gc12_1110 0 n24 ns1110 0 -8.93752094295e-05
Gc12_1111 0 n24 ns1111 0 -2.10502272768e-05
Gc12_1112 0 n24 ns1112 0 -9.89368910946e-06
Gc12_1113 0 n24 ns1113 0 -0.00416625572677
Gc12_1114 0 n24 ns1114 0 0.000235165340426
Gc12_1115 0 n24 ns1115 0 0.00106434807361
Gc12_1116 0 n24 ns1116 0 0.000121707623637
Gc12_1117 0 n24 ns1117 0 0.000414041694638
Gc12_1118 0 n24 ns1118 0 -0.000967531566791
Gc12_1119 0 n24 ns1119 0 -0.000585674917464
Gc12_1120 0 n24 ns1120 0 -0.000452372516903
Gc12_1121 0 n24 ns1121 0 -0.000103776557117
Gc12_1122 0 n24 ns1122 0 0.000266504181231
Gc12_1123 0 n24 ns1123 0 7.20581424447e-05
Gc12_1124 0 n24 ns1124 0 -0.00235046288736
Gc12_1125 0 n24 ns1125 0 -0.00499510729313
Gc12_1126 0 n24 ns1126 0 -0.00154773493482
Gc12_1127 0 n24 ns1127 0 8.37483299749e-06
Gc12_1128 0 n24 ns1128 0 0.000463067652927
Gc12_1129 0 n24 ns1129 0 0.0014590891522
Gc12_1130 0 n24 ns1130 0 -0.00902257322189
Gc12_1131 0 n24 ns1131 0 -0.00528482040651
Gc12_1132 0 n24 ns1132 0 -0.00153703301193
Gc12_1133 0 n24 ns1133 0 0.00384532830984
Gc12_1134 0 n24 ns1134 0 0.00229249530734
Gc12_1135 0 n24 ns1135 0 -0.000329251232151
Gc12_1136 0 n24 ns1136 0 -0.0694821383974
Gc12_1137 0 n24 ns1137 0 0.0605248451181
Gc12_1138 0 n24 ns1138 0 -0.00288795738173
Gc12_1139 0 n24 ns1139 0 -8.86551234112e-06
Gc12_1140 0 n24 ns1140 0 -2.16165292496e-05
Gc12_1141 0 n24 ns1141 0 0.000313732506203
Gc12_1142 0 n24 ns1142 0 -0.00064895673934
Gc12_1143 0 n24 ns1143 0 0.00556009530986
Gc12_1144 0 n24 ns1144 0 -5.34058778806e-05
Gc12_1145 0 n24 ns1145 0 0.000378134209709
Gc12_1146 0 n24 ns1146 0 0.000374410525559
Gc12_1147 0 n24 ns1147 0 0.000175143486461
Gc12_1148 0 n24 ns1148 0 2.46818013078e-05
Gc12_1149 0 n24 ns1149 0 -3.46946967077e-06
Gc12_1150 0 n24 ns1150 0 -0.000419469792555
Gc12_1151 0 n24 ns1151 0 -0.00208782561334
Gc12_1152 0 n24 ns1152 0 0.000153702830367
Gc12_1153 0 n24 ns1153 0 0.000359579697379
Gc12_1154 0 n24 ns1154 0 0.000229223711587
Gc12_1155 0 n24 ns1155 0 0.000299361613227
Gc12_1156 0 n24 ns1156 0 0.000761163971165
Gc12_1157 0 n24 ns1157 0 -0.000730603868909
Gc12_1158 0 n24 ns1158 0 -0.00091818015384
Gc12_1159 0 n24 ns1159 0 5.73505655912e-05
Gc12_1160 0 n24 ns1160 0 0.00012883191587
Gc12_1161 0 n24 ns1161 0 2.5463565559e-06
Gc12_1162 0 n24 ns1162 0 -0.00100963025778
Gc12_1163 0 n24 ns1163 0 -0.00245709509624
Gc12_1164 0 n24 ns1164 0 -0.00113867429455
Gc12_1165 0 n24 ns1165 0 -0.00110949163294
Gc12_1166 0 n24 ns1166 0 0.000340079524373
Gc12_1167 0 n24 ns1167 0 0.00145177243176
Gc12_1168 0 n24 ns1168 0 -0.00624098494313
Gc12_1169 0 n24 ns1169 0 -0.00388649837456
Gc12_1170 0 n24 ns1170 0 -0.00018964353662
Gc12_1171 0 n24 ns1171 0 0.00333233186539
Gc12_1172 0 n24 ns1172 0 0.00136289717968
Gc12_1173 0 n24 ns1173 0 -0.000661219078434
Gc12_1174 0 n24 ns1174 0 -0.03263456779
Gc12_1175 0 n24 ns1175 0 0.0274097268342
Gc12_1176 0 n24 ns1176 0 -0.00108151135356
Gc12_1177 0 n24 ns1177 0 -4.68742253313e-06
Gc12_1178 0 n24 ns1178 0 -2.05698694761e-05
Gc12_1179 0 n24 ns1179 0 0.000268590063189
Gc12_1180 0 n24 ns1180 0 -0.000714892141282
Gc12_1181 0 n24 ns1181 0 0.00415381554026
Gc12_1182 0 n24 ns1182 0 6.56716622133e-05
Gc12_1183 0 n24 ns1183 0 0.000215492363202
Gc12_1184 0 n24 ns1184 0 0.000165540128387
Gc12_1185 0 n24 ns1185 0 -0.000111113702665
Gc12_1186 0 n24 ns1186 0 -1.90774914777e-05
Gc12_1187 0 n24 ns1187 0 -3.98470495454e-05
Gc12_1188 0 n24 ns1188 0 0.000905910615656
Gc12_1189 0 n24 ns1189 0 -0.000825353406827
Gc12_1190 0 n24 ns1190 0 -0.000758259153878
Gc12_1191 0 n24 ns1191 0 -1.39103488651e-05
Gc12_1192 0 n24 ns1192 0 0.000160842330685
Gc12_1193 0 n24 ns1193 0 0.000324419159324
Gc12_1194 0 n24 ns1194 0 -0.000306502017926
Gc12_1195 0 n24 ns1195 0 -0.00180078222308
Gc12_1196 0 n24 ns1196 0 -0.000575029722844
Gc12_1197 0 n24 ns1197 0 0.00100665630929
Gc12_1198 0 n24 ns1198 0 0.000222530599168
Gc12_1199 0 n24 ns1199 0 -1.00580131226e-08
Gc12_1200 0 n24 ns1200 0 -0.000336477300014
Gc12_1201 0 n24 ns1201 0 -0.00135302684162
Gc12_1202 0 n24 ns1202 0 -0.00137146324455
Gc12_1203 0 n24 ns1203 0 -0.000880710546026
Gc12_1204 0 n24 ns1204 0 0.000572622533576
Gc12_1205 0 n24 ns1205 0 0.00107416323956
Gc12_1206 0 n24 ns1206 0 -0.0048683655002
Gc12_1207 0 n24 ns1207 0 -0.00202066271344
Gc12_1208 0 n24 ns1208 0 0.000525891736125
Gc12_1209 0 n24 ns1209 0 0.00218535318055
Gc12_1210 0 n24 ns1210 0 0.000726336415625
Gc12_1211 0 n24 ns1211 0 -0.000586798696431
Gc12_1212 0 n24 ns1212 0 -0.0180079237535
Gc12_1213 0 n24 ns1213 0 0.0146681146258
Gc12_1214 0 n24 ns1214 0 -0.000518806439513
Gc12_1215 0 n24 ns1215 0 2.69461523298e-06
Gc12_1216 0 n24 ns1216 0 -1.65579863418e-05
Gd12_1 0 n24 ni1 0 0.000242228834952
Gd12_2 0 n24 ni2 0 0.000235839115863
Gd12_3 0 n24 ni3 0 -0.000697062355328
Gd12_4 0 n24 ni4 0 -0.00264261601642
Gd12_5 0 n24 ni5 0 -0.000804794849045
Gd12_6 0 n24 ni6 0 -0.00124349998062
Gd12_7 0 n24 ni7 0 0.000105001693424
Gd12_8 0 n24 ni8 0 0.000162512727114
Gd12_9 0 n24 ni9 0 0.000234864660451
Gd12_10 0 n24 ni10 0 -0.00028456475743
Gd12_11 0 n24 ni11 0 -0.0017287350735
Gd12_12 0 n24 ni12 0 6.182225676e-05
Gd12_13 0 n24 ni13 0 -0.00187284304212
Gd12_14 0 n24 ni14 0 -0.0004585348479
Gd12_15 0 n24 ni15 0 0.00020231853483
Gd12_16 0 n24 ni16 0 2.47280102651e-05
Gd12_17 0 n24 ni17 0 0.00026574703212
Gd12_18 0 n24 ni18 0 0.000240791743313
Gd12_19 0 n24 ni19 0 -7.99348776765e-05
Gd12_20 0 n24 ni20 0 -0.00169005056572
Gd12_21 0 n24 ni21 0 -0.00301335180182
Gd12_22 0 n24 ni22 0 -0.000104448952679
Gd12_23 0 n24 ni23 0 0.000240456830549
Gd12_24 0 n24 ni24 0 0.000204505294442
Gd12_25 0 n24 ni25 0 4.0762772042e-05
Gd12_26 0 n24 ni26 0 0.00051477714239
Gd12_27 0 n24 ni27 0 -0.000464336172731
Gd12_28 0 n24 ni28 0 -0.00686617150102
Gd12_29 0 n24 ni29 0 -0.000346566832888
Gd12_30 0 n24 ni30 0 0.0006157675616
Gd12_31 0 n24 ni31 0 0.000190136678294
Gd12_32 0 n24 ni32 0 8.69273421041e-05
Gc13_1 0 n26 ns1 0 -0.000145386979918
Gc13_2 0 n26 ns2 0 -0.000258004430085
Gc13_3 0 n26 ns3 0 0.002570689327
Gc13_4 0 n26 ns4 0 8.22567144896e-05
Gc13_5 0 n26 ns5 0 2.10082139835e-05
Gc13_6 0 n26 ns6 0 -7.95480453034e-05
Gc13_7 0 n26 ns7 0 0.000177984983518
Gc13_8 0 n26 ns8 0 1.75360234612e-05
Gc13_9 0 n26 ns9 0 3.30119027889e-05
Gc13_10 0 n26 ns10 0 -0.000122071999405
Gc13_11 0 n26 ns11 0 -0.00104704804415
Gc13_12 0 n26 ns12 0 0.000540753736772
Gc13_13 0 n26 ns13 0 0.000668003504582
Gc13_14 0 n26 ns14 0 -1.63059580279e-07
Gc13_15 0 n26 ns15 0 -0.000258213314922
Gc13_16 0 n26 ns16 0 -0.000113615828796
Gc13_17 0 n26 ns17 0 -0.00184832394652
Gc13_18 0 n26 ns18 0 -0.000778714792638
Gc13_19 0 n26 ns19 0 0.000994887138955
Gc13_20 0 n26 ns20 0 0.0002430428584
Gc13_21 0 n26 ns21 0 5.86782447093e-05
Gc13_22 0 n26 ns22 0 -0.00181085938152
Gc13_23 0 n26 ns23 0 -0.000206850084674
Gc13_24 0 n26 ns24 0 0.000537318675008
Gc13_25 0 n26 ns25 0 0.00136831024276
Gc13_26 0 n26 ns26 0 -3.22392126557e-05
Gc13_27 0 n26 ns27 0 -0.000945040003333
Gc13_28 0 n26 ns28 0 -0.00247678464078
Gc13_29 0 n26 ns29 0 -0.00011814128668
Gc13_30 0 n26 ns30 0 0.000486673016452
Gc13_31 0 n26 ns31 0 0.00136577296335
Gc13_32 0 n26 ns32 0 0.00050156190869
Gc13_33 0 n26 ns33 0 -0.000564842287149
Gc13_34 0 n26 ns34 0 0.00125497573015
Gc13_35 0 n26 ns35 0 -0.00247216882734
Gc13_36 0 n26 ns36 0 0.000355003433755
Gc13_37 0 n26 ns37 0 -7.56702742929e-06
Gc13_38 0 n26 ns38 0 -7.6230365301e-06
Gc13_39 0 n26 ns39 0 -0.000380841425978
Gc13_40 0 n26 ns40 0 0.000610494375208
Gc13_41 0 n26 ns41 0 0.00101772894255
Gc13_42 0 n26 ns42 0 -4.02306780077e-05
Gc13_43 0 n26 ns43 0 0.000122405100033
Gc13_44 0 n26 ns44 0 -4.83164482206e-05
Gc13_45 0 n26 ns45 0 0.000138125607385
Gc13_46 0 n26 ns46 0 -1.85661125235e-06
Gc13_47 0 n26 ns47 0 4.54962542485e-06
Gc13_48 0 n26 ns48 0 1.07716611167e-05
Gc13_49 0 n26 ns49 0 -0.000574713640113
Gc13_50 0 n26 ns50 0 0.000481844179342
Gc13_51 0 n26 ns51 0 0.000622531743702
Gc13_52 0 n26 ns52 0 -2.67312408203e-05
Gc13_53 0 n26 ns53 0 -0.000319136210375
Gc13_54 0 n26 ns54 0 0.00042382574405
Gc13_55 0 n26 ns55 0 -0.00153987305617
Gc13_56 0 n26 ns56 0 -0.000902539902675
Gc13_57 0 n26 ns57 0 0.000800019478793
Gc13_58 0 n26 ns58 0 0.000254290142757
Gc13_59 0 n26 ns59 0 3.26195168714e-05
Gc13_60 0 n26 ns60 0 -0.00126950630231
Gc13_61 0 n26 ns61 0 -0.000434057022875
Gc13_62 0 n26 ns62 0 0.000430843329139
Gc13_63 0 n26 ns63 0 0.00148534651138
Gc13_64 0 n26 ns64 0 5.18418467604e-06
Gc13_65 0 n26 ns65 0 -0.00107989221023
Gc13_66 0 n26 ns66 0 -0.00213145260587
Gc13_67 0 n26 ns67 0 -0.00056085254889
Gc13_68 0 n26 ns68 0 0.000308230919842
Gc13_69 0 n26 ns69 0 0.00165984480317
Gc13_70 0 n26 ns70 0 0.000650174257974
Gc13_71 0 n26 ns71 0 -0.000646512745229
Gc13_72 0 n26 ns72 0 0.00567891751325
Gc13_73 0 n26 ns73 0 -0.00641150241464
Gc13_74 0 n26 ns74 0 0.000547120025856
Gc13_75 0 n26 ns75 0 -6.39271422372e-06
Gc13_76 0 n26 ns76 0 -6.71480071548e-06
Gc13_77 0 n26 ns77 0 -0.000931054355181
Gc13_78 0 n26 ns78 0 0.00163882237654
Gc13_79 0 n26 ns79 0 -0.00270750132027
Gc13_80 0 n26 ns80 0 -3.025967862e-05
Gc13_81 0 n26 ns81 0 -0.000222411017277
Gc13_82 0 n26 ns82 0 6.1414041445e-05
Gc13_83 0 n26 ns83 0 -0.000315593960092
Gc13_84 0 n26 ns84 0 -3.66350041033e-05
Gc13_85 0 n26 ns85 0 -2.62361983278e-05
Gc13_86 0 n26 ns86 0 -0.00114888836223
Gc13_87 0 n26 ns87 0 0.00170361303632
Gc13_88 0 n26 ns88 0 0.000153771843657
Gc13_89 0 n26 ns89 0 -0.000276261983542
Gc13_90 0 n26 ns90 0 -4.85527639325e-05
Gc13_91 0 n26 ns91 0 -0.000406096970309
Gc13_92 0 n26 ns92 0 0.000328398491224
Gc13_93 0 n26 ns93 0 0.00137455454878
Gc13_94 0 n26 ns94 0 -0.000209837449478
Gc13_95 0 n26 ns95 0 -0.000162962618911
Gc13_96 0 n26 ns96 0 0.000304554263912
Gc13_97 0 n26 ns97 0 -0.00010249688058
Gc13_98 0 n26 ns98 0 0.0015717506496
Gc13_99 0 n26 ns99 0 0.00138291930468
Gc13_100 0 n26 ns100 0 0.000229872312395
Gc13_101 0 n26 ns101 0 0.000740033501652
Gc13_102 0 n26 ns102 0 4.39342528605e-06
Gc13_103 0 n26 ns103 0 -0.00111989870162
Gc13_104 0 n26 ns104 0 0.00157159256774
Gc13_105 0 n26 ns105 0 -0.000332615146687
Gc13_106 0 n26 ns106 0 -0.000872678271668
Gc13_107 0 n26 ns107 0 0.00151221598782
Gc13_108 0 n26 ns108 0 0.00103662968661
Gc13_109 0 n26 ns109 0 -0.000640593914485
Gc13_110 0 n26 ns110 0 0.0309502276974
Gc13_111 0 n26 ns111 0 -0.0284999223546
Gc13_112 0 n26 ns112 0 0.00155889913887
Gc13_113 0 n26 ns113 0 -5.60671432926e-06
Gc13_114 0 n26 ns114 0 -8.59104094582e-06
Gc13_115 0 n26 ns115 0 -0.00172131687361
Gc13_116 0 n26 ns116 0 0.000580715022349
Gc13_117 0 n26 ns117 0 -0.00161315200115
Gc13_118 0 n26 ns118 0 0.000501225211966
Gc13_119 0 n26 ns119 0 -0.000505654054943
Gc13_120 0 n26 ns120 0 0.000625267977819
Gc13_121 0 n26 ns121 0 -1.33751916332e-05
Gc13_122 0 n26 ns122 0 -0.000130986568152
Gc13_123 0 n26 ns123 0 7.64816719977e-06
Gc13_124 0 n26 ns124 0 -0.00192799477252
Gc13_125 0 n26 ns125 0 0.000317233111659
Gc13_126 0 n26 ns126 0 0.000637662829609
Gc13_127 0 n26 ns127 0 -0.000544883028172
Gc13_128 0 n26 ns128 0 0.000151441131602
Gc13_129 0 n26 ns129 0 -0.000467082455299
Gc13_130 0 n26 ns130 0 -0.0018402534042
Gc13_131 0 n26 ns131 0 9.61332552845e-05
Gc13_132 0 n26 ns132 0 0.000176356262398
Gc13_133 0 n26 ns133 0 0.000134090485349
Gc13_134 0 n26 ns134 0 0.000451651160595
Gc13_135 0 n26 ns135 0 5.85050505698e-05
Gc13_136 0 n26 ns136 0 -0.000946634921457
Gc13_137 0 n26 ns137 0 0.00352538685642
Gc13_138 0 n26 ns138 0 0.000979872100319
Gc13_139 0 n26 ns139 0 0.000398966132379
Gc13_140 0 n26 ns140 0 0.000128659807897
Gc13_141 0 n26 ns141 0 -0.00137420308262
Gc13_142 0 n26 ns142 0 0.00170570424478
Gc13_143 0 n26 ns143 0 0.00211643513313
Gc13_144 0 n26 ns144 0 -0.00175008008863
Gc13_145 0 n26 ns145 0 0.000317506394106
Gc13_146 0 n26 ns146 0 0.00162004795926
Gc13_147 0 n26 ns147 0 -0.000258500500345
Gc13_148 0 n26 ns148 0 0.0515794733344
Gc13_149 0 n26 ns149 0 -0.050064786645
Gc13_150 0 n26 ns150 0 0.00372281870157
Gc13_151 0 n26 ns151 0 -6.87537715181e-07
Gc13_152 0 n26 ns152 0 -8.75545309852e-06
Gc13_153 0 n26 ns153 0 -0.00520131536281
Gc13_154 0 n26 ns154 0 -0.00016414946867
Gc13_155 0 n26 ns155 0 -0.00721501893969
Gc13_156 0 n26 ns156 0 2.6560241103e-05
Gc13_157 0 n26 ns157 0 -0.00125390948567
Gc13_158 0 n26 ns158 0 -0.000254635037595
Gc13_159 0 n26 ns159 0 0.000918430857725
Gc13_160 0 n26 ns160 0 -9.9052886871e-05
Gc13_161 0 n26 ns161 0 -3.3415057262e-05
Gc13_162 0 n26 ns162 0 0.00039449045902
Gc13_163 0 n26 ns163 0 0.00255861813192
Gc13_164 0 n26 ns164 0 0.000481206912878
Gc13_165 0 n26 ns165 0 -0.000545924270007
Gc13_166 0 n26 ns166 0 0.000190101609815
Gc13_167 0 n26 ns167 0 -0.000422250151933
Gc13_168 0 n26 ns168 0 0.000860466892722
Gc13_169 0 n26 ns169 0 -0.000276589120777
Gc13_170 0 n26 ns170 0 0.000206025979472
Gc13_171 0 n26 ns171 0 -0.000246062698128
Gc13_172 0 n26 ns172 0 0.000394443359793
Gc13_173 0 n26 ns173 0 0.00010708152078
Gc13_174 0 n26 ns174 0 -0.000356747955715
Gc13_175 0 n26 ns175 0 0.00115414277188
Gc13_176 0 n26 ns176 0 0.00162868703595
Gc13_177 0 n26 ns177 0 0.00144073703317
Gc13_178 0 n26 ns178 0 0.00062390078609
Gc13_179 0 n26 ns179 0 -0.0018029974123
Gc13_180 0 n26 ns180 0 0.00230343704495
Gc13_181 0 n26 ns181 0 0.00135739473243
Gc13_182 0 n26 ns182 0 0.000207680968948
Gc13_183 0 n26 ns183 0 -0.000450473740218
Gc13_184 0 n26 ns184 0 0.002297779963
Gc13_185 0 n26 ns185 0 8.48969911239e-05
Gc13_186 0 n26 ns186 0 0.037664991095
Gc13_187 0 n26 ns187 0 -0.0346901082402
Gc13_188 0 n26 ns188 0 0.00686432532283
Gc13_189 0 n26 ns189 0 -4.18169537123e-06
Gc13_190 0 n26 ns190 0 -5.79812454241e-06
Gc13_191 0 n26 ns191 0 -0.00499187844963
Gc13_192 0 n26 ns192 0 0.000346843949658
Gc13_193 0 n26 ns193 0 -0.00719399222505
Gc13_194 0 n26 ns194 0 -0.000239346690932
Gc13_195 0 n26 ns195 0 -0.000863378231583
Gc13_196 0 n26 ns196 0 -7.09278383834e-06
Gc13_197 0 n26 ns197 0 0.00034085835987
Gc13_198 0 n26 ns198 0 -0.000102889943918
Gc13_199 0 n26 ns199 0 -3.25951597248e-05
Gc13_200 0 n26 ns200 0 -0.00150162357572
Gc13_201 0 n26 ns201 0 0.00291781639342
Gc13_202 0 n26 ns202 0 0.000677058622044
Gc13_203 0 n26 ns203 0 -0.000543440892877
Gc13_204 0 n26 ns204 0 0.000221438760657
Gc13_205 0 n26 ns205 0 -0.000447354478931
Gc13_206 0 n26 ns206 0 0.000344585232938
Gc13_207 0 n26 ns207 0 0.00183836746736
Gc13_208 0 n26 ns208 0 0.000695051944881
Gc13_209 0 n26 ns209 0 -5.83294157399e-05
Gc13_210 0 n26 ns210 0 0.000502693505395
Gc13_211 0 n26 ns211 0 7.74227788401e-05
Gc13_212 0 n26 ns212 0 0.00240450915404
Gc13_213 0 n26 ns213 0 0.00174304342804
Gc13_214 0 n26 ns214 0 0.0013472809585
Gc13_215 0 n26 ns215 0 0.00218908616464
Gc13_216 0 n26 ns216 0 0.00103122539046
Gc13_217 0 n26 ns217 0 -0.00193040497094
Gc13_218 0 n26 ns218 0 0.00351447371605
Gc13_219 0 n26 ns219 0 -0.00157385150856
Gc13_220 0 n26 ns220 0 0.00176168398204
Gc13_221 0 n26 ns221 0 0.00112794372155
Gc13_222 0 n26 ns222 0 0.00292232719722
Gc13_223 0 n26 ns223 0 3.61870063499e-05
Gc13_224 0 n26 ns224 0 -0.00681749251039
Gc13_225 0 n26 ns225 0 0.0110962047516
Gc13_226 0 n26 ns226 0 0.00709864016
Gc13_227 0 n26 ns227 0 -1.47683393523e-06
Gc13_228 0 n26 ns228 0 -1.5964458394e-06
Gc13_229 0 n26 ns229 0 -0.00184202340064
Gc13_230 0 n26 ns230 0 -0.000642602904744
Gc13_231 0 n26 ns231 0 0.00249355998674
Gc13_232 0 n26 ns232 0 0.000663236420367
Gc13_233 0 n26 ns233 0 -0.000336109851808
Gc13_234 0 n26 ns234 0 0.000702875380242
Gc13_235 0 n26 ns235 0 0.000334989453684
Gc13_236 0 n26 ns236 0 -0.000155676143474
Gc13_237 0 n26 ns237 0 -5.41087091929e-05
Gc13_238 0 n26 ns238 0 -0.00146008589986
Gc13_239 0 n26 ns239 0 -0.000521162240545
Gc13_240 0 n26 ns240 0 0.00100019572233
Gc13_241 0 n26 ns241 0 -0.000294840251247
Gc13_242 0 n26 ns242 0 0.000189952750284
Gc13_243 0 n26 ns243 0 -0.000538192733833
Gc13_244 0 n26 ns244 0 -0.00119846963123
Gc13_245 0 n26 ns245 0 -0.00192584844778
Gc13_246 0 n26 ns246 0 -0.000412583135845
Gc13_247 0 n26 ns247 0 0.000321880472171
Gc13_248 0 n26 ns248 0 0.00039960182377
Gc13_249 0 n26 ns249 0 0.000181157929818
Gc13_250 0 n26 ns250 0 -0.00380395672553
Gc13_251 0 n26 ns251 0 0.00151823737841
Gc13_252 0 n26 ns252 0 0.000843441163204
Gc13_253 0 n26 ns253 0 0.00113924162033
Gc13_254 0 n26 ns254 0 0.000549841455836
Gc13_255 0 n26 ns255 0 -0.00151909499471
Gc13_256 0 n26 ns256 0 -0.00221200650436
Gc13_257 0 n26 ns257 0 0.00165509074006
Gc13_258 0 n26 ns258 0 -0.00168004235304
Gc13_259 0 n26 ns259 0 0.000441755308354
Gc13_260 0 n26 ns260 0 0.00200324989383
Gc13_261 0 n26 ns261 0 1.69646139633e-05
Gc13_262 0 n26 ns262 0 0.0413284255733
Gc13_263 0 n26 ns263 0 -0.044365085481
Gc13_264 0 n26 ns264 0 0.0044937175925
Gc13_265 0 n26 ns265 0 3.12338519237e-06
Gc13_266 0 n26 ns266 0 3.47664904762e-06
Gc13_267 0 n26 ns267 0 -0.000886396633771
Gc13_268 0 n26 ns268 0 0.00179707969914
Gc13_269 0 n26 ns269 0 -0.00193316580711
Gc13_270 0 n26 ns270 0 0.000135762030579
Gc13_271 0 n26 ns271 0 -0.00026735358477
Gc13_272 0 n26 ns272 0 0.000173404536126
Gc13_273 0 n26 ns273 0 -0.00030363819689
Gc13_274 0 n26 ns274 0 -3.54349058252e-07
Gc13_275 0 n26 ns275 0 1.08163268707e-05
Gc13_276 0 n26 ns276 0 -0.00165071612474
Gc13_277 0 n26 ns277 0 0.000435702029417
Gc13_278 0 n26 ns278 0 0.000292228207387
Gc13_279 0 n26 ns279 0 6.30426271402e-05
Gc13_280 0 n26 ns280 0 7.26251250324e-05
Gc13_281 0 n26 ns281 0 -0.000429291208319
Gc13_282 0 n26 ns282 0 -0.000743527838
Gc13_283 0 n26 ns283 0 0.000850849826003
Gc13_284 0 n26 ns284 0 -0.000277785009164
Gc13_285 0 n26 ns285 0 0.000201071998894
Gc13_286 0 n26 ns286 0 0.000402554982849
Gc13_287 0 n26 ns287 0 1.56386733377e-05
Gc13_288 0 n26 ns288 0 0.000632090171844
Gc13_289 0 n26 ns289 0 0.00252486121325
Gc13_290 0 n26 ns290 0 0.000318347769473
Gc13_291 0 n26 ns291 0 0.000888901226132
Gc13_292 0 n26 ns292 0 0.000186438638694
Gc13_293 0 n26 ns293 0 -0.00129114772543
Gc13_294 0 n26 ns294 0 0.00201424232108
Gc13_295 0 n26 ns295 0 0.000616632512838
Gc13_296 0 n26 ns296 0 -0.00129106618113
Gc13_297 0 n26 ns297 0 0.00123229857954
Gc13_298 0 n26 ns298 0 0.00120185873119
Gc13_299 0 n26 ns299 0 -0.000527021555229
Gc13_300 0 n26 ns300 0 0.0353117369917
Gc13_301 0 n26 ns301 0 -0.0329477570022
Gc13_302 0 n26 ns302 0 0.00189793300168
Gc13_303 0 n26 ns303 0 -4.59969560817e-06
Gc13_304 0 n26 ns304 0 2.29316933031e-06
Gc13_305 0 n26 ns305 0 -0.000844033008379
Gc13_306 0 n26 ns306 0 0.00174515937921
Gc13_307 0 n26 ns307 0 -0.00163887911017
Gc13_308 0 n26 ns308 0 -7.24829650408e-05
Gc13_309 0 n26 ns309 0 -0.000137852802981
Gc13_310 0 n26 ns310 0 -0.000324153703786
Gc13_311 0 n26 ns311 0 2.43993243097e-05
Gc13_312 0 n26 ns312 0 -4.35018762525e-05
Gc13_313 0 n26 ns313 0 1.31122618669e-05
Gc13_314 0 n26 ns314 0 0.000576157294789
Gc13_315 0 n26 ns315 0 0.000664035814482
Gc13_316 0 n26 ns316 0 -7.98180944796e-05
Gc13_317 0 n26 ns317 0 0.000507153529193
Gc13_318 0 n26 ns318 0 4.32888978064e-05
Gc13_319 0 n26 ns319 0 -0.000284777293743
Gc13_320 0 n26 ns320 0 0.00168221885872
Gc13_321 0 n26 ns321 0 -0.000515366268601
Gc13_322 0 n26 ns322 0 -0.00106651461025
Gc13_323 0 n26 ns323 0 -3.14538132713e-07
Gc13_324 0 n26 ns324 0 0.000159675221688
Gc13_325 0 n26 ns325 0 6.35778530074e-05
Gc13_326 0 n26 ns326 0 -2.77693425482e-05
Gc13_327 0 n26 ns327 0 -0.00109648083581
Gc13_328 0 n26 ns328 0 -0.000304786552277
Gc13_329 0 n26 ns329 0 0.00136517093314
Gc13_330 0 n26 ns330 0 0.000361612679765
Gc13_331 0 n26 ns331 0 -0.000921993323703
Gc13_332 0 n26 ns332 0 -0.00112042249645
Gc13_333 0 n26 ns333 0 -0.000975656633685
Gc13_334 0 n26 ns334 0 -9.50126765388e-05
Gc13_335 0 n26 ns335 0 0.00164788521534
Gc13_336 0 n26 ns336 0 0.000754743785631
Gc13_337 0 n26 ns337 0 -0.000585352786358
Gc13_338 0 n26 ns338 0 0.0116470670256
Gc13_339 0 n26 ns339 0 -0.0114300829944
Gc13_340 0 n26 ns340 0 0.000747024553174
Gc13_341 0 n26 ns341 0 -9.82108802286e-06
Gc13_342 0 n26 ns342 0 3.58703053255e-06
Gc13_343 0 n26 ns343 0 -0.000620694940152
Gc13_344 0 n26 ns344 0 0.00149114591717
Gc13_345 0 n26 ns345 0 -0.0022102042553
Gc13_346 0 n26 ns346 0 -0.00016379914508
Gc13_347 0 n26 ns347 0 -0.000169287671119
Gc13_348 0 n26 ns348 0 -0.000153862097063
Gc13_349 0 n26 ns349 0 -0.000119142555983
Gc13_350 0 n26 ns350 0 -9.47770622211e-06
Gc13_351 0 n26 ns351 0 -1.97925454765e-05
Gc13_352 0 n26 ns352 0 -0.000505859560563
Gc13_353 0 n26 ns353 0 0.00136860991735
Gc13_354 0 n26 ns354 0 0.000225916111541
Gc13_355 0 n26 ns355 0 3.56529506186e-05
Gc13_356 0 n26 ns356 0 -8.17650153977e-05
Gc13_357 0 n26 ns357 0 -0.000376268549392
Gc13_358 0 n26 ns358 0 0.000743999222941
Gc13_359 0 n26 ns359 0 0.000526919698906
Gc13_360 0 n26 ns360 0 -0.000458514733368
Gc13_361 0 n26 ns361 0 0.000118861740539
Gc13_362 0 n26 ns362 0 0.000270976699433
Gc13_363 0 n26 ns363 0 -8.51942975369e-05
Gc13_364 0 n26 ns364 0 0.000955353839963
Gc13_365 0 n26 ns365 0 0.000547788641173
Gc13_366 0 n26 ns366 0 0.000298805144651
Gc13_367 0 n26 ns367 0 0.00102989735261
Gc13_368 0 n26 ns368 0 -3.31009538549e-05
Gc13_369 0 n26 ns369 0 -0.00110732913795
Gc13_370 0 n26 ns370 0 0.000638919874582
Gc13_371 0 n26 ns371 0 -0.000427479963397
Gc13_372 0 n26 ns372 0 -0.000387450284638
Gc13_373 0 n26 ns373 0 0.00152152540593
Gc13_374 0 n26 ns374 0 0.000822426500661
Gc13_375 0 n26 ns375 0 -0.000667034391176
Gc13_376 0 n26 ns376 0 0.023842625584
Gc13_377 0 n26 ns377 0 -0.0219654007033
Gc13_378 0 n26 ns378 0 0.00116165249656
Gc13_379 0 n26 ns379 0 -6.16481368939e-06
Gc13_380 0 n26 ns380 0 -7.34901994101e-06
Gc13_381 0 n26 ns381 0 -0.00132782433917
Gc13_382 0 n26 ns382 0 0.000765696603946
Gc13_383 0 n26 ns383 0 -0.00184978454714
Gc13_384 0 n26 ns384 0 0.000400934718942
Gc13_385 0 n26 ns385 0 -0.000484679906645
Gc13_386 0 n26 ns386 0 0.000435529784349
Gc13_387 0 n26 ns387 0 -0.000212686664512
Gc13_388 0 n26 ns388 0 -5.9005949313e-05
Gc13_389 0 n26 ns389 0 4.32298568323e-08
Gc13_390 0 n26 ns390 0 -0.00199515079554
Gc13_391 0 n26 ns391 0 0.000685124293119
Gc13_392 0 n26 ns392 0 0.000371918966636
Gc13_393 0 n26 ns393 0 -0.000489496842455
Gc13_394 0 n26 ns394 0 5.8436055836e-05
Gc13_395 0 n26 ns395 0 -0.00042335934371
Gc13_396 0 n26 ns396 0 -0.00164299110854
Gc13_397 0 n26 ns397 0 0.00103321734774
Gc13_398 0 n26 ns398 0 0.000177033017704
Gc13_399 0 n26 ns399 0 0.000101174262576
Gc13_400 0 n26 ns400 0 0.000423011422584
Gc13_401 0 n26 ns401 0 -1.40600657834e-05
Gc13_402 0 n26 ns402 0 0.000379859909066
Gc13_403 0 n26 ns403 0 0.00373496915922
Gc13_404 0 n26 ns404 0 0.000740308297862
Gc13_405 0 n26 ns405 0 0.000387362858004
Gc13_406 0 n26 ns406 0 2.0020619488e-05
Gc13_407 0 n26 ns407 0 -0.00126734794447
Gc13_408 0 n26 ns408 0 0.00278040685483
Gc13_409 0 n26 ns409 0 0.00177701033796
Gc13_410 0 n26 ns410 0 -0.0016092896576
Gc13_411 0 n26 ns411 0 0.000684029111119
Gc13_412 0 n26 ns412 0 0.00136019021512
Gc13_413 0 n26 ns413 0 -0.000432708514225
Gc13_414 0 n26 ns414 0 0.0483153189178
Gc13_415 0 n26 ns415 0 -0.0453085750467
Gc13_416 0 n26 ns416 0 0.00276481596202
Gc13_417 0 n26 ns417 0 -1.88542330685e-06
Gc13_418 0 n26 ns418 0 -9.70028249721e-06
Gc13_419 0 n26 ns419 0 -0.00232952285121
Gc13_420 0 n26 ns420 0 -0.00126018382778
Gc13_421 0 n26 ns421 0 0.00147469670213
Gc13_422 0 n26 ns422 0 0.000130732000378
Gc13_423 0 n26 ns423 0 -0.000398565768965
Gc13_424 0 n26 ns424 0 0.000473366913139
Gc13_425 0 n26 ns425 0 0.000499506902202
Gc13_426 0 n26 ns426 0 -0.000155935011726
Gc13_427 0 n26 ns427 0 -5.73239075638e-05
Gc13_428 0 n26 ns428 0 -0.000489423487022
Gc13_429 0 n26 ns429 0 0.000308913335101
Gc13_430 0 n26 ns430 0 0.000736129182325
Gc13_431 0 n26 ns431 0 -0.00010952131292
Gc13_432 0 n26 ns432 0 0.000308638520224
Gc13_433 0 n26 ns433 0 -0.000430368446693
Gc13_434 0 n26 ns434 0 0.000457370306447
Gc13_435 0 n26 ns435 0 -0.00164653932478
Gc13_436 0 n26 ns436 0 -0.000302894060329
Gc13_437 0 n26 ns437 0 -0.000130942334945
Gc13_438 0 n26 ns438 0 0.000345585268886
Gc13_439 0 n26 ns439 0 0.000190318238744
Gc13_440 0 n26 ns440 0 -0.00298529494158
Gc13_441 0 n26 ns441 0 -0.000805006710494
Gc13_442 0 n26 ns442 0 0.000905934272263
Gc13_443 0 n26 ns443 0 0.00112766135913
Gc13_444 0 n26 ns444 0 0.000663369424074
Gc13_445 0 n26 ns445 0 -0.00147026824979
Gc13_446 0 n26 ns446 0 -0.0041862573266
Gc13_447 0 n26 ns447 0 -0.00091457454819
Gc13_448 0 n26 ns448 0 -0.00121890555504
Gc13_449 0 n26 ns449 0 0.000491086312536
Gc13_450 0 n26 ns450 0 0.00230367094912
Gc13_451 0 n26 ns451 0 0.000235212591453
Gc13_452 0 n26 ns452 0 0.0295903024638
Gc13_453 0 n26 ns453 0 -0.0355884926719
Gc13_454 0 n26 ns454 0 0.00567666982911
Gc13_455 0 n26 ns455 0 1.12498551959e-06
Gc13_456 0 n26 ns456 0 -2.72878595372e-06
Gc13_457 0 n26 ns457 0 -0.00393221026367
Gc13_458 0 n26 ns458 0 -0.000108994466548
Gc13_459 0 n26 ns459 0 -0.00370500298457
Gc13_460 0 n26 ns460 0 0.00038581966495
Gc13_461 0 n26 ns461 0 -0.000464873425161
Gc13_462 0 n26 ns462 0 0.000224553216512
Gc13_463 0 n26 ns463 0 -0.000183377298911
Gc13_464 0 n26 ns464 0 -0.00020761643808
Gc13_465 0 n26 ns465 0 -6.05491069276e-05
Gc13_466 0 n26 ns466 0 -0.00340372167953
Gc13_467 0 n26 ns467 0 0.0023752373829
Gc13_468 0 n26 ns468 0 0.00121778440319
Gc13_469 0 n26 ns469 0 -0.000369482322317
Gc13_470 0 n26 ns470 0 0.000360601445448
Gc13_471 0 n26 ns471 0 -0.000544245426273
Gc13_472 0 n26 ns472 0 0.000196352323815
Gc13_473 0 n26 ns473 0 0.00160956698625
Gc13_474 0 n26 ns474 0 0.000648206230874
Gc13_475 0 n26 ns475 0 0.000197918840851
Gc13_476 0 n26 ns476 0 0.000563616676993
Gc13_477 0 n26 ns477 0 0.000152219067069
Gc13_478 0 n26 ns478 0 0.0014086787203
Gc13_479 0 n26 ns479 0 0.0010736745489
Gc13_480 0 n26 ns480 0 0.00153695170283
Gc13_481 0 n26 ns481 0 0.00256507290052
Gc13_482 0 n26 ns482 0 0.00111291181379
Gc13_483 0 n26 ns483 0 -0.00212521141656
Gc13_484 0 n26 ns484 0 0.00064383015533
Gc13_485 0 n26 ns485 0 -0.00244333390746
Gc13_486 0 n26 ns486 0 0.00209602078558
Gc13_487 0 n26 ns487 0 0.00154046127437
Gc13_488 0 n26 ns488 0 0.00309932061028
Gc13_489 0 n26 ns489 0 1.19644010582e-05
Gc13_490 0 n26 ns490 0 -0.0149365330589
Gc13_491 0 n26 ns491 0 0.0161903037478
Gc13_492 0 n26 ns492 0 0.00714585244531
Gc13_493 0 n26 ns493 0 1.05439478008e-05
Gc13_494 0 n26 ns494 0 -2.39327661188e-06
Gc13_495 0 n26 ns495 0 -0.00208964938659
Gc13_496 0 n26 ns496 0 -0.00190788930014
Gc13_497 0 n26 ns497 0 0.00386993438185
Gc13_498 0 n26 ns498 0 0.000329010985834
Gc13_499 0 n26 ns499 0 -0.000357097745349
Gc13_500 0 n26 ns500 0 0.000622675366726
Gc13_501 0 n26 ns501 0 0.000400945038355
Gc13_502 0 n26 ns502 0 -0.000175434140326
Gc13_503 0 n26 ns503 0 -8.92045446865e-05
Gc13_504 0 n26 ns504 0 -0.00136914284487
Gc13_505 0 n26 ns505 0 2.44358965294e-05
Gc13_506 0 n26 ns506 0 0.0010923873474
Gc13_507 0 n26 ns507 0 -0.000137424242874
Gc13_508 0 n26 ns508 0 0.000308177561355
Gc13_509 0 n26 ns509 0 -0.000510956055161
Gc13_510 0 n26 ns510 0 0.000115485670615
Gc13_511 0 n26 ns511 0 -0.00189346474843
Gc13_512 0 n26 ns512 0 -0.000341451552375
Gc13_513 0 n26 ns513 0 6.22450546509e-05
Gc13_514 0 n26 ns514 0 0.000381755835002
Gc13_515 0 n26 ns515 0 0.000208488729106
Gc13_516 0 n26 ns516 0 -0.0036446972144
Gc13_517 0 n26 ns517 0 -0.000904591639304
Gc13_518 0 n26 ns518 0 0.000862531621294
Gc13_519 0 n26 ns519 0 0.00139579191785
Gc13_520 0 n26 ns520 0 0.000770036077986
Gc13_521 0 n26 ns521 0 -0.0015754119389
Gc13_522 0 n26 ns522 0 -0.00528169908447
Gc13_523 0 n26 ns523 0 -0.00130015532397
Gc13_524 0 n26 ns524 0 -0.00122717379646
Gc13_525 0 n26 ns525 0 0.000831674905193
Gc13_526 0 n26 ns526 0 0.00243246081458
Gc13_527 0 n26 ns527 0 0.000238500515468
Gc13_528 0 n26 ns528 0 0.0219421808005
Gc13_529 0 n26 ns529 0 -0.0293438886964
Gc13_530 0 n26 ns530 0 0.00550356813091
Gc13_531 0 n26 ns531 0 1.76796858929e-06
Gc13_532 0 n26 ns532 0 4.01517255454e-06
Gc13_533 0 n26 ns533 0 -0.00111018162412
Gc13_534 0 n26 ns534 0 0.000402466005579
Gc13_535 0 n26 ns535 0 7.89094916803e-05
Gc13_536 0 n26 ns536 0 0.000564992317417
Gc13_537 0 n26 ns537 0 -0.000523514617431
Gc13_538 0 n26 ns538 0 0.00046451473919
Gc13_539 0 n26 ns539 0 -0.000204533505763
Gc13_540 0 n26 ns540 0 -4.22824432869e-05
Gc13_541 0 n26 ns541 0 -6.60574717014e-07
Gc13_542 0 n26 ns542 0 -0.00255678829175
Gc13_543 0 n26 ns543 0 1.10286766363e-05
Gc13_544 0 n26 ns544 0 0.000653535003262
Gc13_545 0 n26 ns545 0 -0.000244043634802
Gc13_546 0 n26 ns546 0 0.000117669871313
Gc13_547 0 n26 ns547 0 -0.000504888754652
Gc13_548 0 n26 ns548 0 -0.00194156564228
Gc13_549 0 n26 ns549 0 0.000465974464684
Gc13_550 0 n26 ns550 0 -4.30280914318e-05
Gc13_551 0 n26 ns551 0 0.000391004299449
Gc13_552 0 n26 ns552 0 0.000486923003571
Gc13_553 0 n26 ns553 0 5.189861378e-05
Gc13_554 0 n26 ns554 0 -0.000513080118683
Gc13_555 0 n26 ns555 0 0.00364316282261
Gc13_556 0 n26 ns556 0 0.000684174650725
Gc13_557 0 n26 ns557 0 0.00078408473982
Gc13_558 0 n26 ns558 0 0.000183672491818
Gc13_559 0 n26 ns559 0 -0.00143388616125
Gc13_560 0 n26 ns560 0 0.00177582277817
Gc13_561 0 n26 ns561 0 0.00171817671075
Gc13_562 0 n26 ns562 0 -0.00156244529672
Gc13_563 0 n26 ns563 0 0.000894769301345
Gc13_564 0 n26 ns564 0 0.00144759627003
Gc13_565 0 n26 ns565 0 -0.000436423565942
Gc13_566 0 n26 ns566 0 0.0420466481107
Gc13_567 0 n26 ns567 0 -0.0402357384579
Gc13_568 0 n26 ns568 0 0.00263231139794
Gc13_569 0 n26 ns569 0 -2.04725334365e-06
Gc13_570 0 n26 ns570 0 6.94928101831e-07
Gc13_571 0 n26 ns571 0 -0.000872652491154
Gc13_572 0 n26 ns572 0 0.00216298191097
Gc13_573 0 n26 ns573 0 -0.00241301873958
Gc13_574 0 n26 ns574 0 -0.00018237402508
Gc13_575 0 n26 ns575 0 -0.00014440852566
Gc13_576 0 n26 ns576 0 -0.000265892645518
Gc13_577 0 n26 ns577 0 -8.73443494804e-05
Gc13_578 0 n26 ns578 0 -1.98173038033e-05
Gc13_579 0 n26 ns579 0 1.6608657771e-05
Gc13_580 0 n26 ns580 0 0.000237443932967
Gc13_581 0 n26 ns581 0 0.000963644556084
Gc13_582 0 n26 ns582 0 -9.35714935148e-05
Gc13_583 0 n26 ns583 0 0.000409346978767
Gc13_584 0 n26 ns584 0 3.7939073241e-05
Gc13_585 0 n26 ns585 0 -0.000347125319325
Gc13_586 0 n26 ns586 0 0.00147015897377
Gc13_587 0 n26 ns587 0 5.12540258748e-05
Gc13_588 0 n26 ns588 0 -0.000964807721448
Gc13_589 0 n26 ns589 0 -7.68063509226e-05
Gc13_590 0 n26 ns590 0 0.000228320191464
Gc13_591 0 n26 ns591 0 3.66942806435e-05
Gc13_592 0 n26 ns592 0 0.000511251675052
Gc13_593 0 n26 ns593 0 -0.000404626282983
Gc13_594 0 n26 ns594 0 -0.000250888690592
Gc13_595 0 n26 ns595 0 0.00134617491805
Gc13_596 0 n26 ns596 0 0.000353746619743
Gc13_597 0 n26 ns597 0 -0.00109222834396
Gc13_598 0 n26 ns598 0 -0.000198927253943
Gc13_599 0 n26 ns599 0 -0.000855428049604
Gc13_600 0 n26 ns600 0 -0.000436272587042
Gc13_601 0 n26 ns601 0 0.0017280171837
Gc13_602 0 n26 ns602 0 0.000922804976971
Gc13_603 0 n26 ns603 0 -0.000630981098921
Gc13_604 0 n26 ns604 0 0.0192916914753
Gc13_605 0 n26 ns605 0 -0.0182809507014
Gc13_606 0 n26 ns606 0 0.00108538447001
Gc13_607 0 n26 ns607 0 -8.14277813083e-06
Gc13_608 0 n26 ns608 0 4.70574447296e-06
Gc13_609 0 n26 ns609 0 0.000122383345962
Gc13_610 0 n26 ns610 0 -0.000567266866885
Gc13_611 0 n26 ns611 0 0.00435575462029
Gc13_612 0 n26 ns612 0 0.000199134957362
Gc13_613 0 n26 ns613 0 0.000176677424648
Gc13_614 0 n26 ns614 0 0.00021991646868
Gc13_615 0 n26 ns615 0 -0.000171089076766
Gc13_616 0 n26 ns616 0 -1.96315823974e-05
Gc13_617 0 n26 ns617 0 -7.15459912697e-05
Gc13_618 0 n26 ns618 0 0.000598289317562
Gc13_619 0 n26 ns619 0 -0.000261429062542
Gc13_620 0 n26 ns620 0 -0.00058456071126
Gc13_621 0 n26 ns621 0 -0.000432135242728
Gc13_622 0 n26 ns622 0 3.03146790131e-05
Gc13_623 0 n26 ns623 0 0.000304047552586
Gc13_624 0 n26 ns624 0 1.94234368953e-05
Gc13_625 0 n26 ns625 0 -0.00210665438676
Gc13_626 0 n26 ns626 0 -0.000918499479976
Gc13_627 0 n26 ns627 0 0.000993588606957
Gc13_628 0 n26 ns628 0 0.000230418453987
Gc13_629 0 n26 ns629 0 9.85373233436e-05
Gc13_630 0 n26 ns630 0 -0.000589708366695
Gc13_631 0 n26 ns631 0 -0.00114452195074
Gc13_632 0 n26 ns632 0 -0.00114664310902
Gc13_633 0 n26 ns633 0 -0.000938447665365
Gc13_634 0 n26 ns634 0 0.000438880105475
Gc13_635 0 n26 ns635 0 0.00106144472316
Gc13_636 0 n26 ns636 0 -0.00496178408272
Gc13_637 0 n26 ns637 0 -0.00215963989872
Gc13_638 0 n26 ns638 0 0.000444506091281
Gc13_639 0 n26 ns639 0 0.00223970194642
Gc13_640 0 n26 ns640 0 0.00077205462218
Gc13_641 0 n26 ns641 0 -0.000554092355348
Gc13_642 0 n26 ns642 0 -0.018971985978
Gc13_643 0 n26 ns643 0 0.0153956227694
Gc13_644 0 n26 ns644 0 -0.000528932852624
Gc13_645 0 n26 ns645 0 3.67097662929e-06
Gc13_646 0 n26 ns646 0 -6.24052539753e-06
Gc13_647 0 n26 ns647 0 0.000221943694703
Gc13_648 0 n26 ns648 0 -0.000918485879312
Gc13_649 0 n26 ns649 0 0.00555959104629
Gc13_650 0 n26 ns650 0 0.000237826314421
Gc13_651 0 n26 ns651 0 0.000139437743537
Gc13_652 0 n26 ns652 0 0.000219044070434
Gc13_653 0 n26 ns653 0 -0.000138012759087
Gc13_654 0 n26 ns654 0 -2.66819679841e-06
Gc13_655 0 n26 ns655 0 -3.99433196046e-05
Gc13_656 0 n26 ns656 0 0.000373592714563
Gc13_657 0 n26 ns657 0 -0.000575787997416
Gc13_658 0 n26 ns658 0 -0.000487101796202
Gc13_659 0 n26 ns659 0 -0.000374745570438
Gc13_660 0 n26 ns660 0 7.33512845537e-05
Gc13_661 0 n26 ns661 0 0.000355306605726
Gc13_662 0 n26 ns662 0 0.000318440015662
Gc13_663 0 n26 ns663 0 -0.00209237795695
Gc13_664 0 n26 ns664 0 -0.00112156150219
Gc13_665 0 n26 ns665 0 0.000891028762581
Gc13_666 0 n26 ns666 0 0.000236488555281
Gc13_667 0 n26 ns667 0 9.85092158368e-05
Gc13_668 0 n26 ns668 0 -0.000813909869229
Gc13_669 0 n26 ns669 0 -0.00161506542332
Gc13_670 0 n26 ns670 0 -0.00129565320601
Gc13_671 0 n26 ns671 0 -0.0011369890313
Gc13_672 0 n26 ns672 0 0.000468337327998
Gc13_673 0 n26 ns673 0 0.00131718676948
Gc13_674 0 n26 ns674 0 -0.00603897453797
Gc13_675 0 n26 ns675 0 -0.00296780486052
Gc13_676 0 n26 ns676 0 0.000361752791586
Gc13_677 0 n26 ns677 0 0.00281910333498
Gc13_678 0 n26 ns678 0 0.00100513239397
Gc13_679 0 n26 ns679 0 -0.00064141017213
Gc13_680 0 n26 ns680 0 -0.02626405823
Gc13_681 0 n26 ns681 0 0.0215888498624
Gc13_682 0 n26 ns682 0 -0.000761171879178
Gc13_683 0 n26 ns683 0 -2.81360035789e-08
Gc13_684 0 n26 ns684 0 -7.34415136261e-06
Gc13_685 0 n26 ns685 0 0.000649775826638
Gc13_686 0 n26 ns686 0 -0.001526632838
Gc13_687 0 n26 ns687 0 0.00807618609378
Gc13_688 0 n26 ns688 0 0.000189397955697
Gc13_689 0 n26 ns689 0 9.10424957021e-06
Gc13_690 0 n26 ns690 0 4.86061609547e-05
Gc13_691 0 n26 ns691 0 0.000146164493459
Gc13_692 0 n26 ns692 0 1.43291918931e-05
Gc13_693 0 n26 ns693 0 5.00780577623e-05
Gc13_694 0 n26 ns694 0 -0.000450371260965
Gc13_695 0 n26 ns695 0 -0.0025999143816
Gc13_696 0 n26 ns696 0 0.000135062705536
Gc13_697 0 n26 ns697 0 0.000565138696492
Gc13_698 0 n26 ns698 0 0.000200866624724
Gc13_699 0 n26 ns699 0 0.00039991139325
Gc13_700 0 n26 ns700 0 0.000275071635286
Gc13_701 0 n26 ns701 0 -0.000355508931598
Gc13_702 0 n26 ns702 0 -0.000811264019567
Gc13_703 0 n26 ns703 0 -8.40903895058e-05
Gc13_704 0 n26 ns704 0 0.000195118841801
Gc13_705 0 n26 ns705 0 9.71417016343e-06
Gc13_706 0 n26 ns706 0 -0.00157465934726
Gc13_707 0 n26 ns707 0 -0.00294949497146
Gc13_708 0 n26 ns708 0 -0.00103189124718
Gc13_709 0 n26 ns709 0 -0.000940855325989
Gc13_710 0 n26 ns710 0 0.000254823722369
Gc13_711 0 n26 ns711 0 0.00152953607538
Gc13_712 0 n26 ns712 0 -0.00719770054684
Gc13_713 0 n26 ns713 0 -0.00446488050851
Gc13_714 0 n26 ns714 0 -0.000631868628571
Gc13_715 0 n26 ns715 0 0.00371119554866
Gc13_716 0 n26 ns716 0 0.00170610517739
Gc13_717 0 n26 ns717 0 -0.000612402626866
Gc13_718 0 n26 ns718 0 -0.0439776126061
Gc13_719 0 n26 ns719 0 0.0373231532039
Gc13_720 0 n26 ns720 0 -0.00155301271384
Gc13_721 0 n26 ns721 0 -6.95687510012e-06
Gc13_722 0 n26 ns722 0 -1.14384979905e-05
Gc13_723 0 n26 ns723 0 0.000286720068263
Gc13_724 0 n26 ns724 0 -0.00115819743487
Gc13_725 0 n26 ns725 0 0.0101585938735
Gc13_726 0 n26 ns726 0 -0.000150940904394
Gc13_727 0 n26 ns727 0 0.000536637522324
Gc13_728 0 n26 ns728 0 0.000600083126237
Gc13_729 0 n26 ns729 0 -0.000314541889528
Gc13_730 0 n26 ns730 0 -0.000121153508572
Gc13_731 0 n26 ns731 0 -2.68212228062e-05
Gc13_732 0 n26 ns732 0 0.00103503667703
Gc13_733 0 n26 ns733 0 -0.00385502264297
Gc13_734 0 n26 ns734 0 -0.00017552608085
Gc13_735 0 n26 ns735 0 0.00114905149898
Gc13_736 0 n26 ns736 0 2.20587560481e-05
Gc13_737 0 n26 ns737 0 0.000474981278483
Gc13_738 0 n26 ns738 0 -0.0014201648031
Gc13_739 0 n26 ns739 0 -0.00123444824349
Gc13_740 0 n26 ns740 0 -0.000339436285022
Gc13_741 0 n26 ns741 0 3.20340670304e-05
Gc13_742 0 n26 ns742 0 0.000328795518223
Gc13_743 0 n26 ns743 0 0.000133940900431
Gc13_744 0 n26 ns744 0 -0.00148207620247
Gc13_745 0 n26 ns745 0 -0.00576587866942
Gc13_746 0 n26 ns746 0 -0.00210651429619
Gc13_747 0 n26 ns747 0 -5.13197839259e-05
Gc13_748 0 n26 ns748 0 0.000458366607533
Gc13_749 0 n26 ns749 0 0.00172109310173
Gc13_750 0 n26 ns750 0 -0.00976739065179
Gc13_751 0 n26 ns751 0 -0.00527038459762
Gc13_752 0 n26 ns752 0 -0.00172743758566
Gc13_753 0 n26 ns753 0 0.00342056752867
Gc13_754 0 n26 ns754 0 0.00253892542654
Gc13_755 0 n26 ns755 0 -0.000138628809457
Gc13_756 0 n26 ns756 0 -0.0774532646605
Gc13_757 0 n26 ns757 0 0.069058339071
Gc13_758 0 n26 ns758 0 -0.00393353437032
Gc13_759 0 n26 ns759 0 -9.16024555257e-06
Gc13_760 0 n26 ns760 0 -1.21128172379e-05
Gc13_761 0 n26 ns761 0 -0.00243792385011
Gc13_762 0 n26 ns762 0 -0.00307499665713
Gc13_763 0 n26 ns763 0 0.00713885446756
Gc13_764 0 n26 ns764 0 0.000926299148153
Gc13_765 0 n26 ns765 0 -0.00170494891855
Gc13_766 0 n26 ns766 0 0.000680547080387
Gc13_767 0 n26 ns767 0 0.00198111278616
Gc13_768 0 n26 ns768 0 4.03640390722e-05
Gc13_769 0 n26 ns769 0 -0.000226187189199
Gc13_770 0 n26 ns770 0 0.000576110735474
Gc13_771 0 n26 ns771 0 -0.0010016135985
Gc13_772 0 n26 ns772 0 -0.000826096260894
Gc13_773 0 n26 ns773 0 0.000484012835603
Gc13_774 0 n26 ns774 0 -0.000228721158866
Gc13_775 0 n26 ns775 0 0.000446985963391
Gc13_776 0 n26 ns776 0 0.00160982648743
Gc13_777 0 n26 ns777 0 -0.00257804836039
Gc13_778 0 n26 ns778 0 -0.000629295174746
Gc13_779 0 n26 ns779 0 -0.00037481276648
Gc13_780 0 n26 ns780 0 0.000215878518238
Gc13_781 0 n26 ns781 0 0.000236936197824
Gc13_782 0 n26 ns782 0 0.00203313954674
Gc13_783 0 n26 ns783 0 -0.00230187126083
Gc13_784 0 n26 ns784 0 -0.00254372710715
Gc13_785 0 n26 ns785 0 -0.0016266274383
Gc13_786 0 n26 ns786 0 -0.000290778496144
Gc13_787 0 n26 ns787 0 0.00223409977193
Gc13_788 0 n26 ns788 0 -0.011539687823
Gc13_789 0 n26 ns789 0 -0.00431439870875
Gc13_790 0 n26 ns790 0 0.000385165648144
Gc13_791 0 n26 ns791 0 0.00226497620827
Gc13_792 0 n26 ns792 0 0.00307202752797
Gc13_793 0 n26 ns793 0 0.000170488958092
Gc13_794 0 n26 ns794 0 -0.0325742111587
Gc13_795 0 n26 ns795 0 0.0348848874755
Gc13_796 0 n26 ns796 0 -0.00694735272333
Gc13_797 0 n26 ns797 0 -8.56062048649e-06
Gc13_798 0 n26 ns798 0 -8.32552513801e-06
Gc13_799 0 n26 ns799 0 -0.00538957547182
Gc13_800 0 n26 ns800 0 -0.0043820724708
Gc13_801 0 n26 ns801 0 0.00720875550096
Gc13_802 0 n26 ns802 0 0.00220856646597
Gc13_803 0 n26 ns803 0 -0.00190548286698
Gc13_804 0 n26 ns804 0 0.000812927873746
Gc13_805 0 n26 ns805 0 0.00299714848283
Gc13_806 0 n26 ns806 0 2.92496908486e-05
Gc13_807 0 n26 ns807 0 -0.000322909912356
Gc13_808 0 n26 ns808 0 -0.0012018709845
Gc13_809 0 n26 ns809 0 -0.00180746454232
Gc13_810 0 n26 ns810 0 -0.000599021848435
Gc13_811 0 n26 ns811 0 0.000829962602811
Gc13_812 0 n26 ns812 0 -7.85980043806e-05
Gc13_813 0 n26 ns813 0 0.000461413242479
Gc13_814 0 n26 ns814 0 0.00287714323459
Gc13_815 0 n26 ns815 0 -0.00186208505702
Gc13_816 0 n26 ns816 0 -0.000536132379225
Gc13_817 0 n26 ns817 0 -0.000907069279536
Gc13_818 0 n26 ns818 0 0.000117168938115
Gc13_819 0 n26 ns819 0 9.05537951173e-05
Gc13_820 0 n26 ns820 0 0.00269233535477
Gc13_821 0 n26 ns821 0 0.0012058605917
Gc13_822 0 n26 ns822 0 -0.0012639526808
Gc13_823 0 n26 ns823 0 -0.00247122965674
Gc13_824 0 n26 ns824 0 -0.0010399219487
Gc13_825 0 n26 ns825 0 0.00198445939808
Gc13_826 0 n26 ns826 0 -0.0137869031273
Gc13_827 0 n26 ns827 0 -0.00469971906151
Gc13_828 0 n26 ns828 0 0.00221150607702
Gc13_829 0 n26 ns829 0 0.00348497940293
Gc13_830 0 n26 ns830 0 0.00355658902278
Gc13_831 0 n26 ns831 0 0.000106739462292
Gc13_832 0 n26 ns832 0 0.0187245826174
Gc13_833 0 n26 ns833 0 -0.00943556467622
Gc13_834 0 n26 ns834 0 -0.00759691043838
Gc13_835 0 n26 ns835 0 -1.15129468571e-05
Gc13_836 0 n26 ns836 0 -7.80921003588e-06
Gc13_837 0 n26 ns837 0 0.000206136049917
Gc13_838 0 n26 ns838 0 -0.0010718476888
Gc13_839 0 n26 ns839 0 0.00985646598266
Gc13_840 0 n26 ns840 0 -0.000251283868948
Gc13_841 0 n26 ns841 0 0.000176100420087
Gc13_842 0 n26 ns842 0 0.00048610048956
Gc13_843 0 n26 ns843 0 -0.000511964808649
Gc13_844 0 n26 ns844 0 -8.39815693614e-05
Gc13_845 0 n26 ns845 0 3.3835286753e-05
Gc13_846 0 n26 ns846 0 0.00201961509641
Gc13_847 0 n26 ns847 0 -0.00276994565605
Gc13_848 0 n26 ns848 0 -0.000632350747412
Gc13_849 0 n26 ns849 0 0.000848617011753
Gc13_850 0 n26 ns850 0 -4.76817883871e-05
Gc13_851 0 n26 ns851 0 0.000523050984634
Gc13_852 0 n26 ns852 0 -0.00135088153535
Gc13_853 0 n26 ns853 0 -0.00244553836209
Gc13_854 0 n26 ns854 0 -0.000628698929639
Gc13_855 0 n26 ns855 0 0.00044019136024
Gc13_856 0 n26 ns856 0 0.000366368953676
Gc13_857 0 n26 ns857 0 0.000261540095661
Gc13_858 0 n26 ns858 0 -0.000251534546494
Gc13_859 0 n26 ns859 0 -0.00646243725071
Gc13_860 0 n26 ns860 0 -0.0029159775997
Gc13_861 0 n26 ns861 0 -0.000479807427247
Gc13_862 0 n26 ns862 0 0.000499392765737
Gc13_863 0 n26 ns863 0 0.00210712981915
Gc13_864 0 n26 ns864 0 -0.0109178659812
Gc13_865 0 n26 ns865 0 -0.00562699989917
Gc13_866 0 n26 ns866 0 -0.00184763761922
Gc13_867 0 n26 ns867 0 0.00293720520251
Gc13_868 0 n26 ns868 0 0.00271224911899
Gc13_869 0 n26 ns869 0 0.000163585522143
Gc13_870 0 n26 ns870 0 -0.0913994928586
Gc13_871 0 n26 ns871 0 0.0831613350672
Gc13_872 0 n26 ns872 0 -0.0052638046357
Gc13_873 0 n26 ns873 0 -1.01346745287e-05
Gc13_874 0 n26 ns874 0 -3.68128069499e-07
Gc13_875 0 n26 ns875 0 0.000610020099232
Gc13_876 0 n26 ns876 0 -0.0020287698721
Gc13_877 0 n26 ns877 0 0.0107737814252
Gc13_878 0 n26 ns878 0 0.000567228514013
Gc13_879 0 n26 ns879 0 7.37836447838e-05
Gc13_880 0 n26 ns880 0 6.1929109573e-05
Gc13_881 0 n26 ns881 0 -3.1105004131e-05
Gc13_882 0 n26 ns882 0 -4.78653914898e-05
Gc13_883 0 n26 ns883 0 1.03285817166e-05
Gc13_884 0 n26 ns884 0 -0.000277250229288
Gc13_885 0 n26 ns885 0 -0.00308941431564
Gc13_886 0 n26 ns886 0 -1.85958713206e-05
Gc13_887 0 n26 ns887 0 0.000501459917652
Gc13_888 0 n26 ns888 0 0.000119654802531
Gc13_889 0 n26 ns889 0 0.00050516070607
Gc13_890 0 n26 ns890 0 -0.000302197831491
Gc13_891 0 n26 ns891 0 -0.000824395593834
Gc13_892 0 n26 ns892 0 -0.000883097791357
Gc13_893 0 n26 ns893 0 9.33898351981e-05
Gc13_894 0 n26 ns894 0 0.000272549164253
Gc13_895 0 n26 ns895 0 9.41672616695e-05
Gc13_896 0 n26 ns896 0 -0.00235942645064
Gc13_897 0 n26 ns897 0 -0.00360283030683
Gc13_898 0 n26 ns898 0 -0.000979957712742
Gc13_899 0 n26 ns899 0 -0.000598265702258
Gc13_900 0 n26 ns900 0 0.000206009820324
Gc13_901 0 n26 ns901 0 0.00147409521075
Gc13_902 0 n26 ns902 0 -0.00839598906399
Gc13_903 0 n26 ns903 0 -0.00566970502832
Gc13_904 0 n26 ns904 0 -0.00129896458745
Gc13_905 0 n26 ns905 0 0.00414658279654
Gc13_906 0 n26 ns906 0 0.00209018120064
Gc13_907 0 n26 ns907 0 -0.000417888068535
Gc13_908 0 n26 ns908 0 -0.0622287100599
Gc13_909 0 n26 ns909 0 0.0533151639969
Gc13_910 0 n26 ns910 0 -0.00224511179776
Gc13_911 0 n26 ns911 0 -8.81616035617e-06
Gc13_912 0 n26 ns912 0 4.1793018927e-07
Gc13_913 0 n26 ns913 0 -2.65524945164e-05
Gc13_914 0 n26 ns914 0 0.000217072084819
Gc13_915 0 n26 ns915 0 0.00407566308462
Gc13_916 0 n26 ns916 0 -6.84923239468e-05
Gc13_917 0 n26 ns917 0 0.00029647833372
Gc13_918 0 n26 ns918 0 0.000423390810622
Gc13_919 0 n26 ns919 0 -1.31801015944e-05
Gc13_920 0 n26 ns920 0 3.30261348531e-05
Gc13_921 0 n26 ns921 0 -4.25538131503e-05
Gc13_922 0 n26 ns922 0 -0.000487135779973
Gc13_923 0 n26 ns923 0 -9.74262318028e-05
Gc13_924 0 n26 ns924 0 0.000224593059496
Gc13_925 0 n26 ns925 0 -0.000621148677371
Gc13_926 0 n26 ns926 0 -4.91792367472e-05
Gc13_927 0 n26 ns927 0 0.000204165143085
Gc13_928 0 n26 ns928 0 0.00146174299618
Gc13_929 0 n26 ns929 0 -0.00144420165791
Gc13_930 0 n26 ns930 0 -0.00147982736343
Gc13_931 0 n26 ns931 0 0.000153715154077
Gc13_932 0 n26 ns932 0 0.000114229706461
Gc13_933 0 n26 ns933 0 0.000191305408516
Gc13_934 0 n26 ns934 0 -0.000830618094145
Gc13_935 0 n26 ns935 0 -0.00137049041691
Gc13_936 0 n26 ns936 0 -0.000579722733367
Gc13_937 0 n26 ns937 0 -0.00131551233664
Gc13_938 0 n26 ns938 0 7.03105326945e-07
Gc13_939 0 n26 ns939 0 0.00126604091142
Gc13_940 0 n26 ns940 0 -0.00511476352154
Gc13_941 0 n26 ns941 0 -0.00355697776908
Gc13_942 0 n26 ns942 0 -0.000173915451059
Gc13_943 0 n26 ns943 0 0.00288514741496
Gc13_944 0 n26 ns944 0 0.00115113660655
Gc13_945 0 n26 ns945 0 -0.000533871078176
Gc13_946 0 n26 ns946 0 -0.0256869352112
Gc13_947 0 n26 ns947 0 0.0213967000416
Gc13_948 0 n26 ns948 0 -0.000820125035717
Gc13_949 0 n26 ns949 0 -1.22774966096e-06
Gc13_950 0 n26 ns950 0 3.51800640269e-06
Gc13_951 0 n26 ns951 0 0.000260170151914
Gc13_952 0 n26 ns952 0 -0.000956734846985
Gc13_953 0 n26 ns953 0 0.00670425569567
Gc13_954 0 n26 ns954 0 0.00014531080951
Gc13_955 0 n26 ns955 0 0.000287131705127
Gc13_956 0 n26 ns956 0 0.000324904280415
Gc13_957 0 n26 ns957 0 6.97969754967e-05
Gc13_958 0 n26 ns958 0 7.22732200684e-07
Gc13_959 0 n26 ns959 0 4.17032371436e-06
Gc13_960 0 n26 ns960 0 -0.000301182544484
Gc13_961 0 n26 ns961 0 -0.00208032735354
Gc13_962 0 n26 ns962 0 -1.30174198424e-05
Gc13_963 0 n26 ns963 0 0.000260126423185
Gc13_964 0 n26 ns964 0 0.000213698602754
Gc13_965 0 n26 ns965 0 0.000370773898743
Gc13_966 0 n26 ns966 0 0.00062840503055
Gc13_967 0 n26 ns967 0 -0.00112145058285
Gc13_968 0 n26 ns968 0 -0.00106916537636
Gc13_969 0 n26 ns969 0 0.000243288913639
Gc13_970 0 n26 ns970 0 0.000173853391772
Gc13_971 0 n26 ns971 0 4.78205655319e-05
Gc13_972 0 n26 ns972 0 -0.00122513359588
Gc13_973 0 n26 ns973 0 -0.002500487282
Gc13_974 0 n26 ns974 0 -0.00116769476143
Gc13_975 0 n26 ns975 0 -0.00117758396767
Gc13_976 0 n26 ns976 0 0.000331259520147
Gc13_977 0 n26 ns977 0 0.00152125072178
Gc13_978 0 n26 ns978 0 -0.0069347033328
Gc13_979 0 n26 ns979 0 -0.00437961797209
Gc13_980 0 n26 ns980 0 -0.000238985411544
Gc13_981 0 n26 ns981 0 0.00358953921651
Gc13_982 0 n26 ns982 0 0.00145884750898
Gc13_983 0 n26 ns983 0 -0.0006443630527
Gc13_984 0 n26 ns984 0 -0.0382308496373
Gc13_985 0 n26 ns985 0 0.0320915777675
Gc13_986 0 n26 ns986 0 -0.00123131613423
Gc13_987 0 n26 ns987 0 -4.95121978687e-06
Gc13_988 0 n26 ns988 0 -7.98498380804e-06
Gc13_989 0 n26 ns989 0 0.000782117864768
Gc13_990 0 n26 ns990 0 -0.000804791544496
Gc13_991 0 n26 ns991 0 0.0102866458751
Gc13_992 0 n26 ns992 0 1.97659911628e-05
Gc13_993 0 n26 ns993 0 0.000737611772004
Gc13_994 0 n26 ns994 0 0.000414971665911
Gc13_995 0 n26 ns995 0 -0.000127175626942
Gc13_996 0 n26 ns996 0 -8.6365011581e-05
Gc13_997 0 n26 ns997 0 -1.09904618052e-05
Gc13_998 0 n26 ns998 0 0.000140671781375
Gc13_999 0 n26 ns999 0 -0.00445775946101
Gc13_1000 0 n26 ns1000 0 0.00012061507837
Gc13_1001 0 n26 ns1001 0 0.00121103837858
Gc13_1002 0 n26 ns1002 0 0.000176359765215
Gc13_1003 0 n26 ns1003 0 0.000453724812945
Gc13_1004 0 n26 ns1004 0 -0.00115097630045
Gc13_1005 0 n26 ns1005 0 -0.000633284684449
Gc13_1006 0 n26 ns1006 0 -0.000402467874742
Gc13_1007 0 n26 ns1007 0 -5.498121281e-06
Gc13_1008 0 n26 ns1008 0 0.000293815190633
Gc13_1009 0 n26 ns1009 0 6.04173199803e-05
Gc13_1010 0 n26 ns1010 0 -0.00223990560659
Gc13_1011 0 n26 ns1011 0 -0.00495742524724
Gc13_1012 0 n26 ns1012 0 -0.00156972595716
Gc13_1013 0 n26 ns1013 0 -9.07371024357e-05
Gc13_1014 0 n26 ns1014 0 0.000443434652663
Gc13_1015 0 n26 ns1015 0 0.00151901153996
Gc13_1016 0 n26 ns1016 0 -0.00903151048164
Gc13_1017 0 n26 ns1017 0 -0.00539705460174
Gc13_1018 0 n26 ns1018 0 -0.00157298026399
Gc13_1019 0 n26 ns1019 0 0.00385949623145
Gc13_1020 0 n26 ns1020 0 0.00230173001342
Gc13_1021 0 n26 ns1021 0 -0.00031358314538
Gc13_1022 0 n26 ns1022 0 -0.0701527098182
Gc13_1023 0 n26 ns1023 0 0.0611233966565
Gc13_1024 0 n26 ns1024 0 -0.00291190291435
Gc13_1025 0 n26 ns1025 0 -9.66753198777e-06
Gc13_1026 0 n26 ns1026 0 -1.30641679253e-05
Gc13_1027 0 n26 ns1027 0 -0.000162613365179
Gc13_1028 0 n26 ns1028 0 -0.000249825694019
Gc13_1029 0 n26 ns1029 0 0.0059875425174
Gc13_1030 0 n26 ns1030 0 -0.00132753074944
Gc13_1031 0 n26 ns1031 0 -0.000416717340457
Gc13_1032 0 n26 ns1032 0 0.00186261720594
Gc13_1033 0 n26 ns1033 0 0.000527440163035
Gc13_1034 0 n26 ns1034 0 -0.000161899037115
Gc13_1035 0 n26 ns1035 0 -0.000185777658148
Gc13_1036 0 n26 ns1036 0 0.00185257372471
Gc13_1037 0 n26 ns1037 0 -0.00220957413557
Gc13_1038 0 n26 ns1038 0 -0.000528806123246
Gc13_1039 0 n26 ns1039 0 0.000872376405637
Gc13_1040 0 n26 ns1040 0 -0.000129020089816
Gc13_1041 0 n26 ns1041 0 0.00044162695464
Gc13_1042 0 n26 ns1042 0 -0.000183207226859
Gc13_1043 0 n26 ns1043 0 -0.00321874167451
Gc13_1044 0 n26 ns1044 0 -0.000884110761004
Gc13_1045 0 n26 ns1045 0 0.000109969536522
Gc13_1046 0 n26 ns1046 0 0.000263012757989
Gc13_1047 0 n26 ns1047 0 0.000342600024185
Gc13_1048 0 n26 ns1048 0 0.000933967211375
Gc13_1049 0 n26 ns1049 0 -0.00544606655636
Gc13_1050 0 n26 ns1050 0 -0.00291158348018
Gc13_1051 0 n26 ns1051 0 -0.000847320994432
Gc13_1052 0 n26 ns1052 0 0.000216728741038
Gc13_1053 0 n26 ns1053 0 0.00214743092099
Gc13_1054 0 n26 ns1054 0 -0.0122490963071
Gc13_1055 0 n26 ns1055 0 -0.00510264057899
Gc13_1056 0 n26 ns1056 0 -0.000830074015344
Gc13_1057 0 n26 ns1057 0 0.00283979708901
Gc13_1058 0 n26 ns1058 0 0.00301166470608
Gc13_1059 0 n26 ns1059 0 0.000219836249378
Gc13_1060 0 n26 ns1060 0 -0.0661400678567
Gc13_1061 0 n26 ns1061 0 0.0630589819477
Gc13_1062 0 n26 ns1062 0 -0.00631247790977
Gc13_1063 0 n26 ns1063 0 -8.3817896435e-06
Gc13_1064 0 n26 ns1064 0 -6.7347146384e-06
Gc13_1065 0 n26 ns1065 0 -0.0168278534561
Gc13_1066 0 n26 ns1066 0 -0.00157571078278
Gc13_1067 0 n26 ns1067 0 0.0208828871499
Gc13_1068 0 n26 ns1068 0 0.00623416136803
Gc13_1069 0 n26 ns1069 0 0.0102892293575
Gc13_1070 0 n26 ns1070 0 0.00152976514748
Gc13_1071 0 n26 ns1071 0 -0.00330065135682
Gc13_1072 0 n26 ns1072 0 -0.000508415546514
Gc13_1073 0 n26 ns1073 0 2.75128636613e-05
Gc13_1074 0 n26 ns1074 0 -0.00155800165066
Gc13_1075 0 n26 ns1075 0 -0.0143935427257
Gc13_1076 0 n26 ns1076 0 0.00127432989241
Gc13_1077 0 n26 ns1077 0 0.0019802095691
Gc13_1078 0 n26 ns1078 0 0.000210817089484
Gc13_1079 0 n26 ns1079 0 0.000321151442918
Gc13_1080 0 n26 ns1080 0 0.000384863599935
Gc13_1081 0 n26 ns1081 0 0.000732410830404
Gc13_1082 0 n26 ns1082 0 6.16858439991e-05
Gc13_1083 0 n26 ns1083 0 0.0003141184031
Gc13_1084 0 n26 ns1084 0 0.000468922528966
Gc13_1085 0 n26 ns1085 0 0.000335590162663
Gc13_1086 0 n26 ns1086 0 -0.0118549005845
Gc13_1087 0 n26 ns1087 0 -0.00792471601535
Gc13_1088 0 n26 ns1088 0 -0.00364406894865
Gc13_1089 0 n26 ns1089 0 -0.00113076365471
Gc13_1090 0 n26 ns1090 0 0.000165726259381
Gc13_1091 0 n26 ns1091 0 0.00245934870895
Gc13_1092 0 n26 ns1092 0 0.00827134046763
Gc13_1093 0 n26 ns1093 0 -0.00525266629637
Gc13_1094 0 n26 ns1094 0 0.00195201302721
Gc13_1095 0 n26 ns1095 0 0.00182735218676
Gc13_1096 0 n26 ns1096 0 0.00326873631575
Gc13_1097 0 n26 ns1097 0 -4.6205271596e-05
Gc13_1098 0 n26 ns1098 0 -0.107202611957
Gc13_1099 0 n26 ns1099 0 0.069315745139
Gc13_1100 0 n26 ns1100 0 -0.0087728976658
Gc13_1101 0 n26 ns1101 0 -1.09150061886e-05
Gc13_1102 0 n26 ns1102 0 -8.23207084821e-06
Gc13_1103 0 n26 ns1103 0 -0.000355809647655
Gc13_1104 0 n26 ns1104 0 4.754067113e-05
Gc13_1105 0 n26 ns1105 0 0.00571497945379
Gc13_1106 0 n26 ns1106 0 -0.00132474886677
Gc13_1107 0 n26 ns1107 0 -0.000357489733922
Gc13_1108 0 n26 ns1108 0 0.00187456664627
Gc13_1109 0 n26 ns1109 0 0.000580844857473
Gc13_1110 0 n26 ns1110 0 -0.000161227716287
Gc13_1111 0 n26 ns1111 0 -0.000186535315073
Gc13_1112 0 n26 ns1112 0 0.00209081086138
Gc13_1113 0 n26 ns1113 0 -0.00277576869759
Gc13_1114 0 n26 ns1114 0 -0.000671219151237
Gc13_1115 0 n26 ns1115 0 0.00111710928854
Gc13_1116 0 n26 ns1116 0 -4.3617646012e-05
Gc13_1117 0 n26 ns1117 0 0.000500923155907
Gc13_1118 0 n26 ns1118 0 -0.00040973874419
Gc13_1119 0 n26 ns1119 0 -0.00334126779503
Gc13_1120 0 n26 ns1120 0 -0.000845824980184
Gc13_1121 0 n26 ns1121 0 0.000250364314463
Gc13_1122 0 n26 ns1122 0 0.00030108802048
Gc13_1123 0 n26 ns1123 0 0.000330507962749
Gc13_1124 0 n26 ns1124 0 0.00108964029739
Gc13_1125 0 n26 ns1125 0 -0.00546941650474
Gc13_1126 0 n26 ns1126 0 -0.00296731451562
Gc13_1127 0 n26 ns1127 0 -0.00100589450789
Gc13_1128 0 n26 ns1128 0 0.000193818063567
Gc13_1129 0 n26 ns1129 0 0.00225255248407
Gc13_1130 0 n26 ns1130 0 -0.0123568379834
Gc13_1131 0 n26 ns1131 0 -0.00540214003007
Gc13_1132 0 n26 ns1132 0 -0.000890218005898
Gc13_1133 0 n26 ns1133 0 0.00291854948675
Gc13_1134 0 n26 ns1134 0 0.00304114981235
Gc13_1135 0 n26 ns1135 0 0.000240482559643
Gc13_1136 0 n26 ns1136 0 -0.0677841351457
Gc13_1137 0 n26 ns1137 0 0.0644970424889
Gc13_1138 0 n26 ns1138 0 -0.00636373625124
Gc13_1139 0 n26 ns1139 0 -9.92198238107e-06
Gc13_1140 0 n26 ns1140 0 2.8334941183e-06
Gc13_1141 0 n26 ns1141 0 0.000756151042985
Gc13_1142 0 n26 ns1142 0 -0.00108826260928
Gc13_1143 0 n26 ns1143 0 0.0115141821623
Gc13_1144 0 n26 ns1144 0 0.000245652783688
Gc13_1145 0 n26 ns1145 0 0.000646603597468
Gc13_1146 0 n26 ns1146 0 0.000367247062003
Gc13_1147 0 n26 ns1147 0 -0.000249191679464
Gc13_1148 0 n26 ns1148 0 -0.000116126832861
Gc13_1149 0 n26 ns1149 0 -5.91827029161e-06
Gc13_1150 0 n26 ns1150 0 0.000374516333876
Gc13_1151 0 n26 ns1151 0 -0.00444707018466
Gc13_1152 0 n26 ns1152 0 -0.00011378785404
Gc13_1153 0 n26 ns1153 0 0.00106690517896
Gc13_1154 0 n26 ns1154 0 0.000149023759084
Gc13_1155 0 n26 ns1155 0 0.000556104665076
Gc13_1156 0 n26 ns1156 0 -0.00126501776769
Gc13_1157 0 n26 ns1157 0 -0.00119916030556
Gc13_1158 0 n26 ns1158 0 -0.00064438823522
Gc13_1159 0 n26 ns1159 0 0.000238499412078
Gc13_1160 0 n26 ns1160 0 0.000353607969896
Gc13_1161 0 n26 ns1161 0 0.000127264476934
Gc13_1162 0 n26 ns1162 0 -0.00250895350046
Gc13_1163 0 n26 ns1163 0 -0.00501738246168
Gc13_1164 0 n26 ns1164 0 -0.00159382377056
Gc13_1165 0 n26 ns1165 0 -0.000201441405832
Gc13_1166 0 n26 ns1166 0 0.000418544382677
Gc13_1167 0 n26 ns1167 0 0.00161774127695
Gc13_1168 0 n26 ns1168 0 -0.00990179551062
Gc13_1169 0 n26 ns1169 0 -0.00607798928715
Gc13_1170 0 n26 ns1170 0 -0.00163858471811
Gc13_1171 0 n26 ns1171 0 0.00420283867869
Gc13_1172 0 n26 ns1172 0 0.00242519451295
Gc13_1173 0 n26 ns1173 0 -0.000296115391072
Gc13_1174 0 n26 ns1174 0 -0.0773731369872
Gc13_1175 0 n26 ns1175 0 0.0672013502853
Gc13_1176 0 n26 ns1176 0 -0.00311341636798
Gc13_1177 0 n26 ns1177 0 -9.45653142912e-06
Gc13_1178 0 n26 ns1178 0 6.43935477852e-08
Gc13_1179 0 n26 ns1179 0 8.66372271812e-05
Gc13_1180 0 n26 ns1180 0 -0.000488245958578
Gc13_1181 0 n26 ns1181 0 0.00622191891852
Gc13_1182 0 n26 ns1182 0 0.000226926101489
Gc13_1183 0 n26 ns1183 0 0.00017314849967
Gc13_1184 0 n26 ns1184 0 0.000353920655467
Gc13_1185 0 n26 ns1185 0 4.91770604299e-06
Gc13_1186 0 n26 ns1186 0 5.6351375001e-06
Gc13_1187 0 n26 ns1187 0 -2.39732116631e-05
Gc13_1188 0 n26 ns1188 0 -0.00071686889689
Gc13_1189 0 n26 ns1189 0 -0.00101658458018
Gc13_1190 0 n26 ns1190 0 0.000259102466756
Gc13_1191 0 n26 ns1191 0 -0.000354798908481
Gc13_1192 0 n26 ns1192 0 1.12948105748e-05
Gc13_1193 0 n26 ns1193 0 0.00031048835096
Gc13_1194 0 n26 ns1194 0 0.00122395175251
Gc13_1195 0 n26 ns1195 0 -0.00129580123678
Gc13_1196 0 n26 ns1196 0 -0.00149507300428
Gc13_1197 0 n26 ns1197 0 8.59392981602e-05
Gc13_1198 0 n26 ns1198 0 0.000159168778281
Gc13_1199 0 n26 ns1199 0 0.000176330901335
Gc13_1200 0 n26 ns1200 0 -0.00136974826815
Gc13_1201 0 n26 ns1201 0 -0.0020298512299
Gc13_1202 0 n26 ns1202 0 -0.00068195504073
Gc13_1203 0 n26 ns1203 0 -0.00129735455718
Gc13_1204 0 n26 ns1204 0 3.24597333238e-05
Gc13_1205 0 n26 ns1205 0 0.00145408533364
Gc13_1206 0 n26 ns1206 0 -0.00645505545885
Gc13_1207 0 n26 ns1207 0 -0.00453368709817
Gc13_1208 0 n26 ns1208 0 -0.00046202679881
Gc13_1209 0 n26 ns1209 0 0.00353559880376
Gc13_1210 0 n26 ns1210 0 0.00148916156783
Gc13_1211 0 n26 ns1211 0 -0.000565899384625
Gc13_1212 0 n26 ns1212 0 -0.0377650895645
Gc13_1213 0 n26 ns1213 0 0.0317819227866
Gc13_1214 0 n26 ns1214 0 -0.00123802885415
Gc13_1215 0 n26 ns1215 0 -5.75434545311e-06
Gc13_1216 0 n26 ns1216 0 2.32575322377e-06
Gd13_1 0 n26 ni1 0 5.54238699935e-05
Gd13_2 0 n26 ni2 0 0.000179374519832
Gd13_3 0 n26 ni3 0 0.000169996633621
Gd13_4 0 n26 ni4 0 -0.000858683287362
Gd13_5 0 n26 ni5 0 -0.00275534922366
Gd13_6 0 n26 ni6 0 -0.000808013252706
Gd13_7 0 n26 ni7 0 -0.00114412609597
Gd13_8 0 n26 ni8 0 0.000260596635387
Gd13_9 0 n26 ni9 0 0.000209670638081
Gd13_10 0 n26 ni10 0 0.00028657219262
Gd13_11 0 n26 ni11 0 -0.000402319469783
Gd13_12 0 n26 ni12 0 -0.001872843062
Gd13_13 0 n26 ni13 0 -7.48962372539e-06
Gd13_14 0 n26 ni14 0 -0.00181966477876
Gd13_15 0 n26 ni15 0 -0.000314480299539
Gd13_16 0 n26 ni16 0 0.000346008034885
Gd13_17 0 n26 ni17 0 7.34667444891e-05
Gd13_18 0 n26 ni18 0 4.94698513976e-05
Gd13_19 0 n26 ni19 0 0.00018539073841
Gd13_20 0 n26 ni20 0 2.67558674954e-05
Gd13_21 0 n26 ni21 0 -0.00165282779156
Gd13_22 0 n26 ni22 0 -0.00303353500691
Gd13_23 0 n26 ni23 0 -0.000177672325928
Gd13_24 0 n26 ni24 0 0.000124514698675
Gd13_25 0 n26 ni25 0 0.000261973256043
Gd13_26 0 n26 ni26 0 0.000105237924624
Gd13_27 0 n26 ni27 0 0.00057440318255
Gd13_28 0 n26 ni28 0 -0.000346805350861
Gd13_29 0 n26 ni29 0 -0.00677371270411
Gd13_30 0 n26 ni30 0 -0.000380952779892
Gd13_31 0 n26 ni31 0 0.000496669445881
Gd13_32 0 n26 ni32 0 0.000149394312639
Gc14_1 0 n28 ns1 0 0.000388591108461
Gc14_2 0 n28 ns2 0 -0.00124104363237
Gc14_3 0 n28 ns3 0 0.00219040347385
Gc14_4 0 n28 ns4 0 0.000197089047345
Gc14_5 0 n28 ns5 0 -0.000132743351758
Gc14_6 0 n28 ns6 0 0.000100173205221
Gc14_7 0 n28 ns7 0 1.62005864098e-05
Gc14_8 0 n28 ns8 0 3.42788567725e-05
Gc14_9 0 n28 ns9 0 -3.71341669629e-05
Gc14_10 0 n28 ns10 0 -0.0013902787146
Gc14_11 0 n28 ns11 0 -5.97093925006e-05
Gc14_12 0 n28 ns12 0 0.000721726345954
Gc14_13 0 n28 ns13 0 -0.000253349954723
Gc14_14 0 n28 ns14 0 -0.000139963825565
Gc14_15 0 n28 ns15 0 -0.000129245771141
Gc14_16 0 n28 ns16 0 -0.00135828235016
Gc14_17 0 n28 ns17 0 -0.000143976713463
Gc14_18 0 n28 ns18 0 0.000462016271107
Gc14_19 0 n28 ns19 0 0.000745554043536
Gc14_20 0 n28 ns20 0 0.00015486258534
Gc14_21 0 n28 ns21 0 -0.000135480092174
Gc14_22 0 n28 ns22 0 -0.000437464979895
Gc14_23 0 n28 ns23 0 0.00129875785983
Gc14_24 0 n28 ns24 0 0.000975987495113
Gc14_25 0 n28 ns25 0 0.000134000830853
Gc14_26 0 n28 ns26 0 -0.000525674774255
Gc14_27 0 n28 ns27 0 -0.00037733067383
Gc14_28 0 n28 ns28 0 -0.000422323657614
Gc14_29 0 n28 ns29 0 0.000821469834792
Gc14_30 0 n28 ns30 0 0.000457182913352
Gc14_31 0 n28 ns31 0 0.000356141620124
Gc14_32 0 n28 ns32 0 9.16335513529e-05
Gc14_33 0 n28 ns33 0 -0.000357192387727
Gc14_34 0 n28 ns34 0 0.00673467965118
Gc14_35 0 n28 ns35 0 -0.00633095467802
Gc14_36 0 n28 ns36 0 0.000319912510447
Gc14_37 0 n28 ns37 0 -7.18067868398e-06
Gc14_38 0 n28 ns38 0 -2.41496369889e-05
Gc14_39 0 n28 ns39 0 0.000358086716897
Gc14_40 0 n28 ns40 0 -0.000857644052224
Gc14_41 0 n28 ns41 0 0.00241650047433
Gc14_42 0 n28 ns42 0 6.57045739223e-05
Gc14_43 0 n28 ns43 0 0.000186749363173
Gc14_44 0 n28 ns44 0 0.000267590704087
Gc14_45 0 n28 ns45 0 6.87687957564e-06
Gc14_46 0 n28 ns46 0 5.99844369566e-06
Gc14_47 0 n28 ns47 0 -3.41803213078e-05
Gc14_48 0 n28 ns48 0 -0.00119170694949
Gc14_49 0 n28 ns49 0 -0.000487384685146
Gc14_50 0 n28 ns50 0 0.00080489048099
Gc14_51 0 n28 ns51 0 -8.37245709906e-05
Gc14_52 0 n28 ns52 0 -0.000146173606847
Gc14_53 0 n28 ns53 0 -0.00016128578839
Gc14_54 0 n28 ns54 0 -0.00125398982978
Gc14_55 0 n28 ns55 0 -0.000645677015564
Gc14_56 0 n28 ns56 0 0.000248761474937
Gc14_57 0 n28 ns57 0 0.000917093180943
Gc14_58 0 n28 ns58 0 0.000183939840501
Gc14_59 0 n28 ns59 0 -0.000119285177404
Gc14_60 0 n28 ns60 0 -0.000782672855807
Gc14_61 0 n28 ns61 0 0.00102334299579
Gc14_62 0 n28 ns62 0 0.00104644880719
Gc14_63 0 n28 ns63 0 0.000378354938213
Gc14_64 0 n28 ns64 0 -0.000537819049076
Gc14_65 0 n28 ns65 0 -0.000532937420386
Gc14_66 0 n28 ns66 0 -0.00101338544172
Gc14_67 0 n28 ns67 0 0.000193753812476
Gc14_68 0 n28 ns68 0 0.00036685849346
Gc14_69 0 n28 ns69 0 0.000747162211664
Gc14_70 0 n28 ns70 0 0.000241898984892
Gc14_71 0 n28 ns71 0 -0.000393803102245
Gc14_72 0 n28 ns72 0 0.00301836480003
Gc14_73 0 n28 ns73 0 -0.00333595775577
Gc14_74 0 n28 ns74 0 0.000257405968494
Gc14_75 0 n28 ns75 0 -3.84898849829e-06
Gc14_76 0 n28 ns76 0 -2.55272306053e-05
Gc14_77 0 n28 ns77 0 -0.00050751454666
Gc14_78 0 n28 ns78 0 0.000881263553969
Gc14_79 0 n28 ns79 0 -0.00180433057285
Gc14_80 0 n28 ns80 0 -0.000303081263549
Gc14_81 0 n28 ns81 0 0.000113537998648
Gc14_82 0 n28 ns82 0 -0.000134656735033
Gc14_83 0 n28 ns83 0 0.00012675211198
Gc14_84 0 n28 ns84 0 -1.07541126777e-05
Gc14_85 0 n28 ns85 0 1.29086168955e-05
Gc14_86 0 n28 ns86 0 0.000777717548686
Gc14_87 0 n28 ns87 0 0.000578030354617
Gc14_88 0 n28 ns88 0 8.969083543e-05
Gc14_89 0 n28 ns89 0 0.000190122561478
Gc14_90 0 n28 ns90 0 -0.000141389625612
Gc14_91 0 n28 ns91 0 -0.000201377831262
Gc14_92 0 n28 ns92 0 0.000732388679451
Gc14_93 0 n28 ns93 0 -0.000598947803484
Gc14_94 0 n28 ns94 0 -0.000483419476155
Gc14_95 0 n28 ns95 0 0.000415691107802
Gc14_96 0 n28 ns96 0 0.000173032083
Gc14_97 0 n28 ns97 0 -8.91613668158e-05
Gc14_98 0 n28 ns98 0 0.000154998504496
Gc14_99 0 n28 ns99 0 -6.7406841057e-05
Gc14_100 0 n28 ns100 0 0.000637495793337
Gc14_101 0 n28 ns101 0 0.000843961583124
Gc14_102 0 n28 ns102 0 -0.000318988049303
Gc14_103 0 n28 ns103 0 -0.000848485906807
Gc14_104 0 n28 ns104 0 -0.00040616651278
Gc14_105 0 n28 ns105 0 -0.000305253345263
Gc14_106 0 n28 ns106 0 0.00026282770924
Gc14_107 0 n28 ns107 0 0.00128051175883
Gc14_108 0 n28 ns108 0 0.000488797232211
Gc14_109 0 n28 ns109 0 -0.000657131282199
Gc14_110 0 n28 ns110 0 0.0164474648514
Gc14_111 0 n28 ns111 0 -0.015130057048
Gc14_112 0 n28 ns112 0 0.000764732258632
Gc14_113 0 n28 ns113 0 -4.87792914405e-06
Gc14_114 0 n28 ns114 0 -2.63556548776e-05
Gc14_115 0 n28 ns115 0 -0.00126679291076
Gc14_116 0 n28 ns116 0 0.00250108211558
Gc14_117 0 n28 ns117 0 -0.00613791370269
Gc14_118 0 n28 ns118 0 -0.000280263520124
Gc14_119 0 n28 ns119 0 -0.000305019384255
Gc14_120 0 n28 ns120 0 -0.000167810593814
Gc14_121 0 n28 ns121 0 -0.000220468709452
Gc14_122 0 n28 ns122 0 -1.70935710277e-05
Gc14_123 0 n28 ns123 0 2.42155747746e-05
Gc14_124 0 n28 ns124 0 8.60412500347e-05
Gc14_125 0 n28 ns125 0 0.00228723655493
Gc14_126 0 n28 ns126 0 -0.000378893544882
Gc14_127 0 n28 ns127 0 -0.000319450288428
Gc14_128 0 n28 ns128 0 -6.55769002554e-05
Gc14_129 0 n28 ns129 0 -0.00028333081862
Gc14_130 0 n28 ns130 0 0.000829843700009
Gc14_131 0 n28 ns131 0 0.00182240439633
Gc14_132 0 n28 ns132 0 -0.000112200807577
Gc14_133 0 n28 ns133 0 -0.000475560934878
Gc14_134 0 n28 ns134 0 0.000243633520056
Gc14_135 0 n28 ns135 0 -0.00013931424456
Gc14_136 0 n28 ns136 0 0.00259473032505
Gc14_137 0 n28 ns137 0 0.00154395828148
Gc14_138 0 n28 ns138 0 0.000300732028583
Gc14_139 0 n28 ns139 0 0.000318759887867
Gc14_140 0 n28 ns140 0 -0.000165380939809
Gc14_141 0 n28 ns141 0 -0.000953925286431
Gc14_142 0 n28 ns142 0 0.00319101060833
Gc14_143 0 n28 ns143 0 0.000200110821046
Gc14_144 0 n28 ns144 0 -0.000866475677259
Gc14_145 0 n28 ns145 0 0.00102664785991
Gc14_146 0 n28 ns146 0 0.000850908704465
Gc14_147 0 n28 ns147 0 -0.000646088130001
Gc14_148 0 n28 ns148 0 0.0421474207141
Gc14_149 0 n28 ns149 0 -0.0376334414837
Gc14_150 0 n28 ns150 0 0.00180748136573
Gc14_151 0 n28 ns151 0 -6.43382098422e-06
Gc14_152 0 n28 ns152 0 -2.17694551813e-05
Gc14_153 0 n28 ns153 0 -0.00171802376928
Gc14_154 0 n28 ns154 0 0.00057484453796
Gc14_155 0 n28 ns155 0 -0.00157957119133
Gc14_156 0 n28 ns156 0 0.00050331658189
Gc14_157 0 n28 ns157 0 -0.00050702888117
Gc14_158 0 n28 ns158 0 0.000625953167172
Gc14_159 0 n28 ns159 0 -1.88468681442e-05
Gc14_160 0 n28 ns160 0 -0.000131922200316
Gc14_161 0 n28 ns161 0 8.50303840251e-06
Gc14_162 0 n28 ns162 0 -0.00193636344578
Gc14_163 0 n28 ns163 0 0.000324688544837
Gc14_164 0 n28 ns164 0 0.000638573653217
Gc14_165 0 n28 ns165 0 -0.000548202034441
Gc14_166 0 n28 ns166 0 0.000150578725896
Gc14_167 0 n28 ns167 0 -0.000468531514069
Gc14_168 0 n28 ns168 0 -0.00184051301978
Gc14_169 0 n28 ns169 0 9.5673609035e-05
Gc14_170 0 n28 ns170 0 0.000173764510343
Gc14_171 0 n28 ns171 0 0.000134674880051
Gc14_172 0 n28 ns172 0 0.000452379481121
Gc14_173 0 n28 ns173 0 5.85688376182e-05
Gc14_174 0 n28 ns174 0 -0.000952102784008
Gc14_175 0 n28 ns175 0 0.00352195815482
Gc14_176 0 n28 ns176 0 0.000977380486571
Gc14_177 0 n28 ns177 0 0.000403449624084
Gc14_178 0 n28 ns178 0 0.000130321674499
Gc14_179 0 n28 ns179 0 -0.00137663478734
Gc14_180 0 n28 ns180 0 0.00168637511793
Gc14_181 0 n28 ns181 0 0.00210805116393
Gc14_182 0 n28 ns182 0 -0.00174896802025
Gc14_183 0 n28 ns183 0 0.000326327802526
Gc14_184 0 n28 ns184 0 0.00162254798081
Gc14_185 0 n28 ns185 0 -0.000260607575818
Gc14_186 0 n28 ns186 0 0.0514668705674
Gc14_187 0 n28 ns187 0 -0.049972276988
Gc14_188 0 n28 ns188 0 0.00371976363894
Gc14_189 0 n28 ns189 0 -7.40810175549e-07
Gc14_190 0 n28 ns190 0 -8.66401444022e-06
Gc14_191 0 n28 ns191 0 -0.00485327359101
Gc14_192 0 n28 ns192 0 -0.00104071925219
Gc14_193 0 n28 ns193 0 -0.00391252333196
Gc14_194 0 n28 ns194 0 0.000261986389071
Gc14_195 0 n28 ns195 0 -0.00118083418483
Gc14_196 0 n28 ns196 0 -3.40796561855e-05
Gc14_197 0 n28 ns197 0 0.000840743874572
Gc14_198 0 n28 ns198 0 -0.000115083699676
Gc14_199 0 n28 ns199 0 -8.3615669e-05
Gc14_200 0 n28 ns200 0 -0.000800879951559
Gc14_201 0 n28 ns201 0 0.00198412731005
Gc14_202 0 n28 ns202 0 0.00100391021402
Gc14_203 0 n28 ns203 0 -0.000500453232673
Gc14_204 0 n28 ns204 0 0.000207063657299
Gc14_205 0 n28 ns205 0 -0.000542406753324
Gc14_206 0 n28 ns206 0 0.000355606409042
Gc14_207 0 n28 ns207 0 -0.000715425478739
Gc14_208 0 n28 ns208 0 0.000116726089394
Gc14_209 0 n28 ns209 0 6.67494823838e-05
Gc14_210 0 n28 ns210 0 0.000456472385061
Gc14_211 0 n28 ns211 0 0.0001423101889
Gc14_212 0 n28 ns212 0 -0.0013540575556
Gc14_213 0 n28 ns213 0 0.00104132731011
Gc14_214 0 n28 ns214 0 0.00158341911083
Gc14_215 0 n28 ns215 0 0.001851625519
Gc14_216 0 n28 ns216 0 0.000780024262662
Gc14_217 0 n28 ns217 0 -0.00197445639749
Gc14_218 0 n28 ns218 0 0.000794108214985
Gc14_219 0 n28 ns219 0 0.000889690495374
Gc14_220 0 n28 ns220 0 0.000200445819234
Gc14_221 0 n28 ns221 0 -2.60873034893e-06
Gc14_222 0 n28 ns222 0 0.00247135151901
Gc14_223 0 n28 ns223 0 8.94088272226e-05
Gc14_224 0 n28 ns224 0 0.0271992405908
Gc14_225 0 n28 ns225 0 -0.0261609672852
Gc14_226 0 n28 ns226 0 0.00663109208254
Gc14_227 0 n28 ns227 0 -3.70176515809e-06
Gc14_228 0 n28 ns228 0 8.55325494194e-06
Gc14_229 0 n28 ns229 0 -0.00457494072654
Gc14_230 0 n28 ns230 0 -0.000317137542413
Gc14_231 0 n28 ns231 0 -0.00409850431503
Gc14_232 0 n28 ns232 0 -4.96477339456e-05
Gc14_233 0 n28 ns233 0 -0.000874617968013
Gc14_234 0 n28 ns234 0 5.02092134185e-05
Gc14_235 0 n28 ns235 0 0.000348673074877
Gc14_236 0 n28 ns236 0 -8.81561214562e-05
Gc14_237 0 n28 ns237 0 -3.02972198297e-05
Gc14_238 0 n28 ns238 0 -0.0022153532663
Gc14_239 0 n28 ns239 0 0.00188681516747
Gc14_240 0 n28 ns240 0 0.001042615293
Gc14_241 0 n28 ns241 0 -0.000134248491893
Gc14_242 0 n28 ns242 0 0.000325971264027
Gc14_243 0 n28 ns243 0 -0.000561935568927
Gc14_244 0 n28 ns244 0 2.38074975984e-05
Gc14_245 0 n28 ns245 0 0.000946671403846
Gc14_246 0 n28 ns246 0 0.000299774629984
Gc14_247 0 n28 ns247 0 0.000329364040243
Gc14_248 0 n28 ns248 0 0.000585277096315
Gc14_249 0 n28 ns249 0 0.000192941556633
Gc14_250 0 n28 ns250 0 0.000988729308104
Gc14_251 0 n28 ns251 0 0.00146453661591
Gc14_252 0 n28 ns252 0 0.00118061341337
Gc14_253 0 n28 ns253 0 0.00284061382339
Gc14_254 0 n28 ns254 0 0.00133941501266
Gc14_255 0 n28 ns255 0 -0.00217834802564
Gc14_256 0 n28 ns256 0 0.00187890827361
Gc14_257 0 n28 ns257 0 -0.00169066895151
Gc14_258 0 n28 ns258 0 0.00182909753226
Gc14_259 0 n28 ns259 0 0.00147049754797
Gc14_260 0 n28 ns260 0 0.00306683062248
Gc14_261 0 n28 ns261 0 3.78261304782e-05
Gc14_262 0 n28 ns262 0 -0.0167611989638
Gc14_263 0 n28 ns263 0 0.0191201558892
Gc14_264 0 n28 ns264 0 0.00688912407166
Gc14_265 0 n28 ns265 0 1.92260110811e-07
Gc14_266 0 n28 ns266 0 2.00312169032e-05
Gc14_267 0 n28 ns267 0 -0.00196639119858
Gc14_268 0 n28 ns268 0 2.02505918643e-05
Gc14_269 0 n28 ns269 0 0.00204283545279
Gc14_270 0 n28 ns270 0 0.000653545108289
Gc14_271 0 n28 ns271 0 -0.000446623357687
Gc14_272 0 n28 ns272 0 0.000481388967086
Gc14_273 0 n28 ns273 0 0.000331484287427
Gc14_274 0 n28 ns274 0 -0.000170588743181
Gc14_275 0 n28 ns275 0 -4.07767100766e-06
Gc14_276 0 n28 ns276 0 -0.000640467556857
Gc14_277 0 n28 ns277 0 -0.000665553751615
Gc14_278 0 n28 ns278 0 0.000528463219381
Gc14_279 0 n28 ns279 0 8.61135992857e-05
Gc14_280 0 n28 ns280 0 0.000353839297127
Gc14_281 0 n28 ns281 0 -0.000498677619576
Gc14_282 0 n28 ns282 0 -0.00023309638774
Gc14_283 0 n28 ns283 0 -0.00219950644123
Gc14_284 0 n28 ns284 0 -0.000983464570486
Gc14_285 0 n28 ns285 0 -4.60655100782e-05
Gc14_286 0 n28 ns286 0 0.000339398438777
Gc14_287 0 n28 ns287 0 0.000332670937883
Gc14_288 0 n28 ns288 0 -0.00412469281001
Gc14_289 0 n28 ns289 0 0.000482455711084
Gc14_290 0 n28 ns290 0 0.000101770796729
Gc14_291 0 n28 ns291 0 0.00147668298086
Gc14_292 0 n28 ns292 0 0.00106721725598
Gc14_293 0 n28 ns293 0 -0.00147401472798
Gc14_294 0 n28 ns294 0 -0.00280263048119
Gc14_295 0 n28 ns295 0 0.00137981311346
Gc14_296 0 n28 ns296 0 -0.00180417663003
Gc14_297 0 n28 ns297 0 0.000542210232667
Gc14_298 0 n28 ns298 0 0.00209968759028
Gc14_299 0 n28 ns299 0 8.57757054602e-05
Gc14_300 0 n28 ns300 0 0.0381887219992
Gc14_301 0 n28 ns301 0 -0.0418786956208
Gc14_302 0 n28 ns302 0 0.00445754554282
Gc14_303 0 n28 ns303 0 3.19200335105e-06
Gc14_304 0 n28 ns304 0 2.56901304773e-05
Gc14_305 0 n28 ns305 0 -0.00119677249006
Gc14_306 0 n28 ns306 0 0.00259897645901
Gc14_307 0 n28 ns307 0 -0.00415922365679
Gc14_308 0 n28 ns308 0 0.000187857417107
Gc14_309 0 n28 ns309 0 -0.000478234661747
Gc14_310 0 n28 ns310 0 9.10062182053e-05
Gc14_311 0 n28 ns311 0 -0.000508856401222
Gc14_312 0 n28 ns312 0 -3.11103939102e-05
Gc14_313 0 n28 ns313 0 -1.37951380045e-05
Gc14_314 0 n28 ns314 0 -0.00153063838105
Gc14_315 0 n28 ns315 0 0.0016443077791
Gc14_316 0 n28 ns316 0 -0.00037357389316
Gc14_317 0 n28 ns317 0 -0.000428528239245
Gc14_318 0 n28 ns318 0 0.000152606496301
Gc14_319 0 n28 ns319 0 -0.000233513791458
Gc14_320 0 n28 ns320 0 -0.000135797688509
Gc14_321 0 n28 ns321 0 0.00267773444154
Gc14_322 0 n28 ns322 0 0.000129433055007
Gc14_323 0 n28 ns323 0 -0.00088885505075
Gc14_324 0 n28 ns324 0 0.000207155518859
Gc14_325 0 n28 ns325 0 9.8936646865e-06
Gc14_326 0 n28 ns326 0 0.00238387946267
Gc14_327 0 n28 ns327 0 0.00233389359245
Gc14_328 0 n28 ns328 0 -0.000514418844262
Gc14_329 0 n28 ns329 0 -2.39268165842e-06
Gc14_330 0 n28 ns330 0 0.000461222189374
Gc14_331 0 n28 ns331 0 -0.000642108470549
Gc14_332 0 n28 ns332 0 0.00363450306107
Gc14_333 0 n28 ns333 0 0.00027154684697
Gc14_334 0 n28 ns334 0 -0.00189643631549
Gc14_335 0 n28 ns335 0 0.000659022670783
Gc14_336 0 n28 ns336 0 0.00113006684081
Gc14_337 0 n28 ns337 0 -0.000208978213529
Gc14_338 0 n28 ns338 0 0.0369842775538
Gc14_339 0 n28 ns339 0 -0.0338659457813
Gc14_340 0 n28 ns340 0 0.00191148015062
Gc14_341 0 n28 ns341 0 -6.42859922756e-06
Gc14_342 0 n28 ns342 0 1.86537268227e-05
Gc14_343 0 n28 ns343 0 -1.76063825229e-05
Gc14_344 0 n28 ns344 0 -0.000378545497167
Gc14_345 0 n28 ns345 0 0.00100627598698
Gc14_346 0 n28 ns346 0 -4.31613589338e-05
Gc14_347 0 n28 ns347 0 0.00014534082641
Gc14_348 0 n28 ns348 0 5.56136180423e-05
Gc14_349 0 n28 ns349 0 4.66892192081e-05
Gc14_350 0 n28 ns350 0 -1.47829561127e-05
Gc14_351 0 n28 ns351 0 7.74432046863e-06
Gc14_352 0 n28 ns352 0 -0.000246222418059
Gc14_353 0 n28 ns353 0 -0.000121262055166
Gc14_354 0 n28 ns354 0 0.000506508120307
Gc14_355 0 n28 ns355 0 0.000122550989834
Gc14_356 0 n28 ns356 0 -0.000136652964237
Gc14_357 0 n28 ns357 0 -0.000193504821064
Gc14_358 0 n28 ns358 0 -0.000304598183922
Gc14_359 0 n28 ns359 0 -0.000898814393666
Gc14_360 0 n28 ns360 0 -0.000202038934016
Gc14_361 0 n28 ns361 0 0.000789055798861
Gc14_362 0 n28 ns362 0 0.000195224344127
Gc14_363 0 n28 ns363 0 -8.77651336947e-05
Gc14_364 0 n28 ns364 0 -0.000613451934437
Gc14_365 0 n28 ns365 0 0.000373053406849
Gc14_366 0 n28 ns366 0 0.000852750871059
Gc14_367 0 n28 ns367 0 0.00072646279374
Gc14_368 0 n28 ns368 0 -0.00041087302345
Gc14_369 0 n28 ns369 0 -0.00073170112838
Gc14_370 0 n28 ns370 0 -0.00125355994808
Gc14_371 0 n28 ns371 0 -1.19400685478e-05
Gc14_372 0 n28 ns372 0 0.00046698413525
Gc14_373 0 n28 ns373 0 0.00116321591707
Gc14_374 0 n28 ns374 0 0.000395993836023
Gc14_375 0 n28 ns375 0 -0.000590290663907
Gc14_376 0 n28 ns376 0 0.00903732894183
Gc14_377 0 n28 ns377 0 -0.00882797657136
Gc14_378 0 n28 ns378 0 0.00051685414669
Gc14_379 0 n28 ns379 0 -3.32201280863e-06
Gc14_380 0 n28 ns380 0 -2.6480084504e-05
Gc14_381 0 n28 ns381 0 -0.000966717865773
Gc14_382 0 n28 ns382 0 0.00230027518376
Gc14_383 0 n28 ns383 0 -0.00582032516022
Gc14_384 0 n28 ns384 0 -0.000431498033875
Gc14_385 0 n28 ns385 0 -0.000216393021352
Gc14_386 0 n28 ns386 0 -0.000356077346739
Gc14_387 0 n28 ns387 0 -6.48066243988e-05
Gc14_388 0 n28 ns388 0 -4.31474795785e-06
Gc14_389 0 n28 ns389 0 2.46346738843e-05
Gc14_390 0 n28 ns390 0 0.000770383067696
Gc14_391 0 n28 ns391 0 0.00218590253644
Gc14_392 0 n28 ns392 0 -0.000352472670326
Gc14_393 0 n28 ns393 0 -0.000128867733829
Gc14_394 0 n28 ns394 0 -0.00012657822144
Gc14_395 0 n28 ns395 0 -0.000235085602088
Gc14_396 0 n28 ns396 0 0.00131177807394
Gc14_397 0 n28 ns397 0 0.00115931752632
Gc14_398 0 n28 ns398 0 -0.000281044677766
Gc14_399 0 n28 ns399 0 -0.000281471604098
Gc14_400 0 n28 ns400 0 0.000188563671042
Gc14_401 0 n28 ns401 0 -0.000146551776857
Gc14_402 0 n28 ns402 0 0.00221467617833
Gc14_403 0 n28 ns403 0 0.000676491723508
Gc14_404 0 n28 ns404 0 0.00036450545877
Gc14_405 0 n28 ns405 0 0.000493440336448
Gc14_406 0 n28 ns406 0 -0.000245112327565
Gc14_407 0 n28 ns407 0 -0.000883842236515
Gc14_408 0 n28 ns408 0 0.00233914018435
Gc14_409 0 n28 ns409 0 -5.3909940827e-05
Gc14_410 0 n28 ns410 0 -0.000405777478784
Gc14_411 0 n28 ns411 0 0.00107360793704
Gc14_412 0 n28 ns412 0 0.000643164528986
Gc14_413 0 n28 ns413 0 -0.000673469883064
Gc14_414 0 n28 ns414 0 0.0353020629051
Gc14_415 0 n28 ns415 0 -0.0312815459431
Gc14_416 0 n28 ns416 0 0.00141001538872
Gc14_417 0 n28 ns417 0 -7.0191101147e-06
Gc14_418 0 n28 ns418 0 -2.53410217502e-05
Gc14_419 0 n28 ns419 0 -0.00147200156729
Gc14_420 0 n28 ns420 0 0.00114166090303
Gc14_421 0 n28 ns421 0 -0.00346029257927
Gc14_422 0 n28 ns422 0 0.000311815348758
Gc14_423 0 n28 ns423 0 -0.000590163398932
Gc14_424 0 n28 ns424 0 0.000273282650869
Gc14_425 0 n28 ns425 0 -0.000181383232838
Gc14_426 0 n28 ns426 0 -4.51642937504e-05
Gc14_427 0 n28 ns427 0 3.72932609221e-05
Gc14_428 0 n28 ns428 0 -0.00140858612429
Gc14_429 0 n28 ns429 0 0.00102287210768
Gc14_430 0 n28 ns430 0 0.000105025696234
Gc14_431 0 n28 ns431 0 -0.000509988359627
Gc14_432 0 n28 ns432 0 4.96295205734e-05
Gc14_433 0 n28 ns433 0 -0.000369243074848
Gc14_434 0 n28 ns434 0 -0.0014096110656
Gc14_435 0 n28 ns435 0 0.00123445960408
Gc14_436 0 n28 ns436 0 0.000209695328737
Gc14_437 0 n28 ns437 0 -3.25008555396e-05
Gc14_438 0 n28 ns438 0 0.000400445759789
Gc14_439 0 n28 ns439 0 -2.80822949551e-05
Gc14_440 0 n28 ns440 0 0.000841584615285
Gc14_441 0 n28 ns441 0 0.00384928910688
Gc14_442 0 n28 ns442 0 0.000785072002172
Gc14_443 0 n28 ns443 0 0.00020712163892
Gc14_444 0 n28 ns444 0 -5.91163231621e-05
Gc14_445 0 n28 ns445 0 -0.00120353190066
Gc14_446 0 n28 ns446 0 0.00358463671083
Gc14_447 0 n28 ns447 0 0.00212749516598
Gc14_448 0 n28 ns448 0 -0.00158573799266
Gc14_449 0 n28 ns449 0 0.000420142656746
Gc14_450 0 n28 ns450 0 0.00125882040178
Gc14_451 0 n28 ns451 0 -0.000441447272429
Gc14_452 0 n28 ns452 0 0.0540121234142
Gc14_453 0 n28 ns453 0 -0.049960741044
Gc14_454 0 n28 ns454 0 0.00288977887668
Gc14_455 0 n28 ns455 0 -2.98804249823e-06
Gc14_456 0 n28 ns456 0 -1.81851788482e-05
Gc14_457 0 n28 ns457 0 -0.00208964903915
Gc14_458 0 n28 ns458 0 -0.00190788941215
Gc14_459 0 n28 ns459 0 0.00386993678451
Gc14_460 0 n28 ns460 0 0.000329010995779
Gc14_461 0 n28 ns461 0 -0.000357097204126
Gc14_462 0 n28 ns462 0 0.000622675741241
Gc14_463 0 n28 ns463 0 0.000400944913933
Gc14_464 0 n28 ns464 0 -0.000175434185394
Gc14_465 0 n28 ns465 0 -8.92045751322e-05
Gc14_466 0 n28 ns466 0 -0.00136914308818
Gc14_467 0 n28 ns467 0 2.44349075314e-05
Gc14_468 0 n28 ns468 0 0.00109238753762
Gc14_469 0 n28 ns469 0 -0.000137424041955
Gc14_470 0 n28 ns470 0 0.000308177606388
Gc14_471 0 n28 ns471 0 -0.000510956068562
Gc14_472 0 n28 ns472 0 0.00011548570586
Gc14_473 0 n28 ns473 0 -0.00189346540551
Gc14_474 0 n28 ns474 0 -0.000341451831785
Gc14_475 0 n28 ns475 0 6.22451492391e-05
Gc14_476 0 n28 ns476 0 0.000381755825781
Gc14_477 0 n28 ns477 0 0.000208488790438
Gc14_478 0 n28 ns478 0 -0.00364469799489
Gc14_479 0 n28 ns479 0 -0.000904592698561
Gc14_480 0 n28 ns480 0 0.000862531194869
Gc14_481 0 n28 ns481 0 0.00139579218356
Gc14_482 0 n28 ns482 0 0.000770036342133
Gc14_483 0 n28 ns483 0 -0.00157541189786
Gc14_484 0 n28 ns484 0 -0.00528170137501
Gc14_485 0 n28 ns485 0 -0.00130015712913
Gc14_486 0 n28 ns486 0 -0.00122717395528
Gc14_487 0 n28 ns487 0 0.000831675801846
Gc14_488 0 n28 ns488 0 0.00243246112347
Gc14_489 0 n28 ns489 0 0.000238500565521
Gc14_490 0 n28 ns490 0 0.0219421626316
Gc14_491 0 n28 ns491 0 -0.0293438734058
Gc14_492 0 n28 ns492 0 0.00550356761105
Gc14_493 0 n28 ns493 0 1.76797472703e-06
Gc14_494 0 n28 ns494 0 4.01517440775e-06
Gc14_495 0 n28 ns495 0 -0.00360141280897
Gc14_496 0 n28 ns496 0 -0.000722102250553
Gc14_497 0 n28 ns497 0 -0.000585042420378
Gc14_498 0 n28 ns498 0 0.000568034297667
Gc14_499 0 n28 ns499 0 -0.000367859854294
Gc14_500 0 n28 ns500 0 0.000419018235915
Gc14_501 0 n28 ns501 0 -0.00014997227565
Gc14_502 0 n28 ns502 0 -0.000193571342481
Gc14_503 0 n28 ns503 0 -0.000106706143878
Gc14_504 0 n28 ns504 0 -0.00439455962191
Gc14_505 0 n28 ns505 0 0.00132035535442
Gc14_506 0 n28 ns506 0 0.00173206442601
Gc14_507 0 n28 ns507 0 -7.3187160591e-05
Gc14_508 0 n28 ns508 0 0.000431244807004
Gc14_509 0 n28 ns509 0 -0.000669047988669
Gc14_510 0 n28 ns510 0 -0.000280936337924
Gc14_511 0 n28 ns511 0 0.000844042483934
Gc14_512 0 n28 ns512 0 0.000391915861872
Gc14_513 0 n28 ns513 0 0.000602069067649
Gc14_514 0 n28 ns514 0 0.000645414902278
Gc14_515 0 n28 ns515 0 0.00023021640504
Gc14_516 0 n28 ns516 0 0.000132402322834
Gc14_517 0 n28 ns517 0 0.000863522472628
Gc14_518 0 n28 ns518 0 0.00144381767406
Gc14_519 0 n28 ns519 0 0.00312119917479
Gc14_520 0 n28 ns520 0 0.00134432303401
Gc14_521 0 n28 ns521 0 -0.00235014524864
Gc14_522 0 n28 ns522 0 -0.00100770691452
Gc14_523 0 n28 ns523 0 -0.00281053343868
Gc14_524 0 n28 ns524 0 0.0021213767428
Gc14_525 0 n28 ns525 0 0.00197785367211
Gc14_526 0 n28 ns526 0 0.00327425365259
Gc14_527 0 n28 ns527 0 1.3959571545e-05
Gc14_528 0 n28 ns528 0 -0.0257355170256
Gc14_529 0 n28 ns529 0 0.0249609990598
Gc14_530 0 n28 ns530 0 0.00692128894374
Gc14_531 0 n28 ns531 0 1.05668394931e-05
Gc14_532 0 n28 ns532 0 1.69928255303e-05
Gc14_533 0 n28 ns533 0 -0.00194877142405
Gc14_534 0 n28 ns534 0 -0.00176421912183
Gc14_535 0 n28 ns535 0 0.00521686432526
Gc14_536 0 n28 ns536 0 0.000363613622165
Gc14_537 0 n28 ns537 0 -0.000367123082756
Gc14_538 0 n28 ns538 0 0.000536356953537
Gc14_539 0 n28 ns539 0 0.000420306187768
Gc14_540 0 n28 ns540 0 -0.000177914151654
Gc14_541 0 n28 ns541 0 -4.51669946846e-05
Gc14_542 0 n28 ns542 0 -0.00109810237987
Gc14_543 0 n28 ns543 0 -0.000728702952122
Gc14_544 0 n28 ns544 0 0.000996318952323
Gc14_545 0 n28 ns545 0 0.00037015749519
Gc14_546 0 n28 ns546 0 0.000461400260843
Gc14_547 0 n28 ns547 0 -0.000549764050993
Gc14_548 0 n28 ns548 0 0.000542029474895
Gc14_549 0 n28 ns549 0 -0.00268870833197
Gc14_550 0 n28 ns550 0 -0.000945104745001
Gc14_551 0 n28 ns551 0 9.81838022664e-05
Gc14_552 0 n28 ns552 0 0.000396692190481
Gc14_553 0 n28 ns553 0 0.000366385116912
Gc14_554 0 n28 ns554 0 -0.00467811012886
Gc14_555 0 n28 ns555 0 -0.00172536520934
Gc14_556 0 n28 ns556 0 0.000353814171698
Gc14_557 0 n28 ns557 0 0.00197807500205
Gc14_558 0 n28 ns558 0 0.00123362627419
Gc14_559 0 n28 ns559 0 -0.00170097704715
Gc14_560 0 n28 ns560 0 -0.00663920594169
Gc14_561 0 n28 ns561 0 -0.0015626414498
Gc14_562 0 n28 ns562 0 -0.00122529967253
Gc14_563 0 n28 ns563 0 0.00112472075365
Gc14_564 0 n28 ns564 0 0.00257536938585
Gc14_565 0 n28 ns565 0 0.000258077377292
Gc14_566 0 n28 ns566 0 0.0144582116553
Gc14_567 0 n28 ns567 0 -0.0233354244378
Gc14_568 0 n28 ns568 0 0.00536581627437
Gc14_569 0 n28 ns569 0 2.3141119558e-06
Gc14_570 0 n28 ns570 0 2.73202578744e-05
Gc14_571 0 n28 ns571 0 -0.00146614437606
Gc14_572 0 n28 ns572 0 0.00170792498323
Gc14_573 0 n28 ns573 0 -0.00274622299572
Gc14_574 0 n28 ns574 0 0.000455790802108
Gc14_575 0 n28 ns575 0 -0.000691511346172
Gc14_576 0 n28 ns576 0 0.00026701259733
Gc14_577 0 n28 ns577 0 -0.00024378479909
Gc14_578 0 n28 ns578 0 -6.44575242804e-05
Gc14_579 0 n28 ns579 0 -1.05839472308e-05
Gc14_580 0 n28 ns580 0 -0.00176767555231
Gc14_581 0 n28 ns581 0 0.000839276228568
Gc14_582 0 n28 ns582 0 -7.30225813455e-05
Gc14_583 0 n28 ns583 0 -0.000320509836748
Gc14_584 0 n28 ns584 0 0.000247628209287
Gc14_585 0 n28 ns585 0 -0.000359848860069
Gc14_586 0 n28 ns586 0 -0.000795071019343
Gc14_587 0 n28 ns587 0 0.00157828743004
Gc14_588 0 n28 ns588 0 -9.45524289627e-05
Gc14_589 0 n28 ns589 0 -0.00057289559532
Gc14_590 0 n28 ns590 0 0.000317149356691
Gc14_591 0 n28 ns591 0 0.000110435305946
Gc14_592 0 n28 ns592 0 0.000709910101732
Gc14_593 0 n28 ns593 0 0.00287893948114
Gc14_594 0 n28 ns594 0 -0.000247896359827
Gc14_595 0 n28 ns595 0 0.000373116230896
Gc14_596 0 n28 ns596 0 0.000614498386049
Gc14_597 0 n28 ns597 0 -0.000994554431357
Gc14_598 0 n28 ns598 0 0.00288787392209
Gc14_599 0 n28 ns599 0 0.00139605448679
Gc14_600 0 n28 ns600 0 -0.00203538244489
Gc14_601 0 n28 ns601 0 0.000536496777469
Gc14_602 0 n28 ns602 0 0.00143634848899
Gc14_603 0 n28 ns603 0 -0.000210664891334
Gc14_604 0 n28 ns604 0 0.0450841109138
Gc14_605 0 n28 ns605 0 -0.0425836379615
Gc14_606 0 n28 ns606 0 0.00272375992435
Gc14_607 0 n28 ns607 0 -3.01152211619e-06
Gc14_608 0 n28 ns608 0 2.22933967311e-05
Gc14_609 0 n28 ns609 0 0.000114428978707
Gc14_610 0 n28 ns610 0 -0.000909392827552
Gc14_611 0 n28 ns611 0 0.00255104481195
Gc14_612 0 n28 ns612 0 0.000114227935788
Gc14_613 0 n28 ns613 0 9.5720238443e-05
Gc14_614 0 n28 ns614 0 -3.01264164132e-05
Gc14_615 0 n28 ns615 0 -2.3503864865e-05
Gc14_616 0 n28 ns616 0 -2.85097843083e-05
Gc14_617 0 n28 ns617 0 1.25803890854e-05
Gc14_618 0 n28 ns618 0 0.000680310508148
Gc14_619 0 n28 ns619 0 -0.00146826321278
Gc14_620 0 n28 ns620 0 -0.000595559068079
Gc14_621 0 n28 ns621 0 0.000671364553014
Gc14_622 0 n28 ns622 0 0.000280359981608
Gc14_623 0 n28 ns623 0 0.000173172468206
Gc14_624 0 n28 ns624 0 -0.00103297390454
Gc14_625 0 n28 ns625 0 -0.000544623131722
Gc14_626 0 n28 ns626 0 0.000335415504272
Gc14_627 0 n28 ns627 0 0.000660245964823
Gc14_628 0 n28 ns628 0 0.000116448034918
Gc14_629 0 n28 ns629 0 -0.000144447170447
Gc14_630 0 n28 ns630 0 -2.49353354761e-05
Gc14_631 0 n28 ns631 0 -0.000990935257961
Gc14_632 0 n28 ns632 0 -0.00113843766511
Gc14_633 0 n28 ns633 0 -0.000172829932324
Gc14_634 0 n28 ns634 0 0.000604790244064
Gc14_635 0 n28 ns635 0 0.00048280551255
Gc14_636 0 n28 ns636 0 -0.00274813785767
Gc14_637 0 n28 ns637 0 -0.000325449070106
Gc14_638 0 n28 ns638 0 0.000625747384511
Gc14_639 0 n28 ns639 0 0.000989147675493
Gc14_640 0 n28 ns640 0 0.000277231752892
Gc14_641 0 n28 ns641 0 -0.000408307556025
Gc14_642 0 n28 ns642 0 -0.00589627160797
Gc14_643 0 n28 ns643 0 0.00459859785767
Gc14_644 0 n28 ns644 0 -0.000183028501805
Gc14_645 0 n28 ns645 0 8.18850026152e-06
Gc14_646 0 n28 ns646 0 -2.15396623724e-05
Gc14_647 0 n28 ns647 0 0.000246292248161
Gc14_648 0 n28 ns648 0 -0.00102408496886
Gc14_649 0 n28 ns649 0 0.00325526710567
Gc14_650 0 n28 ns650 0 6.53180670623e-05
Gc14_651 0 n28 ns651 0 0.000174786979117
Gc14_652 0 n28 ns652 0 3.75196856265e-05
Gc14_653 0 n28 ns653 0 -1.5414070969e-05
Gc14_654 0 n28 ns654 0 -2.04257297445e-05
Gc14_655 0 n28 ns655 0 -1.01698660005e-05
Gc14_656 0 n28 ns656 0 0.000861593745646
Gc14_657 0 n28 ns657 0 -0.00152329863439
Gc14_658 0 n28 ns658 0 -0.000702648578953
Gc14_659 0 n28 ns659 0 0.000602707149832
Gc14_660 0 n28 ns660 0 0.000290172631366
Gc14_661 0 n28 ns661 0 0.000223356586877
Gc14_662 0 n28 ns662 0 -0.000958213206432
Gc14_663 0 n28 ns663 0 -0.000943499807454
Gc14_664 0 n28 ns664 0 0.000161036605426
Gc14_665 0 n28 ns665 0 0.000827915174644
Gc14_666 0 n28 ns666 0 0.000149929166193
Gc14_667 0 n28 ns667 0 -0.000135220047007
Gc14_668 0 n28 ns668 0 -0.000116968996676
Gc14_669 0 n28 ns669 0 -0.00127445211598
Gc14_670 0 n28 ns670 0 -0.00137936685865
Gc14_671 0 n28 ns671 0 -0.000316185053264
Gc14_672 0 n28 ns672 0 0.000711350505849
Gc14_673 0 n28 ns673 0 0.000667482701392
Gc14_674 0 n28 ns674 0 -0.00348977579427
Gc14_675 0 n28 ns675 0 -0.000882282357989
Gc14_676 0 n28 ns676 0 0.000585738409536
Gc14_677 0 n28 ns677 0 0.00135296000135
Gc14_678 0 n28 ns678 0 0.000412810886731
Gc14_679 0 n28 ns679 0 -0.000452035350878
Gc14_680 0 n28 ns680 0 -0.0109341891539
Gc14_681 0 n28 ns681 0 0.00883925181812
Gc14_682 0 n28 ns682 0 -0.000322834569308
Gc14_683 0 n28 ns683 0 6.34168811342e-06
Gc14_684 0 n28 ns684 0 -2.39422185641e-05
Gc14_685 0 n28 ns685 0 0.000497544252284
Gc14_686 0 n28 ns686 0 -0.000796638633986
Gc14_687 0 n28 ns687 0 0.00420712291695
Gc14_688 0 n28 ns688 0 -9.95893328262e-05
Gc14_689 0 n28 ns689 0 0.000292135611616
Gc14_690 0 n28 ns690 0 0.000292745247068
Gc14_691 0 n28 ns691 0 2.52295111842e-06
Gc14_692 0 n28 ns692 0 2.80540230974e-05
Gc14_693 0 n28 ns693 0 -3.38251509479e-05
Gc14_694 0 n28 ns694 0 8.00867833937e-05
Gc14_695 0 n28 ns695 0 -0.00075134085117
Gc14_696 0 n28 ns696 0 -0.000209239885358
Gc14_697 0 n28 ns697 0 -8.35718167981e-05
Gc14_698 0 n28 ns698 0 0.000145390263784
Gc14_699 0 n28 ns699 0 0.000225046780519
Gc14_700 0 n28 ns700 0 0.000362145695168
Gc14_701 0 n28 ns701 0 -0.00128695723008
Gc14_702 0 n28 ns702 0 -0.000718454223362
Gc14_703 0 n28 ns703 0 0.000585317510421
Gc14_704 0 n28 ns704 0 0.000156485449694
Gc14_705 0 n28 ns705 0 -1.53473688061e-05
Gc14_706 0 n28 ns706 0 -0.000476402362649
Gc14_707 0 n28 ns707 0 -0.00164026954175
Gc14_708 0 n28 ns708 0 -0.00136633498103
Gc14_709 0 n28 ns709 0 -0.000944500181457
Gc14_710 0 n28 ns710 0 0.000572716068989
Gc14_711 0 n28 ns711 0 0.00119174063011
Gc14_712 0 n28 ns712 0 -0.00508894811043
Gc14_713 0 n28 ns713 0 -0.00201158352425
Gc14_714 0 n28 ns714 0 0.000542970863866
Gc14_715 0 n28 ns715 0 0.00241161260559
Gc14_716 0 n28 ns716 0 0.00083509531893
Gc14_717 0 n28 ns717 0 -0.000705764930418
Gc14_718 0 n28 ns718 0 -0.0169596934708
Gc14_719 0 n28 ns719 0 0.0137145093976
Gc14_720 0 n28 ns720 0 -0.000491908126903
Gc14_721 0 n28 ns721 0 4.10402176051e-07
Gc14_722 0 n28 ns722 0 -3.01338518114e-05
Gc14_723 0 n28 ns723 0 0.000895236176344
Gc14_724 0 n28 ns724 0 -0.00172498246723
Gc14_725 0 n28 ns725 0 0.00790319687803
Gc14_726 0 n28 ns726 0 8.28438267345e-05
Gc14_727 0 n28 ns727 0 2.00299742997e-05
Gc14_728 0 n28 ns728 0 8.56537445252e-05
Gc14_729 0 n28 ns729 0 0.000139644350235
Gc14_730 0 n28 ns730 0 2.28238491983e-05
Gc14_731 0 n28 ns731 0 3.87538711238e-05
Gc14_732 0 n28 ns732 0 -0.000755274757646
Gc14_733 0 n28 ns733 0 -0.00197764962394
Gc14_734 0 n28 ns734 0 0.000378829379828
Gc14_735 0 n28 ns735 0 0.000319789868791
Gc14_736 0 n28 ns736 0 0.000104154098805
Gc14_737 0 n28 ns737 0 0.000301367878748
Gc14_738 0 n28 ns738 0 0.000623102028056
Gc14_739 0 n28 ns739 0 -8.74889381811e-05
Gc14_740 0 n28 ns740 0 -0.000818844872551
Gc14_741 0 n28 ns741 0 -0.000328274694392
Gc14_742 0 n28 ns742 0 0.000130309622241
Gc14_743 0 n28 ns743 0 1.20317113263e-05
Gc14_744 0 n28 ns744 0 -0.001676369781
Gc14_745 0 n28 ns745 0 -0.00292862096646
Gc14_746 0 n28 ns746 0 -0.000953786038369
Gc14_747 0 n28 ns747 0 -0.000730694207114
Gc14_748 0 n28 ns748 0 0.000281389787573
Gc14_749 0 n28 ns749 0 0.00138034044436
Gc14_750 0 n28 ns750 0 -0.00681236934088
Gc14_751 0 n28 ns751 0 -0.00398591423326
Gc14_752 0 n28 ns752 0 -0.000558928198221
Gc14_753 0 n28 ns753 0 0.00353439145947
Gc14_754 0 n28 ns754 0 0.0016403589346
Gc14_755 0 n28 ns755 0 -0.000637271429829
Gc14_756 0 n28 ns756 0 -0.0402059328725
Gc14_757 0 n28 ns757 0 0.0341080873231
Gc14_758 0 n28 ns758 0 -0.00144494280436
Gc14_759 0 n28 ns759 0 -6.0070338953e-06
Gc14_760 0 n28 ns760 0 -2.72930986999e-05
Gc14_761 0 n28 ns761 0 0.000299481045099
Gc14_762 0 n28 ns762 0 -0.0011473807698
Gc14_763 0 n28 ns763 0 0.0101510564616
Gc14_764 0 n28 ns764 0 -0.000154221873623
Gc14_765 0 n28 ns765 0 0.000534559469155
Gc14_766 0 n28 ns766 0 0.000600889483247
Gc14_767 0 n28 ns767 0 -0.00031433236738
Gc14_768 0 n28 ns768 0 -0.000121374470748
Gc14_769 0 n28 ns769 0 -2.67357679878e-05
Gc14_770 0 n28 ns770 0 0.00102857311522
Gc14_771 0 n28 ns771 0 -0.00385659992103
Gc14_772 0 n28 ns772 0 -0.000173244600316
Gc14_773 0 n28 ns773 0 0.0011488714102
Gc14_774 0 n28 ns774 0 2.24121807543e-05
Gc14_775 0 n28 ns775 0 0.000475402570212
Gc14_776 0 n28 ns776 0 -0.00142109123674
Gc14_777 0 n28 ns777 0 -0.00123167437684
Gc14_778 0 n28 ns778 0 -0.000340191248395
Gc14_779 0 n28 ns779 0 3.20238717638e-05
Gc14_780 0 n28 ns780 0 0.000329429390087
Gc14_781 0 n28 ns781 0 0.000133565461448
Gc14_782 0 n28 ns782 0 -0.00148572760238
Gc14_783 0 n28 ns783 0 -0.00576652797896
Gc14_784 0 n28 ns784 0 -0.00210727399793
Gc14_785 0 n28 ns785 0 -5.28146088919e-05
Gc14_786 0 n28 ns786 0 0.000459221862377
Gc14_787 0 n28 ns787 0 0.00172340909365
Gc14_788 0 n28 ns788 0 -0.00977559534484
Gc14_789 0 n28 ns789 0 -0.005263495041
Gc14_790 0 n28 ns790 0 -0.00172242687697
Gc14_791 0 n28 ns791 0 0.00342364319646
Gc14_792 0 n28 ns792 0 0.00253910301459
Gc14_793 0 n28 ns793 0 -0.000141994250845
Gc14_794 0 n28 ns794 0 -0.0774126694178
Gc14_795 0 n28 ns795 0 0.06901980167
Gc14_796 0 n28 ns796 0 -0.00393157292328
Gc14_797 0 n28 ns797 0 -9.188928017e-06
Gc14_798 0 n28 ns798 0 -1.20317013539e-05
Gc14_799 0 n28 ns799 0 -0.00258100896466
Gc14_800 0 n28 ns800 0 -0.00290864599076
Gc14_801 0 n28 ns801 0 0.00730468279206
Gc14_802 0 n28 ns802 0 0.000979674066612
Gc14_803 0 n28 ns803 0 -0.00172145245125
Gc14_804 0 n28 ns804 0 0.000647414301211
Gc14_805 0 n28 ns805 0 0.0019983164255
Gc14_806 0 n28 ns806 0 3.37768075644e-05
Gc14_807 0 n28 ns807 0 -0.000213907393669
Gc14_808 0 n28 ns808 0 0.000936677878877
Gc14_809 0 n28 ns809 0 -0.00160473488382
Gc14_810 0 n28 ns810 0 -0.00108813189344
Gc14_811 0 n28 ns811 0 0.000732602989378
Gc14_812 0 n28 ns812 0 -0.00013311201965
Gc14_813 0 n28 ns813 0 0.000549189766447
Gc14_814 0 n28 ns814 0 0.00126649207948
Gc14_815 0 n28 ns815 0 -0.00284506235437
Gc14_816 0 n28 ns816 0 -0.000618874488707
Gc14_817 0 n28 ns817 0 -0.000133204625062
Gc14_818 0 n28 ns818 0 0.000280433450323
Gc14_819 0 n28 ns819 0 0.000233636116989
Gc14_820 0 n28 ns820 0 0.00215744148041
Gc14_821 0 n28 ns821 0 -0.00233825735915
Gc14_822 0 n28 ns822 0 -0.00262894744983
Gc14_823 0 n28 ns823 0 -0.00184036284831
Gc14_824 0 n28 ns824 0 -0.000316581899881
Gc14_825 0 n28 ns825 0 0.00238679090749
Gc14_826 0 n28 ns826 0 -0.011924232101
Gc14_827 0 n28 ns827 0 -0.00483281514711
Gc14_828 0 n28 ns828 0 0.000297033447517
Gc14_829 0 n28 ns829 0 0.00245085494413
Gc14_830 0 n28 ns830 0 0.00314238748029
Gc14_831 0 n28 ns831 0 0.00019905945729
Gc14_832 0 n28 ns832 0 -0.0366135472609
Gc14_833 0 n28 ns833 0 0.0383396030462
Gc14_834 0 n28 ns834 0 -0.00706311055349
Gc14_835 0 n28 ns835 0 -1.00107466242e-05
Gc14_836 0 n28 ns836 0 8.65780088355e-06
Gc14_837 0 n28 ns837 0 -0.0053812372321
Gc14_838 0 n28 ns838 0 -0.00493149560231
Gc14_839 0 n28 ns839 0 0.00901834127647
Gc14_840 0 n28 ns840 0 0.00255313620643
Gc14_841 0 n28 ns841 0 -0.00209650853175
Gc14_842 0 n28 ns842 0 0.000711299548845
Gc14_843 0 n28 ns843 0 0.00280423125409
Gc14_844 0 n28 ns844 0 -7.37267698537e-06
Gc14_845 0 n28 ns845 0 -0.00031296374768
Gc14_846 0 n28 ns846 0 -0.00100599328535
Gc14_847 0 n28 ns847 0 -0.00149872613904
Gc14_848 0 n28 ns848 0 -0.000872900686484
Gc14_849 0 n28 ns849 0 0.000499477308469
Gc14_850 0 n28 ns850 0 -0.000152925034824
Gc14_851 0 n28 ns851 0 0.000584110423516
Gc14_852 0 n28 ns852 0 0.00276867264457
Gc14_853 0 n28 ns853 0 -0.00259870061909
Gc14_854 0 n28 ns854 0 -0.000896541024973
Gc14_855 0 n28 ns855 0 -0.000581815099919
Gc14_856 0 n28 ns856 0 0.000205025865237
Gc14_857 0 n28 ns857 0 0.000195688868736
Gc14_858 0 n28 ns858 0 0.00239011055589
Gc14_859 0 n28 ns859 0 0.00132434309947
Gc14_860 0 n28 ns860 0 -0.00117810125803
Gc14_861 0 n28 ns861 0 -0.00268747639546
Gc14_862 0 n28 ns862 0 -0.00115344848762
Gc14_863 0 n28 ns863 0 0.00211146793489
Gc14_864 0 n28 ns864 0 -0.0147527645596
Gc14_865 0 n28 ns865 0 -0.00568291704687
Gc14_866 0 n28 ns866 0 0.00203321242445
Gc14_867 0 n28 ns867 0 0.00391960159953
Gc14_868 0 n28 ns868 0 0.00372630971184
Gc14_869 0 n28 ns869 0 0.000165613501868
Gc14_870 0 n28 ns870 0 0.00889464882436
Gc14_871 0 n28 ns871 0 -0.00112722734179
Gc14_872 0 n28 ns872 0 -0.00787364634744
Gc14_873 0 n28 ns873 0 -1.33754695922e-05
Gc14_874 0 n28 ns874 0 1.5993063056e-05
Gc14_875 0 n28 ns875 0 7.33511800655e-05
Gc14_876 0 n28 ns876 0 -0.000571812340265
Gc14_877 0 n28 ns877 0 0.00925539942955
Gc14_878 0 n28 ns878 0 -0.000220119879657
Gc14_879 0 n28 ns879 0 6.4638660773e-05
Gc14_880 0 n28 ns880 0 0.000559736661348
Gc14_881 0 n28 ns881 0 -0.000577015142516
Gc14_882 0 n28 ns882 0 -8.1731777963e-05
Gc14_883 0 n28 ns883 0 6.14725988458e-06
Gc14_884 0 n28 ns884 0 0.00138059055877
Gc14_885 0 n28 ns885 0 -0.0014332866588
Gc14_886 0 n28 ns886 0 -0.00018134444893
Gc14_887 0 n28 ns887 0 8.85292972315e-05
Gc14_888 0 n28 ns888 0 -0.000317884326833
Gc14_889 0 n28 ns889 0 0.000424078045669
Gc14_890 0 n28 ns890 0 -0.000508832226798
Gc14_891 0 n28 ns891 0 -0.00251595600085
Gc14_892 0 n28 ns892 0 -0.00117564818026
Gc14_893 0 n28 ns893 0 0.00012950696103
Gc14_894 0 n28 ns894 0 0.000332558898735
Gc14_895 0 n28 ns895 0 0.000437458003343
Gc14_896 0 n28 ns896 0 -0.000415002566623
Gc14_897 0 n28 ns897 0 -0.00577086719189
Gc14_898 0 n28 ns898 0 -0.00215179133366
Gc14_899 0 n28 ns899 0 -0.000642700157095
Gc14_900 0 n28 ns900 0 2.66514676044e-05
Gc14_901 0 n28 ns901 0 0.00198642207688
Gc14_902 0 n28 ns902 0 -0.0100872517246
Gc14_903 0 n28 ns903 0 -0.00596069027993
Gc14_904 0 n28 ns904 0 -0.00225943420468
Gc14_905 0 n28 ns905 0 0.00285750797469
Gc14_906 0 n28 ns906 0 0.00276730739674
Gc14_907 0 n28 ns907 0 0.000304473737803
Gc14_908 0 n28 ns908 0 -0.0913272500228
Gc14_909 0 n28 ns909 0 0.0832662117928
Gc14_910 0 n28 ns910 0 -0.00528849742397
Gc14_911 0 n28 ns911 0 -1.25996890487e-05
Gc14_912 0 n28 ns912 0 2.0970462779e-05
Gc14_913 0 n28 ns913 0 0.000354912655192
Gc14_914 0 n28 ns914 0 -0.00121491267793
Gc14_915 0 n28 ns915 0 0.00840517717701
Gc14_916 0 n28 ns916 0 0.000497408238951
Gc14_917 0 n28 ns917 0 -0.00014266497053
Gc14_918 0 n28 ns918 0 -8.89609022432e-05
Gc14_919 0 n28 ns919 0 0.000177999992154
Gc14_920 0 n28 ns920 0 -1.02488345983e-05
Gc14_921 0 n28 ns921 0 4.67899910314e-05
Gc14_922 0 n28 ns922 0 -0.00135578523526
Gc14_923 0 n28 ns923 0 -0.00286693565122
Gc14_924 0 n28 ns924 0 0.000836461499725
Gc14_925 0 n28 ns925 0 0.000710410250574
Gc14_926 0 n28 ns926 0 2.25849753067e-05
Gc14_927 0 n28 ns927 0 0.000215506261984
Gc14_928 0 n28 ns928 0 0.000228516031908
Gc14_929 0 n28 ns929 0 0.000802184780974
Gc14_930 0 n28 ns930 0 -0.000570793299535
Gc14_931 0 n28 ns931 0 -0.000959430718662
Gc14_932 0 n28 ns932 0 6.5380882094e-05
Gc14_933 0 n28 ns933 0 0.000111199609893
Gc14_934 0 n28 ns934 0 -0.0024676165549
Gc14_935 0 n28 ns935 0 -0.00299117243634
Gc14_936 0 n28 ns936 0 9.33493435906e-05
Gc14_937 0 n28 ns937 0 -1.4567315501e-05
Gc14_938 0 n28 ns938 0 -0.000276910527726
Gc14_939 0 n28 ns939 0 0.000823948742845
Gc14_940 0 n28 ns940 0 -0.00567857423737
Gc14_941 0 n28 ns941 0 -0.00473121957603
Gc14_942 0 n28 ns942 0 -0.00189451329536
Gc14_943 0 n28 ns943 0 0.00313869654801
Gc14_944 0 n28 ns944 0 0.00190743119221
Gc14_945 0 n28 ns945 0 -0.000105485538586
Gc14_946 0 n28 ns946 0 -0.052647844462
Gc14_947 0 n28 ns947 0 0.0456575097786
Gc14_948 0 n28 ns948 0 -0.00207880470451
Gc14_949 0 n28 ns949 0 -7.41734518108e-06
Gc14_950 0 n28 ns950 0 1.65756214162e-05
Gc14_951 0 n28 ns951 0 0.000407266693544
Gc14_952 0 n28 ns952 0 -0.000520721630481
Gc14_953 0 n28 ns953 0 0.0031610318344
Gc14_954 0 n28 ns954 0 -0.000165696500037
Gc14_955 0 n28 ns955 0 0.000336658118992
Gc14_956 0 n28 ns956 0 0.000230184777208
Gc14_957 0 n28 ns957 0 1.03223239283e-05
Gc14_958 0 n28 ns958 0 9.6999843103e-06
Gc14_959 0 n28 ns959 0 -4.47821907741e-05
Gc14_960 0 n28 ns960 0 0.000693336366458
Gc14_961 0 n28 ns961 0 -0.000912165261906
Gc14_962 0 n28 ns962 0 -0.000522225908107
Gc14_963 0 n28 ns963 0 0.00014686541035
Gc14_964 0 n28 ns964 0 0.000189764092009
Gc14_965 0 n28 ns965 0 0.000226578893971
Gc14_966 0 n28 ns966 0 -0.000165378364871
Gc14_967 0 n28 ns967 0 -0.001308157633
Gc14_968 0 n28 ns968 0 -0.000372426964849
Gc14_969 0 n28 ns969 0 0.0007646632846
Gc14_970 0 n28 ns970 0 0.000158573916405
Gc14_971 0 n28 ns971 0 -6.00497631747e-05
Gc14_972 0 n28 ns972 0 -0.000201291865809
Gc14_973 0 n28 ns973 0 -0.00140086300709
Gc14_974 0 n28 ns974 0 -0.00139375591264
Gc14_975 0 n28 ns975 0 -0.000702388585772
Gc14_976 0 n28 ns976 0 0.000643572586628
Gc14_977 0 n28 ns977 0 0.000961219027377
Gc14_978 0 n28 ns978 0 -0.00417401757986
Gc14_979 0 n28 ns979 0 -0.00139449290887
Gc14_980 0 n28 ns980 0 0.000596103913039
Gc14_981 0 n28 ns981 0 0.00188483283227
Gc14_982 0 n28 ns982 0 0.000616228130061
Gc14_983 0 n28 ns983 0 -0.000604610749499
Gc14_984 0 n28 ns984 0 -0.0120462153345
Gc14_985 0 n28 ns985 0 0.00963423926991
Gc14_986 0 n28 ns986 0 -0.000344733685155
Gc14_987 0 n28 ns987 0 2.60702670542e-06
Gc14_988 0 n28 ns988 0 -2.70500690286e-05
Gc14_989 0 n28 ns989 0 0.000509993675072
Gc14_990 0 n28 ns990 0 -0.000942759634213
Gc14_991 0 n28 ns991 0 0.00578680282863
Gc14_992 0 n28 ns992 0 -8.08951022292e-05
Gc14_993 0 n28 ns993 0 0.000336508335245
Gc14_994 0 n28 ns994 0 0.000370188671374
Gc14_995 0 n28 ns995 0 0.000142574418837
Gc14_996 0 n28 ns996 0 2.72538248966e-05
Gc14_997 0 n28 ns997 0 -6.95974619529e-06
Gc14_998 0 n28 ns998 0 -0.000623570689946
Gc14_999 0 n28 ns999 0 -0.00156865319743
Gc14_1000 0 n28 ns1000 0 0.000293664309774
Gc14_1001 0 n28 ns1001 0 0.000137071215009
Gc14_1002 0 n28 ns1002 0 0.000148049297088
Gc14_1003 0 n28 ns1003 0 0.000241685463322
Gc14_1004 0 n28 ns1004 0 0.000993051353452
Gc14_1005 0 n28 ns1005 0 -0.000607826983208
Gc14_1006 0 n28 ns1006 0 -0.000956811691344
Gc14_1007 0 n28 ns1007 0 -8.77192788285e-05
Gc14_1008 0 n28 ns1008 0 8.96966409448e-05
Gc14_1009 0 n28 ns1009 0 1.482787381e-05
Gc14_1010 0 n28 ns1010 0 -0.00115521770479
Gc14_1011 0 n28 ns1011 0 -0.00244111977534
Gc14_1012 0 n28 ns1012 0 -0.00108395136145
Gc14_1013 0 n28 ns1013 0 -0.000953624376781
Gc14_1014 0 n28 ns1014 0 0.000362283333644
Gc14_1015 0 n28 ns1015 0 0.00134826085368
Gc14_1016 0 n28 ns1016 0 -0.00611677198572
Gc14_1017 0 n28 ns1017 0 -0.00359300170282
Gc14_1018 0 n28 ns1018 0 -0.00013134136746
Gc14_1019 0 n28 ns1019 0 0.00325171191568
Gc14_1020 0 n28 ns1020 0 0.00133177561101
Gc14_1021 0 n28 ns1021 0 -0.000681737988918
Gc14_1022 0 n28 ns1022 0 -0.0309216835965
Gc14_1023 0 n28 ns1023 0 0.0259190217775
Gc14_1024 0 n28 ns1024 0 -0.00102907025673
Gc14_1025 0 n28 ns1025 0 -4.11560997701e-06
Gc14_1026 0 n28 ns1026 0 -2.90395011632e-05
Gc14_1027 0 n28 ns1027 0 0.000920272154089
Gc14_1028 0 n28 ns1028 0 -0.000926311868166
Gc14_1029 0 n28 ns1029 0 0.0103874694413
Gc14_1030 0 n28 ns1030 0 -8.23091082792e-06
Gc14_1031 0 n28 ns1031 0 0.000762589840906
Gc14_1032 0 n28 ns1032 0 0.00045872880382
Gc14_1033 0 n28 ns1033 0 -0.000148913155039
Gc14_1034 0 n28 ns1034 0 -9.03723290658e-05
Gc14_1035 0 n28 ns1035 0 -2.16726283443e-05
Gc14_1036 0 n28 ns1036 0 -2.0413324692e-05
Gc14_1037 0 n28 ns1037 0 -0.00417005352026
Gc14_1038 0 n28 ns1038 0 0.000238443061278
Gc14_1039 0 n28 ns1039 0 0.0010640110553
Gc14_1040 0 n28 ns1040 0 0.0001219286423
Gc14_1041 0 n28 ns1041 0 0.000413187602704
Gc14_1042 0 n28 ns1042 0 -0.000971369820979
Gc14_1043 0 n28 ns1043 0 -0.000587402212259
Gc14_1044 0 n28 ns1044 0 -0.000452256875178
Gc14_1045 0 n28 ns1045 0 -0.000102544329982
Gc14_1046 0 n28 ns1046 0 0.000266670158482
Gc14_1047 0 n28 ns1047 0 7.23409667173e-05
Gc14_1048 0 n28 ns1048 0 -0.00235658849034
Gc14_1049 0 n28 ns1049 0 -0.00499656179852
Gc14_1050 0 n28 ns1050 0 -0.00154830902363
Gc14_1051 0 n28 ns1051 0 1.04243036703e-05
Gc14_1052 0 n28 ns1052 0 0.000463923590245
Gc14_1053 0 n28 ns1053 0 0.00145866603378
Gc14_1054 0 n28 ns1054 0 -0.00903211877014
Gc14_1055 0 n28 ns1055 0 -0.00528529369288
Gc14_1056 0 n28 ns1056 0 -0.00153604525364
Gc14_1057 0 n28 ns1057 0 0.00384726827686
Gc14_1058 0 n28 ns1058 0 0.00229315525297
Gc14_1059 0 n28 ns1059 0 -0.000329518795205
Gc14_1060 0 n28 ns1060 0 -0.0695352184827
Gc14_1061 0 n28 ns1061 0 0.0605678655113
Gc14_1062 0 n28 ns1062 0 -0.00288905917786
Gc14_1063 0 n28 ns1063 0 -8.86120846187e-06
Gc14_1064 0 n28 ns1064 0 -2.15459343263e-05
Gc14_1065 0 n28 ns1065 0 -0.0003554088638
Gc14_1066 0 n28 ns1066 0 4.5385701496e-05
Gc14_1067 0 n28 ns1067 0 0.00570832882223
Gc14_1068 0 n28 ns1068 0 -0.0013237440097
Gc14_1069 0 n28 ns1069 0 -0.000358781618297
Gc14_1070 0 n28 ns1070 0 0.0018728100094
Gc14_1071 0 n28 ns1071 0 0.00057995513514
Gc14_1072 0 n28 ns1072 0 -0.000160980169785
Gc14_1073 0 n28 ns1073 0 -0.000186061550144
Gc14_1074 0 n28 ns1074 0 0.00208964413659
Gc14_1075 0 n28 ns1075 0 -0.00277014934084
Gc14_1076 0 n28 ns1076 0 -0.000671051330344
Gc14_1077 0 n28 ns1077 0 0.00111544590218
Gc14_1078 0 n28 ns1078 0 -4.3795410011e-05
Gc14_1079 0 n28 ns1079 0 0.000500634800227
Gc14_1080 0 n28 ns1080 0 -0.000408671524508
Gc14_1081 0 n28 ns1081 0 -0.0033384056231
Gc14_1082 0 n28 ns1082 0 -0.000844744357562
Gc14_1083 0 n28 ns1083 0 0.000249675626044
Gc14_1084 0 n28 ns1084 0 0.000300863567203
Gc14_1085 0 n28 ns1085 0 0.000330181889517
Gc14_1086 0 n28 ns1086 0 0.00109402579536
Gc14_1087 0 n28 ns1087 0 -0.00546709166248
Gc14_1088 0 n28 ns1088 0 -0.00296657429205
Gc14_1089 0 n28 ns1089 0 -0.00100734868452
Gc14_1090 0 n28 ns1090 0 0.000192878513391
Gc14_1091 0 n28 ns1091 0 0.00225264168111
Gc14_1092 0 n28 ns1092 0 -0.0123501959291
Gc14_1093 0 n28 ns1093 0 -0.0053984554807
Gc14_1094 0 n28 ns1094 0 -0.000890194019814
Gc14_1095 0 n28 ns1095 0 0.00291578217873
Gc14_1096 0 n28 ns1096 0 0.00304041248778
Gc14_1097 0 n28 ns1097 0 0.000240657934518
Gc14_1098 0 n28 ns1098 0 -0.067752408142
Gc14_1099 0 n28 ns1099 0 0.0644737853736
Gc14_1100 0 n28 ns1100 0 -0.00636376735217
Gc14_1101 0 n28 ns1101 0 -9.90308548025e-06
Gc14_1102 0 n28 ns1102 0 2.93758902407e-06
Gc14_1103 0 n28 ns1103 0 -0.0171208930058
Gc14_1104 0 n28 ns1104 0 -0.00160737150747
Gc14_1105 0 n28 ns1105 0 0.0215906438232
Gc14_1106 0 n28 ns1106 0 0.00650478269317
Gc14_1107 0 n28 ns1107 0 0.0101740700858
Gc14_1108 0 n28 ns1108 0 0.00142307243031
Gc14_1109 0 n28 ns1109 0 -0.00338590750065
Gc14_1110 0 n28 ns1110 0 -0.000529778640045
Gc14_1111 0 n28 ns1111 0 4.38979464707e-05
Gc14_1112 0 n28 ns1112 0 -0.00109985420826
Gc14_1113 0 n28 ns1113 0 -0.0146636825581
Gc14_1114 0 n28 ns1114 0 0.000898727222793
Gc14_1115 0 n28 ns1115 0 0.00198799506276
Gc14_1116 0 n28 ns1116 0 0.000238201688506
Gc14_1117 0 n28 ns1117 0 0.000469570362455
Gc14_1118 0 n28 ns1118 0 0.000108936658368
Gc14_1119 0 n28 ns1119 0 0.000140046872598
Gc14_1120 0 n28 ns1120 0 -0.000121494049094
Gc14_1121 0 n28 ns1121 0 0.000649769909043
Gc14_1122 0 n28 ns1122 0 0.00055627286875
Gc14_1123 0 n28 ns1123 0 0.00038767574703
Gc14_1124 0 n28 ns1124 0 -0.011923610837
Gc14_1125 0 n28 ns1125 0 -0.00785453733808
Gc14_1126 0 n28 ns1126 0 -0.00363037163424
Gc14_1127 0 n28 ns1127 0 -0.0013733268951
Gc14_1128 0 n28 ns1128 0 7.7505967643e-05
Gc14_1129 0 n28 ns1129 0 0.00260876937709
Gc14_1130 0 n28 ns1130 0 0.00757316689691
Gc14_1131 0 n28 ns1131 0 -0.00595299713608
Gc14_1132 0 n28 ns1132 0 0.00186209881748
Gc14_1133 0 n28 ns1133 0 0.00215664597097
Gc14_1134 0 n28 ns1134 0 0.00339648866634
Gc14_1135 0 n28 ns1135 0 -2.46950976799e-05
Gc14_1136 0 n28 ns1136 0 -0.112453691746
Gc14_1137 0 n28 ns1137 0 0.0736524518839
Gc14_1138 0 n28 ns1138 0 -0.00890226366243
Gc14_1139 0 n28 ns1139 0 -1.11632513746e-05
Gc14_1140 0 n28 ns1140 0 1.2841589513e-05
Gc14_1141 0 n28 ns1141 0 -0.000351872952142
Gc14_1142 0 n28 ns1142 0 -6.92332489275e-05
Gc14_1143 0 n28 ns1143 0 0.00641330988345
Gc14_1144 0 n28 ns1144 0 -0.001117349471
Gc14_1145 0 n28 ns1145 0 -0.000593154485525
Gc14_1146 0 n28 ns1146 0 0.00183178935026
Gc14_1147 0 n28 ns1147 0 0.000424979471802
Gc14_1148 0 n28 ns1148 0 -0.000177514347116
Gc14_1149 0 n28 ns1149 0 -0.000202070625787
Gc14_1150 0 n28 ns1150 0 0.0018976252022
Gc14_1151 0 n28 ns1151 0 -0.001578498148
Gc14_1152 0 n28 ns1152 0 -0.000612019193384
Gc14_1153 0 n28 ns1153 0 0.000375851790706
Gc14_1154 0 n28 ns1154 0 -0.00027176723742
Gc14_1155 0 n28 ns1155 0 0.00052096296316
Gc14_1156 0 n28 ns1156 0 5.35526101556e-05
Gc14_1157 0 n28 ns1157 0 -0.00385979469628
Gc14_1158 0 n28 ns1158 0 -0.00139874971727
Gc14_1159 0 n28 ns1159 0 0.000279837452424
Gc14_1160 0 n28 ns1160 0 0.000336307514707
Gc14_1161 0 n28 ns1161 0 0.000496060048576
Gc14_1162 0 n28 ns1162 0 0.000815346620167
Gc14_1163 0 n28 ns1163 0 -0.00496538254118
Gc14_1164 0 n28 ns1164 0 -0.00248807740816
Gc14_1165 0 n28 ns1165 0 -0.00122210091562
Gc14_1166 0 n28 ns1166 0 -0.000129596940199
Gc14_1167 0 n28 ns1167 0 0.00225731607397
Gc14_1168 0 n28 ns1168 0 -0.0124150567255
Gc14_1169 0 n28 ns1169 0 -0.00601457119938
Gc14_1170 0 n28 ns1170 0 -0.00117741633092
Gc14_1171 0 n28 ns1171 0 0.00309845597211
Gc14_1172 0 n28 ns1172 0 0.00315663247572
Gc14_1173 0 n28 ns1173 0 0.000333282284898
Gc14_1174 0 n28 ns1174 0 -0.0722578161256
Gc14_1175 0 n28 ns1175 0 0.0683309661208
Gc14_1176 0 n28 ns1176 0 -0.00649924336091
Gc14_1177 0 n28 ns1177 0 -1.17412159008e-05
Gc14_1178 0 n28 ns1178 0 2.60557449218e-05
Gc14_1179 0 n28 ns1179 0 0.000455937738457
Gc14_1180 0 n28 ns1180 0 -0.000250986415869
Gc14_1181 0 n28 ns1181 0 0.00965770417548
Gc14_1182 0 n28 ns1182 0 0.000181324983825
Gc14_1183 0 n28 ns1183 0 0.00051457963729
Gc14_1184 0 n28 ns1184 0 0.000368826052201
Gc14_1185 0 n28 ns1185 0 -0.000213832742589
Gc14_1186 0 n28 ns1186 0 -9.15484593294e-05
Gc14_1187 0 n28 ns1187 0 2.04340516632e-05
Gc14_1188 0 n28 ns1188 0 -0.00087122600338
Gc14_1189 0 n28 ns1189 0 -0.00347368597288
Gc14_1190 0 n28 ns1190 0 0.000753710184639
Gc14_1191 0 n28 ns1191 0 0.000741228697625
Gc14_1192 0 n28 ns1192 0 -4.57023690789e-05
Gc14_1193 0 n28 ns1193 0 0.000297927469732
Gc14_1194 0 n28 ns1194 0 -0.000380106487163
Gc14_1195 0 n28 ns1195 0 -9.93549851685e-05
Gc14_1196 0 n28 ns1196 0 -0.00072663560879
Gc14_1197 0 n28 ns1197 0 -0.000630485256353
Gc14_1198 0 n28 ns1198 0 0.000195287492992
Gc14_1199 0 n28 ns1199 0 0.000215725885297
Gc14_1200 0 n28 ns1200 0 -0.00254251778629
Gc14_1201 0 n28 ns1201 0 -0.00421441238883
Gc14_1202 0 n28 ns1202 0 -0.000502354467343
Gc14_1203 0 n28 ns1203 0 -6.67815580585e-06
Gc14_1204 0 n28 ns1204 0 -0.000160768702897
Gc14_1205 0 n28 ns1205 0 0.00117824200634
Gc14_1206 0 n28 ns1206 0 -0.00766311355476
Gc14_1207 0 n28 ns1207 0 -0.00576974279736
Gc14_1208 0 n28 ns1208 0 -0.00226362609416
Gc14_1209 0 n28 ns1209 0 0.00357260591439
Gc14_1210 0 n28 ns1210 0 0.00235221296199
Gc14_1211 0 n28 ns1211 0 -3.14567743878e-05
Gc14_1212 0 n28 ns1212 0 -0.0713735718969
Gc14_1213 0 n28 ns1213 0 0.0625541160682
Gc14_1214 0 n28 ns1214 0 -0.00303163291958
Gc14_1215 0 n28 ns1215 0 -1.09922847518e-05
Gc14_1216 0 n28 ns1216 0 1.74227699005e-05
Gd14_1 0 n28 ni1 0 -4.41213347288e-05
Gd14_2 0 n28 ni2 0 0.000115549232265
Gd14_3 0 n28 ni3 0 6.16037137134e-05
Gd14_4 0 n28 ni4 0 7.54661928663e-05
Gd14_5 0 n28 ni5 0 -0.000857063129332
Gd14_6 0 n28 ni6 0 -0.00266595935424
Gd14_7 0 n28 ni7 0 -0.000636319523908
Gd14_8 0 n28 ni8 0 -0.00102238763222
Gd14_9 0 n28 ni9 0 0.000306168751377
Gd14_10 0 n28 ni10 0 -1.18040893569e-06
Gd14_11 0 n28 ni11 0 0.00015810502516
Gd14_12 0 n28 ni12 0 -0.000458534948871
Gd14_13 0 n28 ni13 0 -0.00181966451058
Gd14_14 0 n28 ni14 0 0.000139856061931
Gd14_15 0 n28 ni15 0 -0.00161759351184
Gd14_16 0 n28 ni16 0 -0.000194562276427
Gd14_17 0 n28 ni17 0 -0.00013708724802
Gd14_18 0 n28 ni18 0 -7.42393668719e-05
Gd14_19 0 n28 ni19 0 0.000197158310849
Gd14_20 0 n28 ni20 0 0.000264209417712
Gd14_21 0 n28 ni21 0 3.55830839222e-05
Gd14_22 0 n28 ni22 0 -0.00168966129851
Gd14_23 0 n28 ni23 0 -0.0031395674449
Gd14_24 0 n28 ni24 0 -8.74460716134e-05
Gd14_25 0 n28 ni25 0 0.000194504447797
Gd14_26 0 n28 ni26 0 0.000211536804993
Gd14_27 0 n28 ni27 0 0.000225898109105
Gd14_28 0 n28 ni28 0 0.000614274505229
Gd14_29 0 n28 ni29 0 -0.000381797948797
Gd14_30 0 n28 ni30 0 -0.0069337582468
Gd14_31 0 n28 ni31 0 -0.000383619443871
Gd14_32 0 n28 ni32 0 0.000574742715006
Gc15_1 0 n30 ns1 0 -1.62591664428e-05
Gc15_2 0 n30 ns2 0 -0.00014710447478
Gc15_3 0 n30 ns3 0 -0.00141205513581
Gc15_4 0 n30 ns4 0 -9.96410146497e-05
Gc15_5 0 n30 ns5 0 -0.000114632715997
Gc15_6 0 n30 ns6 0 -3.15268982391e-05
Gc15_7 0 n30 ns7 0 -3.52496352528e-05
Gc15_8 0 n30 ns8 0 -1.54046800704e-05
Gc15_9 0 n30 ns9 0 -2.00389512733e-05
Gc15_10 0 n30 ns10 0 4.44859925732e-05
Gc15_11 0 n30 ns11 0 0.0010722569095
Gc15_12 0 n30 ns12 0 -0.000116339202318
Gc15_13 0 n30 ns13 0 -0.000498592806867
Gc15_14 0 n30 ns14 0 -0.000127466885839
Gc15_15 0 n30 ns15 0 5.88972902949e-05
Gc15_16 0 n30 ns16 0 -0.000140004258128
Gc15_17 0 n30 ns17 0 0.000864920027973
Gc15_18 0 n30 ns18 0 0.000517031523988
Gc15_19 0 n30 ns19 0 -0.000165772564461
Gc15_20 0 n30 ns20 0 -3.79475381061e-05
Gc15_21 0 n30 ns21 0 -0.000140296807226
Gc15_22 0 n30 ns22 0 0.00104271292753
Gc15_23 0 n30 ns23 0 0.000659239710802
Gc15_24 0 n30 ns24 0 0.000433042417218
Gc15_25 0 n30 ns25 0 -0.000519770610167
Gc15_26 0 n30 ns26 0 -0.000421222350627
Gc15_27 0 n30 ns27 0 0.000109578489678
Gc15_28 0 n30 ns28 0 0.00099656607573
Gc15_29 0 n30 ns29 0 0.000492334178478
Gc15_30 0 n30 ns30 0 0.000187706291945
Gc15_31 0 n30 ns31 0 -7.35012568354e-05
Gc15_32 0 n30 ns32 0 -5.32693599664e-05
Gc15_33 0 n30 ns33 0 -0.000183241279824
Gc15_34 0 n30 ns34 0 0.0118303402677
Gc15_35 0 n30 ns35 0 -0.0100973038156
Gc15_36 0 n30 ns36 0 0.00036504891069
Gc15_37 0 n30 ns37 0 -7.6967662053e-06
Gc15_38 0 n30 ns38 0 -2.77515482336e-05
Gc15_39 0 n30 ns39 0 0.000108684677063
Gc15_40 0 n30 ns40 0 -0.000220156378933
Gc15_41 0 n30 ns41 0 -0.00150486781952
Gc15_42 0 n30 ns42 0 -0.000125720720595
Gc15_43 0 n30 ns43 0 -0.00010008168763
Gc15_44 0 n30 ns44 0 -1.29115343721e-05
Gc15_45 0 n30 ns45 0 -4.48737124246e-05
Gc15_46 0 n30 ns46 0 -9.36263656836e-06
Gc15_47 0 n30 ns47 0 -1.35988691407e-05
Gc15_48 0 n30 ns48 0 -6.58033374578e-05
Gc15_49 0 n30 ns49 0 0.00110863758561
Gc15_50 0 n30 ns50 0 -3.76752500741e-05
Gc15_51 0 n30 ns51 0 -0.000559505363239
Gc15_52 0 n30 ns52 0 -0.000162068548743
Gc15_53 0 n30 ns53 0 5.38060875247e-05
Gc15_54 0 n30 ns54 0 -0.000383208829983
Gc15_55 0 n30 ns55 0 0.00088866949567
Gc15_56 0 n30 ns56 0 0.000637969023999
Gc15_57 0 n30 ns57 0 -3.9896152838e-05
Gc15_58 0 n30 ns58 0 -1.16472287251e-05
Gc15_59 0 n30 ns59 0 -0.000176043807751
Gc15_60 0 n30 ns60 0 0.0011150100152
Gc15_61 0 n30 ns61 0 0.000963261544658
Gc15_62 0 n30 ns62 0 0.000648976013986
Gc15_63 0 n30 ns63 0 -0.000572147857793
Gc15_64 0 n30 ns64 0 -0.000561721439369
Gc15_65 0 n30 ns65 0 6.51058189768e-05
Gc15_66 0 n30 ns66 0 0.00118396289298
Gc15_67 0 n30 ns67 0 0.000667913240206
Gc15_68 0 n30 ns68 0 0.00024306098664
Gc15_69 0 n30 ns69 0 -8.67753530301e-05
Gc15_70 0 n30 ns70 0 -6.84461155408e-05
Gc15_71 0 n30 ns71 0 -0.000233001077599
Gc15_72 0 n30 ns72 0 0.014160100115
Gc15_73 0 n30 ns73 0 -0.0121115065369
Gc15_74 0 n30 ns74 0 0.00043650145726
Gc15_75 0 n30 ns75 0 -4.90120508215e-06
Gc15_76 0 n30 ns76 0 -3.06488546754e-05
Gc15_77 0 n30 ns77 0 0.000140421311619
Gc15_78 0 n30 ns78 0 -0.000129085850187
Gc15_79 0 n30 ns79 0 -0.000943976262505
Gc15_80 0 n30 ns80 0 -0.000246264497354
Gc15_81 0 n30 ns81 0 0.000104837797033
Gc15_82 0 n30 ns82 0 3.28026825754e-05
Gc15_83 0 n30 ns83 0 0.000127756287919
Gc15_84 0 n30 ns84 0 3.19564149952e-05
Gc15_85 0 n30 ns85 0 1.52194890718e-05
Gc15_86 0 n30 ns86 0 0.000115760340107
Gc15_87 0 n30 ns87 0 0.000115250227017
Gc15_88 0 n30 ns88 0 0.000252486111718
Gc15_89 0 n30 ns89 0 -0.000120458735959
Gc15_90 0 n30 ns90 0 -0.000164601596296
Gc15_91 0 n30 ns91 0 -3.47959892859e-05
Gc15_92 0 n30 ns92 0 -0.000737077275964
Gc15_93 0 n30 ns93 0 -0.000182063407391
Gc15_94 0 n30 ns94 0 0.000351991616865
Gc15_95 0 n30 ns95 0 0.000597766422979
Gc15_96 0 n30 ns96 0 0.000122193590046
Gc15_97 0 n30 ns97 0 -0.000160036992975
Gc15_98 0 n30 ns98 0 0.000266975573646
Gc15_99 0 n30 ns99 0 0.00118513022153
Gc15_100 0 n30 ns100 0 0.00112275587857
Gc15_101 0 n30 ns101 0 -4.93409940712e-05
Gc15_102 0 n30 ns102 0 -0.000714535217245
Gc15_103 0 n30 ns103 0 -0.000366735588765
Gc15_104 0 n30 ns104 0 0.000623496373356
Gc15_105 0 n30 ns105 0 0.000697722332547
Gc15_106 0 n30 ns106 0 0.000363348903724
Gc15_107 0 n30 ns107 0 0.00027046216105
Gc15_108 0 n30 ns108 0 5.80895820297e-05
Gc15_109 0 n30 ns109 0 -0.000398851208913
Gc15_110 0 n30 ns110 0 0.0140826914593
Gc15_111 0 n30 ns111 0 -0.0123371595798
Gc15_112 0 n30 ns112 0 0.000494760940028
Gc15_113 0 n30 ns113 0 -3.58479439364e-06
Gc15_114 0 n30 ns114 0 -3.52678626966e-05
Gc15_115 0 n30 ns115 0 -0.000497847513501
Gc15_116 0 n30 ns116 0 0.000864793895526
Gc15_117 0 n30 ns117 0 -0.00179932955783
Gc15_118 0 n30 ns118 0 -0.000301786244329
Gc15_119 0 n30 ns119 0 0.000106837404062
Gc15_120 0 n30 ns120 0 -0.000139392127191
Gc15_121 0 n30 ns121 0 0.000125418646292
Gc15_122 0 n30 ns122 0 -1.03527722495e-05
Gc15_123 0 n30 ns123 0 1.37133663466e-05
Gc15_124 0 n30 ns124 0 0.000774737748685
Gc15_125 0 n30 ns125 0 0.000591982885912
Gc15_126 0 n30 ns126 0 8.82612630563e-05
Gc15_127 0 n30 ns127 0 0.000186006612103
Gc15_128 0 n30 ns128 0 -0.000141964598328
Gc15_129 0 n30 ns129 0 -0.000201341664979
Gc15_130 0 n30 ns130 0 0.000730528728488
Gc15_131 0 n30 ns131 0 -0.000590600644062
Gc15_132 0 n30 ns132 0 -0.000480104979588
Gc15_133 0 n30 ns133 0 0.000414138543861
Gc15_134 0 n30 ns134 0 0.000173109429365
Gc15_135 0 n30 ns135 0 -8.95697518551e-05
Gc15_136 0 n30 ns136 0 0.000160413557265
Gc15_137 0 n30 ns137 0 -5.88675934769e-05
Gc15_138 0 n30 ns138 0 0.000638613827434
Gc15_139 0 n30 ns139 0 0.000842080079414
Gc15_140 0 n30 ns140 0 -0.000319299662418
Gc15_141 0 n30 ns141 0 -0.000848312914468
Gc15_142 0 n30 ns142 0 -0.000391967751425
Gc15_143 0 n30 ns143 0 -0.000295233591364
Gc15_144 0 n30 ns144 0 0.000261268090793
Gc15_145 0 n30 ns145 0 0.00127482473082
Gc15_146 0 n30 ns146 0 0.000487715371926
Gc15_147 0 n30 ns147 0 -0.000656131213426
Gc15_148 0 n30 ns148 0 0.0165318291525
Gc15_149 0 n30 ns149 0 -0.0152019119829
Gc15_150 0 n30 ns150 0 0.000767214150832
Gc15_151 0 n30 ns151 0 -4.86520166118e-06
Gc15_152 0 n30 ns152 0 -2.58848109467e-05
Gc15_153 0 n30 ns153 0 -0.000926619888908
Gc15_154 0 n30 ns154 0 0.00163229967956
Gc15_155 0 n30 ns155 0 -0.00271181312424
Gc15_156 0 n30 ns156 0 -3.27772414589e-05
Gc15_157 0 n30 ns157 0 -0.000222083563157
Gc15_158 0 n30 ns158 0 6.07261282496e-05
Gc15_159 0 n30 ns159 0 -0.00031368709313
Gc15_160 0 n30 ns160 0 -3.62904695338e-05
Gc15_161 0 n30 ns161 0 -2.62706665828e-05
Gc15_162 0 n30 ns162 0 -0.00114239542408
Gc15_163 0 n30 ns163 0 0.00170367135227
Gc15_164 0 n30 ns164 0 0.000153053811231
Gc15_165 0 n30 ns165 0 -0.000275547673699
Gc15_166 0 n30 ns166 0 -4.91432924963e-05
Gc15_167 0 n30 ns167 0 -0.000405861396585
Gc15_168 0 n30 ns168 0 0.000329737378111
Gc15_169 0 n30 ns169 0 0.00137232844292
Gc15_170 0 n30 ns170 0 -0.000210065846404
Gc15_171 0 n30 ns171 0 -0.000162225431357
Gc15_172 0 n30 ns172 0 0.000304371660039
Gc15_173 0 n30 ns173 0 -0.000102682693549
Gc15_174 0 n30 ns174 0 0.00157110580795
Gc15_175 0 n30 ns175 0 0.00138334092937
Gc15_176 0 n30 ns176 0 0.000231189994972
Gc15_177 0 n30 ns177 0 0.000740158013889
Gc15_178 0 n30 ns178 0 3.81324714498e-06
Gc15_179 0 n30 ns179 0 -0.00111997373625
Gc15_180 0 n30 ns180 0 0.0015762488726
Gc15_181 0 n30 ns181 0 -0.000327017029597
Gc15_182 0 n30 ns182 0 -0.000871699779454
Gc15_183 0 n30 ns183 0 0.00150893524749
Gc15_184 0 n30 ns184 0 0.00103543683512
Gc15_185 0 n30 ns185 0 -0.000640358134138
Gc15_186 0 n30 ns186 0 0.030988468222
Gc15_187 0 n30 ns187 0 -0.0285312062828
Gc15_188 0 n30 ns188 0 0.00155953754238
Gc15_189 0 n30 ns189 0 -5.61713955204e-06
Gc15_190 0 n30 ns190 0 -8.20176006754e-06
Gc15_191 0 n30 ns191 0 -0.00136227050058
Gc15_192 0 n30 ns192 0 -1.9874632815e-05
Gc15_193 0 n30 ns193 0 0.00155560765077
Gc15_194 0 n30 ns194 0 0.000734098967568
Gc15_195 0 n30 ns195 0 -0.000536661611686
Gc15_196 0 n30 ns196 0 0.000683065406931
Gc15_197 0 n30 ns197 0 -2.44678377779e-05
Gc15_198 0 n30 ns198 0 -0.000120666043526
Gc15_199 0 n30 ns199 0 1.10504538512e-05
Gc15_200 0 n30 ns200 0 -0.00271604275564
Gc15_201 0 n30 ns201 0 -0.000698226266767
Gc15_202 0 n30 ns202 0 0.00102335972136
Gc15_203 0 n30 ns203 0 -0.000151581928615
Gc15_204 0 n30 ns204 0 0.000255301138665
Gc15_205 0 n30 ns205 0 -0.000590141374666
Gc15_206 0 n30 ns206 0 -0.0021767310303
Gc15_207 0 n30 ns207 0 -0.000799481177783
Gc15_208 0 n30 ns208 0 -0.000221117066685
Gc15_209 0 n30 ns209 0 0.000525003436596
Gc15_210 0 n30 ns210 0 0.00053782120895
Gc15_211 0 n30 ns211 0 0.000173781895403
Gc15_212 0 n30 ns212 0 -0.00238101378165
Gc15_213 0 n30 ns213 0 0.00322664273603
Gc15_214 0 n30 ns214 0 0.000803153564025
Gc15_215 0 n30 ns215 0 0.00105551831358
Gc15_216 0 n30 ns216 0 0.000441511190336
Gc15_217 0 n30 ns217 0 -0.0016257317254
Gc15_218 0 n30 ns218 0 -2.51469343111e-05
Gc15_219 0 n30 ns219 0 0.00192254402907
Gc15_220 0 n30 ns220 0 -0.00168683475639
Gc15_221 0 n30 ns221 0 0.000706916207375
Gc15_222 0 n30 ns222 0 0.00178185229121
Gc15_223 0 n30 ns223 0 -0.000263224767186
Gc15_224 0 n30 ns224 0 0.0409168719289
Gc15_225 0 n30 ns225 0 -0.04143851417
Gc15_226 0 n30 ns226 0 0.00349939906544
Gc15_227 0 n30 ns227 0 1.16303722966e-07
Gc15_228 0 n30 ns228 0 1.31058595152e-05
Gc15_229 0 n30 ns229 0 -0.00489131069426
Gc15_230 0 n30 ns230 0 -0.000510946619606
Gc15_231 0 n30 ns231 0 -0.00429226217267
Gc15_232 0 n30 ns232 0 0.000233000461464
Gc15_233 0 n30 ns233 0 -0.00131198594434
Gc15_234 0 n30 ns234 0 -0.000275458705397
Gc15_235 0 n30 ns235 0 0.000833064763214
Gc15_236 0 n30 ns236 0 -0.000128589596723
Gc15_237 0 n30 ns237 0 -2.790996991e-05
Gc15_238 0 n30 ns238 0 3.43097688547e-05
Gc15_239 0 n30 ns239 0 0.0019122350707
Gc15_240 0 n30 ns240 0 0.000519032435961
Gc15_241 0 n30 ns241 0 -0.000135779966465
Gc15_242 0 n30 ns242 0 0.000366103047195
Gc15_243 0 n30 ns243 0 -0.000501894977056
Gc15_244 0 n30 ns244 0 0.00131064360529
Gc15_245 0 n30 ns245 0 -0.000960846825941
Gc15_246 0 n30 ns246 0 -0.000442788652623
Gc15_247 0 n30 ns247 0 -0.00029705720658
Gc15_248 0 n30 ns248 0 0.000398818618949
Gc15_249 0 n30 ns249 0 0.000291860243256
Gc15_250 0 n30 ns250 0 -0.00165346786751
Gc15_251 0 n30 ns251 0 6.38677864737e-05
Gc15_252 0 n30 ns252 0 0.000856892576296
Gc15_253 0 n30 ns253 0 0.00218863646833
Gc15_254 0 n30 ns254 0 0.00129129077851
Gc15_255 0 n30 ns255 0 -0.00193391179522
Gc15_256 0 n30 ns256 0 0.000275299270069
Gc15_257 0 n30 ns257 0 0.000715434706824
Gc15_258 0 n30 ns258 0 9.909961244e-05
Gc15_259 0 n30 ns259 0 7.05791248373e-05
Gc15_260 0 n30 ns260 0 0.00255584394465
Gc15_261 0 n30 ns261 0 0.000150233498098
Gc15_262 0 n30 ns262 0 0.0247035695958
Gc15_263 0 n30 ns263 0 -0.0241996440469
Gc15_264 0 n30 ns264 0 0.00660910610635
Gc15_265 0 n30 ns265 0 -3.43433360569e-06
Gc15_266 0 n30 ns266 0 2.99280544684e-05
Gc15_267 0 n30 ns267 0 -0.00464904336669
Gc15_268 0 n30 ns268 0 0.000376746277673
Gc15_269 0 n30 ns269 0 -0.00680081474712
Gc15_270 0 n30 ns270 0 -4.45283462646e-05
Gc15_271 0 n30 ns271 0 -0.00115320474513
Gc15_272 0 n30 ns272 0 -9.22355844392e-05
Gc15_273 0 n30 ns273 0 0.000165549955829
Gc15_274 0 n30 ns274 0 -0.000105773224935
Gc15_275 0 n30 ns275 0 -4.50946743954e-05
Gc15_276 0 n30 ns276 0 -0.00208396484083
Gc15_277 0 n30 ns277 0 0.00315756257674
Gc15_278 0 n30 ns278 0 0.000379927018634
Gc15_279 0 n30 ns279 0 -0.000631919991371
Gc15_280 0 n30 ns280 0 0.000400876642013
Gc15_281 0 n30 ns281 0 -0.000357221332524
Gc15_282 0 n30 ns282 0 0.00050731412129
Gc15_283 0 n30 ns283 0 0.00280720204086
Gc15_284 0 n30 ns284 0 0.000778263174113
Gc15_285 0 n30 ns285 0 -0.000707284100797
Gc15_286 0 n30 ns286 0 0.000398619709532
Gc15_287 0 n30 ns287 0 0.000181070895884
Gc15_288 0 n30 ns288 0 0.00275919038741
Gc15_289 0 n30 ns289 0 0.00154190631259
Gc15_290 0 n30 ns290 0 0.000432734376729
Gc15_291 0 n30 ns291 0 0.00193039652988
Gc15_292 0 n30 ns292 0 0.0015917666521
Gc15_293 0 n30 ns293 0 -0.00154324032356
Gc15_294 0 n30 ns294 0 0.00393402655738
Gc15_295 0 n30 ns295 0 -0.00149353829582
Gc15_296 0 n30 ns296 0 0.0012462220431
Gc15_297 0 n30 ns297 0 0.000714409662356
Gc15_298 0 n30 ns298 0 0.00295666920728
Gc15_299 0 n30 ns299 0 0.000333684890539
Gc15_300 0 n30 ns300 0 -0.00982347622173
Gc15_301 0 n30 ns301 0 0.013583812403
Gc15_302 0 n30 ns302 0 0.00706098746092
Gc15_303 0 n30 ns303 0 -1.27185362838e-06
Gc15_304 0 n30 ns304 0 3.20420122849e-05
Gc15_305 0 n30 ns305 0 -0.00152511626604
Gc15_306 0 n30 ns306 0 -0.00172156585934
Gc15_307 0 n30 ns307 0 0.00498110469665
Gc15_308 0 n30 ns308 0 0.00106047253136
Gc15_309 0 n30 ns309 0 -0.000449562298852
Gc15_310 0 n30 ns310 0 0.000821399604776
Gc15_311 0 n30 ns311 0 0.000501653206527
Gc15_312 0 n30 ns312 0 -0.000138805418253
Gc15_313 0 n30 ns313 0 -3.69890030546e-05
Gc15_314 0 n30 ns314 0 -0.00146536984934
Gc15_315 0 n30 ns315 0 -0.00198362604115
Gc15_316 0 n30 ns316 0 0.000837493073616
Gc15_317 0 n30 ns317 0 -0.000340155138204
Gc15_318 0 n30 ns318 0 0.000339518447129
Gc15_319 0 n30 ns319 0 -0.000227741080265
Gc15_320 0 n30 ns320 0 -0.00238570984534
Gc15_321 0 n30 ns321 0 -0.00232819183612
Gc15_322 0 n30 ns322 0 -3.03621155238e-05
Gc15_323 0 n30 ns323 0 0.000181959847344
Gc15_324 0 n30 ns324 0 0.000225054911961
Gc15_325 0 n30 ns325 0 0.000330604824292
Gc15_326 0 n30 ns326 0 -0.00507475589607
Gc15_327 0 n30 ns327 0 0.00186555935091
Gc15_328 0 n30 ns328 0 0.00048650086109
Gc15_329 0 n30 ns329 0 0.000416283609461
Gc15_330 0 n30 ns330 0 0.000838494200877
Gc15_331 0 n30 ns331 0 -0.000819743466855
Gc15_332 0 n30 ns332 0 -0.002599045178
Gc15_333 0 n30 ns333 0 0.00269747218109
Gc15_334 0 n30 ns334 0 -0.00185852404472
Gc15_335 0 n30 ns335 0 -0.000770665620723
Gc15_336 0 n30 ns336 0 0.00176002921867
Gc15_337 0 n30 ns337 0 0.00052933414956
Gc15_338 0 n30 ns338 0 0.0298682788077
Gc15_339 0 n30 ns339 0 -0.0345933805652
Gc15_340 0 n30 ns340 0 0.00429206236456
Gc15_341 0 n30 ns341 0 2.66001802084e-06
Gc15_342 0 n30 ns342 0 2.81737549473e-05
Gc15_343 0 n30 ns343 0 0.000172596333212
Gc15_344 0 n30 ns344 0 -0.000408065339735
Gc15_345 0 n30 ns345 0 -0.00147494978989
Gc15_346 0 n30 ns346 0 -0.000108692685117
Gc15_347 0 n30 ns347 0 -0.000133966934958
Gc15_348 0 n30 ns348 0 -6.39759312579e-05
Gc15_349 0 n30 ns349 0 5.52027856222e-05
Gc15_350 0 n30 ns350 0 3.12913922918e-05
Gc15_351 0 n30 ns351 0 9.04692724975e-06
Gc15_352 0 n30 ns352 0 -0.000100718441462
Gc15_353 0 n30 ns353 0 0.000679070017997
Gc15_354 0 n30 ns354 0 0.000132137354281
Gc15_355 0 n30 ns355 0 -0.000384602239317
Gc15_356 0 n30 ns356 0 -0.000171014248995
Gc15_357 0 n30 ns357 0 1.52899777522e-05
Gc15_358 0 n30 ns358 0 -0.00078077015939
Gc15_359 0 n30 ns359 0 0.000458401523503
Gc15_360 0 n30 ns360 0 0.00061422490265
Gc15_361 0 n30 ns361 0 0.000345695103362
Gc15_362 0 n30 ns362 0 7.40076471947e-05
Gc15_363 0 n30 ns363 0 -0.000188120169645
Gc15_364 0 n30 ns364 0 0.000803643019403
Gc15_365 0 n30 ns365 0 0.00140661804506
Gc15_366 0 n30 ns366 0 0.00102905982242
Gc15_367 0 n30 ns367 0 -0.000402579658393
Gc15_368 0 n30 ns368 0 -0.000731068866445
Gc15_369 0 n30 ns369 0 -0.000148921846037
Gc15_370 0 n30 ns370 0 0.00123588191
Gc15_371 0 n30 ns371 0 0.00113124325508
Gc15_372 0 n30 ns372 0 0.000416835337421
Gc15_373 0 n30 ns373 0 -6.36035693707e-05
Gc15_374 0 n30 ns374 0 -7.45791491072e-05
Gc15_375 0 n30 ns375 0 -0.000358722816309
Gc15_376 0 n30 ns376 0 0.0178752873856
Gc15_377 0 n30 ns377 0 -0.0153978218779
Gc15_378 0 n30 ns378 0 0.000560034443623
Gc15_379 0 n30 ns379 0 -3.64889928417e-06
Gc15_380 0 n30 ns380 0 -3.37915920731e-05
Gc15_381 0 n30 ns381 0 -0.000169599166513
Gc15_382 0 n30 ns382 0 3.78146570432e-05
Gc15_383 0 n30 ns383 0 -0.000737165489703
Gc15_384 0 n30 ns384 0 -0.000154945997657
Gc15_385 0 n30 ns385 0 6.69744316065e-05
Gc15_386 0 n30 ns386 0 -8.92166862606e-05
Gc15_387 0 n30 ns387 0 0.000116023825148
Gc15_388 0 n30 ns388 0 3.64763226344e-06
Gc15_389 0 n30 ns389 0 3.60634881538e-05
Gc15_390 0 n30 ns390 0 0.000384346946479
Gc15_391 0 n30 ns391 0 0.000120580514845
Gc15_392 0 n30 ns392 0 0.000241122404106
Gc15_393 0 n30 ns393 0 0.000136626450551
Gc15_394 0 n30 ns394 0 -0.000137673187973
Gc15_395 0 n30 ns395 0 -0.000135370673441
Gc15_396 0 n30 ns396 0 -7.30656306117e-05
Gc15_397 0 n30 ns397 0 -0.000720493349859
Gc15_398 0 n30 ns398 0 -0.000172554447482
Gc15_399 0 n30 ns399 0 0.000658638306839
Gc15_400 0 n30 ns400 0 0.0001717917441
Gc15_401 0 n30 ns401 0 -0.000100511097635
Gc15_402 0 n30 ns402 0 -0.000148216855032
Gc15_403 0 n30 ns403 0 0.000485686272751
Gc15_404 0 n30 ns404 0 0.000901512587988
Gc15_405 0 n30 ns405 0 0.00053960646371
Gc15_406 0 n30 ns406 0 -0.000493115980565
Gc15_407 0 n30 ns407 0 -0.000665122282656
Gc15_408 0 n30 ns408 0 -0.000410762132114
Gc15_409 0 n30 ns409 0 0.000339718185332
Gc15_410 0 n30 ns410 0 0.000483283321805
Gc15_411 0 n30 ns411 0 0.000888265286931
Gc15_412 0 n30 ns412 0 0.00029222135609
Gc15_413 0 n30 ns413 0 -0.000596033159365
Gc15_414 0 n30 ns414 0 0.0149310220054
Gc15_415 0 n30 ns415 0 -0.0136367066853
Gc15_416 0 n30 ns416 0 0.000646188381269
Gc15_417 0 n30 ns417 0 -3.94571887855e-06
Gc15_418 0 n30 ns418 0 -3.33591005695e-05
Gc15_419 0 n30 ns419 0 -0.000780687412847
Gc15_420 0 n30 ns420 0 0.00174148899738
Gc15_421 0 n30 ns421 0 -0.00352312377042
Gc15_422 0 n30 ns422 0 -0.000250823061194
Gc15_423 0 n30 ns423 0 -0.000134577508675
Gc15_424 0 n30 ns424 0 -0.000179670848354
Gc15_425 0 n30 ns425 0 -0.000146149997839
Gc15_426 0 n30 ns426 0 -2.50118013319e-05
Gc15_427 0 n30 ns427 0 -1.42884689099e-05
Gc15_428 0 n30 ns428 0 -6.70645251729e-05
Gc15_429 0 n30 ns429 0 0.001829048111
Gc15_430 0 n30 ns430 0 3.47725446099e-06
Gc15_431 0 n30 ns431 0 -0.000133624235091
Gc15_432 0 n30 ns432 0 -0.000123408898427
Gc15_433 0 n30 ns433 0 -0.000313209796324
Gc15_434 0 n30 ns434 0 0.000997954764245
Gc15_435 0 n30 ns435 0 0.00088345356692
Gc15_436 0 n30 ns436 0 -0.000333893192717
Gc15_437 0 n30 ns437 0 -9.29275832728e-05
Gc15_438 0 n30 ns438 0 0.000221964013657
Gc15_439 0 n30 ns439 0 -0.000127143575808
Gc15_440 0 n30 ns440 0 0.00156348094551
Gc15_441 0 n30 ns441 0 0.000515407262003
Gc15_442 0 n30 ns442 0 0.000300829006961
Gc15_443 0 n30 ns443 0 0.000755100876577
Gc15_444 0 n30 ns444 0 -0.000133323599331
Gc15_445 0 n30 ns445 0 -0.000977989946963
Gc15_446 0 n30 ns446 0 0.00119829404034
Gc15_447 0 n30 ns447 0 -0.000520951050179
Gc15_448 0 n30 ns448 0 -0.000423787782117
Gc15_449 0 n30 ns449 0 0.00143921203627
Gc15_450 0 n30 ns450 0 0.000779880746994
Gc15_451 0 n30 ns451 0 -0.000666744591046
Gc15_452 0 n30 ns452 0 0.0272742225933
Gc15_453 0 n30 ns453 0 -0.0247129739103
Gc15_454 0 n30 ns454 0 0.00122744821666
Gc15_455 0 n30 ns455 0 -6.96832857489e-06
Gc15_456 0 n30 ns456 0 -1.90790233355e-05
Gc15_457 0 n30 ns457 0 -0.00111018179259
Gc15_458 0 n30 ns458 0 0.000402466318922
Gc15_459 0 n30 ns459 0 7.89088482945e-05
Gc15_460 0 n30 ns460 0 0.000564992316992
Gc15_461 0 n30 ns461 0 -0.000523514553378
Gc15_462 0 n30 ns462 0 0.000464514796088
Gc15_463 0 n30 ns463 0 -0.000204533496923
Gc15_464 0 n30 ns464 0 -4.22824528723e-05
Gc15_465 0 n30 ns465 0 -6.60584179652e-07
Gc15_466 0 n30 ns466 0 -0.00255678831221
Gc15_467 0 n30 ns467 0 1.10286233079e-05
Gc15_468 0 n30 ns468 0 0.000653535034295
Gc15_469 0 n30 ns469 0 -0.000244043621978
Gc15_470 0 n30 ns470 0 0.000117669873312
Gc15_471 0 n30 ns471 0 -0.000504888763228
Gc15_472 0 n30 ns472 0 -0.00194156562688
Gc15_473 0 n30 ns473 0 0.000465974505817
Gc15_474 0 n30 ns474 0 -4.3028072952e-05
Gc15_475 0 n30 ns475 0 0.000391004284056
Gc15_476 0 n30 ns476 0 0.000486923001418
Gc15_477 0 n30 ns477 0 5.18986085273e-05
Gc15_478 0 n30 ns478 0 -0.000513080003256
Gc15_479 0 n30 ns479 0 0.00364316287911
Gc15_480 0 n30 ns480 0 0.000684174680376
Gc15_481 0 n30 ns481 0 0.000784084696088
Gc15_482 0 n30 ns482 0 0.000183672463803
Gc15_483 0 n30 ns483 0 -0.00143388615541
Gc15_484 0 n30 ns484 0 0.0017758229923
Gc15_485 0 n30 ns485 0 0.00171817683291
Gc15_486 0 n30 ns486 0 -0.00156244526092
Gc15_487 0 n30 ns487 0 0.000894769237341
Gc15_488 0 n30 ns488 0 0.00144759623877
Gc15_489 0 n30 ns489 0 -0.000436423583187
Gc15_490 0 n30 ns490 0 0.0420466503627
Gc15_491 0 n30 ns491 0 -0.0402357403783
Gc15_492 0 n30 ns492 0 0.00263231147882
Gc15_493 0 n30 ns493 0 -2.04725491452e-06
Gc15_494 0 n30 ns494 0 6.94925108771e-07
Gc15_495 0 n30 ns495 0 -0.00194877166355
Gc15_496 0 n30 ns496 0 -0.00176421891557
Gc15_497 0 n30 ns497 0 0.00521686297948
Gc15_498 0 n30 ns498 0 0.00036361359177
Gc15_499 0 n30 ns499 0 -0.000367123271756
Gc15_500 0 n30 ns500 0 0.00053635682884
Gc15_501 0 n30 ns501 0 0.00042030626611
Gc15_502 0 n30 ns502 0 -0.000177914136248
Gc15_503 0 n30 ns503 0 -4.51669918943e-05
Gc15_504 0 n30 ns504 0 -0.00109810224405
Gc15_505 0 n30 ns505 0 -0.000728702583445
Gc15_506 0 n30 ns506 0 0.000996318874782
Gc15_507 0 n30 ns507 0 0.000370157427773
Gc15_508 0 n30 ns508 0 0.000461400244809
Gc15_509 0 n30 ns509 0 -0.000549764044879
Gc15_510 0 n30 ns510 0 0.000542029469593
Gc15_511 0 n30 ns511 0 -0.0026887080482
Gc15_512 0 n30 ns512 0 -0.000945104624881
Gc15_513 0 n30 ns513 0 9.81837583468e-05
Gc15_514 0 n30 ns514 0 0.000396692193642
Gc15_515 0 n30 ns515 0 0.000366385090877
Gc15_516 0 n30 ns516 0 -0.00467810974976
Gc15_517 0 n30 ns517 0 -0.00172536471461
Gc15_518 0 n30 ns518 0 0.000353814374866
Gc15_519 0 n30 ns519 0 0.00197807487402
Gc15_520 0 n30 ns520 0 0.00123362614838
Gc15_521 0 n30 ns521 0 -0.00170097706808
Gc15_522 0 n30 ns522 0 -0.00663920482652
Gc15_523 0 n30 ns523 0 -0.00156264060778
Gc15_524 0 n30 ns524 0 -0.00122529959868
Gc15_525 0 n30 ns525 0 0.00112472033305
Gc15_526 0 n30 ns526 0 0.00257536923969
Gc15_527 0 n30 ns527 0 0.000258077350425
Gc15_528 0 n30 ns528 0 0.0144582206377
Gc15_529 0 n30 ns529 0 -0.023335432008
Gc15_530 0 n30 ns530 0 0.00536581653698
Gc15_531 0 n30 ns531 0 2.3141102346e-06
Gc15_532 0 n30 ns532 0 2.73202549965e-05
Gc15_533 0 n30 ns533 0 -0.00369103021028
Gc15_534 0 n30 ns534 0 0.000309113011205
Gc15_535 0 n30 ns535 0 -0.00278217019463
Gc15_536 0 n30 ns536 0 0.000482261213715
Gc15_537 0 n30 ns537 0 -0.000508639904376
Gc15_538 0 n30 ns538 0 0.00021626494897
Gc15_539 0 n30 ns539 0 -0.000310720986932
Gc15_540 0 n30 ns540 0 -0.000235130327328
Gc15_541 0 n30 ns541 0 -8.91129790688e-05
Gc15_542 0 n30 ns542 0 -0.00373427897719
Gc15_543 0 n30 ns543 0 0.00229814863903
Gc15_544 0 n30 ns544 0 0.00102468557764
Gc15_545 0 n30 ns545 0 -0.000206173870751
Gc15_546 0 n30 ns546 0 0.000552444515773
Gc15_547 0 n30 ns547 0 -0.000536820361367
Gc15_548 0 n30 ns548 0 0.000832675298193
Gc15_549 0 n30 ns549 0 0.00193646572261
Gc15_550 0 n30 ns550 0 0.000333632329198
Gc15_551 0 n30 ns551 0 -0.000335000766162
Gc15_552 0 n30 ns552 0 0.000484380531702
Gc15_553 0 n30 ns553 0 0.000291523334004
Gc15_554 0 n30 ns554 0 0.00122626579037
Gc15_555 0 n30 ns555 0 0.000117042807569
Gc15_556 0 n30 ns556 0 0.000517999154366
Gc15_557 0 n30 ns557 0 0.00277114766846
Gc15_558 0 n30 ns558 0 0.00179365161014
Gc15_559 0 n30 ns559 0 -0.00194359513299
Gc15_560 0 n30 ns560 0 -8.49905061533e-05
Gc15_561 0 n30 ns561 0 -0.00315461934232
Gc15_562 0 n30 ns562 0 0.00162866244784
Gc15_563 0 n30 ns563 0 0.00169817616749
Gc15_564 0 n30 ns564 0 0.00330431503752
Gc15_565 0 n30 ns565 0 0.00023537915328
Gc15_566 0 n30 ns566 0 -0.0234675337867
Gc15_567 0 n30 ns567 0 0.0231667999467
Gc15_568 0 n30 ns568 0 0.00699617266538
Gc15_569 0 n30 ns569 0 1.03503963767e-05
Gc15_570 0 n30 ns570 0 3.57110138194e-05
Gc15_571 0 n30 ns571 0 -0.00173217411888
Gc15_572 0 n30 ns572 0 -0.00230482862361
Gc15_573 0 n30 ns573 0 0.00553419710045
Gc15_574 0 n30 ns574 0 0.00065278886137
Gc15_575 0 n30 ns575 0 -0.000436038496459
Gc15_576 0 n30 ns576 0 0.000763982651589
Gc15_577 0 n30 ns577 0 0.000355977493575
Gc15_578 0 n30 ns578 0 -0.000150671155654
Gc15_579 0 n30 ns579 0 -8.9296803642e-05
Gc15_580 0 n30 ns580 0 -0.0018748171885
Gc15_581 0 n30 ns581 0 -0.00106614861788
Gc15_582 0 n30 ns582 0 0.000891522386151
Gc15_583 0 n30 ns583 0 -0.000156447176036
Gc15_584 0 n30 ns584 0 0.000493062933625
Gc15_585 0 n30 ns585 0 -0.000284385199837
Gc15_586 0 n30 ns586 0 -0.000840365267315
Gc15_587 0 n30 ns587 0 -0.00160747020947
Gc15_588 0 n30 ns588 0 -6.36765219639e-06
Gc15_589 0 n30 ns589 0 -0.000249429889084
Gc15_590 0 n30 ns590 0 0.000246187043513
Gc15_591 0 n30 ns591 0 0.00034295241451
Gc15_592 0 n30 ns592 0 -0.00419242386841
Gc15_593 0 n30 ns593 0 -0.000454753678326
Gc15_594 0 n30 ns594 0 0.000257633933916
Gc15_595 0 n30 ns595 0 0.000764031266067
Gc15_596 0 n30 ns596 0 0.00117773994462
Gc15_597 0 n30 ns597 0 -0.000960361957227
Gc15_598 0 n30 ns598 0 -0.00503176560852
Gc15_599 0 n30 ns599 0 -0.00067853670016
Gc15_600 0 n30 ns600 0 -0.00177629335978
Gc15_601 0 n30 ns601 0 -9.16554287361e-05
Gc15_602 0 n30 ns602 0 0.00234499577729
Gc15_603 0 n30 ns603 0 0.000738380656903
Gc15_604 0 n30 ns604 0 0.0139109168014
Gc15_605 0 n30 ns605 0 -0.0225712829541
Gc15_606 0 n30 ns606 0 0.00537189970833
Gc15_607 0 n30 ns607 0 2.25884291187e-06
Gc15_608 0 n30 ns608 0 3.37148462272e-05
Gc15_609 0 n30 ns609 0 -5.22856423759e-05
Gc15_610 0 n30 ns610 0 3.35390990883e-05
Gc15_611 0 n30 ns611 0 -0.000889587862758
Gc15_612 0 n30 ns612 0 -0.000228820455565
Gc15_613 0 n30 ns613 0 0.000172429005376
Gc15_614 0 n30 ns614 0 5.89320029416e-05
Gc15_615 0 n30 ns615 0 0.000198004770884
Gc15_616 0 n30 ns616 0 3.65534695655e-05
Gc15_617 0 n30 ns617 0 -4.98492402051e-06
Gc15_618 0 n30 ns618 0 -0.000180581262731
Gc15_619 0 n30 ns619 0 -0.000758928086661
Gc15_620 0 n30 ns620 0 0.000177625003858
Gc15_621 0 n30 ns621 0 0.00054192633662
Gc15_622 0 n30 ns622 0 0.000163330360822
Gc15_623 0 n30 ns623 0 -9.04349534383e-05
Gc15_624 0 n30 ns624 0 -0.000243984467217
Gc15_625 0 n30 ns625 0 0.000721661573003
Gc15_626 0 n30 ns626 0 0.000523551675283
Gc15_627 0 n30 ns627 0 -0.000157511713109
Gc15_628 0 n30 ns628 0 -5.28702571483e-05
Gc15_629 0 n30 ns629 0 -0.000158231246221
Gc15_630 0 n30 ns630 0 0.000450640682258
Gc15_631 0 n30 ns631 0 -0.000376792140681
Gc15_632 0 n30 ns632 0 -0.000448858788052
Gc15_633 0 n30 ns633 0 6.20742776213e-05
Gc15_634 0 n30 ns634 0 0.000275606995082
Gc15_635 0 n30 ns635 0 7.44089835422e-05
Gc15_636 0 n30 ns636 0 6.23376494631e-05
Gc15_637 0 n30 ns637 0 0.000835291785777
Gc15_638 0 n30 ns638 0 0.00038664917147
Gc15_639 0 n30 ns639 0 -2.324566334e-05
Gc15_640 0 n30 ns640 0 -4.05959522679e-05
Gc15_641 0 n30 ns641 0 -0.000230880375635
Gc15_642 0 n30 ns642 0 0.00857907881149
Gc15_643 0 n30 ns643 0 -0.00731424410703
Gc15_644 0 n30 ns644 0 0.000193769928369
Gc15_645 0 n30 ns645 0 6.28985604632e-06
Gc15_646 0 n30 ns646 0 -2.78477695172e-05
Gc15_647 0 n30 ns647 0 0.000176662197476
Gc15_648 0 n30 ns648 0 -0.000319229502985
Gc15_649 0 n30 ns649 0 -0.000170142858544
Gc15_650 0 n30 ns650 0 -0.000249302065708
Gc15_651 0 n30 ns651 0 0.000165892321452
Gc15_652 0 n30 ns652 0 3.11593759321e-05
Gc15_653 0 n30 ns653 0 0.000175301414665
Gc15_654 0 n30 ns654 0 2.95500434641e-05
Gc15_655 0 n30 ns655 0 4.74151951132e-06
Gc15_656 0 n30 ns656 0 -7.01538233798e-06
Gc15_657 0 n30 ns657 0 -0.000885511172256
Gc15_658 0 n30 ns658 0 4.26939802097e-05
Gc15_659 0 n30 ns659 0 0.000623069828655
Gc15_660 0 n30 ns660 0 0.000199104401907
Gc15_661 0 n30 ns661 0 -6.09170081384e-05
Gc15_662 0 n30 ns662 0 -0.000406956605073
Gc15_663 0 n30 ns663 0 0.000620481505311
Gc15_664 0 n30 ns664 0 0.0005831052494
Gc15_665 0 n30 ns665 0 -4.62602364611e-05
Gc15_666 0 n30 ns666 0 -3.75230887016e-05
Gc15_667 0 n30 ns667 0 -0.000186075973789
Gc15_668 0 n30 ns668 0 0.000378940581152
Gc15_669 0 n30 ns669 0 -0.000569791309358
Gc15_670 0 n30 ns670 0 -0.000656382676437
Gc15_671 0 n30 ns671 0 9.32162880115e-05
Gc15_672 0 n30 ns672 0 0.000407316452032
Gc15_673 0 n30 ns673 0 0.000127294726026
Gc15_674 0 n30 ns674 0 -0.000420426475647
Gc15_675 0 n30 ns675 0 0.000772562276504
Gc15_676 0 n30 ns676 0 0.000483026292197
Gc15_677 0 n30 ns677 0 0.000133681637663
Gc15_678 0 n30 ns678 0 -1.92978502503e-06
Gc15_679 0 n30 ns679 0 -0.000290431908409
Gc15_680 0 n30 ns680 0 0.00658035723494
Gc15_681 0 n30 ns681 0 -0.00565971071019
Gc15_682 0 n30 ns682 0 0.000133941680091
Gc15_683 0 n30 ns683 0 5.62041657547e-06
Gc15_684 0 n30 ns684 0 -3.0882793061e-05
Gc15_685 0 n30 ns685 0 0.000615761921614
Gc15_686 0 n30 ns686 0 -0.00137436820595
Gc15_687 0 n30 ns687 0 0.00339275299567
Gc15_688 0 n30 ns688 0 8.22221452928e-06
Gc15_689 0 n30 ns689 0 0.000189811908179
Gc15_690 0 n30 ns690 0 0.000102628055618
Gc15_691 0 n30 ns691 0 -6.70967569175e-05
Gc15_692 0 n30 ns692 0 -2.33966119757e-05
Gc15_693 0 n30 ns693 0 -1.98200165668e-05
Gc15_694 0 n30 ns694 0 0.000375963862139
Gc15_695 0 n30 ns695 0 -0.000941551119684
Gc15_696 0 n30 ns696 0 -0.000406852310837
Gc15_697 0 n30 ns697 0 0.000355392646566
Gc15_698 0 n30 ns698 0 0.000201206066729
Gc15_699 0 n30 ns699 0 0.000112866912435
Gc15_700 0 n30 ns700 0 -0.000682144839679
Gc15_701 0 n30 ns701 0 -0.000682705765233
Gc15_702 0 n30 ns702 0 0.000160709855564
Gc15_703 0 n30 ns703 0 0.000611755635252
Gc15_704 0 n30 ns704 0 9.19707474441e-05
Gc15_705 0 n30 ns705 0 -0.000131332760565
Gc15_706 0 n30 ns706 0 -0.000291658178943
Gc15_707 0 n30 ns707 0 -0.00123966504754
Gc15_708 0 n30 ns708 0 -0.00130946317277
Gc15_709 0 n30 ns709 0 -8.88951131458e-05
Gc15_710 0 n30 ns710 0 0.000750686680385
Gc15_711 0 n30 ns711 0 0.000515611636911
Gc15_712 0 n30 ns712 0 -0.00324810026471
Gc15_713 0 n30 ns713 0 -0.00040996388528
Gc15_714 0 n30 ns714 0 0.000684574209303
Gc15_715 0 n30 ns715 0 0.00121409979474
Gc15_716 0 n30 ns716 0 0.000353908153002
Gc15_717 0 n30 ns717 0 -0.000488815966264
Gc15_718 0 n30 ns718 0 -0.00798756085839
Gc15_719 0 n30 ns719 0 0.00629345591956
Gc15_720 0 n30 ns720 0 -0.000230475119975
Gc15_721 0 n30 ns721 0 7.78395616987e-06
Gc15_722 0 n30 ns722 0 -3.71063666972e-05
Gc15_723 0 n30 ns723 0 0.000498331432211
Gc15_724 0 n30 ns724 0 -0.000806921868283
Gc15_725 0 n30 ns725 0 0.00421134603951
Gc15_726 0 n30 ns726 0 -9.8363440043e-05
Gc15_727 0 n30 ns727 0 0.000291232038595
Gc15_728 0 n30 ns728 0 0.000291732934648
Gc15_729 0 n30 ns729 0 2.45866010655e-06
Gc15_730 0 n30 ns730 0 2.80045765168e-05
Gc15_731 0 n30 ns731 0 -3.36896898695e-05
Gc15_732 0 n30 ns732 0 7.95904091576e-05
Gc15_733 0 n30 ns733 0 -0.000748113787766
Gc15_734 0 n30 ns734 0 -0.000208699034095
Gc15_735 0 n30 ns735 0 -8.44152119991e-05
Gc15_736 0 n30 ns736 0 0.000144834700882
Gc15_737 0 n30 ns737 0 0.000224740571014
Gc15_738 0 n30 ns738 0 0.000362905544464
Gc15_739 0 n30 ns739 0 -0.00128431577144
Gc15_740 0 n30 ns740 0 -0.000717929067037
Gc15_741 0 n30 ns741 0 0.000583691533916
Gc15_742 0 n30 ns742 0 0.000156201336596
Gc15_743 0 n30 ns743 0 -1.51924197838e-05
Gc15_744 0 n30 ns744 0 -0.000476166341242
Gc15_745 0 n30 ns745 0 -0.00163717279227
Gc15_746 0 n30 ns746 0 -0.00136326111085
Gc15_747 0 n30 ns747 0 -0.000943743569458
Gc15_748 0 n30 ns748 0 0.000571059332045
Gc15_749 0 n30 ns749 0 0.00119034984104
Gc15_750 0 n30 ns750 0 -0.00508086866487
Gc15_751 0 n30 ns751 0 -0.00200807783203
Gc15_752 0 n30 ns752 0 0.000541101173521
Gc15_753 0 n30 ns753 0 0.00240799173212
Gc15_754 0 n30 ns754 0 0.000834543861228
Gc15_755 0 n30 ns755 0 -0.000704674295463
Gc15_756 0 n30 ns756 0 -0.0169495012856
Gc15_757 0 n30 ns757 0 0.0137092945152
Gc15_758 0 n30 ns758 0 -0.00049247408301
Gc15_759 0 n30 ns759 0 3.44441972167e-07
Gc15_760 0 n30 ns760 0 -3.00079873515e-05
Gc15_761 0 n30 ns761 0 0.000648827149548
Gc15_762 0 n30 ns762 0 -0.00152051363137
Gc15_763 0 n30 ns763 0 0.00805468990168
Gc15_764 0 n30 ns764 0 0.00018459281155
Gc15_765 0 n30 ns765 0 1.05096170913e-05
Gc15_766 0 n30 ns766 0 4.78112423237e-05
Gc15_767 0 n30 ns767 0 0.000149622961992
Gc15_768 0 n30 ns768 0 1.53001206558e-05
Gc15_769 0 n30 ns769 0 4.9812757328e-05
Gc15_770 0 n30 ns770 0 -0.000438495729369
Gc15_771 0 n30 ns771 0 -0.00260080933532
Gc15_772 0 n30 ns772 0 0.000131386625678
Gc15_773 0 n30 ns773 0 0.000566636569826
Gc15_774 0 n30 ns774 0 0.000201209207337
Gc15_775 0 n30 ns775 0 0.000400826644632
Gc15_776 0 n30 ns776 0 0.000277706268691
Gc15_777 0 n30 ns777 0 -0.000356536603406
Gc15_778 0 n30 ns778 0 -0.000811294140474
Gc15_779 0 n30 ns779 0 -8.39801899278e-05
Gc15_780 0 n30 ns780 0 0.000194972426297
Gc15_781 0 n30 ns781 0 9.46222670903e-06
Gc15_782 0 n30 ns782 0 -0.0015688996905
Gc15_783 0 n30 ns783 0 -0.00294878271084
Gc15_784 0 n30 ns784 0 -0.00103198853228
Gc15_785 0 n30 ns785 0 -0.000942032201772
Gc15_786 0 n30 ns786 0 0.00025444261506
Gc15_787 0 n30 ns787 0 0.00152951353187
Gc15_788 0 n30 ns788 0 -0.00718636391242
Gc15_789 0 n30 ns789 0 -0.00446194174666
Gc15_790 0 n30 ns790 0 -0.000632528029058
Gc15_791 0 n30 ns791 0 0.00370694821238
Gc15_792 0 n30 ns792 0 0.00170469792969
Gc15_793 0 n30 ns793 0 -0.000611716806036
Gc15_794 0 n30 ns794 0 -0.043926369875
Gc15_795 0 n30 ns795 0 0.037284125901
Gc15_796 0 n30 ns796 0 -0.00155251140579
Gc15_797 0 n30 ns797 0 -7.03994277527e-06
Gc15_798 0 n30 ns798 0 -1.12013612267e-05
Gc15_799 0 n30 ns799 0 0.000224857418815
Gc15_800 0 n30 ns800 0 -0.00149917950497
Gc15_801 0 n30 ns801 0 0.0116466280887
Gc15_802 0 n30 ns802 0 0.000154924700192
Gc15_803 0 n30 ns803 0 0.000355956934127
Gc15_804 0 n30 ns804 0 0.000518385081264
Gc15_805 0 n30 ns805 0 -0.000468958699488
Gc15_806 0 n30 ns806 0 -0.000154725964031
Gc15_807 0 n30 ns807 0 -2.59613104669e-05
Gc15_808 0 n30 ns808 0 0.00129319923109
Gc15_809 0 n30 ns809 0 -0.00362831830595
Gc15_810 0 n30 ns810 0 -0.000458926552387
Gc15_811 0 n30 ns811 0 0.000850043554232
Gc15_812 0 n30 ns812 0 -4.72307339591e-05
Gc15_813 0 n30 ns813 0 0.000606694454825
Gc15_814 0 n30 ns814 0 -0.00152356422477
Gc15_815 0 n30 ns815 0 -0.00198698799388
Gc15_816 0 n30 ns816 0 -0.000709483924896
Gc15_817 0 n30 ns817 0 0.000356394442742
Gc15_818 0 n30 ns818 0 0.000418830602522
Gc15_819 0 n30 ns819 0 0.000240251726216
Gc15_820 0 n30 ns820 0 -0.00177609437784
Gc15_821 0 n30 ns821 0 -0.00565966823685
Gc15_822 0 n30 ns822 0 -0.00202321403616
Gc15_823 0 n30 ns823 0 -0.000274018092691
Gc15_824 0 n30 ns824 0 0.000344341934802
Gc15_825 0 n30 ns825 0 0.00185772287701
Gc15_826 0 n30 ns826 0 -0.0106919988392
Gc15_827 0 n30 ns827 0 -0.00615426219341
Gc15_828 0 n30 ns828 0 -0.00187501795212
Gc15_829 0 n30 ns829 0 0.00382984542558
Gc15_830 0 n30 ns830 0 0.00269964325636
Gc15_831 0 n30 ns831 0 -9.6236626061e-05
Gc15_832 0 n30 ns832 0 -0.0862049196522
Gc15_833 0 n30 ns833 0 0.0764386111343
Gc15_834 0 n30 ns834 0 -0.00417750659708
Gc15_835 0 n30 ns835 0 -9.59150053745e-06
Gc15_836 0 n30 ns836 0 1.25514686269e-05
Gc15_837 0 n30 ns837 0 -0.00261871065319
Gc15_838 0 n30 ns838 0 -0.00249522487335
Gc15_839 0 n30 ns839 0 0.00682975732535
Gc15_840 0 n30 ns840 0 0.000990811131324
Gc15_841 0 n30 ns841 0 -0.00182531502156
Gc15_842 0 n30 ns842 0 0.000732112489131
Gc15_843 0 n30 ns843 0 0.00192382773499
Gc15_844 0 n30 ns844 0 3.20475426572e-05
Gc15_845 0 n30 ns845 0 -0.000240520022624
Gc15_846 0 n30 ns846 0 0.000278271221414
Gc15_847 0 n30 ns847 0 -0.000239306819037
Gc15_848 0 n30 ns848 0 -0.00063267044551
Gc15_849 0 n30 ns849 0 -3.84872527342e-05
Gc15_850 0 n30 ns850 0 -0.000404988770974
Gc15_851 0 n30 ns851 0 0.000447594846611
Gc15_852 0 n30 ns852 0 0.00210508865623
Gc15_853 0 n30 ns853 0 -0.00290828774992
Gc15_854 0 n30 ns854 0 -0.00116301224398
Gc15_855 0 n30 ns855 0 -0.000442001869833
Gc15_856 0 n30 ns856 0 0.000246991407843
Gc15_857 0 n30 ns857 0 0.000408679606817
Gc15_858 0 n30 ns858 0 0.00198892590168
Gc15_859 0 n30 ns859 0 -0.00163554756126
Gc15_860 0 n30 ns860 0 -0.00186383381585
Gc15_861 0 n30 ns861 0 -0.00200341676649
Gc15_862 0 n30 ns862 0 -0.000787755033493
Gc15_863 0 n30 ns863 0 0.00226459513987
Gc15_864 0 n30 ns864 0 -0.0111136634207
Gc15_865 0 n30 ns865 0 -0.00519337902123
Gc15_866 0 n30 ns866 0 -0.00012058315165
Gc15_867 0 n30 ns867 0 0.00238299234107
Gc15_868 0 n30 ns868 0 0.00319956457203
Gc15_869 0 n30 ns869 0 0.000343657399588
Gc15_870 0 n30 ns870 0 -0.0368942638721
Gc15_871 0 n30 ns871 0 0.0387502326939
Gc15_872 0 n30 ns872 0 -0.007101521946
Gc15_873 0 n30 ns873 0 -1.32560076043e-05
Gc15_874 0 n30 ns874 0 2.94669600061e-05
Gc15_875 0 n30 ns875 0 -0.00558541049448
Gc15_876 0 n30 ns876 0 -0.00414710377586
Gc15_877 0 n30 ns877 0 0.00646253672816
Gc15_878 0 n30 ns878 0 0.00237585303275
Gc15_879 0 n30 ns879 0 -0.00222086885519
Gc15_880 0 n30 ns880 0 0.000657303259732
Gc15_881 0 n30 ns881 0 0.00296799530859
Gc15_882 0 n30 ns882 0 9.71648303879e-06
Gc15_883 0 n30 ns883 0 -0.000277236160873
Gc15_884 0 n30 ns884 0 -0.00205375477281
Gc15_885 0 n30 ns885 0 -0.0011715015502
Gc15_886 0 n30 ns886 0 -3.40654121872e-05
Gc15_887 0 n30 ns887 0 0.000679158895646
Gc15_888 0 n30 ns888 0 -0.000254285661088
Gc15_889 0 n30 ns889 0 0.000282614860792
Gc15_890 0 n30 ns890 0 0.00327063470169
Gc15_891 0 n30 ns891 0 -0.000926837649033
Gc15_892 0 n30 ns892 0 -0.0005197908506
Gc15_893 0 n30 ns893 0 -0.00162438947065
Gc15_894 0 n30 ns894 0 -2.71208718264e-06
Gc15_895 0 n30 ns895 0 0.000200982345253
Gc15_896 0 n30 ns896 0 0.00244727751961
Gc15_897 0 n30 ns897 0 0.00201058182348
Gc15_898 0 n30 ns898 0 -6.32186927284e-05
Gc15_899 0 n30 ns899 0 -0.00212366367812
Gc15_900 0 n30 ns900 0 -0.00167598243147
Gc15_901 0 n30 ns901 0 0.00143749067832
Gc15_902 0 n30 ns902 0 -0.0116577644542
Gc15_903 0 n30 ns903 0 -0.00485498587618
Gc15_904 0 n30 ns904 0 0.00128632469559
Gc15_905 0 n30 ns905 0 0.00285521490929
Gc15_906 0 n30 ns906 0 0.0035438866914
Gc15_907 0 n30 ns907 0 0.000519433153754
Gc15_908 0 n30 ns908 0 0.0174667859937
Gc15_909 0 n30 ns909 0 -0.00768132686761
Gc15_910 0 n30 ns910 0 -0.00777237624339
Gc15_911 0 n30 ns911 0 -1.48148557773e-05
Gc15_912 0 n30 ns912 0 2.63376579303e-05
Gc15_913 0 n30 ns913 0 0.000210195777137
Gc15_914 0 n30 ns914 0 -0.000302416840279
Gc15_915 0 n30 ns915 0 0.00740604955945
Gc15_916 0 n30 ns916 0 -8.93621584325e-05
Gc15_917 0 n30 ns917 0 -6.14274240521e-05
Gc15_918 0 n30 ns918 0 0.000257461139403
Gc15_919 0 n30 ns919 0 -0.000756406554802
Gc15_920 0 n30 ns920 0 -0.000134107289969
Gc15_921 0 n30 ns921 0 1.54928876863e-05
Gc15_922 0 n30 ns922 0 0.00187208601188
Gc15_923 0 n30 ns923 0 -0.00170373415688
Gc15_924 0 n30 ns924 0 -0.000450603836002
Gc15_925 0 n30 ns925 0 0.000756143666138
Gc15_926 0 n30 ns926 0 -0.000258006368115
Gc15_927 0 n30 ns927 0 0.000210073692311
Gc15_928 0 n30 ns928 0 -0.00223609153751
Gc15_929 0 n30 ns929 0 -0.00175655693058
Gc15_930 0 n30 ns930 0 0.000124449124507
Gc15_931 0 n30 ns931 0 0.000153965125166
Gc15_932 0 n30 ns932 0 0.000248409665715
Gc15_933 0 n30 ns933 0 0.000319486905081
Gc15_934 0 n30 ns934 0 -0.000274342521106
Gc15_935 0 n30 ns935 0 -0.00555870854891
Gc15_936 0 n30 ns936 0 -0.00205059590084
Gc15_937 0 n30 ns937 0 0.00079855310169
Gc15_938 0 n30 ns938 0 0.000214783277814
Gc15_939 0 n30 ns939 0 0.000991265855618
Gc15_940 0 n30 ns940 0 -0.007745918
Gc15_941 0 n30 ns941 0 -0.0031603312199
Gc15_942 0 n30 ns942 0 -0.00218416990159
Gc15_943 0 n30 ns943 0 0.00089880741851
Gc15_944 0 n30 ns944 0 0.00222837496424
Gc15_945 0 n30 ns945 0 0.000667776259919
Gc15_946 0 n30 ns946 0 -0.0774721099809
Gc15_947 0 n30 ns947 0 0.071944338664
Gc15_948 0 n30 ns948 0 -0.00506308897613
Gc15_949 0 n30 ns949 0 -6.79210851189e-06
Gc15_950 0 n30 ns950 0 2.32450694766e-05
Gc15_951 0 n30 ns951 0 0.000520105496703
Gc15_952 0 n30 ns952 0 -0.00105096510773
Gc15_953 0 n30 ns953 0 0.00193593302749
Gc15_954 0 n30 ns954 0 -0.000112484582092
Gc15_955 0 n30 ns955 0 0.000144041011713
Gc15_956 0 n30 ns956 0 2.93340566155e-05
Gc15_957 0 n30 ns957 0 3.44199926265e-05
Gc15_958 0 n30 ns958 0 -5.83314231011e-06
Gc15_959 0 n30 ns959 0 -3.49986079233e-07
Gc15_960 0 n30 ns960 0 0.000284562969477
Gc15_961 0 n30 ns961 0 -0.000900512151077
Gc15_962 0 n30 ns962 0 -0.000253026658265
Gc15_963 0 n30 ns963 0 0.000508813783556
Gc15_964 0 n30 ns964 0 0.000200561130143
Gc15_965 0 n30 ns965 0 3.51830957234e-05
Gc15_966 0 n30 ns966 0 -0.000650545932695
Gc15_967 0 n30 ns967 0 -5.9107545167e-05
Gc15_968 0 n30 ns968 0 0.00041648202867
Gc15_969 0 n30 ns969 0 0.000326730672686
Gc15_970 0 n30 ns970 0 3.20699915894e-05
Gc15_971 0 n30 ns971 0 -0.000166541306983
Gc15_972 0 n30 ns972 0 -3.01777199014e-05
Gc15_973 0 n30 ns973 0 -0.000932936192434
Gc15_974 0 n30 ns974 0 -0.00104042425127
Gc15_975 0 n30 ns975 0 7.68218852918e-05
Gc15_976 0 n30 ns976 0 0.000635854956104
Gc15_977 0 n30 ns977 0 0.000295540599767
Gc15_978 0 n30 ns978 0 -0.00198704169578
Gc15_979 0 n30 ns979 0 0.000359261112895
Gc15_980 0 n30 ns980 0 0.000694937295846
Gc15_981 0 n30 ns981 0 0.000678974956254
Gc15_982 0 n30 ns982 0 0.000160548897384
Gc15_983 0 n30 ns983 0 -0.000432277519805
Gc15_984 0 n30 ns984 0 -0.000351048902387
Gc15_985 0 n30 ns985 0 -1.26503069544e-05
Gc15_986 0 n30 ns986 0 -4.18073150271e-05
Gc15_987 0 n30 ns987 0 7.34291792756e-06
Gc15_988 0 n30 ns988 0 -3.45703366678e-05
Gc15_989 0 n30 ns989 0 0.000594163876429
Gc15_990 0 n30 ns990 0 -0.000753848574275
Gc15_991 0 n30 ns991 0 0.00340689979117
Gc15_992 0 n30 ns992 0 -0.000175325516524
Gc15_993 0 n30 ns993 0 0.000335933195932
Gc15_994 0 n30 ns994 0 0.00025741240707
Gc15_995 0 n30 ns995 0 -3.73350653126e-05
Gc15_996 0 n30 ns996 0 3.76216967932e-06
Gc15_997 0 n30 ns997 0 -4.87480263637e-05
Gc15_998 0 n30 ns998 0 0.00048990939081
Gc15_999 0 n30 ns999 0 -0.000558789450385
Gc15_1000 0 n30 ns1000 0 -0.000402869177522
Gc15_1001 0 n30 ns1001 0 -2.19458027243e-05
Gc15_1002 0 n30 ns1002 0 0.000131667098682
Gc15_1003 0 n30 ns1003 0 0.000182107014808
Gc15_1004 0 n30 ns1004 0 -1.30197206716e-05
Gc15_1005 0 n30 ns1005 0 -0.00124245615453
Gc15_1006 0 n30 ns1006 0 -0.000406975719345
Gc15_1007 0 n30 ns1007 0 0.00067491028607
Gc15_1008 0 n30 ns1008 0 0.000133916941323
Gc15_1009 0 n30 ns1009 0 -4.9961002368e-05
Gc15_1010 0 n30 ns1010 0 -0.000318430063908
Gc15_1011 0 n30 ns1011 0 -0.00140718491866
Gc15_1012 0 n30 ns1012 0 -0.00136442808644
Gc15_1013 0 n30 ns1013 0 -0.00059652745573
Gc15_1014 0 n30 ns1014 0 0.000662110630486
Gc15_1015 0 n30 ns1015 0 0.000894280121913
Gc15_1016 0 n30 ns1016 0 -0.00416895597037
Gc15_1017 0 n30 ns1017 0 -0.00126008072438
Gc15_1018 0 n30 ns1018 0 0.000633958260686
Gc15_1019 0 n30 ns1019 0 0.00186605914837
Gc15_1020 0 n30 ns1020 0 0.000606100163751
Gc15_1021 0 n30 ns1021 0 -0.000620271439774
Gc15_1022 0 n30 ns1022 0 -0.0115176615504
Gc15_1023 0 n30 ns1023 0 0.0091579816001
Gc15_1024 0 n30 ns1024 0 -0.000326477840801
Gc15_1025 0 n30 ns1025 0 3.53258262382e-06
Gc15_1026 0 n30 ns1026 0 -3.48008834837e-05
Gc15_1027 0 n30 ns1027 0 0.000311536704107
Gc15_1028 0 n30 ns1028 0 -0.000646945298313
Gc15_1029 0 n30 ns1029 0 0.00554640036179
Gc15_1030 0 n30 ns1030 0 -5.70966640508e-05
Gc15_1031 0 n30 ns1031 0 0.000373356734661
Gc15_1032 0 n30 ns1032 0 0.000369242898084
Gc15_1033 0 n30 ns1033 0 0.000177604344702
Gc15_1034 0 n30 ns1034 0 2.58320600433e-05
Gc15_1035 0 n30 ns1035 0 -2.74339423539e-06
Gc15_1036 0 n30 ns1036 0 -0.00040838329032
Gc15_1037 0 n30 ns1037 0 -0.00207795203868
Gc15_1038 0 n30 ns1038 0 0.000149660363913
Gc15_1039 0 n30 ns1039 0 0.000358357771428
Gc15_1040 0 n30 ns1040 0 0.000228407278047
Gc15_1041 0 n30 ns1041 0 0.000300072936978
Gc15_1042 0 n30 ns1042 0 0.000765146029986
Gc15_1043 0 n30 ns1043 0 -0.000726232074028
Gc15_1044 0 n30 ns1044 0 -0.000917205546253
Gc15_1045 0 n30 ns1045 0 5.52074483288e-05
Gc15_1046 0 n30 ns1046 0 0.000128599422559
Gc15_1047 0 n30 ns1047 0 2.06574099933e-06
Gc15_1048 0 n30 ns1048 0 -0.00100189452547
Gc15_1049 0 n30 ns1049 0 -0.00245463623211
Gc15_1050 0 n30 ns1050 0 -0.00113739995154
Gc15_1051 0 n30 ns1051 0 -0.00111229432561
Gc15_1052 0 n30 ns1052 0 0.000338566725646
Gc15_1053 0 n30 ns1053 0 0.00145252776606
Gc15_1054 0 n30 ns1054 0 -0.00622863106081
Gc15_1055 0 n30 ns1055 0 -0.00388455925565
Gc15_1056 0 n30 ns1056 0 -0.000191019006723
Gc15_1057 0 n30 ns1057 0 0.00332948235645
Gc15_1058 0 n30 ns1058 0 0.00136204678504
Gc15_1059 0 n30 ns1059 0 -0.000660915691225
Gc15_1060 0 n30 ns1060 0 -0.0325746998814
Gc15_1061 0 n30 ns1061 0 0.0273619243438
Gc15_1062 0 n30 ns1062 0 -0.00108034557291
Gc15_1063 0 n30 ns1063 0 -4.75997810223e-06
Gc15_1064 0 n30 ns1064 0 -2.06612423153e-05
Gc15_1065 0 n30 ns1065 0 0.000757194889328
Gc15_1066 0 n30 ns1066 0 -0.00110340406669
Gc15_1067 0 n30 ns1067 0 0.0115445245285
Gc15_1068 0 n30 ns1068 0 0.000251883882215
Gc15_1069 0 n30 ns1069 0 0.000641959235098
Gc15_1070 0 n30 ns1070 0 0.000365923500563
Gc15_1071 0 n30 ns1071 0 -0.000251748426484
Gc15_1072 0 n30 ns1072 0 -0.000116713208257
Gc15_1073 0 n30 ns1073 0 -5.91589001977e-06
Gc15_1074 0 n30 ns1074 0 0.000361840637785
Gc15_1075 0 n30 ns1075 0 -0.00444181883925
Gc15_1076 0 n30 ns1076 0 -0.000110913865017
Gc15_1077 0 n30 ns1077 0 0.00106414869122
Gc15_1078 0 n30 ns1078 0 0.000148687978234
Gc15_1079 0 n30 ns1079 0 0.000555113200627
Gc15_1080 0 n30 ns1080 0 -0.00126979768409
Gc15_1081 0 n30 ns1081 0 -0.00119752959287
Gc15_1082 0 n30 ns1082 0 -0.000643152490594
Gc15_1083 0 n30 ns1083 0 0.000239720163043
Gc15_1084 0 n30 ns1084 0 0.000353997351638
Gc15_1085 0 n30 ns1085 0 0.00012731647074
Gc15_1086 0 n30 ns1086 0 -0.00251412518829
Gc15_1087 0 n30 ns1087 0 -0.00501425309348
Gc15_1088 0 n30 ns1088 0 -0.00159304895774
Gc15_1089 0 n30 ns1089 0 -0.000200021531293
Gc15_1090 0 n30 ns1090 0 0.000418783358239
Gc15_1091 0 n30 ns1091 0 0.00161712565052
Gc15_1092 0 n30 ns1092 0 -0.00990841037621
Gc15_1093 0 n30 ns1093 0 -0.00607359523171
Gc15_1094 0 n30 ns1094 0 -0.00163693301408
Gc15_1095 0 n30 ns1095 0 0.0042031486374
Gc15_1096 0 n30 ns1096 0 0.00242528509004
Gc15_1097 0 n30 ns1097 0 -0.000296603876514
Gc15_1098 0 n30 ns1098 0 -0.077410699807
Gc15_1099 0 n30 ns1099 0 0.0672318861183
Gc15_1100 0 n30 ns1100 0 -0.00311440442404
Gc15_1101 0 n30 ns1101 0 -9.44551626924e-06
Gc15_1102 0 n30 ns1102 0 1.73470925577e-07
Gc15_1103 0 n30 ns1103 0 -0.000349992406951
Gc15_1104 0 n30 ns1104 0 -5.77539336449e-05
Gc15_1105 0 n30 ns1105 0 0.00642882470897
Gc15_1106 0 n30 ns1106 0 -0.00112270163265
Gc15_1107 0 n30 ns1107 0 -0.000588186536322
Gc15_1108 0 n30 ns1108 0 0.00183780740199
Gc15_1109 0 n30 ns1109 0 0.00042648739979
Gc15_1110 0 n30 ns1110 0 -0.000177995388424
Gc15_1111 0 n30 ns1111 0 -0.00020317087615
Gc15_1112 0 n30 ns1112 0 0.00189474320116
Gc15_1113 0 n30 ns1113 0 -0.00158874043032
Gc15_1114 0 n30 ns1114 0 -0.000609630768067
Gc15_1115 0 n30 ns1115 0 0.000378443356773
Gc15_1116 0 n30 ns1116 0 -0.000271056411496
Gc15_1117 0 n30 ns1117 0 0.00052058301084
Gc15_1118 0 n30 ns1118 0 5.15201647871e-05
Gc15_1119 0 n30 ns1119 0 -0.00386533766267
Gc15_1120 0 n30 ns1120 0 -0.00140044548082
Gc15_1121 0 n30 ns1121 0 0.000281371211784
Gc15_1122 0 n30 ns1122 0 0.00033648218572
Gc15_1123 0 n30 ns1123 0 0.000496838340066
Gc15_1124 0 n30 ns1124 0 0.000809300693537
Gc15_1125 0 n30 ns1125 0 -0.00497169458771
Gc15_1126 0 n30 ns1126 0 -0.00249081034931
Gc15_1127 0 n30 ns1127 0 -0.00122084408942
Gc15_1128 0 n30 ns1128 0 -0.000128267121887
Gc15_1129 0 n30 ns1129 0 0.00225820928691
Gc15_1130 0 n30 ns1130 0 -0.0124332786789
Gc15_1131 0 n30 ns1131 0 -0.00602479793605
Gc15_1132 0 n30 ns1132 0 -0.00117779873957
Gc15_1133 0 n30 ns1133 0 0.00310478079333
Gc15_1134 0 n30 ns1134 0 0.00315896953344
Gc15_1135 0 n30 ns1135 0 0.000333193698202
Gc15_1136 0 n30 ns1136 0 -0.0723796170827
Gc15_1137 0 n30 ns1137 0 0.0684318053925
Gc15_1138 0 n30 ns1138 0 -0.00650214729547
Gc15_1139 0 n30 ns1139 0 -1.17375945157e-05
Gc15_1140 0 n30 ns1140 0 2.62815169816e-05
Gc15_1141 0 n30 ns1141 0 -0.0175784499504
Gc15_1142 0 n30 ns1142 0 -0.000670616949753
Gc15_1143 0 n30 ns1143 0 0.0193269060103
Gc15_1144 0 n30 ns1144 0 0.0064129360461
Gc15_1145 0 n30 ns1145 0 0.0101744382677
Gc15_1146 0 n30 ns1146 0 0.0014690326433
Gc15_1147 0 n30 ns1147 0 -0.00325288015754
Gc15_1148 0 n30 ns1148 0 -0.00049140582904
Gc15_1149 0 n30 ns1149 0 4.83132937282e-05
Gc15_1150 0 n30 ns1150 0 -0.00208406706456
Gc15_1151 0 n30 ns1151 0 -0.0139766006244
Gc15_1152 0 n30 ns1152 0 0.00171247415332
Gc15_1153 0 n30 ns1153 0 0.00175965646718
Gc15_1154 0 n30 ns1154 0 6.03895440022e-05
Gc15_1155 0 n30 ns1155 0 0.000240188846155
Gc15_1156 0 n30 ns1156 0 0.00110778540991
Gc15_1157 0 n30 ns1157 0 0.00113678699582
Gc15_1158 0 n30 ns1158 0 -0.000255823019463
Gc15_1159 0 n30 ns1159 0 -0.000236955599651
Gc15_1160 0 n30 ns1160 0 0.000391916918918
Gc15_1161 0 n30 ns1161 0 0.000480979431906
Gc15_1162 0 n30 ns1162 0 -0.0118973512446
Gc15_1163 0 n30 ns1163 0 -0.00716823152063
Gc15_1164 0 n30 ns1164 0 -0.00257508190252
Gc15_1165 0 n30 ns1165 0 -0.00120546540811
Gc15_1166 0 n30 ns1166 0 -0.000498077469114
Gc15_1167 0 n30 ns1167 0 0.0021963484502
Gc15_1168 0 n30 ns1168 0 0.00996950407691
Gc15_1169 0 n30 ns1169 0 -0.00595845762441
Gc15_1170 0 n30 ns1170 0 0.00109713973188
Gc15_1171 0 n30 ns1171 0 0.00155836388596
Gc15_1172 0 n30 ns1172 0 0.00334516748285
Gc15_1173 0 n30 ns1173 0 0.00027916073579
Gc15_1174 0 n30 ns1174 0 -0.107518336628
Gc15_1175 0 n30 ns1175 0 0.0699490312047
Gc15_1176 0 n30 ns1176 0 -0.00883634378615
Gc15_1177 0 n30 ns1177 0 -1.46481870703e-05
Gc15_1178 0 n30 ns1178 0 2.91749666083e-05
Gc15_1179 0 n30 ns1179 0 -0.000356311960108
Gc15_1180 0 n30 ns1180 0 -0.000458256769936
Gc15_1181 0 n30 ns1181 0 0.00564154730896
Gc15_1182 0 n30 ns1182 0 -0.000858356617915
Gc15_1183 0 n30 ns1183 0 -0.000916615235683
Gc15_1184 0 n30 ns1184 0 0.00141414039355
Gc15_1185 0 n30 ns1185 0 0.000414680697059
Gc15_1186 0 n30 ns1186 0 -0.000191670662589
Gc15_1187 0 n30 ns1187 0 -0.000148905173113
Gc15_1188 0 n30 ns1188 0 0.00156622549784
Gc15_1189 0 n30 ns1189 0 -0.00189894879688
Gc15_1190 0 n30 ns1190 0 -0.000389746942965
Gc15_1191 0 n30 ns1191 0 0.00101693492595
Gc15_1192 0 n30 ns1192 0 -0.000252394704294
Gc15_1193 0 n30 ns1193 0 0.000271492565792
Gc15_1194 0 n30 ns1194 0 -0.000997071248848
Gc15_1195 0 n30 ns1195 0 -0.00234546603968
Gc15_1196 0 n30 ns1196 0 -0.000273555638078
Gc15_1197 0 n30 ns1197 0 -0.000232398070221
Gc15_1198 0 n30 ns1198 0 0.000192144910363
Gc15_1199 0 n30 ns1199 0 0.000390499815431
Gc15_1200 0 n30 ns1200 0 0.000663950723004
Gc15_1201 0 n30 ns1201 0 -0.00466692033162
Gc15_1202 0 n30 ns1202 0 -0.00188821071684
Gc15_1203 0 n30 ns1203 0 8.28493536864e-05
Gc15_1204 0 n30 ns1204 0 -0.000225292676694
Gc15_1205 0 n30 ns1205 0 0.00126983520805
Gc15_1206 0 n30 ns1206 0 -0.0097050143803
Gc15_1207 0 n30 ns1207 0 -0.00419187608425
Gc15_1208 0 n30 ns1208 0 -0.00169740194978
Gc15_1209 0 n30 ns1209 0 0.00150514080378
Gc15_1210 0 n30 ns1210 0 0.00281817242821
Gc15_1211 0 n30 ns1211 0 0.00078777291831
Gc15_1212 0 n30 ns1212 0 -0.0651863386604
Gc15_1213 0 n30 ns1213 0 0.0630414231945
Gc15_1214 0 n30 ns1214 0 -0.00647697030375
Gc15_1215 0 n30 ns1215 0 -9.242165929e-06
Gc15_1216 0 n30 ns1216 0 2.98256711471e-05
Gd15_1 0 n30 ni1 0 -9.81487022009e-05
Gd15_2 0 n30 ni2 0 -5.03632972934e-05
Gd15_3 0 n30 ni3 0 4.77711262911e-05
Gd15_4 0 n30 ni4 0 6.22124989145e-05
Gd15_5 0 n30 ni5 0 0.000170111381083
Gd15_6 0 n30 ni6 0 -0.000696975530486
Gd15_7 0 n30 ni7 0 -0.00252682055188
Gd15_8 0 n30 ni8 0 -0.000586797971685
Gd15_9 0 n30 ni9 0 -0.00122715891432
Gd15_10 0 n30 ni10 0 -0.000102175277474
Gd15_11 0 n30 ni11 0 -5.6028411147e-05
Gd15_12 0 n30 ni12 0 0.000202318799064
Gd15_13 0 n30 ni13 0 -0.000314480323484
Gd15_14 0 n30 ni14 0 -0.0016175936391
Gd15_15 0 n30 ni15 0 0.000371987542332
Gd15_16 0 n30 ni16 0 -0.0016791282557
Gd15_17 0 n30 ni17 0 -5.64792718672e-05
Gd15_18 0 n30 ni18 0 -7.71046616703e-06
Gd15_19 0 n30 ni19 0 3.2318429738e-05
Gd15_20 0 n30 ni20 0 0.000194843354802
Gd15_21 0 n30 ni21 0 0.000186391566523
Gd15_22 0 n30 ni22 0 -7.36330490368e-05
Gd15_23 0 n30 ni23 0 -0.00156556442071
Gd15_24 0 n30 ni24 0 -0.00306576734013
Gd15_25 0 n30 ni25 0 6.53798904111e-06
Gd15_26 0 n30 ni26 0 4.35607305609e-05
Gd15_27 0 n30 ni27 0 0.000249925956538
Gd15_28 0 n30 ni28 0 0.000189248686102
Gd15_29 0 n30 ni29 0 0.000494031429519
Gd15_30 0 n30 ni30 0 -0.000377070815475
Gd15_31 0 n30 ni31 0 -0.00692729071577
Gd15_32 0 n30 ni32 0 -0.000504684269009
Gc16_1 0 n32 ns1 0 -0.000184793122056
Gc16_2 0 n32 ns2 0 0.000784297332576
Gc16_3 0 n32 ns3 0 -0.00342627737058
Gc16_4 0 n32 ns4 0 -0.000320074700758
Gc16_5 0 n32 ns5 0 -0.000100277630791
Gc16_6 0 n32 ns6 0 -0.00021345586365
Gc16_7 0 n32 ns7 0 0.000115621342309
Gc16_8 0 n32 ns8 0 1.66216288103e-05
Gc16_9 0 n32 ns9 0 3.81250367752e-05
Gc16_10 0 n32 ns10 0 0.00119638672853
Gc16_11 0 n32 ns11 0 0.000731393581564
Gc16_12 0 n32 ns12 0 -0.000527558788782
Gc16_13 0 n32 ns13 0 -0.000106553718626
Gc16_14 0 n32 ns14 0 -3.24656252427e-05
Gc16_15 0 n32 ns15 0 0.000122954698972
Gc16_16 0 n32 ns16 0 0.000450811892405
Gc16_17 0 n32 ns17 0 0.000563557211045
Gc16_18 0 n32 ns18 0 0.000166874487887
Gc16_19 0 n32 ns19 0 -0.000324464357915
Gc16_20 0 n32 ns20 0 -6.50879501899e-05
Gc16_21 0 n32 ns21 0 -5.12877690515e-05
Gc16_22 0 n32 ns22 0 0.00110386632172
Gc16_23 0 n32 ns23 0 0.000315234489144
Gc16_24 0 n32 ns24 0 0.00017063980092
Gc16_25 0 n32 ns25 0 -0.000496835961908
Gc16_26 0 n32 ns26 0 -0.000253132213963
Gc16_27 0 n32 ns27 0 0.000177270743054
Gc16_28 0 n32 ns28 0 0.00150428302967
Gc16_29 0 n32 ns29 0 0.00077926202372
Gc16_30 0 n32 ns30 0 0.000157132315475
Gc16_31 0 n32 ns31 0 -0.000380094893158
Gc16_32 0 n32 ns32 0 -0.000147060228432
Gc16_33 0 n32 ns33 0 -0.000116286449845
Gc16_34 0 n32 ns34 0 0.0152423435896
Gc16_35 0 n32 ns35 0 -0.0128703975738
Gc16_36 0 n32 ns36 0 0.000447789117232
Gc16_37 0 n32 ns37 0 -8.14280501521e-06
Gc16_38 0 n32 ns38 0 -2.24330752154e-05
Gc16_39 0 n32 ns39 0 -0.000122799366888
Gc16_40 0 n32 ns40 0 0.000693702470496
Gc16_41 0 n32 ns41 0 -0.00355064768515
Gc16_42 0 n32 ns42 0 -0.000324976979207
Gc16_43 0 n32 ns43 0 -0.000142705049957
Gc16_44 0 n32 ns44 0 -0.000236172653775
Gc16_45 0 n32 ns45 0 4.667497763e-05
Gc16_46 0 n32 ns46 0 4.48097904683e-06
Gc16_47 0 n32 ns47 0 4.75508217683e-05
Gc16_48 0 n32 ns48 0 0.00117193746477
Gc16_49 0 n32 ns49 0 0.00109142071374
Gc16_50 0 n32 ns50 0 -0.000571117264485
Gc16_51 0 n32 ns51 0 -0.000267118496501
Gc16_52 0 n32 ns52 0 -6.95579662454e-05
Gc16_53 0 n32 ns53 0 0.000138740409165
Gc16_54 0 n32 ns54 0 0.000424847265443
Gc16_55 0 n32 ns55 0 0.000798405611838
Gc16_56 0 n32 ns56 0 0.000297794155866
Gc16_57 0 n32 ns57 0 -0.000376995270894
Gc16_58 0 n32 ns58 0 -7.61063111839e-05
Gc16_59 0 n32 ns59 0 -8.73498928871e-05
Gc16_60 0 n32 ns60 0 0.00135010770326
Gc16_61 0 n32 ns61 0 0.000420903268098
Gc16_62 0 n32 ns62 0 0.000239167529047
Gc16_63 0 n32 ns63 0 -0.000620439712894
Gc16_64 0 n32 ns64 0 -0.000336482442437
Gc16_65 0 n32 ns65 0 0.000215683475155
Gc16_66 0 n32 ns66 0 0.00166825248984
Gc16_67 0 n32 ns67 0 0.00079259266667
Gc16_68 0 n32 ns68 0 0.000178746067905
Gc16_69 0 n32 ns69 0 -0.000385440766292
Gc16_70 0 n32 ns70 0 -0.0001607641413
Gc16_71 0 n32 ns71 0 -0.000142131458602
Gc16_72 0 n32 ns72 0 0.016557199632
Gc16_73 0 n32 ns73 0 -0.0139541612466
Gc16_74 0 n32 ns74 0 0.000477167131257
Gc16_75 0 n32 ns75 0 -6.08384784859e-06
Gc16_76 0 n32 ns76 0 -2.4951132197e-05
Gc16_77 0 n32 ns77 0 0.000117133658709
Gc16_78 0 n32 ns78 0 -0.000233475265576
Gc16_79 0 n32 ns79 0 -0.00148974678681
Gc16_80 0 n32 ns80 0 -0.000127384443117
Gc16_81 0 n32 ns81 0 -0.000100071697307
Gc16_82 0 n32 ns82 0 -1.34737163264e-05
Gc16_83 0 n32 ns83 0 -4.53595753877e-05
Gc16_84 0 n32 ns84 0 -9.27596319934e-06
Gc16_85 0 n32 ns85 0 -1.33045553712e-05
Gc16_86 0 n32 ns86 0 -6.38513355457e-05
Gc16_87 0 n32 ns87 0 0.00111191072738
Gc16_88 0 n32 ns88 0 -3.86543205923e-05
Gc16_89 0 n32 ns89 0 -0.000560587854504
Gc16_90 0 n32 ns90 0 -0.000162452798295
Gc16_91 0 n32 ns91 0 5.40552034937e-05
Gc16_92 0 n32 ns92 0 -0.000382825322497
Gc16_93 0 n32 ns93 0 0.000889356840608
Gc16_94 0 n32 ns94 0 0.000638270395059
Gc16_95 0 n32 ns95 0 -4.02724078264e-05
Gc16_96 0 n32 ns96 0 -1.18057646693e-05
Gc16_97 0 n32 ns97 0 -0.000176146362237
Gc16_98 0 n32 ns98 0 0.00111461433598
Gc16_99 0 n32 ns99 0 0.000963045422708
Gc16_100 0 n32 ns100 0 0.000649035289017
Gc16_101 0 n32 ns101 0 -0.000572147666345
Gc16_102 0 n32 ns102 0 -0.000561823697881
Gc16_103 0 n32 ns103 0 6.51413037075e-05
Gc16_104 0 n32 ns104 0 0.00118097412699
Gc16_105 0 n32 ns105 0 0.000666105102265
Gc16_106 0 n32 ns106 0 0.000242955909399
Gc16_107 0 n32 ns107 0 -8.57606258943e-05
Gc16_108 0 n32 ns108 0 -6.81295763363e-05
Gc16_109 0 n32 ns109 0 -0.000232927541486
Gc16_110 0 n32 ns110 0 0.0141294493434
Gc16_111 0 n32 ns111 0 -0.0120853500154
Gc16_112 0 n32 ns112 0 0.000435438874001
Gc16_113 0 n32 ns113 0 -4.92568294812e-06
Gc16_114 0 n32 ns114 0 -3.07216376636e-05
Gc16_115 0 n32 ns115 0 0.000364021609243
Gc16_116 0 n32 ns116 0 -0.000851871256358
Gc16_117 0 n32 ns117 0 0.00241802169074
Gc16_118 0 n32 ns118 0 6.18749057797e-05
Gc16_119 0 n32 ns119 0 0.000198571100178
Gc16_120 0 n32 ns120 0 0.00027775881511
Gc16_121 0 n32 ns121 0 6.97626340574e-06
Gc16_122 0 n32 ns122 0 4.67724945864e-06
Gc16_123 0 n32 ns123 0 -3.5483378101e-05
Gc16_124 0 n32 ns124 0 -0.00119473603568
Gc16_125 0 n32 ns125 0 -0.000506407790727
Gc16_126 0 n32 ns126 0 0.000808489964417
Gc16_127 0 n32 ns127 0 -7.91348624046e-05
Gc16_128 0 n32 ns128 0 -0.000144942305085
Gc16_129 0 n32 ns129 0 -0.000161550782472
Gc16_130 0 n32 ns130 0 -0.00125413067734
Gc16_131 0 n32 ns131 0 -0.000652787966
Gc16_132 0 n32 ns132 0 0.00024574130485
Gc16_133 0 n32 ns133 0 0.0009182913516
Gc16_134 0 n32 ns134 0 0.000183949378217
Gc16_135 0 n32 ns135 0 -0.000118459708847
Gc16_136 0 n32 ns136 0 -0.00078738759616
Gc16_137 0 n32 ns137 0 0.00101634749716
Gc16_138 0 n32 ns138 0 0.0010439221524
Gc16_139 0 n32 ns139 0 0.000379046065118
Gc16_140 0 n32 ns140 0 -0.000536555734817
Gc16_141 0 n32 ns141 0 -0.000532274214219
Gc16_142 0 n32 ns142 0 -0.00102766416583
Gc16_143 0 n32 ns143 0 0.00018061474194
Gc16_144 0 n32 ns144 0 0.000366962428674
Gc16_145 0 n32 ns145 0 0.00075240210699
Gc16_146 0 n32 ns146 0 0.000243016460357
Gc16_147 0 n32 ns147 0 -0.000393589950128
Gc16_148 0 n32 ns148 0 0.00289425917496
Gc16_149 0 n32 ns149 0 -0.00322959121766
Gc16_150 0 n32 ns150 0 0.000253737385743
Gc16_151 0 n32 ns151 0 -3.87759084703e-06
Gc16_152 0 n32 ns152 0 -2.50942706924e-05
Gc16_153 0 n32 ns153 0 -0.000372468502578
Gc16_154 0 n32 ns154 0 0.000608244159793
Gc16_155 0 n32 ns155 0 0.00104724032378
Gc16_156 0 n32 ns156 0 -4.1024904091e-05
Gc16_157 0 n32 ns157 0 0.000136400188318
Gc16_158 0 n32 ns158 0 -3.58793774014e-05
Gc16_159 0 n32 ns159 0 0.000137201156367
Gc16_160 0 n32 ns160 0 -3.6209388973e-06
Gc16_161 0 n32 ns161 0 2.98185753631e-06
Gc16_162 0 n32 ns162 0 3.57255439533e-07
Gc16_163 0 n32 ns163 0 -0.000601018229638
Gc16_164 0 n32 ns164 0 0.000489179937331
Gc16_165 0 n32 ns165 0 0.000627731591964
Gc16_166 0 n32 ns166 0 -2.55741705595e-05
Gc16_167 0 n32 ns167 0 -0.000319913538003
Gc16_168 0 n32 ns168 0 0.000418345358328
Gc16_169 0 n32 ns169 0 -0.0015528226193
Gc16_170 0 n32 ns170 0 -0.000905898823393
Gc16_171 0 n32 ns171 0 0.00080470615349
Gc16_172 0 n32 ns172 0 0.000254635917745
Gc16_173 0 n32 ns173 0 3.35426822769e-05
Gc16_174 0 n32 ns174 0 -0.00128327441424
Gc16_175 0 n32 ns175 0 -0.00044295148644
Gc16_176 0 n32 ns176 0 0.000428640175135
Gc16_177 0 n32 ns177 0 0.00148746062734
Gc16_178 0 n32 ns178 0 6.48569834941e-06
Gc16_179 0 n32 ns179 0 -0.00107925278648
Gc16_180 0 n32 ns180 0 -0.00216635384113
Gc16_181 0 n32 ns181 0 -0.00057623027263
Gc16_182 0 n32 ns182 0 0.000311722171081
Gc16_183 0 n32 ns183 0 0.00167139347834
Gc16_184 0 n32 ns184 0 0.000653293191551
Gc16_185 0 n32 ns185 0 -0.000647904188884
Gc16_186 0 n32 ns186 0 0.00550913644109
Gc16_187 0 n32 ns187 0 -0.00627506238243
Gc16_188 0 n32 ns188 0 0.000543903687784
Gc16_189 0 n32 ns189 0 -6.39850333314e-06
Gc16_190 0 n32 ns190 0 -6.35812841813e-06
Gc16_191 0 n32 ns191 0 -0.00128665879684
Gc16_192 0 n32 ns192 0 0.00261747561709
Gc16_193 0 n32 ns193 0 -0.00364527757092
Gc16_194 0 n32 ns194 0 -6.67190492941e-05
Gc16_195 0 n32 ns195 0 -0.000315673221061
Gc16_196 0 n32 ns196 0 -0.000159887884079
Gc16_197 0 n32 ns197 0 -0.000232269161794
Gc16_198 0 n32 ns198 0 -3.63150179135e-05
Gc16_199 0 n32 ns199 0 6.14665873418e-06
Gc16_200 0 n32 ns200 0 -0.000161620154009
Gc16_201 0 n32 ns201 0 0.00142884408126
Gc16_202 0 n32 ns202 0 -0.000349321547223
Gc16_203 0 n32 ns203 0 0.000161823095601
Gc16_204 0 n32 ns204 0 0.000124238815259
Gc16_205 0 n32 ns205 0 -0.000353750146289
Gc16_206 0 n32 ns206 0 0.00138170166746
Gc16_207 0 n32 ns207 0 0.00107453908927
Gc16_208 0 n32 ns208 0 -0.000805689964357
Gc16_209 0 n32 ns209 0 -0.000566120373657
Gc16_210 0 n32 ns210 0 0.000233506035904
Gc16_211 0 n32 ns211 0 5.10048821307e-05
Gc16_212 0 n32 ns212 0 0.0013106425562
Gc16_213 0 n32 ns213 0 0.00024101910547
Gc16_214 0 n32 ns214 0 -0.000545801173703
Gc16_215 0 n32 ns215 0 0.00106159314543
Gc16_216 0 n32 ns216 0 0.000530512406227
Gc16_217 0 n32 ns217 0 -0.00105749941982
Gc16_218 0 n32 ns218 0 0.00105277785407
Gc16_219 0 n32 ns219 0 -0.000694106939981
Gc16_220 0 n32 ns220 0 -0.00101749089829
Gc16_221 0 n32 ns221 0 0.00158877483344
Gc16_222 0 n32 ns222 0 0.00112256701821
Gc16_223 0 n32 ns223 0 -0.000556318871579
Gc16_224 0 n32 ns224 0 0.0277768350935
Gc16_225 0 n32 ns225 0 -0.0259330117674
Gc16_226 0 n32 ns226 0 0.00152198270104
Gc16_227 0 n32 ns227 0 -7.29658680584e-06
Gc16_228 0 n32 ns228 0 1.59040445353e-05
Gc16_229 0 n32 ns229 0 -0.00153960590234
Gc16_230 0 n32 ns230 0 0.000912687390533
Gc16_231 0 n32 ns231 0 -0.00142484220086
Gc16_232 0 n32 ns232 0 0.000682166796213
Gc16_233 0 n32 ns233 0 -0.000756755237854
Gc16_234 0 n32 ns234 0 0.000550378181022
Gc16_235 0 n32 ns235 0 -0.000132979253142
Gc16_236 0 n32 ns236 0 -0.000123179400408
Gc16_237 0 n32 ns237 0 -1.79591980176e-05
Gc16_238 0 n32 ns238 0 -0.0024179061011
Gc16_239 0 n32 ns239 0 0.000424776868182
Gc16_240 0 n32 ns240 0 0.000333138325478
Gc16_241 0 n32 ns241 0 -0.000590602992939
Gc16_242 0 n32 ns242 0 0.000337560886527
Gc16_243 0 n32 ns243 0 -0.000369391866351
Gc16_244 0 n32 ns244 0 -0.00164788280808
Gc16_245 0 n32 ns245 0 0.00103579788273
Gc16_246 0 n32 ns246 0 0.000248679995529
Gc16_247 0 n32 ns247 0 -0.000535356871697
Gc16_248 0 n32 ns248 0 0.000339361467442
Gc16_249 0 n32 ns249 0 0.000163185937047
Gc16_250 0 n32 ns250 0 -0.00055933286886
Gc16_251 0 n32 ns251 0 0.00323598304359
Gc16_252 0 n32 ns252 0 3.44454660357e-05
Gc16_253 0 n32 ns253 0 0.000114933293888
Gc16_254 0 n32 ns254 0 0.000691967218655
Gc16_255 0 n32 ns255 0 -0.000964439681292
Gc16_256 0 n32 ns256 0 0.00207430661538
Gc16_257 0 n32 ns257 0 0.00198532513556
Gc16_258 0 n32 ns258 0 -0.00230081680416
Gc16_259 0 n32 ns259 0 -5.32965951134e-05
Gc16_260 0 n32 ns260 0 0.00166630969114
Gc16_261 0 n32 ns261 0 6.14376297921e-05
Gc16_262 0 n32 ns262 0 0.0471448430558
Gc16_263 0 n32 ns263 0 -0.0462949964719
Gc16_264 0 n32 ns264 0 0.00365338463502
Gc16_265 0 n32 ns265 0 -4.59004968586e-07
Gc16_266 0 n32 ns266 0 2.8089737998e-05
Gc16_267 0 n32 ns267 0 -0.00441997994052
Gc16_268 0 n32 ns268 0 -0.00232081713171
Gc16_269 0 n32 ns269 0 -0.00122115341222
Gc16_270 0 n32 ns270 0 0.000758170484371
Gc16_271 0 n32 ns271 0 -0.00134279401675
Gc16_272 0 n32 ns272 0 1.80558800118e-06
Gc16_273 0 n32 ns273 0 0.000942111845287
Gc16_274 0 n32 ns274 0 -9.42222310338e-05
Gc16_275 0 n32 ns275 0 -5.81704584715e-05
Gc16_276 0 n32 ns276 0 -0.000898323972535
Gc16_277 0 n32 ns277 0 0.000610984585968
Gc16_278 0 n32 ns278 0 0.000859160305622
Gc16_279 0 n32 ns279 0 -0.000555935470219
Gc16_280 0 n32 ns280 0 0.000338349969219
Gc16_281 0 n32 ns281 0 -0.000233737991986
Gc16_282 0 n32 ns282 0 -0.000825021490018
Gc16_283 0 n32 ns283 0 -0.00115784587471
Gc16_284 0 n32 ns284 0 0.000498123130806
Gc16_285 0 n32 ns285 0 -2.33048050332e-05
Gc16_286 0 n32 ns286 0 0.00027406161941
Gc16_287 0 n32 ns287 0 0.000289238421008
Gc16_288 0 n32 ns288 0 -0.00273422567984
Gc16_289 0 n32 ns289 0 0.00137005321824
Gc16_290 0 n32 ns290 0 0.00123271688605
Gc16_291 0 n32 ns291 0 0.0011542449097
Gc16_292 0 n32 ns292 0 0.00108087381796
Gc16_293 0 n32 ns293 0 -0.0012517429841
Gc16_294 0 n32 ns294 0 0.000419003471784
Gc16_295 0 n32 ns295 0 0.00208734108651
Gc16_296 0 n32 ns296 0 -2.24188330394e-05
Gc16_297 0 n32 ns297 0 -0.00128852422547
Gc16_298 0 n32 ns298 0 0.00223226614812
Gc16_299 0 n32 ns299 0 0.000644432546018
Gc16_300 0 n32 ns300 0 0.0168342225153
Gc16_301 0 n32 ns301 0 -0.01751192365
Gc16_302 0 n32 ns302 0 0.00648940481775
Gc16_303 0 n32 ns303 0 -2.61195927149e-06
Gc16_304 0 n32 ns304 0 2.68853664204e-05
Gc16_305 0 n32 ns305 0 -0.00555307875493
Gc16_306 0 n32 ns306 0 -0.00291845023897
Gc16_307 0 n32 ns307 0 -0.00444646554937
Gc16_308 0 n32 ns308 0 0.000152046185985
Gc16_309 0 n32 ns309 0 -0.00134499746943
Gc16_310 0 n32 ns310 0 -0.00066753881229
Gc16_311 0 n32 ns311 0 0.000817624897465
Gc16_312 0 n32 ns312 0 -2.74756358686e-05
Gc16_313 0 n32 ns313 0 -8.35827314513e-05
Gc16_314 0 n32 ns314 0 -0.000195511002045
Gc16_315 0 n32 ns315 0 0.00248675903188
Gc16_316 0 n32 ns316 0 0.000555203144136
Gc16_317 0 n32 ns317 0 -0.000201907961896
Gc16_318 0 n32 ns318 0 0.000202708803647
Gc16_319 0 n32 ns319 0 -9.05124485259e-05
Gc16_320 0 n32 ns320 0 0.00161725679803
Gc16_321 0 n32 ns321 0 0.000747825455078
Gc16_322 0 n32 ns322 0 0.000732433952992
Gc16_323 0 n32 ns323 0 -0.000117457770793
Gc16_324 0 n32 ns324 0 0.000170705770705
Gc16_325 0 n32 ns325 0 0.000132274342221
Gc16_326 0 n32 ns326 0 0.00135330576546
Gc16_327 0 n32 ns327 0 -0.00124466933555
Gc16_328 0 n32 ns328 0 0.00109321769045
Gc16_329 0 n32 ns329 0 0.00198151475185
Gc16_330 0 n32 ns330 0 0.00119443205857
Gc16_331 0 n32 ns331 0 -0.00110045800989
Gc16_332 0 n32 ns332 0 0.000958551225511
Gc16_333 0 n32 ns333 0 -0.00210379817754
Gc16_334 0 n32 ns334 0 0.0030981540334
Gc16_335 0 n32 ns335 0 -0.000112271619561
Gc16_336 0 n32 ns336 0 0.00218395304049
Gc16_337 0 n32 ns337 0 0.000433359706504
Gc16_338 0 n32 ns338 0 -0.0411271533833
Gc16_339 0 n32 ns339 0 0.0424474332037
Gc16_340 0 n32 ns340 0 0.00598353574661
Gc16_341 0 n32 ns341 0 -5.03529615203e-06
Gc16_342 0 n32 ns342 0 2.44196781742e-05
Gc16_343 0 n32 ns343 0 -5.11795685092e-05
Gc16_344 0 n32 ns344 0 0.000209928688061
Gc16_345 0 n32 ns345 0 -0.00300050439378
Gc16_346 0 n32 ns346 0 -0.000235213929377
Gc16_347 0 n32 ns347 0 -0.000196031994228
Gc16_348 0 n32 ns348 0 -0.000174731436274
Gc16_349 0 n32 ns349 0 1.8018182532e-05
Gc16_350 0 n32 ns350 0 1.35593070513e-06
Gc16_351 0 n32 ns351 0 1.42291309816e-05
Gc16_352 0 n32 ns352 0 0.00064047422456
Gc16_353 0 n32 ns353 0 0.00132370834816
Gc16_354 0 n32 ns354 0 -0.000372344195447
Gc16_355 0 n32 ns355 0 -0.000481443987909
Gc16_356 0 n32 ns356 0 -0.000126858486954
Gc16_357 0 n32 ns357 0 0.000111661815824
Gc16_358 0 n32 ns358 0 6.57679363691e-05
Gc16_359 0 n32 ns359 0 0.00102502806406
Gc16_360 0 n32 ns360 0 0.000537399874125
Gc16_361 0 n32 ns361 0 -0.00027628606788
Gc16_362 0 n32 ns362 0 -5.46487967651e-05
Gc16_363 0 n32 ns363 0 -0.000148834590298
Gc16_364 0 n32 ns364 0 0.00146024060185
Gc16_365 0 n32 ns365 0 0.000803361035998
Gc16_366 0 n32 ns366 0 0.000490729405905
Gc16_367 0 n32 ns367 0 -0.000683840701129
Gc16_368 0 n32 ns368 0 -0.000498489701177
Gc16_369 0 n32 ns369 0 0.000161575997296
Gc16_370 0 n32 ns370 0 0.00180801918049
Gc16_371 0 n32 ns371 0 0.00086017915412
Gc16_372 0 n32 ns372 0 0.000197485657291
Gc16_373 0 n32 ns373 0 -0.000340311316321
Gc16_374 0 n32 ns374 0 -0.000150534970991
Gc16_375 0 n32 ns375 0 -0.000187387176501
Gc16_376 0 n32 ns376 0 0.0176501174776
Gc16_377 0 n32 ns377 0 -0.0148933577381
Gc16_378 0 n32 ns378 0 0.000502992663584
Gc16_379 0 n32 ns379 0 -5.24641357708e-06
Gc16_380 0 n32 ns380 0 -2.80818454354e-05
Gc16_381 0 n32 ns381 0 0.000346355691227
Gc16_382 0 n32 ns382 0 -0.000997507695128
Gc16_383 0 n32 ns383 0 0.000873695484598
Gc16_384 0 n32 ns384 0 9.23909727141e-05
Gc16_385 0 n32 ns385 0 -9.36370584727e-05
Gc16_386 0 n32 ns386 0 7.79461936873e-05
Gc16_387 0 n32 ns387 0 -4.53582815347e-05
Gc16_388 0 n32 ns388 0 1.27625096692e-05
Gc16_389 0 n32 ns389 0 -2.14331144821e-05
Gc16_390 0 n32 ns390 0 -0.000959947011465
Gc16_391 0 n32 ns391 0 0.000409388695537
Gc16_392 0 n32 ns392 0 0.000480255082679
Gc16_393 0 n32 ns393 0 -0.000416685668235
Gc16_394 0 n32 ns394 0 -0.00017318150926
Gc16_395 0 n32 ns395 0 -6.34699408901e-05
Gc16_396 0 n32 ns396 0 -0.00110818904189
Gc16_397 0 n32 ns397 0 0.000212636313317
Gc16_398 0 n32 ns398 0 0.000573282380977
Gc16_399 0 n32 ns399 0 0.00053303023328
Gc16_400 0 n32 ns400 0 0.000109221776231
Gc16_401 0 n32 ns401 0 -0.000169568596524
Gc16_402 0 n32 ns402 0 0.000152697339468
Gc16_403 0 n32 ns403 0 0.00129044815684
Gc16_404 0 n32 ns404 0 0.000976311300846
Gc16_405 0 n32 ns405 0 -0.000131690270975
Gc16_406 0 n32 ns406 0 -0.000618826293685
Gc16_407 0 n32 ns407 0 -0.000253475909327
Gc16_408 0 n32 ns408 0 0.000150772439845
Gc16_409 0 n32 ns409 0 0.000753507466501
Gc16_410 0 n32 ns410 0 0.000410201883248
Gc16_411 0 n32 ns411 0 0.000265594786911
Gc16_412 0 n32 ns412 0 5.07247530097e-05
Gc16_413 0 n32 ns413 0 -0.000353037537826
Gc16_414 0 n32 ns414 0 0.0103234643804
Gc16_415 0 n32 ns415 0 -0.00923947116364
Gc16_416 0 n32 ns416 0 0.000394801558299
Gc16_417 0 n32 ns417 0 -3.92042311294e-06
Gc16_418 0 n32 ns418 0 -3.04784395251e-05
Gc16_419 0 n32 ns419 0 0.000109849683461
Gc16_420 0 n32 ns420 0 -0.000745411727562
Gc16_421 0 n32 ns421 0 0.00268549388261
Gc16_422 0 n32 ns422 0 0.00011741832277
Gc16_423 0 n32 ns423 0 9.74104815414e-06
Gc16_424 0 n32 ns424 0 -7.4333186995e-07
Gc16_425 0 n32 ns425 0 9.52950829609e-05
Gc16_426 0 n32 ns426 0 1.73346018594e-05
Gc16_427 0 n32 ns427 0 1.24883546236e-05
Gc16_428 0 n32 ns428 0 -0.00068287437262
Gc16_429 0 n32 ns429 0 -0.000634481637944
Gc16_430 0 n32 ns430 0 0.000739988250273
Gc16_431 0 n32 ns431 0 0.000335416537913
Gc16_432 0 n32 ns432 0 -9.14584192848e-05
Gc16_433 0 n32 ns433 0 -0.000267866825703
Gc16_434 0 n32 ns434 0 -0.000564194256648
Gc16_435 0 n32 ns435 0 -0.00141726250194
Gc16_436 0 n32 ns436 0 -0.000406588913973
Gc16_437 0 n32 ns437 0 0.00105847320186
Gc16_438 0 n32 ns438 0 0.000256335613297
Gc16_439 0 n32 ns439 0 -2.64041158288e-05
Gc16_440 0 n32 ns440 0 -0.0014386953702
Gc16_441 0 n32 ns441 0 0.000361898121497
Gc16_442 0 n32 ns442 0 0.000828517772341
Gc16_443 0 n32 ns443 0 0.00112013019182
Gc16_444 0 n32 ns444 0 -0.000258140282345
Gc16_445 0 n32 ns445 0 -0.000912723676101
Gc16_446 0 n32 ns446 0 -0.00195896644493
Gc16_447 0 n32 ns447 0 0.000109437494532
Gc16_448 0 n32 ns448 0 0.000498398644207
Gc16_449 0 n32 ns449 0 0.00125380856607
Gc16_450 0 n32 ns450 0 0.00044945968449
Gc16_451 0 n32 ns451 0 -0.000583012400794
Gc16_452 0 n32 ns452 0 0.00441094370438
Gc16_453 0 n32 ns453 0 -0.00510071394838
Gc16_454 0 n32 ns454 0 0.000425707902442
Gc16_455 0 n32 ns455 0 -4.97571293032e-06
Gc16_456 0 n32 ns456 0 -1.83441108504e-05
Gc16_457 0 n32 ns457 0 -0.000872652256596
Gc16_458 0 n32 ns458 0 0.00216298182978
Gc16_459 0 n32 ns459 0 -0.00241301611038
Gc16_460 0 n32 ns460 0 -0.000182373861391
Gc16_461 0 n32 ns461 0 -0.000144408003803
Gc16_462 0 n32 ns462 0 -0.00026589223077
Gc16_463 0 n32 ns463 0 -8.73445592637e-05
Gc16_464 0 n32 ns464 0 -1.98173730689e-05
Gc16_465 0 n32 ns465 0 1.66086292452e-05
Gc16_466 0 n32 ns466 0 0.000237443336913
Gc16_467 0 n32 ns467 0 0.000963643538854
Gc16_468 0 n32 ns468 0 -9.35712003814e-05
Gc16_469 0 n32 ns469 0 0.000409347155277
Gc16_470 0 n32 ns470 0 3.79391263048e-05
Gc16_471 0 n32 ns471 0 -0.000347125359458
Gc16_472 0 n32 ns472 0 0.00147015890869
Gc16_473 0 n32 ns473 0 5.12533826237e-05
Gc16_474 0 n32 ns474 0 -0.000964807981487
Gc16_475 0 n32 ns475 0 -7.68062317777e-05
Gc16_476 0 n32 ns476 0 0.000228320185879
Gc16_477 0 n32 ns477 0 3.66943433931e-05
Gc16_478 0 n32 ns478 0 0.000511250762764
Gc16_479 0 n32 ns479 0 -0.000404627298813
Gc16_480 0 n32 ns480 0 -0.000250889106272
Gc16_481 0 n32 ns481 0 0.00134617522696
Gc16_482 0 n32 ns482 0 0.000353746895376
Gc16_483 0 n32 ns483 0 -0.00109222832142
Gc16_484 0 n32 ns484 0 -0.000198929689994
Gc16_485 0 n32 ns485 0 -0.000855429694311
Gc16_486 0 n32 ns486 0 -0.000436272675195
Gc16_487 0 n32 ns487 0 0.00172801807742
Gc16_488 0 n32 ns488 0 0.000922805282317
Gc16_489 0 n32 ns489 0 -0.000630981071648
Gc16_490 0 n32 ns490 0 0.0192916737165
Gc16_491 0 n32 ns491 0 -0.0182809358704
Gc16_492 0 n32 ns492 0 0.00108538399147
Gc16_493 0 n32 ns493 0 -8.14277267744e-06
Gc16_494 0 n32 ns494 0 4.70574338483e-06
Gc16_495 0 n32 ns495 0 -0.00146614441158
Gc16_496 0 n32 ns496 0 0.00170792514963
Gc16_497 0 n32 ns497 0 -0.00274622294383
Gc16_498 0 n32 ns498 0 0.000455790700924
Gc16_499 0 n32 ns499 0 -0.000691511254187
Gc16_500 0 n32 ns500 0 0.000267012639485
Gc16_501 0 n32 ns501 0 -0.000243784726097
Gc16_502 0 n32 ns502 0 -6.4457512438e-05
Gc16_503 0 n32 ns503 0 -1.0583962526e-05
Gc16_504 0 n32 ns504 0 -0.00176767535365
Gc16_505 0 n32 ns505 0 0.00083927599451
Gc16_506 0 n32 ns506 0 -7.30226180112e-05
Gc16_507 0 n32 ns507 0 -0.000320509750342
Gc16_508 0 n32 ns508 0 0.00024762822463
Gc16_509 0 n32 ns509 0 -0.000359848841078
Gc16_510 0 n32 ns510 0 -0.000795070958671
Gc16_511 0 n32 ns511 0 0.00157828730336
Gc16_512 0 n32 ns512 0 -9.45524896686e-05
Gc16_513 0 n32 ns513 0 -0.000572895594517
Gc16_514 0 n32 ns514 0 0.000317149351696
Gc16_515 0 n32 ns515 0 0.000110435316519
Gc16_516 0 n32 ns516 0 0.00070991001861
Gc16_517 0 n32 ns517 0 0.00287893929146
Gc16_518 0 n32 ns518 0 -0.000247896426474
Gc16_519 0 n32 ns519 0 0.000373116260652
Gc16_520 0 n32 ns520 0 0.000614498421614
Gc16_521 0 n32 ns521 0 -0.000994554416594
Gc16_522 0 n32 ns522 0 0.00288787370372
Gc16_523 0 n32 ns523 0 0.00139605425609
Gc16_524 0 n32 ns524 0 -0.00203538248822
Gc16_525 0 n32 ns525 0 0.000536496861273
Gc16_526 0 n32 ns526 0 0.00143634852354
Gc16_527 0 n32 ns527 0 -0.000210664873036
Gc16_528 0 n32 ns528 0 0.0450841087515
Gc16_529 0 n32 ns529 0 -0.0425836360918
Gc16_530 0 n32 ns530 0 0.00272375984547
Gc16_531 0 n32 ns531 0 -3.01152197375e-06
Gc16_532 0 n32 ns532 0 2.22933988085e-05
Gc16_533 0 n32 ns533 0 -0.00173217400024
Gc16_534 0 n32 ns534 0 -0.00230482852911
Gc16_535 0 n32 ns535 0 0.00553419870296
Gc16_536 0 n32 ns536 0 0.000652788865808
Gc16_537 0 n32 ns537 0 -0.000436038056821
Gc16_538 0 n32 ns538 0 0.000763982986039
Gc16_539 0 n32 ns539 0 0.000355977482743
Gc16_540 0 n32 ns540 0 -0.00015067118314
Gc16_541 0 n32 ns541 0 -8.92968556262e-05
Gc16_542 0 n32 ns542 0 -0.00187481740533
Gc16_543 0 n32 ns543 0 -0.00106614961651
Gc16_544 0 n32 ns544 0 0.00089152257126
Gc16_545 0 n32 ns545 0 -0.000156446937033
Gc16_546 0 n32 ns546 0 0.000493062994067
Gc16_547 0 n32 ns547 0 -0.000284385212869
Gc16_548 0 n32 ns548 0 -0.000840365238943
Gc16_549 0 n32 ns549 0 -0.0016074707476
Gc16_550 0 n32 ns550 0 -6.36788255467e-06
Gc16_551 0 n32 ns551 0 -0.000249429828148
Gc16_552 0 n32 ns552 0 0.000246187027203
Gc16_553 0 n32 ns553 0 0.000342952468142
Gc16_554 0 n32 ns554 0 -0.00419242456646
Gc16_555 0 n32 ns555 0 -0.000454754529791
Gc16_556 0 n32 ns556 0 0.000257633599031
Gc16_557 0 n32 ns557 0 0.000764031527272
Gc16_558 0 n32 ns558 0 0.00117774016912
Gc16_559 0 n32 ns559 0 -0.000960361949186
Gc16_560 0 n32 ns560 0 -0.0050317674616
Gc16_561 0 n32 ns561 0 -0.000678537924977
Gc16_562 0 n32 ns562 0 -0.00177629341456
Gc16_563 0 n32 ns563 0 -9.16547180399e-05
Gc16_564 0 n32 ns564 0 0.00234499602741
Gc16_565 0 n32 ns565 0 0.000738380663168
Gc16_566 0 n32 ns566 0 0.0139109053067
Gc16_567 0 n32 ns567 0 -0.0225712735662
Gc16_568 0 n32 ns568 0 0.00537189946423
Gc16_569 0 n32 ns569 0 2.25884564701e-06
Gc16_570 0 n32 ns570 0 3.37148520026e-05
Gc16_571 0 n32 ns571 0 -0.00404046743189
Gc16_572 0 n32 ns572 0 -0.00230443329983
Gc16_573 0 n32 ns573 0 0.00149589819841
Gc16_574 0 n32 ns574 0 0.00111250673397
Gc16_575 0 n32 ns575 0 -0.000455454471146
Gc16_576 0 n32 ns576 0 0.000135544654138
Gc16_577 0 n32 ns577 0 0.000283391479926
Gc16_578 0 n32 ns578 0 -0.000208689304104
Gc16_579 0 n32 ns579 0 -0.000147766730438
Gc16_580 0 n32 ns580 0 -0.00290598646378
Gc16_581 0 n32 ns581 0 0.00057754053721
Gc16_582 0 n32 ns582 0 0.00152566256793
Gc16_583 0 n32 ns583 0 -9.21693831e-05
Gc16_584 0 n32 ns584 0 0.000425489066698
Gc16_585 0 n32 ns585 0 -0.000288874990832
Gc16_586 0 n32 ns586 0 0.000407676771466
Gc16_587 0 n32 ns587 0 -0.000572731656372
Gc16_588 0 n32 ns588 0 0.000453117969817
Gc16_589 0 n32 ns589 0 0.00034647600801
Gc16_590 0 n32 ns590 0 0.000279969304308
Gc16_591 0 n32 ns591 0 0.000321775720215
Gc16_592 0 n32 ns592 0 -0.00167565591743
Gc16_593 0 n32 ns593 0 -0.00145892484617
Gc16_594 0 n32 ns594 0 0.001117156405
Gc16_595 0 n32 ns595 0 0.0025754995966
Gc16_596 0 n32 ns596 0 0.0015350972656
Gc16_597 0 n32 ns597 0 -0.00141689152723
Gc16_598 0 n32 ns598 0 -0.00343650384563
Gc16_599 0 n32 ns599 0 -0.00261265162492
Gc16_600 0 n32 ns600 0 0.00277170071058
Gc16_601 0 n32 ns601 0 0.000591433733949
Gc16_602 0 n32 ns602 0 0.00275517240693
Gc16_603 0 n32 ns603 0 0.000579854532987
Gc16_604 0 n32 ns604 0 -0.0486074356399
Gc16_605 0 n32 ns605 0 0.0446894717458
Gc16_606 0 n32 ns606 0 0.00646238724684
Gc16_607 0 n32 ns607 0 9.57836773226e-06
Gc16_608 0 n32 ns608 0 2.6466278849e-05
Gc16_609 0 n32 ns609 0 7.43200662175e-05
Gc16_610 0 n32 ns610 0 -0.000377449472627
Gc16_611 0 n32 ns611 0 -0.000643736340943
Gc16_612 0 n32 ns612 0 -6.26397319973e-05
Gc16_613 0 n32 ns613 0 -0.000107950012682
Gc16_614 0 n32 ns614 0 -6.05402488134e-05
Gc16_615 0 n32 ns615 0 4.70355498337e-05
Gc16_616 0 n32 ns616 0 2.74998622459e-05
Gc16_617 0 n32 ns617 0 -8.81134467743e-06
Gc16_618 0 n32 ns618 0 -0.000396288854409
Gc16_619 0 n32 ns619 0 0.000733681108509
Gc16_620 0 n32 ns620 0 0.000264894103038
Gc16_621 0 n32 ns621 0 -0.000209836064339
Gc16_622 0 n32 ns622 0 -7.56378143634e-05
Gc16_623 0 n32 ns623 0 -0.000118489835108
Gc16_624 0 n32 ns624 0 0.000291132824814
Gc16_625 0 n32 ns625 0 0.000639307024998
Gc16_626 0 n32 ns626 0 0.000196054954347
Gc16_627 0 n32 ns627 0 -0.000324945888575
Gc16_628 0 n32 ns628 0 -7.78515454999e-05
Gc16_629 0 n32 ns629 0 -5.47380590555e-05
Gc16_630 0 n32 ns630 0 0.000212140894953
Gc16_631 0 n32 ns631 0 7.40466784944e-05
Gc16_632 0 n32 ns632 0 -6.91121354211e-06
Gc16_633 0 n32 ns633 0 0.000136782542377
Gc16_634 0 n32 ns634 0 6.07494927631e-05
Gc16_635 0 n32 ns635 0 -9.8416472058e-05
Gc16_636 0 n32 ns636 0 0.0006480647092
Gc16_637 0 n32 ns637 0 0.00105367485595
Gc16_638 0 n32 ns638 0 0.000274824448946
Gc16_639 0 n32 ns639 0 -0.000261555875957
Gc16_640 0 n32 ns640 0 -0.000109235844416
Gc16_641 0 n32 ns641 0 -0.000143970774176
Gc16_642 0 n32 ns642 0 0.0096536844642
Gc16_643 0 n32 ns643 0 -0.00814272255259
Gc16_644 0 n32 ns644 0 0.000213427262399
Gc16_645 0 n32 ns645 0 6.71678749799e-06
Gc16_646 0 n32 ns646 0 -2.61977610184e-05
Gc16_647 0 n32 ns647 0 8.37238707122e-05
Gc16_648 0 n32 ns648 0 -0.000399808376243
Gc16_649 0 n32 ns649 0 -0.000722226151087
Gc16_650 0 n32 ns650 0 -0.000122014725855
Gc16_651 0 n32 ns651 0 -2.42336530041e-05
Gc16_652 0 n32 ns652 0 -6.21068015556e-06
Gc16_653 0 n32 ns653 0 0.000104540954188
Gc16_654 0 n32 ns654 0 3.34387711084e-05
Gc16_655 0 n32 ns655 0 -1.63904132092e-05
Gc16_656 0 n32 ns656 0 -0.000432346476897
Gc16_657 0 n32 ns657 0 0.000439692342092
Gc16_658 0 n32 ns658 0 0.000325660716819
Gc16_659 0 n32 ns659 0 -5.43242245736e-05
Gc16_660 0 n32 ns660 0 -3.40538041055e-05
Gc16_661 0 n32 ns661 0 -0.00014117675052
Gc16_662 0 n32 ns662 0 0.000248511103736
Gc16_663 0 n32 ns663 0 0.000720729636261
Gc16_664 0 n32 ns664 0 0.000275609397905
Gc16_665 0 n32 ns665 0 -0.000347842267411
Gc16_666 0 n32 ns666 0 -8.98570803018e-05
Gc16_667 0 n32 ns667 0 -8.1031654771e-05
Gc16_668 0 n32 ns668 0 0.000247270472367
Gc16_669 0 n32 ns669 0 -6.83763472553e-05
Gc16_670 0 n32 ns670 0 -0.000110553832207
Gc16_671 0 n32 ns671 0 0.000174082489591
Gc16_672 0 n32 ns672 0 0.000127567188479
Gc16_673 0 n32 ns673 0 -9.05799341106e-05
Gc16_674 0 n32 ns674 0 0.000593385193457
Gc16_675 0 n32 ns675 0 0.00105132025358
Gc16_676 0 n32 ns676 0 0.000303520806258
Gc16_677 0 n32 ns677 0 -0.000235969096875
Gc16_678 0 n32 ns678 0 -0.000106464663043
Gc16_679 0 n32 ns679 0 -0.000167367448505
Gc16_680 0 n32 ns680 0 0.00957412617813
Gc16_681 0 n32 ns681 0 -0.00804055843572
Gc16_682 0 n32 ns682 0 0.000201067827861
Gc16_683 0 n32 ns683 0 4.98582712386e-06
Gc16_684 0 n32 ns684 0 -2.84153575142e-05
Gc16_685 0 n32 ns685 0 0.00018653802096
Gc16_686 0 n32 ns686 0 -0.000341310010779
Gc16_687 0 n32 ns687 0 -0.00012815611185
Gc16_688 0 n32 ns688 0 -0.000242815087185
Gc16_689 0 n32 ns689 0 0.000162815448692
Gc16_690 0 n32 ns690 0 3.11490761032e-05
Gc16_691 0 n32 ns691 0 0.000170596904427
Gc16_692 0 n32 ns692 0 2.86532488689e-05
Gc16_693 0 n32 ns693 0 5.2189964102e-06
Gc16_694 0 n32 ns694 0 -2.54547398429e-05
Gc16_695 0 n32 ns695 0 -0.00088235404082
Gc16_696 0 n32 ns696 0 4.7752581467e-05
Gc16_697 0 n32 ns697 0 0.000620825315954
Gc16_698 0 n32 ns698 0 0.000199139389506
Gc16_699 0 n32 ns699 0 -6.24945966149e-05
Gc16_700 0 n32 ns700 0 -0.000412966426352
Gc16_701 0 n32 ns701 0 0.000620822363152
Gc16_702 0 n32 ns702 0 0.000583736589703
Gc16_703 0 n32 ns703 0 -4.42978985227e-05
Gc16_704 0 n32 ns704 0 -3.70495538429e-05
Gc16_705 0 n32 ns705 0 -0.000185806939868
Gc16_706 0 n32 ns706 0 0.000368847745647
Gc16_707 0 n32 ns707 0 -0.000567456558043
Gc16_708 0 n32 ns708 0 -0.00065665647067
Gc16_709 0 n32 ns709 0 9.72825804884e-05
Gc16_710 0 n32 ns710 0 0.000409045659746
Gc16_711 0 n32 ns711 0 0.000125652359873
Gc16_712 0 n32 ns712 0 -0.000433953628831
Gc16_713 0 n32 ns713 0 0.000780095818712
Gc16_714 0 n32 ns714 0 0.000486690182195
Gc16_715 0 n32 ns715 0 0.000134566242653
Gc16_716 0 n32 ns716 0 -1.71539844654e-06
Gc16_717 0 n32 ns717 0 -0.000291331390368
Gc16_718 0 n32 ns718 0 0.0065349831658
Gc16_719 0 n32 ns719 0 -0.00562566763926
Gc16_720 0 n32 ns720 0 0.000133239466431
Gc16_721 0 n32 ns721 0 5.72004217712e-06
Gc16_722 0 n32 ns722 0 -3.05342872082e-05
Gc16_723 0 n32 ns723 0 0.000247139902074
Gc16_724 0 n32 ns724 0 -0.00103052514408
Gc16_725 0 n32 ns725 0 0.00325499739872
Gc16_726 0 n32 ns726 0 6.55302442695e-05
Gc16_727 0 n32 ns727 0 0.000177883663631
Gc16_728 0 n32 ns728 0 4.07035497935e-05
Gc16_729 0 n32 ns729 0 -1.26299922694e-05
Gc16_730 0 n32 ns730 0 -2.04995836404e-05
Gc16_731 0 n32 ns731 0 -1.11859939101e-05
Gc16_732 0 n32 ns732 0 0.000861084636228
Gc16_733 0 n32 ns733 0 -0.00153505477151
Gc16_734 0 n32 ns734 0 -0.000700947975541
Gc16_735 0 n32 ns735 0 0.000606446910229
Gc16_736 0 n32 ns736 0 0.000291150497263
Gc16_737 0 n32 ns737 0 0.000223355442053
Gc16_738 0 n32 ns738 0 -0.000958302323374
Gc16_739 0 n32 ns739 0 -0.000946130307144
Gc16_740 0 n32 ns740 0 0.000159731193406
Gc16_741 0 n32 ns741 0 0.000828054692563
Gc16_742 0 n32 ns742 0 0.000149873540202
Gc16_743 0 n32 ns743 0 -0.000134782088442
Gc16_744 0 n32 ns744 0 -0.000119968242064
Gc16_745 0 n32 ns745 0 -0.00127631007441
Gc16_746 0 n32 ns746 0 -0.00137955495135
Gc16_747 0 n32 ns747 0 -0.000314741318669
Gc16_748 0 n32 ns748 0 0.000711802883138
Gc16_749 0 n32 ns749 0 0.00066695739075
Gc16_750 0 n32 ns750 0 -0.00349066392989
Gc16_751 0 n32 ns751 0 -0.000881454571738
Gc16_752 0 n32 ns752 0 0.000585792712997
Gc16_753 0 n32 ns753 0 0.00135226054113
Gc16_754 0 n32 ns754 0 0.000412841079745
Gc16_755 0 n32 ns755 0 -0.000451796546551
Gc16_756 0 n32 ns756 0 -0.0109515240656
Gc16_757 0 n32 ns757 0 0.00885701086203
Gc16_758 0 n32 ns758 0 -0.00032437265071
Gc16_759 0 n32 ns759 0 6.37842699054e-06
Gc16_760 0 n32 ns760 0 -2.35140199693e-05
Gc16_761 0 n32 ns761 0 0.000234927943848
Gc16_762 0 n32 ns762 0 -0.000944845376223
Gc16_763 0 n32 ns763 0 0.00557106760274
Gc16_764 0 n32 ns764 0 0.000238604366435
Gc16_765 0 n32 ns765 0 0.000133437014012
Gc16_766 0 n32 ns766 0 0.000214107802992
Gc16_767 0 n32 ns767 0 -0.000139996548292
Gc16_768 0 n32 ns768 0 -2.46807096303e-06
Gc16_769 0 n32 ns769 0 -3.88548964837e-05
Gc16_770 0 n32 ns770 0 0.000375509437115
Gc16_771 0 n32 ns771 0 -0.000562500854574
Gc16_772 0 n32 ns772 0 -0.000490922139599
Gc16_773 0 n32 ns773 0 -0.000378042495001
Gc16_774 0 n32 ns774 0 7.29067461172e-05
Gc16_775 0 n32 ns775 0 0.00035574319336
Gc16_776 0 n32 ns776 0 0.000314439826779
Gc16_777 0 n32 ns777 0 -0.00208697139738
Gc16_778 0 n32 ns778 0 -0.00111747039756
Gc16_779 0 n32 ns779 0 0.000892176903279
Gc16_780 0 n32 ns780 0 0.00023692009658
Gc16_781 0 n32 ns781 0 9.74328942185e-05
Gc16_782 0 n32 ns782 0 -0.000811406726058
Gc16_783 0 n32 ns783 0 -0.0016081081944
Gc16_784 0 n32 ns784 0 -0.00129485688317
Gc16_785 0 n32 ns785 0 -0.00113507851691
Gc16_786 0 n32 ns786 0 0.000469014335016
Gc16_787 0 n32 ns787 0 0.00131530239853
Gc16_788 0 n32 ns788 0 -0.00602865971498
Gc16_789 0 n32 ns789 0 -0.00294872257374
Gc16_790 0 n32 ns790 0 0.000366001767834
Gc16_791 0 n32 ns791 0 0.00281263684789
Gc16_792 0 n32 ns792 0 0.0010026547763
Gc16_793 0 n32 ns793 0 -0.000642665738221
Gc16_794 0 n32 ns794 0 -0.0261519336887
Gc16_795 0 n32 ns795 0 0.0214956293416
Gc16_796 0 n32 ns796 0 -0.00075903306183
Gc16_797 0 n32 ns797 0 2.93368093194e-08
Gc16_798 0 n32 ns798 0 -7.11292544668e-06
Gc16_799 0 n32 ns799 0 0.000391611723765
Gc16_800 0 n32 ns800 0 -0.000905166283484
Gc16_801 0 n32 ns801 0 0.00750157823278
Gc16_802 0 n32 ns802 0 0.000287253329108
Gc16_803 0 n32 ns803 0 -0.000137147864004
Gc16_804 0 n32 ns804 0 9.80810544786e-05
Gc16_805 0 n32 ns805 0 6.36456550068e-05
Gc16_806 0 n32 ns806 0 1.82675297975e-05
Gc16_807 0 n32 ns807 0 2.64785597769e-05
Gc16_808 0 n32 ns808 0 -0.001164736734
Gc16_809 0 n32 ns809 0 -0.00126756312377
Gc16_810 0 n32 ns810 0 0.000605353721845
Gc16_811 0 n32 ns811 0 -0.000196878718224
Gc16_812 0 n32 ns812 0 -6.71936975963e-05
Gc16_813 0 n32 ns813 0 0.000295096128317
Gc16_814 0 n32 ns814 0 0.00111387292063
Gc16_815 0 n32 ns815 0 -0.000436891424693
Gc16_816 0 n32 ns816 0 -0.00136880920529
Gc16_817 0 n32 ns817 0 -0.000398141298942
Gc16_818 0 n32 ns818 0 0.000158372214106
Gc16_819 0 n32 ns819 0 0.000190528869985
Gc16_820 0 n32 ns820 0 -0.00179528048874
Gc16_821 0 n32 ns821 0 -0.00227452346687
Gc16_822 0 n32 ns822 0 -0.000270542778799
Gc16_823 0 n32 ns823 0 -0.00108302232652
Gc16_824 0 n32 ns824 0 -0.000211143001809
Gc16_825 0 n32 ns825 0 0.00140144599422
Gc16_826 0 n32 ns826 0 -0.00645261836442
Gc16_827 0 n32 ns827 0 -0.00476444008149
Gc16_828 0 n32 ns828 0 -0.00101644944428
Gc16_829 0 n32 ns829 0 0.00362838401128
Gc16_830 0 n32 ns830 0 0.00176044899711
Gc16_831 0 n32 ns831 0 -0.000473516143676
Gc16_832 0 n32 ns832 0 -0.0440489812771
Gc16_833 0 n32 ns833 0 0.0375444831234
Gc16_834 0 n32 ns834 0 -0.00159027626708
Gc16_835 0 n32 ns835 0 -8.50372238524e-06
Gc16_836 0 n32 ns836 0 1.02708169437e-05
Gc16_837 0 n32 ns837 0 -7.57370427785e-05
Gc16_838 0 n32 ns838 0 -0.000820842350905
Gc16_839 0 n32 ns839 0 0.00943576989575
Gc16_840 0 n32 ns840 0 0.000111235452764
Gc16_841 0 n32 ns841 0 0.000173333045484
Gc16_842 0 n32 ns842 0 0.000397986662716
Gc16_843 0 n32 ns843 0 -0.000368588307751
Gc16_844 0 n32 ns844 0 -0.000139520898161
Gc16_845 0 n32 ns845 0 2.51001841984e-05
Gc16_846 0 n32 ns846 0 0.000119025240965
Gc16_847 0 n32 ns847 0 -0.00319618253388
Gc16_848 0 n32 ns848 0 0.000393586354541
Gc16_849 0 n32 ns849 0 0.000985773639101
Gc16_850 0 n32 ns850 0 -0.000154085128803
Gc16_851 0 n32 ns851 0 0.000293070666816
Gc16_852 0 n32 ns852 0 -0.00105119110565
Gc16_853 0 n32 ns853 0 -0.000291344425375
Gc16_854 0 n32 ns854 0 -0.000316302759218
Gc16_855 0 n32 ns855 0 -0.000684049245031
Gc16_856 0 n32 ns856 0 0.00020831785522
Gc16_857 0 n32 ns857 0 0.000245347740664
Gc16_858 0 n32 ns858 0 -0.00175955751706
Gc16_859 0 n32 ns859 0 -0.00495270040946
Gc16_860 0 n32 ns860 0 -0.000897700575594
Gc16_861 0 n32 ns861 0 0.00030021426326
Gc16_862 0 n32 ns862 0 -0.000181736099424
Gc16_863 0 n32 ns863 0 0.00117238756349
Gc16_864 0 n32 ns864 0 -0.00775143169713
Gc16_865 0 n32 ns865 0 -0.00535954157603
Gc16_866 0 n32 ns866 0 -0.00259096308283
Gc16_867 0 n32 ns867 0 0.00280293962933
Gc16_868 0 n32 ns868 0 0.00252615736662
Gc16_869 0 n32 ns869 0 0.000259365623923
Gc16_870 0 n32 ns870 0 -0.0779186198554
Gc16_871 0 n32 ns871 0 0.0700542094781
Gc16_872 0 n32 ns872 0 -0.00407998032983
Gc16_873 0 n32 ns873 0 -1.02942458981e-05
Gc16_874 0 n32 ns874 0 2.32907386201e-05
Gc16_875 0 n32 ns875 0 -0.00253406828028
Gc16_876 0 n32 ns876 0 -0.00229598382494
Gc16_877 0 n32 ns877 0 0.00509946442956
Gc16_878 0 n32 ns878 0 0.00115007877262
Gc16_879 0 n32 ns879 0 -0.00191659374766
Gc16_880 0 n32 ns880 0 0.000430541705482
Gc16_881 0 n32 ns881 0 0.00175747657526
Gc16_882 0 n32 ns882 0 -1.22261352465e-05
Gc16_883 0 n32 ns883 0 -0.000229871385762
Gc16_884 0 n32 ns884 0 0.000727625412165
Gc16_885 0 n32 ns885 0 -0.000486515004067
Gc16_886 0 n32 ns886 0 -0.000895637367773
Gc16_887 0 n32 ns887 0 0.000605626183092
Gc16_888 0 n32 ns888 0 -0.000330829474575
Gc16_889 0 n32 ns889 0 0.000223116978915
Gc16_890 0 n32 ns890 0 0.000457347814562
Gc16_891 0 n32 ns891 0 -0.00218185586394
Gc16_892 0 n32 ns892 0 0.000125273950988
Gc16_893 0 n32 ns893 0 -0.000396672585723
Gc16_894 0 n32 ns894 0 0.000148571223777
Gc16_895 0 n32 ns895 0 0.000290560134447
Gc16_896 0 n32 ns896 0 0.00223856262283
Gc16_897 0 n32 ns897 0 -0.00143039533184
Gc16_898 0 n32 ns898 0 -0.00176757382119
Gc16_899 0 n32 ns899 0 -0.00060407545462
Gc16_900 0 n32 ns900 0 -0.000622685541295
Gc16_901 0 n32 ns901 0 0.00125422352316
Gc16_902 0 n32 ns902 0 -0.00864751237083
Gc16_903 0 n32 ns903 0 -0.00272581006582
Gc16_904 0 n32 ns904 0 -0.00022700212245
Gc16_905 0 n32 ns905 0 0.000419768047009
Gc16_906 0 n32 ns906 0 0.00268715192899
Gc16_907 0 n32 ns907 0 0.000793160386444
Gc16_908 0 n32 ns908 0 -0.0266131287555
Gc16_909 0 n32 ns909 0 0.0307928701475
Gc16_910 0 n32 ns910 0 -0.00704886036462
Gc16_911 0 n32 ns911 0 -8.40541922653e-06
Gc16_912 0 n32 ns912 0 2.68032655956e-05
Gc16_913 0 n32 ns913 0 -0.00527572089877
Gc16_914 0 n32 ns914 0 -0.00348486113953
Gc16_915 0 n32 ns915 0 -0.00251455499644
Gc16_916 0 n32 ns916 0 0.00204001546406
Gc16_917 0 n32 ns917 0 -0.00353437994247
Gc16_918 0 n32 ns918 0 0.000300003672511
Gc16_919 0 n32 ns919 0 0.0032959442967
Gc16_920 0 n32 ns920 0 0.00014176079361
Gc16_921 0 n32 ns921 0 -0.000299431526377
Gc16_922 0 n32 ns922 0 -0.00111619561598
Gc16_923 0 n32 ns923 0 0.00301170073969
Gc16_924 0 n32 ns924 0 -0.000994314500402
Gc16_925 0 n32 ns925 0 -0.000301769852212
Gc16_926 0 n32 ns926 0 -0.000284897825141
Gc16_927 0 n32 ns927 0 6.409170214e-05
Gc16_928 0 n32 ns928 0 0.00347767136179
Gc16_929 0 n32 ns929 0 -0.00165221138602
Gc16_930 0 n32 ns930 0 2.68854540377e-06
Gc16_931 0 n32 ns931 0 -0.000813052280191
Gc16_932 0 n32 ns932 0 -9.40968430277e-05
Gc16_933 0 n32 ns933 0 8.74521847984e-05
Gc16_934 0 n32 ns934 0 0.00538116882905
Gc16_935 0 n32 ns935 0 0.00565740120902
Gc16_936 0 n32 ns936 0 -2.62312007624e-05
Gc16_937 0 n32 ns937 0 -0.00240992208087
Gc16_938 0 n32 ns938 0 -0.0016607344457
Gc16_939 0 n32 ns939 0 0.000794963249207
Gc16_940 0 n32 ns940 0 -0.00699118121871
Gc16_941 0 n32 ns941 0 0.000757884617173
Gc16_942 0 n32 ns942 0 0.00354627685777
Gc16_943 0 n32 ns943 0 -0.000185044710118
Gc16_944 0 n32 ns944 0 0.00212131961299
Gc16_945 0 n32 ns945 0 0.000407146138729
Gc16_946 0 n32 ns946 0 0.0853962628433
Gc16_947 0 n32 ns947 0 -0.0662591511467
Gc16_948 0 n32 ns948 0 -0.00594882663275
Gc16_949 0 n32 ns949 0 -6.25408648192e-06
Gc16_950 0 n32 ns950 0 2.36908610626e-05
Gc16_951 0 n32 ns951 0 0.000151966829163
Gc16_952 0 n32 ns952 0 -0.000245571882168
Gc16_953 0 n32 ns953 0 -0.000610014388354
Gc16_954 0 n32 ns954 0 -0.000238567484122
Gc16_955 0 n32 ns955 0 0.000157125115796
Gc16_956 0 n32 ns956 0 8.13624523552e-05
Gc16_957 0 n32 ns957 0 0.000153139238273
Gc16_958 0 n32 ns958 0 2.96027369568e-05
Gc16_959 0 n32 ns959 0 -1.04608209121e-05
Gc16_960 0 n32 ns960 0 -0.000366099866941
Gc16_961 0 n32 ns961 0 -0.000367153862518
Gc16_962 0 n32 ns962 0 0.000285310373699
Gc16_963 0 n32 ns963 0 0.000353263451591
Gc16_964 0 n32 ns964 0 9.92069463818e-05
Gc16_965 0 n32 ns965 0 -0.000130590180921
Gc16_966 0 n32 ns966 0 -9.50085664468e-05
Gc16_967 0 n32 ns967 0 0.00077389181115
Gc16_968 0 n32 ns968 0 0.000479588693738
Gc16_969 0 n32 ns969 0 -0.000236116030907
Gc16_970 0 n32 ns970 0 -7.27133635488e-05
Gc16_971 0 n32 ns971 0 -0.000144626916595
Gc16_972 0 n32 ns972 0 0.000348227962788
Gc16_973 0 n32 ns973 0 -0.000340143872854
Gc16_974 0 n32 ns974 0 -0.000397373206334
Gc16_975 0 n32 ns975 0 0.000148679159497
Gc16_976 0 n32 ns976 0 0.000277784214267
Gc16_977 0 n32 ns977 0 1.08364699039e-05
Gc16_978 0 n32 ns978 0 0.000138245630567
Gc16_979 0 n32 ns979 0 0.000951253572098
Gc16_980 0 n32 ns980 0 0.000399956370262
Gc16_981 0 n32 ns981 0 -6.54423741838e-05
Gc16_982 0 n32 ns982 0 -5.9287012045e-05
Gc16_983 0 n32 ns983 0 -0.000234359945819
Gc16_984 0 n32 ns984 0 0.00861988286118
Gc16_985 0 n32 ns985 0 -0.00730777227194
Gc16_986 0 n32 ns986 0 0.000183997525777
Gc16_987 0 n32 ns987 0 4.90168634564e-06
Gc16_988 0 n32 ns988 0 -2.97085208106e-05
Gc16_989 0 n32 ns989 0 0.000206246153284
Gc16_990 0 n32 ns990 0 -0.000618020753038
Gc16_991 0 n32 ns991 0 0.00148201535254
Gc16_992 0 n32 ns992 0 -0.000103441364346
Gc16_993 0 n32 ns993 0 0.000205481174934
Gc16_994 0 n32 ns994 0 4.18477801825e-05
Gc16_995 0 n32 ns995 0 9.84874287703e-05
Gc16_996 0 n32 ns996 0 -4.8199989301e-06
Gc16_997 0 n32 ns997 0 -3.04733271474e-06
Gc16_998 0 n32 ns998 0 0.00055931461482
Gc16_999 0 n32 ns999 0 -0.0014785005843
Gc16_1000 0 n32 ns1000 0 -0.000404954184986
Gc16_1001 0 n32 ns1001 0 0.000758324338354
Gc16_1002 0 n32 ns1002 0 0.000285678017035
Gc16_1003 0 n32 ns1003 0 9.73141603846e-05
Gc16_1004 0 n32 ns1004 0 -0.000858121056599
Gc16_1005 0 n32 ns1005 0 -0.000185482353766
Gc16_1006 0 n32 ns1006 0 0.000451622304415
Gc16_1007 0 n32 ns1007 0 0.000460678977018
Gc16_1008 0 n32 ns1008 0 6.83403715146e-05
Gc16_1009 0 n32 ns1009 0 -0.000178824610539
Gc16_1010 0 n32 ns1010 0 0.000160701146898
Gc16_1011 0 n32 ns1011 0 -0.000966217604227
Gc16_1012 0 n32 ns1012 0 -0.0010948500774
Gc16_1013 0 n32 ns1013 0 -0.000101955232218
Gc16_1014 0 n32 ns1014 0 0.00060346422636
Gc16_1015 0 n32 ns1015 0 0.000410280536113
Gc16_1016 0 n32 ns1016 0 -0.00206817911972
Gc16_1017 0 n32 ns1017 0 5.26538559425e-05
Gc16_1018 0 n32 ns1018 0 0.000631811577082
Gc16_1019 0 n32 ns1019 0 0.000752455150872
Gc16_1020 0 n32 ns1020 0 0.000190909175158
Gc16_1021 0 n32 ns1021 0 -0.000409320222088
Gc16_1022 0 n32 ns1022 0 -0.00158814399446
Gc16_1023 0 n32 ns1023 0 0.0010799872626
Gc16_1024 0 n32 ns1024 0 -8.33601480619e-05
Gc16_1025 0 n32 ns1025 0 6.13832051168e-06
Gc16_1026 0 n32 ns1026 0 -2.81244346555e-05
Gc16_1027 0 n32 ns1027 0 0.000258514479846
Gc16_1028 0 n32 ns1028 0 -0.00070676283841
Gc16_1029 0 n32 ns1029 0 0.00415055297443
Gc16_1030 0 n32 ns1030 0 6.66690352185e-05
Gc16_1031 0 n32 ns1031 0 0.00022012272267
Gc16_1032 0 n32 ns1032 0 0.000169953486023
Gc16_1033 0 n32 ns1033 0 -0.000107840224525
Gc16_1034 0 n32 ns1034 0 -1.91165612658e-05
Gc16_1035 0 n32 ns1035 0 -4.12881729289e-05
Gc16_1036 0 n32 ns1036 0 0.00090506088439
Gc16_1037 0 n32 ns1037 0 -0.000842316791956
Gc16_1038 0 n32 ns1038 0 -0.000755707677582
Gc16_1039 0 n32 ns1039 0 -9.16835913098e-06
Gc16_1040 0 n32 ns1040 0 0.000161983530687
Gc16_1041 0 n32 ns1041 0 0.000324434434309
Gc16_1042 0 n32 ns1042 0 -0.000306602245092
Gc16_1043 0 n32 ns1043 0 -0.00180756651106
Gc16_1044 0 n32 ns1044 0 -0.000577890850056
Gc16_1045 0 n32 ns1045 0 0.00100783081416
Gc16_1046 0 n32 ns1046 0 0.000222510079564
Gc16_1047 0 n32 ns1047 0 7.42755773258e-07
Gc16_1048 0 n32 ns1048 0 -0.000342521034155
Gc16_1049 0 n32 ns1049 0 -0.00135798590634
Gc16_1050 0 n32 ns1050 0 -0.00137318731748
Gc16_1051 0 n32 ns1051 0 -0.000878760554786
Gc16_1052 0 n32 ns1052 0 0.000574096243275
Gc16_1053 0 n32 ns1053 0 0.00107408703111
Gc16_1054 0 n32 ns1054 0 -0.00487468601601
Gc16_1055 0 n32 ns1055 0 -0.00202437788193
Gc16_1056 0 n32 ns1056 0 0.000525485292948
Gc16_1057 0 n32 ns1057 0 0.00218697643984
Gc16_1058 0 n32 ns1058 0 0.000727072488086
Gc16_1059 0 n32 ns1059 0 -0.000586631294233
Gc16_1060 0 n32 ns1060 0 -0.0180698257789
Gc16_1061 0 n32 ns1061 0 0.0147237229652
Gc16_1062 0 n32 ns1062 0 -0.000521590974307
Gc16_1063 0 n32 ns1063 0 2.6208072815e-06
Gc16_1064 0 n32 ns1064 0 -1.64638473247e-05
Gc16_1065 0 n32 ns1065 0 8.36229027531e-05
Gc16_1066 0 n32 ns1066 0 -0.000495757296545
Gc16_1067 0 n32 ns1067 0 0.00621366606857
Gc16_1068 0 n32 ns1068 0 0.000228042667777
Gc16_1069 0 n32 ns1069 0 0.000163724428914
Gc16_1070 0 n32 ns1070 0 0.000346061001556
Gc16_1071 0 n32 ns1071 0 5.15844277885e-06
Gc16_1072 0 n32 ns1072 0 6.54503006517e-06
Gc16_1073 0 n32 ns1073 0 -2.2763579491e-05
Gc16_1074 0 n32 ns1074 0 -0.000711529627454
Gc16_1075 0 n32 ns1075 0 -0.000998986633191
Gc16_1076 0 n32 ns1076 0 0.000255505431483
Gc16_1077 0 n32 ns1077 0 -0.000358664975894
Gc16_1078 0 n32 ns1078 0 9.98002358509e-06
Gc16_1079 0 n32 ns1079 0 0.000310717279859
Gc16_1080 0 n32 ns1080 0 0.00122493724292
Gc16_1081 0 n32 ns1081 0 -0.00128832737212
Gc16_1082 0 n32 ns1082 0 -0.00149218811854
Gc16_1083 0 n32 ns1083 0 8.43004237388e-05
Gc16_1084 0 n32 ns1084 0 0.00015920616918
Gc16_1085 0 n32 ns1085 0 0.000175567435145
Gc16_1086 0 n32 ns1086 0 -0.001362208177
Gc16_1087 0 n32 ns1087 0 -0.00202129496701
Gc16_1088 0 n32 ns1088 0 -0.00067832534772
Gc16_1089 0 n32 ns1089 0 -0.00129967763703
Gc16_1090 0 n32 ns1090 0 3.01038342566e-05
Gc16_1091 0 n32 ns1091 0 0.0014537858197
Gc16_1092 0 n32 ns1092 0 -0.00643621620106
Gc16_1093 0 n32 ns1093 0 -0.00452045208117
Gc16_1094 0 n32 ns1094 0 -0.000461211776375
Gc16_1095 0 n32 ns1095 0 0.00352888754031
Gc16_1096 0 n32 ns1096 0 0.00148684052778
Gc16_1097 0 n32 ns1097 0 -0.000566304403473
Gc16_1098 0 n32 ns1098 0 -0.0376438269766
Gc16_1099 0 n32 ns1099 0 0.0316830158177
Gc16_1100 0 n32 ns1100 0 -0.00123559896727
Gc16_1101 0 n32 ns1101 0 -5.80049442595e-06
Gc16_1102 0 n32 ns1102 0 2.33811462782e-06
Gc16_1103 0 n32 ns1103 0 0.000439437406241
Gc16_1104 0 n32 ns1104 0 -0.000244667824469
Gc16_1105 0 n32 ns1105 0 0.00964423498479
Gc16_1106 0 n32 ns1106 0 0.000184530044688
Gc16_1107 0 n32 ns1107 0 0.000518305741387
Gc16_1108 0 n32 ns1108 0 0.000372237796907
Gc16_1109 0 n32 ns1109 0 -0.000210334015402
Gc16_1110 0 n32 ns1110 0 -9.17543143452e-05
Gc16_1111 0 n32 ns1111 0 1.87430449084e-05
Gc16_1112 0 n32 ns1112 0 -0.000869760328944
Gc16_1113 0 n32 ns1113 0 -0.00348611581714
Gc16_1114 0 n32 ns1114 0 0.000754829095
Gc16_1115 0 n32 ns1115 0 0.000744551714518
Gc16_1116 0 n32 ns1116 0 -4.50226187304e-05
Gc16_1117 0 n32 ns1117 0 0.000298024206063
Gc16_1118 0 n32 ns1118 0 -0.000379489382349
Gc16_1119 0 n32 ns1119 0 -0.000102408901243
Gc16_1120 0 n32 ns1120 0 -0.000727446469877
Gc16_1121 0 n32 ns1121 0 -0.000630628784376
Gc16_1122 0 n32 ns1122 0 0.00019507709767
Gc16_1123 0 n32 ns1123 0 0.000215964687731
Gc16_1124 0 n32 ns1124 0 -0.00254297666197
Gc16_1125 0 n32 ns1125 0 -0.00421791196539
Gc16_1126 0 n32 ns1126 0 -0.000502965251798
Gc16_1127 0 n32 ns1127 0 -6.71986428222e-06
Gc16_1128 0 n32 ns1128 0 -0.000160700506108
Gc16_1129 0 n32 ns1129 0 0.00117872801466
Gc16_1130 0 n32 ns1130 0 -0.00766071536397
Gc16_1131 0 n32 ns1131 0 -0.00577019984926
Gc16_1132 0 n32 ns1132 0 -0.00226406732414
Gc16_1133 0 n32 ns1133 0 0.00357176748276
Gc16_1134 0 n32 ns1134 0 0.00235196758836
Gc16_1135 0 n32 ns1135 0 -3.1309090145e-05
Gc16_1136 0 n32 ns1136 0 -0.0713647859872
Gc16_1137 0 n32 ns1137 0 0.0625487181192
Gc16_1138 0 n32 ns1138 0 -0.003031694034
Gc16_1139 0 n32 ns1139 0 -1.1037377299e-05
Gc16_1140 0 n32 ns1140 0 1.74708288815e-05
Gc16_1141 0 n32 ns1141 0 -0.000344377007191
Gc16_1142 0 n32 ns1142 0 -0.000471111420258
Gc16_1143 0 n32 ns1143 0 0.00563655179671
Gc16_1144 0 n32 ns1144 0 -0.000861045257003
Gc16_1145 0 n32 ns1145 0 -0.000925541508544
Gc16_1146 0 n32 ns1146 0 0.00140662916113
Gc16_1147 0 n32 ns1147 0 0.000414808395909
Gc16_1148 0 n32 ns1148 0 -0.000190583120263
Gc16_1149 0 n32 ns1149 0 -0.000147468304845
Gc16_1150 0 n32 ns1150 0 0.0015710714182
Gc16_1151 0 n32 ns1151 0 -0.0018773925081
Gc16_1152 0 n32 ns1152 0 -0.000392911298075
Gc16_1153 0 n32 ns1153 0 0.00101170922156
Gc16_1154 0 n32 ns1154 0 -0.000253939320043
Gc16_1155 0 n32 ns1155 0 0.000271588278392
Gc16_1156 0 n32 ns1156 0 -0.000994590251229
Gc16_1157 0 n32 ns1157 0 -0.00233785060145
Gc16_1158 0 n32 ns1158 0 -0.000271150419307
Gc16_1159 0 n32 ns1159 0 -0.000233700161584
Gc16_1160 0 n32 ns1160 0 0.000192246830029
Gc16_1161 0 n32 ns1161 0 0.000389594268825
Gc16_1162 0 n32 ns1162 0 0.000673685937559
Gc16_1163 0 n32 ns1163 0 -0.00465793416436
Gc16_1164 0 n32 ns1164 0 -0.00188532841694
Gc16_1165 0 n32 ns1165 0 7.96100174827e-05
Gc16_1166 0 n32 ns1166 0 -0.000227446019579
Gc16_1167 0 n32 ns1167 0 0.00126980045619
Gc16_1168 0 n32 ns1168 0 -0.00968866563775
Gc16_1169 0 n32 ns1169 0 -0.00418402167443
Gc16_1170 0 n32 ns1170 0 -0.00169766134135
Gc16_1171 0 n32 ns1171 0 0.00150028758065
Gc16_1172 0 n32 ns1172 0 0.00281653395977
Gc16_1173 0 n32 ns1173 0 0.00078788458106
Gc16_1174 0 n32 ns1174 0 -0.0650801934852
Gc16_1175 0 n32 ns1175 0 0.062952333214
Gc16_1176 0 n32 ns1176 0 -0.00647408152789
Gc16_1177 0 n32 ns1177 0 -9.2141309365e-06
Gc16_1178 0 n32 ns1178 0 2.95962737756e-05
Gc16_1179 0 n32 ns1179 0 -0.017057962245
Gc16_1180 0 n32 ns1180 0 0.0010543343637
Gc16_1181 0 n32 ns1181 0 0.0122104775726
Gc16_1182 0 n32 ns1182 0 0.00589584348873
Gc16_1183 0 n32 ns1183 0 0.00976504023023
Gc16_1184 0 n32 ns1184 0 0.00129512828649
Gc16_1185 0 n32 ns1185 0 -0.00331504565444
Gc16_1186 0 n32 ns1186 0 -0.00045543080219
Gc16_1187 0 n32 ns1187 0 3.2708983444e-06
Gc16_1188 0 n32 ns1188 0 -0.000675436086426
Gc16_1189 0 n32 ns1189 0 -0.0117784582265
Gc16_1190 0 n32 ns1190 0 0.000921255620172
Gc16_1191 0 n32 ns1191 0 0.00150536527623
Gc16_1192 0 n32 ns1192 0 6.02264609898e-05
Gc16_1193 0 n32 ns1193 0 8.60691137919e-06
Gc16_1194 0 n32 ns1194 0 0.000188466315421
Gc16_1195 0 n32 ns1195 0 0.000469965024633
Gc16_1196 0 n32 ns1196 0 0.000545534739022
Gc16_1197 0 n32 ns1197 0 0.00053957977596
Gc16_1198 0 n32 ns1198 0 0.000326369335368
Gc16_1199 0 n32 ns1199 0 0.000412467538532
Gc16_1200 0 n32 ns1200 0 -0.00971201876812
Gc16_1201 0 n32 ns1201 0 -0.00569563229438
Gc16_1202 0 n32 ns1202 0 -0.00303746568309
Gc16_1203 0 n32 ns1203 0 -0.000792257121484
Gc16_1204 0 n32 ns1204 0 -0.000230692505227
Gc16_1205 0 n32 ns1205 0 0.00152084879981
Gc16_1206 0 n32 ns1206 0 0.0131896276324
Gc16_1207 0 n32 ns1207 0 -0.00134834022394
Gc16_1208 0 n32 ns1208 0 0.00246119389331
Gc16_1209 0 n32 ns1209 0 -0.00133370907284
Gc16_1210 0 n32 ns1210 0 0.00225929165888
Gc16_1211 0 n32 ns1211 0 0.000461248674274
Gc16_1212 0 n32 ns1212 0 -0.0699640865321
Gc16_1213 0 n32 ns1213 0 0.0387979295174
Gc16_1214 0 n32 ns1214 0 -0.00815720619977
Gc16_1215 0 n32 ns1215 0 -8.17428624985e-06
Gc16_1216 0 n32 ns1216 0 2.78389763153e-05
Gd16_1 0 n32 ni1 0 -4.60535582596e-06
Gd16_2 0 n32 ni2 0 -1.57527214496e-06
Gd16_3 0 n32 ni3 0 -4.90914703729e-05
Gd16_4 0 n32 ni4 0 0.000120889080336
Gd16_5 0 n32 ni5 0 0.00018525867252
Gd16_6 0 n32 ni6 0 0.000239383360038
Gd16_7 0 n32 ni7 0 -0.000609864891827
Gd16_8 0 n32 ni8 0 -0.00277637353559
Gd16_9 0 n32 ni9 0 -0.00247619833117
Gd16_10 0 n32 ni10 0 -9.3461489694e-05
Gd16_11 0 n32 ni11 0 -7.05068713112e-05
Gd16_12 0 n32 ni12 0 2.47276866878e-05
Gd16_13 0 n32 ni13 0 0.000346008255357
Gd16_14 0 n32 ni14 0 -0.000194562232564
Gd16_15 0 n32 ni15 0 -0.00167912808647
Gd16_16 0 n32 ni16 0 -0.000668523271804
Gd16_17 0 n32 ni17 0 -0.000111300184856
Gd16_18 0 n32 ni18 0 -0.000120725261193
Gd16_19 0 n32 ni19 0 -7.31494988959e-06
Gd16_20 0 n32 ni20 0 -7.59773547907e-05
Gd16_21 0 n32 ni21 0 4.8494860771e-05
Gd16_22 0 n32 ni22 0 0.000246887035416
Gd16_23 0 n32 ni23 0 -5.84744441244e-05
Gd16_24 0 n32 ni24 0 -0.0015180237575
Gd16_25 0 n32 ni25 0 -0.00315752410827
Gd16_26 0 n32 ni26 0 -1.33825508871e-05
Gd16_27 0 n32 ni27 0 -2.41489042409e-05
Gd16_28 0 n32 ni28 0 8.35060421464e-05
Gd16_29 0 n32 ni29 0 0.000145218390953
Gd16_30 0 n32 ni30 0 0.000567156945386
Gd16_31 0 n32 ni31 0 -0.000502773853045
Gd16_32 0 n32 ni32 0 -0.00654355871656
Gc17_1 0 n34 ns1 0 -0.0180265580875
Gc17_2 0 n34 ns2 0 -0.00349072239332
Gc17_3 0 n34 ns3 0 0.0153250828822
Gc17_4 0 n34 ns4 0 0.00896009756047
Gc17_5 0 n34 ns5 0 0.00847762346226
Gc17_6 0 n34 ns6 0 -0.000534323712459
Gc17_7 0 n34 ns7 0 -0.00314493931315
Gc17_8 0 n34 ns8 0 -0.000261234600831
Gc17_9 0 n34 ns9 0 0.000225006803887
Gc17_10 0 n34 ns10 0 -0.00378565114652
Gc17_11 0 n34 ns11 0 -0.00900278851059
Gc17_12 0 n34 ns12 0 0.00114627478384
Gc17_13 0 n34 ns13 0 0.00032728241379
Gc17_14 0 n34 ns14 0 4.4958991399e-05
Gc17_15 0 n34 ns15 0 -0.000156848089285
Gc17_16 0 n34 ns16 0 0.00187653994604
Gc17_17 0 n34 ns17 0 0.00187335918996
Gc17_18 0 n34 ns18 0 0.000722765231887
Gc17_19 0 n34 ns19 0 0.000237381253263
Gc17_20 0 n34 ns20 0 0.000218351953188
Gc17_21 0 n34 ns21 0 0.00020920352029
Gc17_22 0 n34 ns22 0 -0.00977017853678
Gc17_23 0 n34 ns23 0 -0.00163485881759
Gc17_24 0 n34 ns24 0 -0.00204987943883
Gc17_25 0 n34 ns25 0 -0.00126423302888
Gc17_26 0 n34 ns26 0 -0.000501692590489
Gc17_27 0 n34 ns27 0 0.00115838869098
Gc17_28 0 n34 ns28 0 0.016515680956
Gc17_29 0 n34 ns29 0 -0.000453536933618
Gc17_30 0 n34 ns30 0 0.00345497915971
Gc17_31 0 n34 ns31 0 -0.001818991006
Gc17_32 0 n34 ns32 0 0.00154026756388
Gc17_33 0 n34 ns33 0 0.000125427989444
Gc17_34 0 n34 ns34 0 -0.0360945452447
Gc17_35 0 n34 ns35 0 0.00659987802061
Gc17_36 0 n34 ns36 0 -0.00617619220449
Gc17_37 0 n34 ns37 0 -5.07330013859e-06
Gc17_38 0 n34 ns38 0 1.64670994745e-05
Gc17_39 0 n34 ns39 0 -0.00525547302413
Gc17_40 0 n34 ns40 0 -0.00341574603544
Gc17_41 0 n34 ns41 0 -0.00261160227855
Gc17_42 0 n34 ns42 0 0.00201658978153
Gc17_43 0 n34 ns43 0 -0.00353432798126
Gc17_44 0 n34 ns44 0 0.000312349055612
Gc17_45 0 n34 ns45 0 0.00329731696073
Gc17_46 0 n34 ns46 0 0.000139862019416
Gc17_47 0 n34 ns47 0 -0.000300418632574
Gc17_48 0 n34 ns48 0 -0.00110396171332
Gc17_49 0 n34 ns49 0 0.003008008336
Gc17_50 0 n34 ns50 0 -0.000996552957538
Gc17_51 0 n34 ns51 0 -0.00029835595249
Gc17_52 0 n34 ns52 0 -0.000285511336177
Gc17_53 0 n34 ns53 0 6.49495649313e-05
Gc17_54 0 n34 ns54 0 0.00346711139166
Gc17_55 0 n34 ns55 0 -0.0016547278375
Gc17_56 0 n34 ns56 0 5.27710871033e-06
Gc17_57 0 n34 ns57 0 -0.000810228900889
Gc17_58 0 n34 ns58 0 -9.23246111289e-05
Gc17_59 0 n34 ns59 0 8.7669246355e-05
Gc17_60 0 n34 ns60 0 0.00539443024498
Gc17_61 0 n34 ns61 0 0.00565409104294
Gc17_62 0 n34 ns62 0 -2.74758210415e-05
Gc17_63 0 n34 ns63 0 -0.00241372170579
Gc17_64 0 n34 ns64 0 -0.00166286815949
Gc17_65 0 n34 ns65 0 0.000798460682168
Gc17_66 0 n34 ns66 0 -0.00697949160437
Gc17_67 0 n34 ns67 0 0.000771809620624
Gc17_68 0 n34 ns68 0 0.00354605088753
Gc17_69 0 n34 ns69 0 -0.000191161872955
Gc17_70 0 n34 ns70 0 0.00212147122688
Gc17_71 0 n34 ns71 0 0.000405403991611
Gc17_72 0 n34 ns72 0 0.0854908940797
Gc17_73 0 n34 ns73 0 -0.0663249987511
Gc17_74 0 n34 ns74 0 -0.00594892886785
Gc17_75 0 n34 ns75 0 -6.40689770536e-06
Gc17_76 0 n34 ns76 0 2.37876356565e-05
Gc17_77 0 n34 ns77 0 0.000241840521282
Gc17_78 0 n34 ns78 0 -0.000289280366075
Gc17_79 0 n34 ns79 0 0.00744641338417
Gc17_80 0 n34 ns80 0 -9.88563621785e-05
Gc17_81 0 n34 ns81 0 -6.17605584657e-05
Gc17_82 0 n34 ns82 0 0.000265006925428
Gc17_83 0 n34 ns83 0 -0.000760318163461
Gc17_84 0 n34 ns84 0 -0.000136173698849
Gc17_85 0 n34 ns85 0 1.56927758759e-05
Gc17_86 0 n34 ns86 0 0.00185394206426
Gc17_87 0 n34 ns87 0 -0.00171306405225
Gc17_88 0 n34 ns88 0 -0.000443232428989
Gc17_89 0 n34 ns89 0 0.000758258670408
Gc17_90 0 n34 ns90 0 -0.000258231630497
Gc17_91 0 n34 ns91 0 0.000209516274146
Gc17_92 0 n34 ns92 0 -0.00224504990998
Gc17_93 0 n34 ns93 0 -0.0017567150376
Gc17_94 0 n34 ns94 0 0.000122272639644
Gc17_95 0 n34 ns95 0 0.000154359197759
Gc17_96 0 n34 ns96 0 0.00024993852258
Gc17_97 0 n34 ns97 0 0.00032058743544
Gc17_98 0 n34 ns98 0 -0.000291713494285
Gc17_99 0 n34 ns99 0 -0.00556577933234
Gc17_100 0 n34 ns100 0 -0.00205170929101
Gc17_101 0 n34 ns101 0 0.000799548776445
Gc17_102 0 n34 ns102 0 0.000215827058415
Gc17_103 0 n34 ns103 0 0.000994710314602
Gc17_104 0 n34 ns104 0 -0.00778815325844
Gc17_105 0 n34 ns105 0 -0.00317340392903
Gc17_106 0 n34 ns106 0 -0.00218205197477
Gc17_107 0 n34 ns107 0 0.000915354427037
Gc17_108 0 n34 ns108 0 0.00223412511752
Gc17_109 0 n34 ns109 0 0.000664233114771
Gc17_110 0 n34 ns110 0 -0.0776822727165
Gc17_111 0 n34 ns111 0 0.0721133741004
Gc17_112 0 n34 ns112 0 -0.00506761959251
Gc17_113 0 n34 ns113 0 -6.62397516665e-06
Gc17_114 0 n34 ns114 0 2.33133575134e-05
Gc17_115 0 n34 ns115 0 0.00036682893489
Gc17_116 0 n34 ns116 0 -0.00121403336928
Gc17_117 0 n34 ns117 0 0.0084151427404
Gc17_118 0 n34 ns118 0 0.000494580657358
Gc17_119 0 n34 ns119 0 -0.0001432454675
Gc17_120 0 n34 ns120 0 -8.74371469618e-05
Gc17_121 0 n34 ns121 0 0.000177377379426
Gc17_122 0 n34 ns122 0 -1.05102945415e-05
Gc17_123 0 n34 ns123 0 4.68744145652e-05
Gc17_124 0 n34 ns124 0 -0.00136236969507
Gc17_125 0 n34 ns125 0 -0.00286430259117
Gc17_126 0 n34 ns126 0 0.000839362927438
Gc17_127 0 n34 ns127 0 0.000707987193684
Gc17_128 0 n34 ns128 0 2.19021794882e-05
Gc17_129 0 n34 ns129 0 0.00021533650965
Gc17_130 0 n34 ns130 0 0.000229124413488
Gc17_131 0 n34 ns131 0 0.000801803286707
Gc17_132 0 n34 ns132 0 -0.000573165687122
Gc17_133 0 n34 ns133 0 -0.000959154848238
Gc17_134 0 n34 ns134 0 6.59381833102e-05
Gc17_135 0 n34 ns135 0 0.000111771536277
Gc17_136 0 n34 ns136 0 -0.00247100413222
Gc17_137 0 n34 ns137 0 -0.00298930072987
Gc17_138 0 n34 ns138 0 9.49395112612e-05
Gc17_139 0 n34 ns139 0 -1.57973555802e-05
Gc17_140 0 n34 ns140 0 -0.00027782225534
Gc17_141 0 n34 ns141 0 0.000824717083593
Gc17_142 0 n34 ns142 0 -0.00568734386037
Gc17_143 0 n34 ns143 0 -0.00473577336042
Gc17_144 0 n34 ns144 0 -0.00189438501295
Gc17_145 0 n34 ns145 0 0.00314375547337
Gc17_146 0 n34 ns146 0 0.00190918410681
Gc17_147 0 n34 ns147 0 -0.000106428040327
Gc17_148 0 n34 ns148 0 -0.0526807525917
Gc17_149 0 n34 ns149 0 0.0456815698168
Gc17_150 0 n34 ns150 0 -0.00207894674858
Gc17_151 0 n34 ns151 0 -7.29025652924e-06
Gc17_152 0 n34 ns152 0 1.62872321942e-05
Gc17_153 0 n34 ns153 0 -2.80010241908e-05
Gc17_154 0 n34 ns154 0 0.000225360359915
Gc17_155 0 n34 ns155 0 0.0040992938965
Gc17_156 0 n34 ns156 0 -6.46960079196e-05
Gc17_157 0 n34 ns157 0 0.000297947637938
Gc17_158 0 n34 ns158 0 0.000425978001213
Gc17_159 0 n34 ns159 0 -1.70760669157e-05
Gc17_160 0 n34 ns160 0 3.23189624788e-05
Gc17_161 0 n34 ns161 0 -4.23519452989e-05
Gc17_162 0 n34 ns162 0 -0.000497559829875
Gc17_163 0 n34 ns163 0 -0.000101474710407
Gc17_164 0 n34 ns164 0 0.000227613542775
Gc17_165 0 n34 ns165 0 -0.000622774856604
Gc17_166 0 n34 ns166 0 -4.91078061001e-05
Gc17_167 0 n34 ns167 0 0.000204080740837
Gc17_168 0 n34 ns168 0 0.00146043735738
Gc17_169 0 n34 ns169 0 -0.00145229560466
Gc17_170 0 n34 ns170 0 -0.00148409362714
Gc17_171 0 n34 ns171 0 0.000156622515436
Gc17_172 0 n34 ns172 0 0.000114768721382
Gc17_173 0 n34 ns173 0 0.000192307443168
Gc17_174 0 n34 ns174 0 -0.000842529027917
Gc17_175 0 n34 ns175 0 -0.00137592927452
Gc17_176 0 n34 ns176 0 -0.000583037022346
Gc17_177 0 n34 ns177 0 -0.00131304087087
Gc17_178 0 n34 ns178 0 3.50663430837e-06
Gc17_179 0 n34 ns179 0 0.00126658708789
Gc17_180 0 n34 ns180 0 -0.00514106319619
Gc17_181 0 n34 ns181 0 -0.0035638388983
Gc17_182 0 n34 ns182 0 -0.000170827121234
Gc17_183 0 n34 ns183 0 0.00289407599499
Gc17_184 0 n34 ns184 0 0.00115381202908
Gc17_185 0 n34 ns185 0 -0.000535687203511
Gc17_186 0 n34 ns186 0 -0.0257879393361
Gc17_187 0 n34 ns187 0 0.0214743606596
Gc17_188 0 n34 ns188 0 -0.000821208772587
Gc17_189 0 n34 ns189 0 -1.22419265474e-06
Gc17_190 0 n34 ns190 0 3.15920385898e-06
Gc17_191 0 n34 ns191 0 0.0002032257395
Gc17_192 0 n34 ns192 0 -0.00076518415044
Gc17_193 0 n34 ns193 0 0.00392091607544
Gc17_194 0 n34 ns194 0 0.00021443605107
Gc17_195 0 n34 ns195 0 0.000161793580766
Gc17_196 0 n34 ns196 0 0.000121367974609
Gc17_197 0 n34 ns197 0 -0.000187770850043
Gc17_198 0 n34 ns198 0 -5.3807693989e-05
Gc17_199 0 n34 ns199 0 -4.32225312622e-05
Gc17_200 0 n34 ns200 0 0.000833583143584
Gc17_201 0 n34 ns201 0 -0.000811188452161
Gc17_202 0 n34 ns202 0 -0.000765288855079
Gc17_203 0 n34 ns203 0 3.54940462439e-05
Gc17_204 0 n34 ns204 0 0.00014499140842
Gc17_205 0 n34 ns205 0 0.000281827650205
Gc17_206 0 n34 ns206 0 -0.000692674955863
Gc17_207 0 n34 ns207 0 -0.00169757784216
Gc17_208 0 n34 ns208 0 -0.000361260896202
Gc17_209 0 n34 ns209 0 0.00105344531508
Gc17_210 0 n34 ns210 0 0.000218503229911
Gc17_211 0 n34 ns211 0 -3.57880844945e-06
Gc17_212 0 n34 ns212 0 -0.000394712753124
Gc17_213 0 n34 ns213 0 -0.00108132074948
Gc17_214 0 n34 ns214 0 -0.00125896780394
Gc17_215 0 n34 ns215 0 -0.000627273902085
Gc17_216 0 n34 ns216 0 0.000570467000881
Gc17_217 0 n34 ns217 0 0.000854018111265
Gc17_218 0 n34 ns218 0 -0.00443753104736
Gc17_219 0 n34 ns219 0 -0.00123774954434
Gc17_220 0 n34 ns220 0 0.000683542420171
Gc17_221 0 n34 ns221 0 0.00179950945632
Gc17_222 0 n34 ns222 0 0.000583982705924
Gc17_223 0 n34 ns223 0 -0.000556738934365
Gc17_224 0 n34 ns224 0 -0.0128765284595
Gc17_225 0 n34 ns225 0 0.0101816110926
Gc17_226 0 n34 ns226 0 -0.00033875992046
Gc17_227 0 n34 ns227 0 6.41906225537e-06
Gc17_228 0 n34 ns228 0 -1.54946360245e-05
Gc17_229 0 n34 ns229 0 4.46762679022e-05
Gc17_230 0 n34 ns230 0 -0.000411819441356
Gc17_231 0 n34 ns231 0 0.000842174507909
Gc17_232 0 n34 ns232 0 -0.000123153809623
Gc17_233 0 n34 ns233 0 0.000175623601617
Gc17_234 0 n34 ns234 0 1.3676267992e-05
Gc17_235 0 n34 ns235 0 0.000126029385202
Gc17_236 0 n34 ns236 0 4.48383472026e-06
Gc17_237 0 n34 ns237 0 1.50838183621e-05
Gc17_238 0 n34 ns238 0 0.000422416792368
Gc17_239 0 n34 ns239 0 -0.00145969152904
Gc17_240 0 n34 ns240 0 -0.000278735434598
Gc17_241 0 n34 ns241 0 0.000802198030489
Gc17_242 0 n34 ns242 0 0.000273295528043
Gc17_243 0 n34 ns243 0 5.91874408598e-05
Gc17_244 0 n34 ns244 0 -0.00077098968608
Gc17_245 0 n34 ns245 0 9.64653251169e-05
Gc17_246 0 n34 ns246 0 0.000505244362945
Gc17_247 0 n34 ns247 0 0.000285927077012
Gc17_248 0 n34 ns248 0 3.61357168987e-05
Gc17_249 0 n34 ns249 0 -0.000170530961885
Gc17_250 0 n34 ns250 0 0.000251651951263
Gc17_251 0 n34 ns251 0 -0.000779803957637
Gc17_252 0 n34 ns252 0 -0.000874547706517
Gc17_253 0 n34 ns253 0 -4.4666014953e-05
Gc17_254 0 n34 ns254 0 0.000483312664354
Gc17_255 0 n34 ns255 0 0.000293855144141
Gc17_256 0 n34 ns256 0 -0.00141374145012
Gc17_257 0 n34 ns257 0 0.000163941976297
Gc17_258 0 n34 ns258 0 0.00049544635925
Gc17_259 0 n34 ns259 0 0.000507731366476
Gc17_260 0 n34 ns260 0 0.000124625549647
Gc17_261 0 n34 ns261 0 -0.000316016065474
Gc17_262 0 n34 ns262 0 0.000280788767229
Gc17_263 0 n34 ns263 0 -0.000404808971593
Gc17_264 0 n34 ns264 0 -3.71339465773e-05
Gc17_265 0 n34 ns265 0 7.50854207606e-06
Gc17_266 0 n34 ns266 0 -2.53281434969e-05
Gc17_267 0 n34 ns267 0 -2.98437279416e-05
Gc17_268 0 n34 ns268 0 -0.000103112267741
Gc17_269 0 n34 ns269 0 -0.00107714433518
Gc17_270 0 n34 ns270 0 -0.00018398172521
Gc17_271 0 n34 ns271 0 7.28426402637e-05
Gc17_272 0 n34 ns272 0 3.83440534819e-05
Gc17_273 0 n34 ns273 0 0.000162699874675
Gc17_274 0 n34 ns274 0 3.92274343079e-05
Gc17_275 0 n34 ns275 0 -1.62804501926e-05
Gc17_276 0 n34 ns276 0 -0.000398642938874
Gc17_277 0 n34 ns277 0 -7.37056487988e-05
Gc17_278 0 n34 ns278 0 0.000312698541736
Gc17_279 0 n34 ns279 0 0.000202839541965
Gc17_280 0 n34 ns280 0 5.04911495056e-05
Gc17_281 0 n34 ns281 0 -0.0001324271105
Gc17_282 0 n34 ns282 0 4.91687595844e-05
Gc17_283 0 n34 ns283 0 0.000789800925119
Gc17_284 0 n34 ns284 0 0.000397124561634
Gc17_285 0 n34 ns285 0 -0.000288993901996
Gc17_286 0 n34 ns286 0 -7.43188265681e-05
Gc17_287 0 n34 ns287 0 -0.000115779323095
Gc17_288 0 n34 ns288 0 0.00041242407084
Gc17_289 0 n34 ns289 0 -0.000123825584969
Gc17_290 0 n34 ns290 0 -0.000211023767033
Gc17_291 0 n34 ns291 0 9.1777029237e-05
Gc17_292 0 n34 ns292 0 0.000156585264142
Gc17_293 0 n34 ns293 0 -1.92096299428e-05
Gc17_294 0 n34 ns294 0 0.000544484329437
Gc17_295 0 n34 ns295 0 0.00103662395967
Gc17_296 0 n34 ns296 0 0.000330672128505
Gc17_297 0 n34 ns297 0 -0.000199205755914
Gc17_298 0 n34 ns298 0 -9.36152730451e-05
Gc17_299 0 n34 ns299 0 -0.000191364356966
Gc17_300 0 n34 ns300 0 0.0104052299686
Gc17_301 0 n34 ns301 0 -0.00878653697843
Gc17_302 0 n34 ns302 0 0.000234313620211
Gc17_303 0 n34 ns303 0 5.61441199387e-06
Gc17_304 0 n34 ns304 0 -2.7161341933e-05
Gc17_305 0 n34 ns305 0 1.57599972002e-05
Gc17_306 0 n34 ns306 0 -0.000590114794157
Gc17_307 0 n34 ns307 0 -0.000334042708862
Gc17_308 0 n34 ns308 0 7.67670959908e-05
Gc17_309 0 n34 ns309 0 -0.000268605925285
Gc17_310 0 n34 ns310 0 -0.000177537804082
Gc17_311 0 n34 ns311 0 2.18604283197e-06
Gc17_312 0 n34 ns312 0 2.68280073557e-05
Gc17_313 0 n34 ns313 0 6.78352960214e-06
Gc17_314 0 n34 ns314 0 -0.000247233304058
Gc17_315 0 n34 ns315 0 0.000933786191431
Gc17_316 0 n34 ns316 0 0.000132359101075
Gc17_317 0 n34 ns317 0 -0.000314538994579
Gc17_318 0 n34 ns318 0 -0.000101460079502
Gc17_319 0 n34 ns319 0 -7.54322232958e-05
Gc17_320 0 n34 ns320 0 0.000287539810507
Gc17_321 0 n34 ns321 0 0.000478259015662
Gc17_322 0 n34 ns322 0 0.000108657214599
Gc17_323 0 n34 ns323 0 -0.000257741458809
Gc17_324 0 n34 ns324 0 -5.73418179174e-05
Gc17_325 0 n34 ns325 0 -2.83538823375e-05
Gc17_326 0 n34 ns326 0 0.000178344996033
Gc17_327 0 n34 ns327 0 0.000156533647594
Gc17_328 0 n34 ns328 0 5.93970701726e-05
Gc17_329 0 n34 ns329 0 7.63730892552e-05
Gc17_330 0 n34 ns330 0 4.76418242595e-06
Gc17_331 0 n34 ns331 0 -7.9665856721e-05
Gc17_332 0 n34 ns332 0 0.000623785308761
Gc17_333 0 n34 ns333 0 0.000842800544706
Gc17_334 0 n34 ns334 0 0.000182631187069
Gc17_335 0 n34 ns335 0 -0.000241994999872
Gc17_336 0 n34 ns336 0 -9.1411689086e-05
Gc17_337 0 n34 ns337 0 -0.00010143603153
Gc17_338 0 n34 ns338 0 0.00735355114574
Gc17_339 0 n34 ns339 0 -0.00611762133541
Gc17_340 0 n34 ns340 0 0.000136468858329
Gc17_341 0 n34 ns341 0 7.80162402781e-06
Gc17_342 0 n34 ns342 0 -2.44257660513e-05
Gc17_343 0 n34 ns343 0 -0.000494700742792
Gc17_344 0 n34 ns344 0 0.000599517313113
Gc17_345 0 n34 ns345 0 0.0018535609366
Gc17_346 0 n34 ns346 0 -0.00120446773902
Gc17_347 0 n34 ns347 0 -0.000843393102346
Gc17_348 0 n34 ns348 0 0.00158248017493
Gc17_349 0 n34 ns349 0 0.000213794534314
Gc17_350 0 n34 ns350 0 -0.000185684603731
Gc17_351 0 n34 ns351 0 -0.00018718215263
Gc17_352 0 n34 ns352 0 0.00243819532691
Gc17_353 0 n34 ns353 0 -0.000397724226609
Gc17_354 0 n34 ns354 0 -0.000897121330858
Gc17_355 0 n34 ns355 0 0.000634609603272
Gc17_356 0 n34 ns356 0 -0.000278225932068
Gc17_357 0 n34 ns357 0 0.00017085774757
Gc17_358 0 n34 ns358 0 -0.00122096290683
Gc17_359 0 n34 ns359 0 -0.00316163381578
Gc17_360 0 n34 ns360 0 -6.61048930882e-05
Gc17_361 0 n34 ns361 0 0.000289806070007
Gc17_362 0 n34 ns362 0 0.00017689964085
Gc17_363 0 n34 ns363 0 0.000383961736601
Gc17_364 0 n34 ns364 0 0.00195710380395
Gc17_365 0 n34 ns365 0 -0.00388800022173
Gc17_366 0 n34 ns366 0 -0.0022198192756
Gc17_367 0 n34 ns367 0 4.42779508697e-05
Gc17_368 0 n34 ns368 0 -9.98001829876e-05
Gc17_369 0 n34 ns369 0 0.00110128357395
Gc17_370 0 n34 ns370 0 -0.00841133164253
Gc17_371 0 n34 ns371 0 -0.00224024167681
Gc17_372 0 n34 ns372 0 -0.000863089619193
Gc17_373 0 n34 ns373 0 0.000330010918348
Gc17_374 0 n34 ns374 0 0.00230501138216
Gc17_375 0 n34 ns375 0 0.000769938332906
Gc17_376 0 n34 ns376 0 -0.0443035428883
Gc17_377 0 n34 ns377 0 0.0452360432755
Gc17_378 0 n34 ns378 0 -0.00596033006532
Gc17_379 0 n34 ns379 0 -5.54778266085e-06
Gc17_380 0 n34 ns380 0 2.86640481885e-05
Gc17_381 0 n34 ns381 0 0.000650378547325
Gc17_382 0 n34 ns382 0 -0.000590813968972
Gc17_383 0 n34 ns383 0 0.00931830971556
Gc17_384 0 n34 ns384 0 0.000328954384565
Gc17_385 0 n34 ns385 0 0.000222356855091
Gc17_386 0 n34 ns386 0 5.67810175464e-05
Gc17_387 0 n34 ns387 0 -0.000185890943583
Gc17_388 0 n34 ns388 0 -0.000116592318535
Gc17_389 0 n34 ns389 0 3.30658776506e-05
Gc17_390 0 n34 ns390 0 -0.000622334826872
Gc17_391 0 n34 ns391 0 -0.00374847591579
Gc17_392 0 n34 ns392 0 0.000616985792847
Gc17_393 0 n34 ns393 0 0.00117638650315
Gc17_394 0 n34 ns394 0 -1.76971247188e-05
Gc17_395 0 n34 ns395 0 0.00021872449477
Gc17_396 0 n34 ns396 0 -0.00119722054479
Gc17_397 0 n34 ns397 0 0.000562035455477
Gc17_398 0 n34 ns398 0 -6.85384633233e-05
Gc17_399 0 n34 ns399 0 -0.000769042651959
Gc17_400 0 n34 ns400 0 0.000149646058105
Gc17_401 0 n34 ns401 0 0.000146011050133
Gc17_402 0 n34 ns402 0 -0.00266246136867
Gc17_403 0 n34 ns403 0 -0.00410323191714
Gc17_404 0 n34 ns404 0 -0.000315978976588
Gc17_405 0 n34 ns405 0 0.000700002125583
Gc17_406 0 n34 ns406 0 -0.000120780528946
Gc17_407 0 n34 ns407 0 0.000698507501803
Gc17_408 0 n34 ns408 0 -0.00654330261147
Gc17_409 0 n34 ns409 0 -0.00454197204401
Gc17_410 0 n34 ns410 0 -0.00230724576484
Gc17_411 0 n34 ns411 0 0.00276090806194
Gc17_412 0 n34 ns412 0 0.0021422631785
Gc17_413 0 n34 ns413 0 0.000120641169126
Gc17_414 0 n34 ns414 0 -0.0655910365762
Gc17_415 0 n34 ns415 0 0.0577952550475
Gc17_416 0 n34 ns416 0 -0.00292429383636
Gc17_417 0 n34 ns417 0 -7.31956577115e-06
Gc17_418 0 n34 ns418 0 2.00869163921e-05
Gc17_419 0 n34 ns419 0 -4.30201557021e-06
Gc17_420 0 n34 ns420 0 4.1355711736e-05
Gc17_421 0 n34 ns421 0 0.00510887472519
Gc17_422 0 n34 ns422 0 9.76736485596e-05
Gc17_423 0 n34 ns423 0 0.000158629847638
Gc17_424 0 n34 ns424 0 0.000368676690813
Gc17_425 0 n34 ns425 0 0.000128370884956
Gc17_426 0 n34 ns426 0 3.68160529892e-05
Gc17_427 0 n34 ns427 0 -6.14284146987e-06
Gc17_428 0 n34 ns428 0 -0.00138968050086
Gc17_429 0 n34 ns429 0 -0.000904489496108
Gc17_430 0 n34 ns430 0 0.000796664133152
Gc17_431 0 n34 ns431 0 -0.00030303590334
Gc17_432 0 n34 ns432 0 -4.02727109787e-05
Gc17_433 0 n34 ns433 0 0.000158385940749
Gc17_434 0 n34 ns434 0 0.00169864310305
Gc17_435 0 n34 ns435 0 -0.000599045283462
Gc17_436 0 n34 ns436 0 -0.00149451968711
Gc17_437 0 n34 ns437 0 -0.000440402583044
Gc17_438 0 n34 ns438 0 5.92781352814e-05
Gc17_439 0 n34 ns439 0 0.00020596596204
Gc17_440 0 n34 ns440 0 -0.00142958595171
Gc17_441 0 n34 ns441 0 -0.00176465078488
Gc17_442 0 n34 ns442 0 -0.000209032560291
Gc17_443 0 n34 ns443 0 -0.00114343362885
Gc17_444 0 n34 ns444 0 -0.000198403471469
Gc17_445 0 n34 ns445 0 0.00123631124998
Gc17_446 0 n34 ns446 0 -0.00542262004872
Gc17_447 0 n34 ns447 0 -0.00417837981116
Gc17_448 0 n34 ns448 0 -0.000664263086739
Gc17_449 0 n34 ns449 0 0.00318448451596
Gc17_450 0 n34 ns450 0 0.00142518165304
Gc17_451 0 n34 ns451 0 -0.000468075029472
Gc17_452 0 n34 ns452 0 -0.033156203216
Gc17_453 0 n34 ns453 0 0.0279844395089
Gc17_454 0 n34 ns454 0 -0.00113157380277
Gc17_455 0 n34 ns455 0 -4.55309984117e-06
Gc17_456 0 n34 ns456 0 1.19677551795e-05
Gc17_457 0 n34 ns457 0 0.000122383316545
Gc17_458 0 n34 ns458 0 -0.000567266785495
Gc17_459 0 n34 ns459 0 0.00435575441989
Gc17_460 0 n34 ns460 0 0.000199134903726
Gc17_461 0 n34 ns461 0 0.000176677420951
Gc17_462 0 n34 ns462 0 0.00021991645822
Gc17_463 0 n34 ns463 0 -0.000171089030833
Gc17_464 0 n34 ns464 0 -1.96315738332e-05
Gc17_465 0 n34 ns465 0 -7.15459974426e-05
Gc17_466 0 n34 ns466 0 0.000598289434927
Gc17_467 0 n34 ns467 0 -0.000261429076306
Gc17_468 0 n34 ns468 0 -0.00058456074958
Gc17_469 0 n34 ns469 0 -0.00043213522507
Gc17_470 0 n34 ns470 0 3.03146815132e-05
Gc17_471 0 n34 ns471 0 0.000304047564516
Gc17_472 0 n34 ns472 0 1.94234493924e-05
Gc17_473 0 n34 ns473 0 -0.00210665438133
Gc17_474 0 n34 ns474 0 -0.000918499478195
Gc17_475 0 n34 ns475 0 0.000993588606991
Gc17_476 0 n34 ns476 0 0.000230418456376
Gc17_477 0 n34 ns477 0 9.85373221718e-05
Gc17_478 0 n34 ns478 0 -0.000589708275272
Gc17_479 0 n34 ns479 0 -0.00114452191318
Gc17_480 0 n34 ns480 0 -0.00114664308523
Gc17_481 0 n34 ns481 0 -0.000938447721319
Gc17_482 0 n34 ns482 0 0.00043888007488
Gc17_483 0 n34 ns483 0 0.00106144474173
Gc17_484 0 n34 ns484 0 -0.00496178400577
Gc17_485 0 n34 ns485 0 -0.00215963996105
Gc17_486 0 n34 ns486 0 0.000444506071759
Gc17_487 0 n34 ns487 0 0.00223970196487
Gc17_488 0 n34 ns488 0 0.00077205462866
Gc17_489 0 n34 ns489 0 -0.000554092357856
Gc17_490 0 n34 ns490 0 -0.0189719855265
Gc17_491 0 n34 ns491 0 0.0153956223959
Gc17_492 0 n34 ns492 0 -0.000528932839612
Gc17_493 0 n34 ns493 0 3.67097704369e-06
Gc17_494 0 n34 ns494 0 -6.24052254348e-06
Gc17_495 0 n34 ns495 0 0.000114429086229
Gc17_496 0 n34 ns496 0 -0.000909392844957
Gc17_497 0 n34 ns497 0 0.00255104541599
Gc17_498 0 n34 ns498 0 0.00011422788669
Gc17_499 0 n34 ns499 0 9.57204238254e-05
Gc17_500 0 n34 ns500 0 -3.01262910205e-05
Gc17_501 0 n34 ns501 0 -2.35038517869e-05
Gc17_502 0 n34 ns502 0 -2.85097920617e-05
Gc17_503 0 n34 ns503 0 1.25803693598e-05
Gc17_504 0 n34 ns504 0 0.00068031053916
Gc17_505 0 n34 ns505 0 -0.00146826358962
Gc17_506 0 n34 ns506 0 -0.000595559037674
Gc17_507 0 n34 ns507 0 0.000671364649088
Gc17_508 0 n34 ns508 0 0.000280360003152
Gc17_509 0 n34 ns509 0 0.000173172475394
Gc17_510 0 n34 ns510 0 -0.00103297387394
Gc17_511 0 n34 ns511 0 -0.000544623351821
Gc17_512 0 n34 ns512 0 0.000335415408802
Gc17_513 0 n34 ns513 0 0.00066024599104
Gc17_514 0 n34 ns514 0 0.000116448030946
Gc17_515 0 n34 ns515 0 -0.000144447150249
Gc17_516 0 n34 ns516 0 -2.49355582401e-05
Gc17_517 0 n34 ns517 0 -0.000990935592734
Gc17_518 0 n34 ns518 0 -0.0011384377981
Gc17_519 0 n34 ns519 0 -0.00017282985618
Gc17_520 0 n34 ns520 0 0.000604790324087
Gc17_521 0 n34 ns521 0 0.000482805528381
Gc17_522 0 n34 ns522 0 -0.00274813853302
Gc17_523 0 n34 ns523 0 -0.000325449603199
Gc17_524 0 n34 ns524 0 0.000625747340252
Gc17_525 0 n34 ns525 0 0.000989147949664
Gc17_526 0 n34 ns526 0 0.00027723184899
Gc17_527 0 n34 ns527 0 -0.000408307545324
Gc17_528 0 n34 ns528 0 -0.00589627652138
Gc17_529 0 n34 ns529 0 0.00459860196047
Gc17_530 0 n34 ns530 0 -0.000183028634997
Gc17_531 0 n34 ns531 0 8.18849879248e-06
Gc17_532 0 n34 ns532 0 -2.15396607815e-05
Gc17_533 0 n34 ns533 0 -5.2285333817e-05
Gc17_534 0 n34 ns534 0 3.35386499059e-05
Gc17_535 0 n34 ns535 0 -0.000889586337672
Gc17_536 0 n34 ns536 0 -0.000228820368384
Gc17_537 0 n34 ns537 0 0.000172429074783
Gc17_538 0 n34 ns538 0 5.89320540731e-05
Gc17_539 0 n34 ns539 0 0.00019800463566
Gc17_540 0 n34 ns540 0 3.6553449725e-05
Gc17_541 0 n34 ns541 0 -4.98490804487e-06
Gc17_542 0 n34 ns542 0 -0.00018058153093
Gc17_543 0 n34 ns543 0 -0.000758928178537
Gc17_544 0 n34 ns544 0 0.000177625087589
Gc17_545 0 n34 ns545 0 0.000541926318942
Gc17_546 0 n34 ns546 0 0.000163330361224
Gc17_547 0 n34 ns547 0 -9.04349726012e-05
Gc17_548 0 n34 ns548 0 -0.000243984512038
Gc17_549 0 n34 ns549 0 0.000721661406724
Gc17_550 0 n34 ns550 0 0.000523551606987
Gc17_551 0 n34 ns551 0 -0.000157511667415
Gc17_552 0 n34 ns552 0 -5.28702538454e-05
Gc17_553 0 n34 ns553 0 -0.00015823122975
Gc17_554 0 n34 ns554 0 0.000450640351046
Gc17_555 0 n34 ns555 0 -0.000376792461018
Gc17_556 0 n34 ns556 0 -0.000448858934246
Gc17_557 0 n34 ns557 0 6.20743932497e-05
Gc17_558 0 n34 ns558 0 0.000275607095474
Gc17_559 0 n34 ns559 0 7.44089873801e-05
Gc17_560 0 n34 ns560 0 6.23367162527e-05
Gc17_561 0 n34 ns561 0 0.000835291189638
Gc17_562 0 n34 ns562 0 0.000386649135867
Gc17_563 0 n34 ns563 0 -2.32453348425e-05
Gc17_564 0 n34 ns564 0 -4.05958402758e-05
Gc17_565 0 n34 ns565 0 -0.00023088036011
Gc17_566 0 n34 ns566 0 0.00857907138633
Gc17_567 0 n34 ns567 0 -0.00731423786117
Gc17_568 0 n34 ns568 0 0.000193769708626
Gc17_569 0 n34 ns569 0 6.28985592859e-06
Gc17_570 0 n34 ns570 0 -2.78477728126e-05
Gc17_571 0 n34 ns571 0 7.43202807279e-05
Gc17_572 0 n34 ns572 0 -0.000377449702472
Gc17_573 0 n34 ns573 0 -0.000643735165719
Gc17_574 0 n34 ns574 0 -6.2639755849e-05
Gc17_575 0 n34 ns575 0 -0.000107949839387
Gc17_576 0 n34 ns576 0 -6.05401528557e-05
Gc17_577 0 n34 ns577 0 4.70355282851e-05
Gc17_578 0 n34 ns578 0 2.74998577084e-05
Gc17_579 0 n34 ns579 0 -8.81135241295e-06
Gc17_580 0 n34 ns580 0 -0.000396288802637
Gc17_581 0 n34 ns581 0 0.000733680764695
Gc17_582 0 n34 ns582 0 0.000264894123267
Gc17_583 0 n34 ns583 0 -0.000209835988417
Gc17_584 0 n34 ns584 0 -7.56378042673e-05
Gc17_585 0 n34 ns585 0 -0.000118489826726
Gc17_586 0 n34 ns586 0 0.000291132889639
Gc17_587 0 n34 ns587 0 0.000639306732786
Gc17_588 0 n34 ns588 0 0.000196054823792
Gc17_589 0 n34 ns589 0 -0.000324945864635
Gc17_590 0 n34 ns590 0 -7.78515552259e-05
Gc17_591 0 n34 ns591 0 -5.4738034327e-05
Gc17_592 0 n34 ns592 0 0.000212140521579
Gc17_593 0 n34 ns593 0 7.404617672e-05
Gc17_594 0 n34 ns594 0 -6.9114093722e-06
Gc17_595 0 n34 ns595 0 0.000136782697206
Gc17_596 0 n34 ns596 0 6.07496252586e-05
Gc17_597 0 n34 ns597 0 -9.84164697012e-05
Gc17_598 0 n34 ns598 0 0.000648063747073
Gc17_599 0 n34 ns599 0 0.00105367409286
Gc17_600 0 n34 ns600 0 0.000274824362414
Gc17_601 0 n34 ns601 0 -0.000261555505947
Gc17_602 0 n34 ns602 0 -0.00010923571207
Gc17_603 0 n34 ns603 0 -0.000143970744764
Gc17_604 0 n34 ns604 0 0.00965367627474
Gc17_605 0 n34 ns605 0 -0.00814271561118
Gc17_606 0 n34 ns606 0 0.000213427011177
Gc17_607 0 n34 ns607 0 6.71679050167e-06
Gc17_608 0 n34 ns608 0 -2.61977590246e-05
Gc17_609 0 n34 ns609 0 -0.00508243945284
Gc17_610 0 n34 ns610 0 -0.00261358541744
Gc17_611 0 n34 ns611 0 -0.00404095220538
Gc17_612 0 n34 ns612 0 6.61945903788e-05
Gc17_613 0 n34 ns613 0 -0.000640730664752
Gc17_614 0 n34 ns614 0 -0.000130214549159
Gc17_615 0 n34 ns615 0 0.000153387150252
Gc17_616 0 n34 ns616 0 -0.000168211270611
Gc17_617 0 n34 ns617 0 -0.000133012200894
Gc17_618 0 n34 ns618 0 -0.00178021674419
Gc17_619 0 n34 ns619 0 0.00180155660588
Gc17_620 0 n34 ns620 0 0.000969673094062
Gc17_621 0 n34 ns621 0 0.000124831587808
Gc17_622 0 n34 ns622 0 0.000267906698802
Gc17_623 0 n34 ns623 0 -0.000150871679283
Gc17_624 0 n34 ns624 0 0.00180676391878
Gc17_625 0 n34 ns625 0 0.000852933464939
Gc17_626 0 n34 ns626 0 0.000558236535416
Gc17_627 0 n34 ns627 0 0.000159407393801
Gc17_628 0 n34 ns628 0 0.000185251193678
Gc17_629 0 n34 ns629 0 0.000170038996053
Gc17_630 0 n34 ns630 0 0.0014754702724
Gc17_631 0 n34 ns631 0 -0.00190886857129
Gc17_632 0 n34 ns632 0 0.00105887722287
Gc17_633 0 n34 ns633 0 0.00246677000161
Gc17_634 0 n34 ns634 0 0.00125701777775
Gc17_635 0 n34 ns635 0 -0.00119945107923
Gc17_636 0 n34 ns636 0 -0.000274355617525
Gc17_637 0 n34 ns637 0 -0.0035046491145
Gc17_638 0 n34 ns638 0 0.00377006773519
Gc17_639 0 n34 ns639 0 0.000723099884027
Gc17_640 0 n34 ns640 0 0.00220288294223
Gc17_641 0 n34 ns641 0 0.000230913132871
Gc17_642 0 n34 ns642 0 -0.0598113007866
Gc17_643 0 n34 ns643 0 0.0606921465415
Gc17_644 0 n34 ns644 0 0.0048805843126
Gc17_645 0 n34 ns645 0 6.3489096408e-06
Gc17_646 0 n34 ns646 0 2.81840778997e-05
Gc17_647 0 n34 ns647 0 -0.005709501441
Gc17_648 0 n34 ns648 0 -0.00338269362659
Gc17_649 0 n34 ns649 0 -0.0038721733249
Gc17_650 0 n34 ns650 0 0.000384964550152
Gc17_651 0 n34 ns651 0 -0.00151765283301
Gc17_652 0 n34 ns652 0 -0.000770350831919
Gc17_653 0 n34 ns653 0 0.000738710312133
Gc17_654 0 n34 ns654 0 -2.97197571434e-05
Gc17_655 0 n34 ns655 0 -6.18414609789e-05
Gc17_656 0 n34 ns656 0 -0.000412261861966
Gc17_657 0 n34 ns657 0 0.00266646286237
Gc17_658 0 n34 ns658 0 0.000575877413228
Gc17_659 0 n34 ns659 0 -0.000283507631036
Gc17_660 0 n34 ns660 0 0.000189317203344
Gc17_661 0 n34 ns661 0 -0.000101824514151
Gc17_662 0 n34 ns662 0 0.00153341825271
Gc17_663 0 n34 ns663 0 0.000778443071554
Gc17_664 0 n34 ns664 0 0.000750119713321
Gc17_665 0 n34 ns665 0 -9.10003140366e-05
Gc17_666 0 n34 ns666 0 0.000177752362559
Gc17_667 0 n34 ns667 0 0.000133672775067
Gc17_668 0 n34 ns668 0 0.00125731503506
Gc17_669 0 n34 ns669 0 -0.00113617301025
Gc17_670 0 n34 ns670 0 0.00113433100584
Gc17_671 0 n34 ns671 0 0.00202865099633
Gc17_672 0 n34 ns672 0 0.00119604270061
Gc17_673 0 n34 ns673 0 -0.00113632425029
Gc17_674 0 n34 ns674 0 0.000922842584584
Gc17_675 0 n34 ns675 0 -0.00194086360824
Gc17_676 0 n34 ns676 0 0.00314164874904
Gc17_677 0 n34 ns677 0 -0.000140555119326
Gc17_678 0 n34 ns678 0 0.00217597576595
Gc17_679 0 n34 ns679 0 0.000419060140124
Gc17_680 0 n34 ns680 0 -0.0408923261826
Gc17_681 0 n34 ns681 0 0.04220584991
Gc17_682 0 n34 ns682 0 0.00599255766662
Gc17_683 0 n34 ns683 0 -4.81472940432e-06
Gc17_684 0 n34 ns684 0 2.19413882856e-05
Gc17_685 0 n34 ns685 0 -0.00159532565282
Gc17_686 0 n34 ns686 0 -0.00163052504596
Gc17_687 0 n34 ns687 0 0.00478510694109
Gc17_688 0 n34 ns688 0 0.00105202216546
Gc17_689 0 n34 ns689 0 -0.000411814475157
Gc17_690 0 n34 ns690 0 0.000841981298915
Gc17_691 0 n34 ns691 0 0.000535852003243
Gc17_692 0 n34 ns692 0 -0.000136197801492
Gc17_693 0 n34 ns693 0 -4.81295126746e-05
Gc17_694 0 n34 ns694 0 -0.00141251013443
Gc17_695 0 n34 ns695 0 -0.00206830564078
Gc17_696 0 n34 ns696 0 0.000837170949308
Gc17_697 0 n34 ns697 0 -0.000310097893779
Gc17_698 0 n34 ns698 0 0.000346242091002
Gc17_699 0 n34 ns699 0 -0.000225691575527
Gc17_700 0 n34 ns700 0 -0.00235082767555
Gc17_701 0 n34 ns701 0 -0.00234894083424
Gc17_702 0 n34 ns702 0 -4.38956102216e-05
Gc17_703 0 n34 ns703 0 0.000171112759913
Gc17_704 0 n34 ns704 0 0.000222972370302
Gc17_705 0 n34 ns705 0 0.000331672980672
Gc17_706 0 n34 ns706 0 -0.00505245493146
Gc17_707 0 n34 ns707 0 0.00181452064533
Gc17_708 0 n34 ns708 0 0.000472053801478
Gc17_709 0 n34 ns709 0 0.000414936421408
Gc17_710 0 n34 ns710 0 0.000842765469712
Gc17_711 0 n34 ns711 0 -0.000817213848058
Gc17_712 0 n34 ns712 0 -0.00258548435614
Gc17_713 0 n34 ns713 0 0.0026426254344
Gc17_714 0 n34 ns714 0 -0.00187131643294
Gc17_715 0 n34 ns715 0 -0.000758875362497
Gc17_716 0 n34 ns716 0 0.00176486645314
Gc17_717 0 n34 ns717 0 0.000530601227688
Gc17_718 0 n34 ns718 0 0.0298787848462
Gc17_719 0 n34 ns719 0 -0.0345822968641
Gc17_720 0 n34 ns720 0 0.00428903871418
Gc17_721 0 n34 ns721 0 2.56260133162e-06
Gc17_722 0 n34 ns722 0 2.87601947427e-05
Gc17_723 0 n34 ns723 0 -0.00117571712011
Gc17_724 0 n34 ns724 0 0.00251234664601
Gc17_725 0 n34 ns725 0 -0.00398552893629
Gc17_726 0 n34 ns726 0 0.000222406167723
Gc17_727 0 n34 ns727 0 -0.000503098210333
Gc17_728 0 n34 ns728 0 7.59821424122e-05
Gc17_729 0 n34 ns729 0 -0.000536175125929
Gc17_730 0 n34 ns730 0 -3.34151148302e-05
Gc17_731 0 n34 ns731 0 -7.22289824102e-06
Gc17_732 0 n34 ns732 0 -0.00158720388268
Gc17_733 0 n34 ns733 0 0.00168766299947
Gc17_734 0 n34 ns734 0 -0.000365311030666
Gc17_735 0 n34 ns735 0 -0.000448066219308
Gc17_736 0 n34 ns736 0 0.000149595522934
Gc17_737 0 n34 ns737 0 -0.000237588839396
Gc17_738 0 n34 ns738 0 -0.000156369359712
Gc17_739 0 n34 ns739 0 0.00268130696031
Gc17_740 0 n34 ns740 0 0.000132333091171
Gc17_741 0 n34 ns741 0 -0.000882043079319
Gc17_742 0 n34 ns742 0 0.000209312961413
Gc17_743 0 n34 ns743 0 1.03163663171e-05
Gc17_744 0 n34 ns744 0 0.00235615724963
Gc17_745 0 n34 ns745 0 0.00234472321046
Gc17_746 0 n34 ns746 0 -0.000514274599124
Gc17_747 0 n34 ns747 0 7.55359852544e-06
Gc17_748 0 n34 ns748 0 0.000465177713032
Gc17_749 0 n34 ns749 0 -0.000647036477917
Gc17_750 0 n34 ns750 0 0.00358468082139
Gc17_751 0 n34 ns751 0 0.000269415511313
Gc17_752 0 n34 ns752 0 -0.00189281683411
Gc17_753 0 n34 ns753 0 0.000672064342483
Gc17_754 0 n34 ns754 0 0.00113506106808
Gc17_755 0 n34 ns755 0 -0.000210603903492
Gc17_756 0 n34 ns756 0 0.0366407653956
Gc17_757 0 n34 ns757 0 -0.0335832890179
Gc17_758 0 n34 ns758 0 0.00190272727079
Gc17_759 0 n34 ns759 0 -6.36518441732e-06
Gc17_760 0 n34 ns760 0 1.80548642383e-05
Gc17_761 0 n34 ns761 0 -0.000862700154775
Gc17_762 0 n34 ns762 0 0.0017837107653
Gc17_763 0 n34 ns763 0 -0.00172757101566
Gc17_764 0 n34 ns764 0 -9.13453095789e-05
Gc17_765 0 n34 ns765 0 -0.000131629250558
Gc17_766 0 n34 ns766 0 -0.000324770671874
Gc17_767 0 n34 ns767 0 3.85479567808e-05
Gc17_768 0 n34 ns768 0 -4.06094247644e-05
Gc17_769 0 n34 ns769 0 1.1522857411e-05
Gc17_770 0 n34 ns770 0 0.000621069328689
Gc17_771 0 n34 ns771 0 0.000654475458493
Gc17_772 0 n34 ns772 0 -9.08331638504e-05
Gc17_773 0 n34 ns773 0 0.000516085625609
Gc17_774 0 n34 ns774 0 4.39755823595e-05
Gc17_775 0 n34 ns775 0 -0.00028216714012
Gc17_776 0 n34 ns776 0 0.00170221765062
Gc17_777 0 n34 ns777 0 -0.0005155275338
Gc17_778 0 n34 ns778 0 -0.00107041717152
Gc17_779 0 n34 ns779 0 -7.23522955296e-06
Gc17_780 0 n34 ns780 0 0.000158279906615
Gc17_781 0 n34 ns781 0 6.32138956052e-05
Gc17_782 0 n34 ns782 0 -7.43676221694e-06
Gc17_783 0 n34 ns783 0 -0.00110930503581
Gc17_784 0 n34 ns784 0 -0.000307463406618
Gc17_785 0 n34 ns785 0 0.00136130378584
Gc17_786 0 n34 ns786 0 0.000360493114608
Gc17_787 0 n34 ns787 0 -0.000920438001477
Gc17_788 0 n34 ns788 0 -0.00109775504278
Gc17_789 0 n34 ns789 0 -0.00098833464904
Gc17_790 0 n34 ns790 0 -9.83115955683e-05
Gc17_791 0 n34 ns791 0 0.0016479243999
Gc17_792 0 n34 ns792 0 0.000754259032641
Gc17_793 0 n34 ns793 0 -0.000585860386171
Gc17_794 0 n34 ns794 0 0.0117669885457
Gc17_795 0 n34 ns795 0 -0.0115224753001
Gc17_796 0 n34 ns796 0 0.000749084382072
Gc17_797 0 n34 ns797 0 -1.01178169782e-05
Gc17_798 0 n34 ns798 0 3.56708944834e-06
Gc17_799 0 n34 ns799 0 0.0002035446405
Gc17_800 0 n34 ns800 0 -0.00041985868205
Gc17_801 0 n34 ns801 0 0.00274709671331
Gc17_802 0 n34 ns802 0 0.000156924514674
Gc17_803 0 n34 ns803 0 0.000132183072721
Gc17_804 0 n34 ns804 0 8.65404244542e-05
Gc17_805 0 n34 ns805 0 5.5945826651e-05
Gc17_806 0 n34 ns806 0 2.70291067229e-05
Gc17_807 0 n34 ns807 0 2.42989675469e-05
Gc17_808 0 n34 ns808 0 -0.000727124258884
Gc17_809 0 n34 ns809 0 -0.000994273681133
Gc17_810 0 n34 ns810 0 0.000744663996961
Gc17_811 0 n34 ns811 0 0.000292223898355
Gc17_812 0 n34 ns812 0 -8.97532568762e-05
Gc17_813 0 n34 ns813 0 -0.000203898144592
Gc17_814 0 n34 ns814 0 -0.000877303746433
Gc17_815 0 n34 ns815 0 -0.00155991799383
Gc17_816 0 n34 ns816 0 -0.000311918086556
Gc17_817 0 n34 ns817 0 0.00108769230227
Gc17_818 0 n34 ns818 0 0.000220537898381
Gc17_819 0 n34 ns819 0 -6.63192084127e-06
Gc17_820 0 n34 ns820 0 -0.00186375494834
Gc17_821 0 n34 ns821 0 0.000418740124352
Gc17_822 0 n34 ns822 0 0.000824494968736
Gc17_823 0 n34 ns823 0 0.00109624524551
Gc17_824 0 n34 ns824 0 -0.000213241880751
Gc17_825 0 n34 ns825 0 -0.000830485156158
Gc17_826 0 n34 ns826 0 -0.00222930148809
Gc17_827 0 n34 ns827 0 0.000716694500652
Gc17_828 0 n34 ns828 0 0.000762573443574
Gc17_829 0 n34 ns829 0 0.00105601701396
Gc17_830 0 n34 ns830 0 0.000356236967229
Gc17_831 0 n34 ns831 0 -0.000602937295466
Gc17_832 0 n34 ns832 0 0.0046989619809
Gc17_833 0 n34 ns833 0 -0.00526551716326
Gc17_834 0 n34 ns834 0 0.000390730966005
Gc17_835 0 n34 ns835 0 -7.9887165743e-06
Gc17_836 0 n34 ns836 0 -1.75181163564e-05
Gc17_837 0 n34 ns837 0 0.000164330297884
Gc17_838 0 n34 ns838 0 -0.000731052612783
Gc17_839 0 n34 ns839 0 0.000367726478695
Gc17_840 0 n34 ns840 0 9.23029651013e-05
Gc17_841 0 n34 ns841 0 -0.000113269912137
Gc17_842 0 n34 ns842 0 9.0583393475e-05
Gc17_843 0 n34 ns843 0 2.74242893985e-06
Gc17_844 0 n34 ns844 0 1.40476896202e-05
Gc17_845 0 n34 ns845 0 -5.54154659089e-05
Gc17_846 0 n34 ns846 0 -0.000919907845253
Gc17_847 0 n34 ns847 0 0.000473287537678
Gc17_848 0 n34 ns848 0 0.000394953863767
Gc17_849 0 n34 ns849 0 -0.000437852316773
Gc17_850 0 n34 ns850 0 -0.000143783811839
Gc17_851 0 n34 ns851 0 -3.9140964174e-05
Gc17_852 0 n34 ns852 0 -0.0009274721368
Gc17_853 0 n34 ns853 0 0.000457922810662
Gc17_854 0 n34 ns854 0 0.000592796026061
Gc17_855 0 n34 ns855 0 0.000325157611123
Gc17_856 0 n34 ns856 0 6.57856335098e-05
Gc17_857 0 n34 ns857 0 -0.000157012024474
Gc17_858 0 n34 ns858 0 0.000360362202575
Gc17_859 0 n34 ns859 0 0.00116590515241
Gc17_860 0 n34 ns860 0 0.000805100278136
Gc17_861 0 n34 ns861 0 -0.000241814362858
Gc17_862 0 n34 ns862 0 -0.000538183298357
Gc17_863 0 n34 ns863 0 -0.000142238651284
Gc17_864 0 n34 ns864 0 0.000477964139385
Gc17_865 0 n34 ns865 0 0.000711476228876
Gc17_866 0 n34 ns866 0 0.000299469376059
Gc17_867 0 n34 ns867 0 8.5575509543e-05
Gc17_868 0 n34 ns868 0 6.94701210719e-08
Gc17_869 0 n34 ns869 0 -0.000262585766964
Gc17_870 0 n34 ns870 0 0.00957402872846
Gc17_871 0 n34 ns871 0 -0.0083882414359
Gc17_872 0 n34 ns872 0 0.000334680898709
Gc17_873 0 n34 ns873 0 -7.50908090698e-06
Gc17_874 0 n34 ns874 0 -2.71749475732e-05
Gc17_875 0 n34 ns875 0 -0.0001356136209
Gc17_876 0 n34 ns876 0 0.000335605351606
Gc17_877 0 n34 ns877 0 -0.00264189356845
Gc17_878 0 n34 ns878 0 -0.000207551087444
Gc17_879 0 n34 ns879 0 -0.000127184998198
Gc17_880 0 n34 ns880 0 -0.000137031176225
Gc17_881 0 n34 ns881 0 2.1075616864e-05
Gc17_882 0 n34 ns882 0 -7.92572758971e-06
Gc17_883 0 n34 ns883 0 1.04948365434e-05
Gc17_884 0 n34 ns884 0 0.000679546167359
Gc17_885 0 n34 ns885 0 0.00103882975253
Gc17_886 0 n34 ns886 0 -0.000377764764558
Gc17_887 0 n34 ns887 0 -0.000344767151924
Gc17_888 0 n34 ns888 0 -8.33846081344e-05
Gc17_889 0 n34 ns889 0 0.000102377898896
Gc17_890 0 n34 ns890 0 0.000221171616829
Gc17_891 0 n34 ns891 0 0.000815259029227
Gc17_892 0 n34 ns892 0 0.000367039252773
Gc17_893 0 n34 ns893 0 -0.00030627504991
Gc17_894 0 n34 ns894 0 -6.43484822522e-05
Gc17_895 0 n34 ns895 0 -0.000102492506982
Gc17_896 0 n34 ns896 0 0.00118515881973
Gc17_897 0 n34 ns897 0 0.000480035621168
Gc17_898 0 n34 ns898 0 0.00029506675427
Gc17_899 0 n34 ns899 0 -0.00055196235757
Gc17_900 0 n34 ns900 0 -0.000348253753199
Gc17_901 0 n34 ns901 0 0.00016546102916
Gc17_902 0 n34 ns902 0 0.00137732441487
Gc17_903 0 n34 ns903 0 0.000659107661519
Gc17_904 0 n34 ns904 0 0.000172022357191
Gc17_905 0 n34 ns905 0 -0.000261969879098
Gc17_906 0 n34 ns906 0 -0.000115547082141
Gc17_907 0 n34 ns907 0 -0.00015148036107
Gc17_908 0 n34 ns908 0 0.0142342859086
Gc17_909 0 n34 ns909 0 -0.0120297070585
Gc17_910 0 n34 ns910 0 0.000415942646946
Gc17_911 0 n34 ns911 0 -7.44147543871e-06
Gc17_912 0 n34 ns912 0 -2.50410298731e-05
Gc17_913 0 n34 ns913 0 -0.000150393667422
Gc17_914 0 n34 ns914 0 0.000167409490285
Gc17_915 0 n34 ns915 0 -0.000963317821386
Gc17_916 0 n34 ns916 0 -0.00021290786083
Gc17_917 0 n34 ns917 0 0.000161812939758
Gc17_918 0 n34 ns918 0 2.30041386663e-06
Gc17_919 0 n34 ns919 0 8.7061109498e-05
Gc17_920 0 n34 ns920 0 3.67644099313e-06
Gc17_921 0 n34 ns921 0 1.2254390807e-05
Gc17_922 0 n34 ns922 0 0.000822884854192
Gc17_923 0 n34 ns923 0 -0.00010228819376
Gc17_924 0 n34 ns924 0 -0.00029460405088
Gc17_925 0 n34 ns925 0 0.000116220213123
Gc17_926 0 n34 ns926 0 2.22715484259e-05
Gc17_927 0 n34 ns927 0 7.82537208911e-05
Gc17_928 0 n34 ns928 0 0.000384385322555
Gc17_929 0 n34 ns929 0 2.76110837002e-05
Gc17_930 0 n34 ns930 0 -6.31040232759e-05
Gc17_931 0 n34 ns931 0 -0.000196335137821
Gc17_932 0 n34 ns932 0 -5.5604647492e-05
Gc17_933 0 n34 ns933 0 8.18467436147e-06
Gc17_934 0 n34 ns934 0 0.000344925791324
Gc17_935 0 n34 ns935 0 -0.000315359394682
Gc17_936 0 n34 ns936 0 -0.000109935284338
Gc17_937 0 n34 ns937 0 -0.000208378215604
Gc17_938 0 n34 ns938 0 -3.10155789818e-05
Gc17_939 0 n34 ns939 0 0.000151094212264
Gc17_940 0 n34 ns940 0 -0.000103723297352
Gc17_941 0 n34 ns941 0 -0.000171704929463
Gc17_942 0 n34 ns942 0 0.00010915124067
Gc17_943 0 n34 ns943 0 0.000139045163383
Gc17_944 0 n34 ns944 0 2.92256769599e-05
Gc17_945 0 n34 ns945 0 -8.72307942366e-05
Gc17_946 0 n34 ns946 0 0.00231501654722
Gc17_947 0 n34 ns947 0 -0.00199086695924
Gc17_948 0 n34 ns948 0 9.12831734757e-05
Gc17_949 0 n34 ns949 0 -7.75828763695e-06
Gc17_950 0 n34 ns950 0 -1.90755267251e-05
Gc17_951 0 n34 ns951 0 -0.00187163261245
Gc17_952 0 n34 ns952 0 -0.00309558769548
Gc17_953 0 n34 ns953 0 0.00642350502814
Gc17_954 0 n34 ns954 0 0.000710638742309
Gc17_955 0 n34 ns955 0 -0.000334629800677
Gc17_956 0 n34 ns956 0 0.000640514153361
Gc17_957 0 n34 ns957 0 0.000775101945992
Gc17_958 0 n34 ns958 0 -0.00015772940978
Gc17_959 0 n34 ns959 0 -9.10644263947e-05
Gc17_960 0 n34 ns960 0 -0.000839695189439
Gc17_961 0 n34 ns961 0 -0.0018627544018
Gc17_962 0 n34 ns962 0 0.00114713492596
Gc17_963 0 n34 ns963 0 5.81232094964e-05
Gc17_964 0 n34 ns964 0 0.000414234585831
Gc17_965 0 n34 ns965 0 -0.000179057531034
Gc17_966 0 n34 ns966 0 -0.000722978285216
Gc17_967 0 n34 ns967 0 -0.00327738366777
Gc17_968 0 n34 ns968 0 -0.000105088383511
Gc17_969 0 n34 ns969 0 0.000185777047073
Gc17_970 0 n34 ns970 0 0.000164016179943
Gc17_971 0 n34 ns971 0 0.000370175543524
Gc17_972 0 n34 ns972 0 -0.00570934525144
Gc17_973 0 n34 ns973 0 -0.00140704578441
Gc17_974 0 n34 ns974 0 0.000671861055686
Gc17_975 0 n34 ns975 0 0.000859446790616
Gc17_976 0 n34 ns976 0 0.00102244455211
Gc17_977 0 n34 ns977 0 -0.000850724227217
Gc17_978 0 n34 ns978 0 -0.00657762613723
Gc17_979 0 n34 ns979 0 -0.000287286599982
Gc17_980 0 n34 ns980 0 -0.0010069073397
Gc17_981 0 n34 ns981 0 -0.000576692059756
Gc17_982 0 n34 ns982 0 0.00203504509334
Gc17_983 0 n34 ns983 0 0.00078972421427
Gc17_984 0 n34 ns984 0 0.00419284843352
Gc17_985 0 n34 ns985 0 -0.0140126469719
Gc17_986 0 n34 ns986 0 0.00513610453702
Gc17_987 0 n34 ns987 0 1.61612830564e-06
Gc17_988 0 n34 ns988 0 3.03518799816e-05
Gc17_989 0 n34 ns989 0 -0.00118301530787
Gc17_990 0 n34 ns990 0 0.000756433403662
Gc17_991 0 n34 ns991 0 -0.000961878072863
Gc17_992 0 n34 ns992 0 0.000748147325396
Gc17_993 0 n34 ns993 0 -0.000683610174984
Gc17_994 0 n34 ns994 0 0.000507367536004
Gc17_995 0 n34 ns995 0 -0.000375878944639
Gc17_996 0 n34 ns996 0 -5.65335078449e-05
Gc17_997 0 n34 ns997 0 -1.23371787777e-05
Gc17_998 0 n34 ns998 0 -0.00277463060327
Gc17_999 0 n34 ns999 0 0.000391302883547
Gc17_1000 0 n34 ns1000 0 0.000116397976973
Gc17_1001 0 n34 ns1001 0 -0.000664510533619
Gc17_1002 0 n34 ns1002 0 0.000252178494731
Gc17_1003 0 n34 ns1003 0 -0.000247644639243
Gc17_1004 0 n34 ns1004 0 -0.00207884259463
Gc17_1005 0 n34 ns1005 0 0.00203363469128
Gc17_1006 0 n34 ns1006 0 0.000514290528955
Gc17_1007 0 n34 ns1007 0 -0.000528954771945
Gc17_1008 0 n34 ns1008 0 0.00029058003275
Gc17_1009 0 n34 ns1009 0 8.96353964258e-05
Gc17_1010 0 n34 ns1010 0 0.000661199936673
Gc17_1011 0 n34 ns1011 0 0.00386710392437
Gc17_1012 0 n34 ns1012 0 -0.000102996787744
Gc17_1013 0 n34 ns1013 0 -0.000231246990463
Gc17_1014 0 n34 ns1014 0 0.000490025293442
Gc17_1015 0 n34 ns1015 0 -0.000678587335521
Gc17_1016 0 n34 ns1016 0 0.00315782478137
Gc17_1017 0 n34 ns1017 0 0.00187082963243
Gc17_1018 0 n34 ns1018 0 -0.00213008091103
Gc17_1019 0 n34 ns1019 0 5.30627442658e-05
Gc17_1020 0 n34 ns1020 0 0.00131955741796
Gc17_1021 0 n34 ns1021 0 -3.72627092794e-05
Gc17_1022 0 n34 ns1022 0 0.0411385427481
Gc17_1023 0 n34 ns1023 0 -0.0390389834808
Gc17_1024 0 n34 ns1024 0 0.00260638831627
Gc17_1025 0 n34 ns1025 0 -2.41586330181e-06
Gc17_1026 0 n34 ns1026 0 2.26302317813e-05
Gc17_1027 0 n34 ns1027 0 -0.00127280505652
Gc17_1028 0 n34 ns1028 0 0.00272728060199
Gc17_1029 0 n34 ns1029 0 -0.00445018958666
Gc17_1030 0 n34 ns1030 0 -0.000194310254447
Gc17_1031 0 n34 ns1031 0 -0.000366457247691
Gc17_1032 0 n34 ns1032 0 -0.000455420516757
Gc17_1033 0 n34 ns1033 0 -0.000118303497049
Gc17_1034 0 n34 ns1034 0 -2.81497315384e-05
Gc17_1035 0 n34 ns1035 0 2.26209880906e-06
Gc17_1036 0 n34 ns1036 0 0.000751813887164
Gc17_1037 0 n34 ns1037 0 0.00194944828905
Gc17_1038 0 n34 ns1038 0 -0.000593692516341
Gc17_1039 0 n34 ns1039 0 0.000161605537123
Gc17_1040 0 n34 ns1040 0 6.33538538163e-05
Gc17_1041 0 n34 ns1041 0 -0.000247413567159
Gc17_1042 0 n34 ns1042 0 0.00221257544634
Gc17_1043 0 n34 ns1043 0 0.00101026371916
Gc17_1044 0 n34 ns1044 0 -0.000871500386732
Gc17_1045 0 n34 ns1045 0 -0.000728238023486
Gc17_1046 0 n34 ns1046 0 0.000121606631998
Gc17_1047 0 n34 ns1047 0 2.61762213536e-05
Gc17_1048 0 n34 ns1048 0 0.00164293457177
Gc17_1049 0 n34 ns1049 0 -0.000699300142507
Gc17_1050 0 n34 ns1050 0 -0.000667642449297
Gc17_1051 0 n34 ns1051 0 0.000954372318413
Gc17_1052 0 n34 ns1052 0 0.000472280873426
Gc17_1053 0 n34 ns1053 0 -0.000817599545349
Gc17_1054 0 n34 ns1054 0 0.00091469769017
Gc17_1055 0 n34 ns1055 0 -0.00108700863842
Gc17_1056 0 n34 ns1056 0 -0.000725736669224
Gc17_1057 0 n34 ns1057 0 0.00144858981008
Gc17_1058 0 n34 ns1058 0 0.000870315205542
Gc17_1059 0 n34 ns1059 0 -0.000506034486188
Gc17_1060 0 n34 ns1060 0 0.0225841572884
Gc17_1061 0 n34 ns1061 0 -0.0207018875232
Gc17_1062 0 n34 ns1062 0 0.00113040259502
Gc17_1063 0 n34 ns1063 0 -9.9028584361e-06
Gc17_1064 0 n34 ns1064 0 1.38732524368e-05
Gc17_1065 0 n34 ns1065 0 -0.000141665797114
Gc17_1066 0 n34 ns1066 0 -0.000259022097226
Gc17_1067 0 n34 ns1067 0 0.0025778115901
Gc17_1068 0 n34 ns1068 0 7.6320566704e-05
Gc17_1069 0 n34 ns1069 0 3.00742664579e-05
Gc17_1070 0 n34 ns1070 0 -7.17528891467e-05
Gc17_1071 0 n34 ns1071 0 0.00018048949098
Gc17_1072 0 n34 ns1072 0 1.69042968824e-05
Gc17_1073 0 n34 ns1073 0 3.15871003146e-05
Gc17_1074 0 n34 ns1074 0 -0.000117591918811
Gc17_1075 0 n34 ns1075 0 -0.00106312039071
Gc17_1076 0 n34 ns1076 0 0.000541680756237
Gc17_1077 0 n34 ns1077 0 0.00067277768112
Gc17_1078 0 n34 ns1078 0 9.22675643544e-07
Gc17_1079 0 n34 ns1079 0 -0.000257911198392
Gc17_1080 0 n34 ns1080 0 -0.00010933172322
Gc17_1081 0 n34 ns1081 0 -0.00185370554679
Gc17_1082 0 n34 ns1082 0 -0.00078157076401
Gc17_1083 0 n34 ns1083 0 0.000993824239305
Gc17_1084 0 n34 ns1084 0 0.000242474184564
Gc17_1085 0 n34 ns1085 0 5.90958808131e-05
Gc17_1086 0 n34 ns1086 0 -0.00181191275222
Gc17_1087 0 n34 ns1087 0 -0.000220891556022
Gc17_1088 0 n34 ns1088 0 0.000532147066537
Gc17_1089 0 n34 ns1089 0 0.00136839094868
Gc17_1090 0 n34 ns1090 0 -3.02198014621e-05
Gc17_1091 0 n34 ns1091 0 -0.000943286630391
Gc17_1092 0 n34 ns1092 0 -0.00249421250522
Gc17_1093 0 n34 ns1093 0 -0.000146038080023
Gc17_1094 0 n34 ns1094 0 0.00048190525218
Gc17_1095 0 n34 ns1095 0 0.00137589199652
Gc17_1096 0 n34 ns1096 0 0.000505018755899
Gc17_1097 0 n34 ns1097 0 -0.00056370055427
Gc17_1098 0 n34 ns1098 0 0.00105990538813
Gc17_1099 0 n34 ns1099 0 -0.00230712689135
Gc17_1100 0 n34 ns1100 0 0.000350342704786
Gc17_1101 0 n34 ns1101 0 -7.72765200871e-06
Gc17_1102 0 n34 ns1102 0 -7.55339412256e-06
Gc17_1103 0 n34 ns1103 0 0.000399518708909
Gc17_1104 0 n34 ns1104 0 -0.00124912636166
Gc17_1105 0 n34 ns1105 0 0.00222013794848
Gc17_1106 0 n34 ns1106 0 0.000187631720193
Gc17_1107 0 n34 ns1107 0 -0.000128552784503
Gc17_1108 0 n34 ns1108 0 0.000104435294155
Gc17_1109 0 n34 ns1109 0 1.72659467161e-05
Gc17_1110 0 n34 ns1110 0 3.38840977223e-05
Gc17_1111 0 n34 ns1111 0 -3.71014698106e-05
Gc17_1112 0 n34 ns1112 0 -0.00138307302221
Gc17_1113 0 n34 ns1113 0 -6.57304833228e-05
Gc17_1114 0 n34 ns1114 0 0.000720328296442
Gc17_1115 0 n34 ns1115 0 -0.000250784438059
Gc17_1116 0 n34 ns1116 0 -0.000139637615162
Gc17_1117 0 n34 ns1117 0 -0.000128765149162
Gc17_1118 0 n34 ns1118 0 -0.00135595122597
Gc17_1119 0 n34 ns1119 0 -0.00014933881787
Gc17_1120 0 n34 ns1120 0 0.000459442335907
Gc17_1121 0 n34 ns1121 0 0.000745743676368
Gc17_1122 0 n34 ns1122 0 0.000154608222375
Gc17_1123 0 n34 ns1123 0 -0.000135041788164
Gc17_1124 0 n34 ns1124 0 -0.000442989369755
Gc17_1125 0 n34 ns1125 0 0.00129008403118
Gc17_1126 0 n34 ns1126 0 0.000973206442021
Gc17_1127 0 n34 ns1127 0 0.000135592239475
Gc17_1128 0 n34 ns1128 0 -0.000524119524564
Gc17_1129 0 n34 ns1129 0 -0.000376884356894
Gc17_1130 0 n34 ns1130 0 -0.000438760269314
Gc17_1131 0 n34 ns1131 0 0.000800544714893
Gc17_1132 0 n34 ns1132 0 0.000452394657289
Gc17_1133 0 n34 ns1133 0 0.000363328463807
Gc17_1134 0 n34 ns1134 0 9.43851459963e-05
Gc17_1135 0 n34 ns1135 0 -0.000355377131951
Gc17_1136 0 n34 ns1136 0 0.0065381149563
Gc17_1137 0 n34 ns1137 0 -0.00616741110564
Gc17_1138 0 n34 ns1138 0 0.000315761690936
Gc17_1139 0 n34 ns1139 0 -7.36842305963e-06
Gc17_1140 0 n34 ns1140 0 -2.38642369147e-05
Gc17_1141 0 n34 ns1141 0 -4.20499630387e-06
Gc17_1142 0 n34 ns1142 0 -0.000132531167714
Gc17_1143 0 n34 ns1143 0 -0.00141357905953
Gc17_1144 0 n34 ns1144 0 -0.000114424341963
Gc17_1145 0 n34 ns1145 0 -0.000107908578764
Gc17_1146 0 n34 ns1146 0 -2.64191125869e-05
Gc17_1147 0 n34 ns1147 0 -3.36059666652e-05
Gc17_1148 0 n34 ns1148 0 -1.57224395582e-05
Gc17_1149 0 n34 ns1149 0 -1.98935536507e-05
Gc17_1150 0 n34 ns1150 0 5.87407886154e-05
Gc17_1151 0 n34 ns1151 0 0.0010674214944
Gc17_1152 0 n34 ns1152 0 -0.000120088031254
Gc17_1153 0 n34 ns1153 0 -0.000496069457054
Gc17_1154 0 n34 ns1154 0 -0.000127333880059
Gc17_1155 0 n34 ns1155 0 6.00984054326e-05
Gc17_1156 0 n34 ns1156 0 -0.000136226079352
Gc17_1157 0 n34 ns1157 0 0.000860922467645
Gc17_1158 0 n34 ns1158 0 0.000514911555392
Gc17_1159 0 n34 ns1159 0 -0.000166369285664
Gc17_1160 0 n34 ns1160 0 -3.83129852584e-05
Gc17_1161 0 n34 ns1161 0 -0.000140013351085
Gc17_1162 0 n34 ns1162 0 0.00104198104015
Gc17_1163 0 n34 ns1163 0 0.000652615609293
Gc17_1164 0 n34 ns1164 0 0.000430846355995
Gc17_1165 0 n34 ns1165 0 -0.000520307500814
Gc17_1166 0 n34 ns1166 0 -0.000420540791218
Gc17_1167 0 n34 ns1167 0 0.000110793095111
Gc17_1168 0 n34 ns1168 0 0.000990469494622
Gc17_1169 0 n34 ns1169 0 0.000477920021502
Gc17_1170 0 n34 ns1170 0 0.00018421037665
Gc17_1171 0 n34 ns1171 0 -7.09729050719e-05
Gc17_1172 0 n34 ns1172 0 -5.2820382202e-05
Gc17_1173 0 n34 ns1173 0 -0.000181480691737
Gc17_1174 0 n34 ns1174 0 0.0117234257029
Gc17_1175 0 n34 ns1175 0 -0.0100105670543
Gc17_1176 0 n34 ns1176 0 0.000364005087914
Gc17_1177 0 n34 ns1177 0 -7.82327555252e-06
Gc17_1178 0 n34 ns1178 0 -2.71449281244e-05
Gc17_1179 0 n34 ns1179 0 -0.000159929058039
Gc17_1180 0 n34 ns1180 0 0.000762044120409
Gc17_1181 0 n34 ns1181 0 -0.00337857570274
Gc17_1182 0 n34 ns1182 0 -0.000306903204599
Gc17_1183 0 n34 ns1183 0 -0.000114005267806
Gc17_1184 0 n34 ns1184 0 -0.000216286075815
Gc17_1185 0 n34 ns1185 0 9.43462452305e-05
Gc17_1186 0 n34 ns1186 0 1.26310341786e-05
Gc17_1187 0 n34 ns1187 0 4.23335213621e-05
Gc17_1188 0 n34 ns1188 0 0.00114608491929
Gc17_1189 0 n34 ns1189 0 0.000768571484772
Gc17_1190 0 n34 ns1190 0 -0.000519651481877
Gc17_1191 0 n34 ns1191 0 -0.000121511379494
Gc17_1192 0 n34 ns1192 0 -3.38174544733e-05
Gc17_1193 0 n34 ns1193 0 0.000119608889533
Gc17_1194 0 n34 ns1194 0 0.000428023000783
Gc17_1195 0 n34 ns1195 0 0.000578606527954
Gc17_1196 0 n34 ns1196 0 0.000175489799444
Gc17_1197 0 n34 ns1197 0 -0.000317897937704
Gc17_1198 0 n34 ns1198 0 -6.25457950219e-05
Gc17_1199 0 n34 ns1199 0 -5.18255931932e-05
Gc17_1200 0 n34 ns1200 0 0.00109767425494
Gc17_1201 0 n34 ns1201 0 0.000353414076841
Gc17_1202 0 n34 ns1202 0 0.000181977913012
Gc17_1203 0 n34 ns1203 0 -0.000498313766269
Gc17_1204 0 n34 ns1204 0 -0.0002574108629
Gc17_1205 0 n34 ns1205 0 0.000174832166703
Gc17_1206 0 n34 ns1206 0 0.00152239399882
Gc17_1207 0 n34 ns1207 0 0.000832851913172
Gc17_1208 0 n34 ns1208 0 0.000165466080001
Gc17_1209 0 n34 ns1209 0 -0.0003993595864
Gc17_1210 0 n34 ns1210 0 -0.000153427467751
Gc17_1211 0 n34 ns1211 0 -0.000116796784591
Gc17_1212 0 n34 ns1212 0 0.0154919735978
Gc17_1213 0 n34 ns1213 0 -0.0130971821033
Gc17_1214 0 n34 ns1214 0 0.000458191047849
Gc17_1215 0 n34 ns1215 0 -8.19700744209e-06
Gc17_1216 0 n34 ns1216 0 -2.24996544622e-05
Gd17_1 0 n34 ni1 0 -0.00771641728833
Gd17_2 0 n34 ni2 0 -0.00313348448378
Gd17_3 0 n34 ni3 0 2.8561154079e-05
Gd17_4 0 n34 ni4 0 0.000201230240572
Gd17_5 0 n34 ni5 0 0.000264557203983
Gd17_6 0 n34 ni6 0 2.92844034421e-05
Gd17_7 0 n34 ni7 0 -8.35571802817e-05
Gd17_8 0 n34 ni8 0 -9.95848659855e-05
Gd17_9 0 n34 ni9 0 -0.000229786784845
Gd17_10 0 n34 ni10 0 -0.000446493533925
Gd17_11 0 n34 ni11 0 0.000560699507904
Gd17_12 0 n34 ni12 0 0.000265747168038
Gd17_13 0 n34 ni13 0 7.3466749371e-05
Gd17_14 0 n34 ni14 0 -0.000137087168916
Gd17_15 0 n34 ni15 0 -5.64791812771e-05
Gd17_16 0 n34 ni16 0 -0.000111300088902
Gd17_17 0 n34 ni17 0 -0.00234495992077
Gd17_18 0 n34 ni18 0 -0.00271623997111
Gd17_19 0 n34 ni19 0 -0.00124870789334
Gd17_20 0 n34 ni20 0 0.000295714525431
Gd17_21 0 n34 ni21 0 0.000206775765193
Gd17_22 0 n34 ni22 0 0.000195149061423
Gd17_23 0 n34 ni23 0 -0.000103727110267
Gd17_24 0 n34 ni24 0 -8.04523626388e-05
Gd17_25 0 n34 ni25 0 -7.85259027079e-05
Gd17_26 0 n34 ni26 0 -0.00208133250833
Gd17_27 0 n34 ni27 0 -0.000240550138318
Gd17_28 0 n34 ni28 0 0.000235847420184
Gd17_29 0 n34 ni29 0 5.59449268846e-05
Gd17_30 0 n34 ni30 0 -3.92471962146e-05
Gd17_31 0 n34 ni31 0 -8.53603301049e-05
Gd17_32 0 n34 ni32 0 5.70737166293e-06
Gc18_1 0 n36 ns1 0 -0.00530706919373
Gc18_2 0 n36 ns2 0 -0.00333619470543
Gc18_3 0 n36 ns3 0 -0.00261596744622
Gc18_4 0 n36 ns4 0 0.00204028695824
Gc18_5 0 n36 ns5 0 -0.00349286668416
Gc18_6 0 n36 ns6 0 0.000354319250685
Gc18_7 0 n36 ns7 0 0.00329543505326
Gc18_8 0 n36 ns8 0 0.00013423577932
Gc18_9 0 n36 ns9 0 -0.000308458744241
Gc18_10 0 n36 ns10 0 -0.00116420853702
Gc18_11 0 n36 ns11 0 0.00289664303192
Gc18_12 0 n36 ns12 0 -0.000965050532526
Gc18_13 0 n36 ns13 0 -0.000273420087162
Gc18_14 0 n36 ns14 0 -0.000276763821996
Gc18_15 0 n36 ns15 0 6.03759130711e-05
Gc18_16 0 n36 ns16 0 0.00345291640842
Gc18_17 0 n36 ns17 0 -0.00169584296066
Gc18_18 0 n36 ns18 0 -8.57647232516e-06
Gc18_19 0 n36 ns19 0 -0.000799784670708
Gc18_20 0 n36 ns20 0 -9.25118297599e-05
Gc18_21 0 n36 ns21 0 9.23404021813e-05
Gc18_22 0 n36 ns22 0 0.00534950007383
Gc18_23 0 n36 ns23 0 0.00561418422499
Gc18_24 0 n36 ns24 0 -4.26811779441e-05
Gc18_25 0 n36 ns25 0 -0.00240103763777
Gc18_26 0 n36 ns26 0 -0.00165296010767
Gc18_27 0 n36 ns27 0 0.000799362239102
Gc18_28 0 n36 ns28 0 -0.00706696421585
Gc18_29 0 n36 ns29 0 0.000734787697421
Gc18_30 0 n36 ns30 0 0.00355024017332
Gc18_31 0 n36 ns31 0 -0.000168144837926
Gc18_32 0 n36 ns32 0 0.00212974852071
Gc18_33 0 n36 ns33 0 0.000404743410546
Gc18_34 0 n36 ns34 0 0.0849863866183
Gc18_35 0 n36 ns35 0 -0.0659016261264
Gc18_36 0 n36 ns36 0 -0.00596267497914
Gc18_37 0 n36 ns37 0 -6.45114863861e-06
Gc18_38 0 n36 ns38 0 2.40588759638e-05
Gc18_39 0 n36 ns39 0 -0.0170291917234
Gc18_40 0 n36 ns40 0 0.00105468270097
Gc18_41 0 n36 ns41 0 0.0122404341338
Gc18_42 0 n36 ns42 0 0.0058783019525
Gc18_43 0 n36 ns43 0 0.00976807968815
Gc18_44 0 n36 ns44 0 0.00128864916928
Gc18_45 0 n36 ns45 0 -0.00332431174435
Gc18_46 0 n36 ns46 0 -0.000455315065167
Gc18_47 0 n36 ns47 0 6.42355146898e-06
Gc18_48 0 n36 ns48 0 -0.000666396199167
Gc18_49 0 n36 ns49 0 -0.0117539433974
Gc18_50 0 n36 ns50 0 0.000918817219533
Gc18_51 0 n36 ns51 0 0.00149887595782
Gc18_52 0 n36 ns52 0 5.87279459391e-05
Gc18_53 0 n36 ns53 0 8.73059582418e-06
Gc18_54 0 n36 ns54 0 0.000186263121965
Gc18_55 0 n36 ns55 0 0.000481890833678
Gc18_56 0 n36 ns56 0 0.000547076526787
Gc18_57 0 n36 ns57 0 0.000539019710316
Gc18_58 0 n36 ns58 0 0.000326125075734
Gc18_59 0 n36 ns59 0 0.000411781832426
Gc18_60 0 n36 ns60 0 -0.00970743480694
Gc18_61 0 n36 ns61 0 -0.00569132659357
Gc18_62 0 n36 ns62 0 -0.00303133292901
Gc18_63 0 n36 ns63 0 -0.000794236606152
Gc18_64 0 n36 ns64 0 -0.000233081906595
Gc18_65 0 n36 ns65 0 0.00151794657684
Gc18_66 0 n36 ns66 0 0.0131856695279
Gc18_67 0 n36 ns67 0 -0.00135407666738
Gc18_68 0 n36 ns68 0 0.00245470437331
Gc18_69 0 n36 ns69 0 -0.00132822050495
Gc18_70 0 n36 ns70 0 0.00226147379052
Gc18_71 0 n36 ns71 0 0.000465767342263
Gc18_72 0 n36 ns72 0 -0.0699899662425
Gc18_73 0 n36 ns73 0 0.0388184030839
Gc18_74 0 n36 ns74 0 -0.00815749532862
Gc18_75 0 n36 ns75 0 -8.14419533856e-06
Gc18_76 0 n36 ns76 0 2.79499622627e-05
Gc18_77 0 n36 ns77 0 -0.000368880677087
Gc18_78 0 n36 ns78 0 -0.00044345341927
Gc18_79 0 n36 ns79 0 0.00566923226685
Gc18_80 0 n36 ns80 0 -0.000851349352127
Gc18_81 0 n36 ns81 0 -0.000909227185845
Gc18_82 0 n36 ns82 0 0.00142436741271
Gc18_83 0 n36 ns83 0 0.000412837645101
Gc18_84 0 n36 ns84 0 -0.000193265215958
Gc18_85 0 n36 ns85 0 -0.000150123261519
Gc18_86 0 n36 ns86 0 0.00154465785181
Gc18_87 0 n36 ns87 0 -0.0019162325194
Gc18_88 0 n36 ns88 0 -0.000381064552745
Gc18_89 0 n36 ns89 0 0.00101843050662
Gc18_90 0 n36 ns90 0 -0.000250994661875
Gc18_91 0 n36 ns91 0 0.000270011308833
Gc18_92 0 n36 ns92 0 -0.000994346768339
Gc18_93 0 n36 ns93 0 -0.00235821894602
Gc18_94 0 n36 ns94 0 -0.000280320437326
Gc18_95 0 n36 ns95 0 -0.000230600561638
Gc18_96 0 n36 ns96 0 0.00019154767677
Gc18_97 0 n36 ns97 0 0.000392307407821
Gc18_98 0 n36 ns98 0 0.000649447773285
Gc18_99 0 n36 ns99 0 -0.00467480446535
Gc18_100 0 n36 ns100 0 -0.00189179054629
Gc18_101 0 n36 ns101 0 8.50376418607e-05
Gc18_102 0 n36 ns102 0 -0.000222956878334
Gc18_103 0 n36 ns103 0 0.00126993770472
Gc18_104 0 n36 ns104 0 -0.0097443680508
Gc18_105 0 n36 ns105 0 -0.00421402818801
Gc18_106 0 n36 ns106 0 -0.00169505979355
Gc18_107 0 n36 ns107 0 0.00151809354929
Gc18_108 0 n36 ns108 0 0.00282228397625
Gc18_109 0 n36 ns109 0 0.000788383122296
Gc18_110 0 n36 ns110 0 -0.065386480899
Gc18_111 0 n36 ns111 0 0.0632089824947
Gc18_112 0 n36 ns112 0 -0.00648535671823
Gc18_113 0 n36 ns113 0 -9.2385312011e-06
Gc18_114 0 n36 ns114 0 2.99229581723e-05
Gc18_115 0 n36 ns115 0 0.000436574374996
Gc18_116 0 n36 ns116 0 -0.000247859643172
Gc18_117 0 n36 ns117 0 0.00964304910393
Gc18_118 0 n36 ns118 0 0.000186195849995
Gc18_119 0 n36 ns119 0 0.000517052928588
Gc18_120 0 n36 ns120 0 0.000368542223045
Gc18_121 0 n36 ns121 0 -0.000215258850818
Gc18_122 0 n36 ns122 0 -9.18122767886e-05
Gc18_123 0 n36 ns123 0 2.00022828012e-05
Gc18_124 0 n36 ns124 0 -0.000863831875929
Gc18_125 0 n36 ns125 0 -0.0034690603099
Gc18_126 0 n36 ns126 0 0.00075091836625
Gc18_127 0 n36 ns127 0 0.000739779297562
Gc18_128 0 n36 ns128 0 -4.64645317463e-05
Gc18_129 0 n36 ns129 0 0.000297180104495
Gc18_130 0 n36 ns130 0 -0.000379673951765
Gc18_131 0 n36 ns131 0 -0.000102167353478
Gc18_132 0 n36 ns132 0 -0.000725133917262
Gc18_133 0 n36 ns133 0 -0.000630659754137
Gc18_134 0 n36 ns134 0 0.00019446765442
Gc18_135 0 n36 ns135 0 0.000216204923475
Gc18_136 0 n36 ns136 0 -0.00253595237966
Gc18_137 0 n36 ns137 0 -0.00421434792877
Gc18_138 0 n36 ns138 0 -0.00050062639324
Gc18_139 0 n36 ns139 0 -4.79676586947e-06
Gc18_140 0 n36 ns140 0 -0.000162642490531
Gc18_141 0 n36 ns141 0 0.00117525558279
Gc18_142 0 n36 ns142 0 -0.0076478748667
Gc18_143 0 n36 ns143 0 -0.0057732778563
Gc18_144 0 n36 ns144 0 -0.00226951743367
Gc18_145 0 n36 ns145 0 0.00356630445958
Gc18_146 0 n36 ns146 0 0.00235154491664
Gc18_147 0 n36 ns147 0 -2.76818682782e-05
Gc18_148 0 n36 ns148 0 -0.0713835426794
Gc18_149 0 n36 ns149 0 0.0625712609592
Gc18_150 0 n36 ns150 0 -0.0030339708482
Gc18_151 0 n36 ns151 0 -1.1009055162e-05
Gc18_152 0 n36 ns152 0 1.7088636939e-05
Gc18_153 0 n36 ns153 0 7.26519925454e-05
Gc18_154 0 n36 ns154 0 -0.000478156276772
Gc18_155 0 n36 ns155 0 0.00619537745733
Gc18_156 0 n36 ns156 0 0.00022608662774
Gc18_157 0 n36 ns157 0 0.000169294515071
Gc18_158 0 n36 ns158 0 0.000350143777185
Gc18_159 0 n36 ns159 0 7.48377942387e-06
Gc18_160 0 n36 ns160 0 6.07605319973e-06
Gc18_161 0 n36 ns161 0 -2.37108060951e-05
Gc18_162 0 n36 ns162 0 -0.000710609044267
Gc18_163 0 n36 ns163 0 -0.00100981535033
Gc18_164 0 n36 ns164 0 0.000258297990042
Gc18_165 0 n36 ns165 0 -0.000354639377862
Gc18_166 0 n36 ns166 0 1.01205029578e-05
Gc18_167 0 n36 ns167 0 0.000310112483262
Gc18_168 0 n36 ns168 0 0.00122761315832
Gc18_169 0 n36 ns169 0 -0.00128689155754
Gc18_170 0 n36 ns170 0 -0.00149277709337
Gc18_171 0 n36 ns171 0 8.0662513062e-05
Gc18_172 0 n36 ns172 0 0.000158362833414
Gc18_173 0 n36 ns173 0 0.000176213401848
Gc18_174 0 n36 ns174 0 -0.00136178879958
Gc18_175 0 n36 ns175 0 -0.00202358532344
Gc18_176 0 n36 ns176 0 -0.000675208972769
Gc18_177 0 n36 ns177 0 -0.00129888743507
Gc18_178 0 n36 ns178 0 2.78803225123e-05
Gc18_179 0 n36 ns179 0 0.0014524558015
Gc18_180 0 n36 ns180 0 -0.00642951750209
Gc18_181 0 n36 ns181 0 -0.00453124821433
Gc18_182 0 n36 ns182 0 -0.00046746175826
Gc18_183 0 n36 ns183 0 0.0035291011195
Gc18_184 0 n36 ns184 0 0.00148788364578
Gc18_185 0 n36 ns185 0 -0.000563927508527
Gc18_186 0 n36 ns186 0 -0.0376890358314
Gc18_187 0 n36 ns187 0 0.0317249315256
Gc18_188 0 n36 ns188 0 -0.0012373453501
Gc18_189 0 n36 ns189 0 -5.7943383632e-06
Gc18_190 0 n36 ns190 0 2.00424058066e-06
Gc18_191 0 n36 ns191 0 0.000245359943982
Gc18_192 0 n36 ns192 0 -0.000706367821197
Gc18_193 0 n36 ns193 0 0.00413282795293
Gc18_194 0 n36 ns194 0 6.88045301096e-05
Gc18_195 0 n36 ns195 0 0.000208384884699
Gc18_196 0 n36 ns196 0 0.000161166256093
Gc18_197 0 n36 ns197 0 -0.000107786447897
Gc18_198 0 n36 ns198 0 -1.8140152439e-05
Gc18_199 0 n36 ns199 0 -3.98698466567e-05
Gc18_200 0 n36 ns200 0 0.000910585614447
Gc18_201 0 n36 ns201 0 -0.000818092822141
Gc18_202 0 n36 ns202 0 -0.000758997571679
Gc18_203 0 n36 ns203 0 -1.61077957332e-05
Gc18_204 0 n36 ns204 0 0.000159651751488
Gc18_205 0 n36 ns205 0 0.000324508245593
Gc18_206 0 n36 ns206 0 -0.000299132808333
Gc18_207 0 n36 ns207 0 -0.00180065471333
Gc18_208 0 n36 ns208 0 -0.000577534296156
Gc18_209 0 n36 ns209 0 0.0010031356542
Gc18_210 0 n36 ns210 0 0.000221465054034
Gc18_211 0 n36 ns211 0 4.2203081683e-07
Gc18_212 0 n36 ns212 0 -0.000347191744351
Gc18_213 0 n36 ns213 0 -0.00135294917781
Gc18_214 0 n36 ns214 0 -0.0013709146758
Gc18_215 0 n36 ns215 0 -0.000870555273343
Gc18_216 0 n36 ns216 0 0.000576224759211
Gc18_217 0 n36 ns217 0 0.00106880245036
Gc18_218 0 n36 ns218 0 -0.00485040785661
Gc18_219 0 n36 ns219 0 -0.00198401790988
Gc18_220 0 n36 ns220 0 0.000533049209821
Gc18_221 0 n36 ns221 0 0.00217157806931
Gc18_222 0 n36 ns222 0 0.000721628355199
Gc18_223 0 n36 ns223 0 -0.000588923554831
Gc18_224 0 n36 ns224 0 -0.0178229609112
Gc18_225 0 n36 ns225 0 0.0145188756298
Gc18_226 0 n36 ns226 0 -0.000516525176702
Gc18_227 0 n36 ns227 0 2.61320643463e-06
Gc18_228 0 n36 ns228 0 -1.69899584113e-05
Gc18_229 0 n36 ns229 0 0.000200972003894
Gc18_230 0 n36 ns230 0 -0.000610211429911
Gc18_231 0 n36 ns231 0 0.00146344845188
Gc18_232 0 n36 ns232 0 -0.000108333039255
Gc18_233 0 n36 ns233 0 0.000200135511645
Gc18_234 0 n36 ns234 0 3.56720835026e-05
Gc18_235 0 n36 ns235 0 0.000100041360392
Gc18_236 0 n36 ns236 0 -3.49963740847e-06
Gc18_237 0 n36 ns237 0 -2.05217995958e-06
Gc18_238 0 n36 ns238 0 0.000572247693118
Gc18_239 0 n36 ns239 0 -0.00146201945668
Gc18_240 0 n36 ns240 0 -0.000409973000022
Gc18_241 0 n36 ns241 0 0.000754575767506
Gc18_242 0 n36 ns242 0 0.000284073304853
Gc18_243 0 n36 ns243 0 9.81299708937e-05
Gc18_244 0 n36 ns244 0 -0.000853049882572
Gc18_245 0 n36 ns245 0 -0.000179779890253
Gc18_246 0 n36 ns246 0 0.000452948120305
Gc18_247 0 n36 ns247 0 0.000458156328576
Gc18_248 0 n36 ns248 0 6.80997285188e-05
Gc18_249 0 n36 ns249 0 -0.000179433564506
Gc18_250 0 n36 ns250 0 0.000172240231138
Gc18_251 0 n36 ns251 0 -0.000961894145708
Gc18_252 0 n36 ns252 0 -0.00109239556915
Gc18_253 0 n36 ns253 0 -0.000106873586885
Gc18_254 0 n36 ns254 0 0.000600551440531
Gc18_255 0 n36 ns255 0 0.000411635329479
Gc18_256 0 n36 ns256 0 -0.0020521465612
Gc18_257 0 n36 ns257 0 5.20428680907e-05
Gc18_258 0 n36 ns258 0 0.000629069537285
Gc18_259 0 n36 ns259 0 0.000749389386879
Gc18_260 0 n36 ns260 0 0.000190032040987
Gc18_261 0 n36 ns261 0 -0.000408456543043
Gc18_262 0 n36 ns262 0 -0.00151741339614
Gc18_263 0 n36 ns263 0 0.00102241308745
Gc18_264 0 n36 ns264 0 -8.15524150969e-05
Gc18_265 0 n36 ns265 0 6.06126858845e-06
Gc18_266 0 n36 ns266 0 -2.84743880555e-05
Gc18_267 0 n36 ns267 0 0.000144844587228
Gc18_268 0 n36 ns268 0 -0.000232019238257
Gc18_269 0 n36 ns269 0 -0.000626879229099
Gc18_270 0 n36 ns270 0 -0.000240983367155
Gc18_271 0 n36 ns271 0 0.000160353779764
Gc18_272 0 n36 ns272 0 8.32421849045e-05
Gc18_273 0 n36 ns273 0 0.000155800066264
Gc18_274 0 n36 ns274 0 2.97801765597e-05
Gc18_275 0 n36 ns275 0 -1.11594636421e-05
Gc18_276 0 n36 ns276 0 -0.000358117868565
Gc18_277 0 n36 ns277 0 -0.00037454189511
Gc18_278 0 n36 ns278 0 0.000283504394243
Gc18_279 0 n36 ns279 0 0.000355643894513
Gc18_280 0 n36 ns280 0 9.95774650275e-05
Gc18_281 0 n36 ns281 0 -0.000129716701052
Gc18_282 0 n36 ns282 0 -9.30659431485e-05
Gc18_283 0 n36 ns283 0 0.000770489861065
Gc18_284 0 n36 ns284 0 0.000478196011945
Gc18_285 0 n36 ns285 0 -0.000235938711799
Gc18_286 0 n36 ns286 0 -7.27900679895e-05
Gc18_287 0 n36 ns287 0 -0.00014444998419
Gc18_288 0 n36 ns288 0 0.000351195519995
Gc18_289 0 n36 ns289 0 -0.000343272691335
Gc18_290 0 n36 ns290 0 -0.000397911367562
Gc18_291 0 n36 ns291 0 0.000146524890144
Gc18_292 0 n36 ns292 0 0.000277115568352
Gc18_293 0 n36 ns293 0 1.21072655982e-05
Gc18_294 0 n36 ns294 0 0.000138678040527
Gc18_295 0 n36 ns295 0 0.000941737636293
Gc18_296 0 n36 ns296 0 0.000397553139174
Gc18_297 0 n36 ns297 0 -6.33881587868e-05
Gc18_298 0 n36 ns298 0 -5.85667757403e-05
Gc18_299 0 n36 ns299 0 -0.000233675593102
Gc18_300 0 n36 ns300 0 0.00859022795591
Gc18_301 0 n36 ns301 0 -0.00728099542587
Gc18_302 0 n36 ns302 0 0.000183062188606
Gc18_303 0 n36 ns303 0 4.87655632812e-06
Gc18_304 0 n36 ns304 0 -2.96469986181e-05
Gc18_305 0 n36 ns305 0 6.49236617005e-05
Gc18_306 0 n36 ns306 0 -0.000412476576004
Gc18_307 0 n36 ns307 0 -0.000520783097357
Gc18_308 0 n36 ns308 0 -4.11743582855e-05
Gc18_309 0 n36 ns309 0 -9.74083077702e-05
Gc18_310 0 n36 ns310 0 -4.87968599507e-05
Gc18_311 0 n36 ns311 0 4.12146914042e-05
Gc18_312 0 n36 ns312 0 2.49079090073e-05
Gc18_313 0 n36 ns313 0 -1.06034092136e-05
Gc18_314 0 n36 ns314 0 -0.000425075589485
Gc18_315 0 n36 ns315 0 0.000688271940556
Gc18_316 0 n36 ns316 0 0.000276149025453
Gc18_317 0 n36 ns317 0 -0.000201167380959
Gc18_318 0 n36 ns318 0 -7.2446369701e-05
Gc18_319 0 n36 ns319 0 -0.000119748715055
Gc18_320 0 n36 ns320 0 0.000284225004088
Gc18_321 0 n36 ns321 0 0.00061219245214
Gc18_322 0 n36 ns322 0 0.000186008207384
Gc18_323 0 n36 ns323 0 -0.000318378772661
Gc18_324 0 n36 ns324 0 -7.78510200241e-05
Gc18_325 0 n36 ns325 0 -5.199347683e-05
Gc18_326 0 n36 ns326 0 0.000175116215179
Gc18_327 0 n36 ns327 0 3.81028841389e-05
Gc18_328 0 n36 ns328 0 -2.26184208535e-05
Gc18_329 0 n36 ns329 0 0.000146547890448
Gc18_330 0 n36 ns330 0 7.08633156309e-05
Gc18_331 0 n36 ns331 0 -9.60765361971e-05
Gc18_332 0 n36 ns332 0 0.000550383749082
Gc18_333 0 n36 ns333 0 0.000995085224913
Gc18_334 0 n36 ns334 0 0.000273324727439
Gc18_335 0 n36 ns335 0 -0.000226152105163
Gc18_336 0 n36 ns336 0 -9.69237057751e-05
Gc18_337 0 n36 ns337 0 -0.00014418298275
Gc18_338 0 n36 ns338 0 0.00900220177851
Gc18_339 0 n36 ns339 0 -0.00760341265194
Gc18_340 0 n36 ns340 0 0.000197339650681
Gc18_341 0 n36 ns341 0 6.65168915444e-06
Gc18_342 0 n36 ns342 0 -2.62185947442e-05
Gc18_343 0 n36 ns343 0 -0.00253268506439
Gc18_344 0 n36 ns344 0 -0.00230317737258
Gc18_345 0 n36 ns345 0 0.00516761687338
Gc18_346 0 n36 ns346 0 0.00115606949613
Gc18_347 0 n36 ns347 0 -0.00190685036724
Gc18_348 0 n36 ns348 0 0.000428130324229
Gc18_349 0 n36 ns349 0 0.00174998077206
Gc18_350 0 n36 ns350 0 -1.23061218573e-05
Gc18_351 0 n36 ns351 0 -0.00022813746879
Gc18_352 0 n36 ns352 0 0.000717118253868
Gc18_353 0 n36 ns353 0 -0.000488522369729
Gc18_354 0 n36 ns354 0 -0.000892070675034
Gc18_355 0 n36 ns355 0 0.000602417676186
Gc18_356 0 n36 ns356 0 -0.000330599394494
Gc18_357 0 n36 ns357 0 0.000222910396479
Gc18_358 0 n36 ns358 0 0.000463562228474
Gc18_359 0 n36 ns359 0 -0.00218494946379
Gc18_360 0 n36 ns360 0 0.000119760096939
Gc18_361 0 n36 ns361 0 -0.000396694010356
Gc18_362 0 n36 ns362 0 0.000147753891845
Gc18_363 0 n36 ns363 0 0.000291273444839
Gc18_364 0 n36 ns364 0 0.00222630094055
Gc18_365 0 n36 ns365 0 -0.00143724730399
Gc18_366 0 n36 ns366 0 -0.00176812010355
Gc18_367 0 n36 ns367 0 -0.000603542822108
Gc18_368 0 n36 ns368 0 -0.000621281425961
Gc18_369 0 n36 ns369 0 0.00125315798598
Gc18_370 0 n36 ns370 0 -0.00868240310866
Gc18_371 0 n36 ns371 0 -0.00276667971742
Gc18_372 0 n36 ns372 0 -0.000233153503231
Gc18_373 0 n36 ns373 0 0.000438240720008
Gc18_374 0 n36 ns374 0 0.00269216569422
Gc18_375 0 n36 ns375 0 0.000797289968171
Gc18_376 0 n36 ns376 0 -0.0269464382626
Gc18_377 0 n36 ns377 0 0.0310733745805
Gc18_378 0 n36 ns378 0 -0.0070585882702
Gc18_379 0 n36 ns379 0 -8.38875233829e-06
Gc18_380 0 n36 ns380 0 2.68002282245e-05
Gc18_381 0 n36 ns381 0 -7.86620154043e-05
Gc18_382 0 n36 ns382 0 -0.000848653221143
Gc18_383 0 n36 ns383 0 0.00948346512234
Gc18_384 0 n36 ns384 0 0.000123646152204
Gc18_385 0 n36 ns385 0 0.000162232193672
Gc18_386 0 n36 ns386 0 0.000390776565663
Gc18_387 0 n36 ns387 0 -0.000377149352056
Gc18_388 0 n36 ns388 0 -0.000139988201986
Gc18_389 0 n36 ns389 0 2.69388476248e-05
Gc18_390 0 n36 ns390 0 0.000105501718819
Gc18_391 0 n36 ns391 0 -0.00316977429553
Gc18_392 0 n36 ns392 0 0.000393660921352
Gc18_393 0 n36 ns393 0 0.000975506133401
Gc18_394 0 n36 ns394 0 -0.000156178069725
Gc18_395 0 n36 ns395 0 0.000291701813468
Gc18_396 0 n36 ns396 0 -0.00105449809586
Gc18_397 0 n36 ns397 0 -0.000289545139086
Gc18_398 0 n36 ns398 0 -0.000314926645733
Gc18_399 0 n36 ns399 0 -0.000682747477929
Gc18_400 0 n36 ns400 0 0.000208498447649
Gc18_401 0 n36 ns401 0 0.000245667038607
Gc18_402 0 n36 ns402 0 -0.0017611632116
Gc18_403 0 n36 ns403 0 -0.00494528926989
Gc18_404 0 n36 ns404 0 -0.00089497733415
Gc18_405 0 n36 ns405 0 0.000300959005892
Gc18_406 0 n36 ns406 0 -0.000183265963766
Gc18_407 0 n36 ns407 0 0.00117060584343
Gc18_408 0 n36 ns408 0 -0.00775602492309
Gc18_409 0 n36 ns409 0 -0.0053605409211
Gc18_410 0 n36 ns410 0 -0.00259248507226
Gc18_411 0 n36 ns411 0 0.00280269080613
Gc18_412 0 n36 ns412 0 0.00252697821807
Gc18_413 0 n36 ns413 0 0.000260913910802
Gc18_414 0 n36 ns414 0 -0.0779975559174
Gc18_415 0 n36 ns415 0 0.0701222026597
Gc18_416 0 n36 ns416 0 -0.00408306155384
Gc18_417 0 n36 ns417 0 -1.02670238633e-05
Gc18_418 0 n36 ns418 0 2.31485271662e-05
Gc18_419 0 n36 ns419 0 0.000382411287903
Gc18_420 0 n36 ns420 0 -0.000907186105293
Gc18_421 0 n36 ns421 0 0.00747724733131
Gc18_422 0 n36 ns422 0 0.00028540701696
Gc18_423 0 n36 ns423 0 -0.000147655639448
Gc18_424 0 n36 ns424 0 8.71345979266e-05
Gc18_425 0 n36 ns425 0 6.63034124471e-05
Gc18_426 0 n36 ns426 0 1.97282314397e-05
Gc18_427 0 n36 ns427 0 2.7854583401e-05
Gc18_428 0 n36 ns428 0 -0.00114697014903
Gc18_429 0 n36 ns429 0 -0.00124575246907
Gc18_430 0 n36 ns430 0 0.000598492263292
Gc18_431 0 n36 ns431 0 -0.000199839022304
Gc18_432 0 n36 ns432 0 -6.94478743078e-05
Gc18_433 0 n36 ns433 0 0.000295467969633
Gc18_434 0 n36 ns434 0 0.00111919907399
Gc18_435 0 n36 ns435 0 -0.000424694460626
Gc18_436 0 n36 ns436 0 -0.00136460961565
Gc18_437 0 n36 ns437 0 -0.000404469422981
Gc18_438 0 n36 ns438 0 0.000157337881608
Gc18_439 0 n36 ns439 0 0.000189960794552
Gc18_440 0 n36 ns440 0 -0.00178153278669
Gc18_441 0 n36 ns441 0 -0.0022665797937
Gc18_442 0 n36 ns442 0 -0.000263111134869
Gc18_443 0 n36 ns443 0 -0.00108438661198
Gc18_444 0 n36 ns444 0 -0.000216339138042
Gc18_445 0 n36 ns445 0 0.00139885212505
Gc18_446 0 n36 ns446 0 -0.00641731732873
Gc18_447 0 n36 ns447 0 -0.0047612934955
Gc18_448 0 n36 ns448 0 -0.00102432482653
Gc18_449 0 n36 ns449 0 0.00361903978944
Gc18_450 0 n36 ns450 0 0.00175872965517
Gc18_451 0 n36 ns451 0 -0.000470431353846
Gc18_452 0 n36 ns452 0 -0.0439527094866
Gc18_453 0 n36 ns453 0 0.037473173901
Gc18_454 0 n36 ns454 0 -0.00158960779971
Gc18_455 0 n36 ns455 0 -8.54083484156e-06
Gc18_456 0 n36 ns456 0 1.02292575398e-05
Gc18_457 0 n36 ns457 0 0.000221943816742
Gc18_458 0 n36 ns458 0 -0.000918485983499
Gc18_459 0 n36 ns459 0 0.00555959214891
Gc18_460 0 n36 ns460 0 0.000237826357238
Gc18_461 0 n36 ns461 0 0.000139437907171
Gc18_462 0 n36 ns462 0 0.000219044209494
Gc18_463 0 n36 ns463 0 -0.000138012818
Gc18_464 0 n36 ns464 0 -2.66821839075e-06
Gc18_465 0 n36 ns465 0 -3.99433334359e-05
Gc18_466 0 n36 ns466 0 0.00037359248553
Gc18_467 0 n36 ns467 0 -0.000575788355104
Gc18_468 0 n36 ns468 0 -0.000487101691645
Gc18_469 0 n36 ns469 0 -0.000374745502353
Gc18_470 0 n36 ns470 0 7.33513078254e-05
Gc18_471 0 n36 ns471 0 0.000355306591411
Gc18_472 0 n36 ns472 0 0.000318439965025
Gc18_473 0 n36 ns473 0 -0.00209237816794
Gc18_474 0 n36 ns474 0 -0.00112156158209
Gc18_475 0 n36 ns475 0 0.000891028815486
Gc18_476 0 n36 ns476 0 0.000236488558336
Gc18_477 0 n36 ns477 0 9.85092360339e-05
Gc18_478 0 n36 ns478 0 -0.000813910146317
Gc18_479 0 n36 ns479 0 -0.00161506575612
Gc18_480 0 n36 ns480 0 -0.00129565333776
Gc18_481 0 n36 ns481 0 -0.00113698897017
Gc18_482 0 n36 ns482 0 0.000468337400131
Gc18_483 0 n36 ns483 0 0.00131718679915
Gc18_484 0 n36 ns484 0 -0.00603897544106
Gc18_485 0 n36 ns485 0 -0.00296780557553
Gc18_486 0 n36 ns486 0 0.000361752726816
Gc18_487 0 n36 ns487 0 0.00281910369705
Gc18_488 0 n36 ns488 0 0.00100513251958
Gc18_489 0 n36 ns489 0 -0.000641410154877
Gc18_490 0 n36 ns490 0 -0.0262640655607
Gc18_491 0 n36 ns491 0 0.0215888560409
Gc18_492 0 n36 ns492 0 -0.000761172093413
Gc18_493 0 n36 ns493 0 -2.81338140409e-08
Gc18_494 0 n36 ns494 0 -7.34414846061e-06
Gc18_495 0 n36 ns495 0 0.000246292413235
Gc18_496 0 n36 ns496 0 -0.00102408516158
Gc18_497 0 n36 ns497 0 0.00325526816181
Gc18_498 0 n36 ns498 0 6.53180869744e-05
Gc18_499 0 n36 ns499 0 0.000174787149749
Gc18_500 0 n36 ns500 0 3.75198211231e-05
Gc18_501 0 n36 ns501 0 -1.54141037359e-05
Gc18_502 0 n36 ns502 0 -2.04257449872e-05
Gc18_503 0 n36 ns503 0 -1.01698826971e-05
Gc18_504 0 n36 ns504 0 0.00086159359666
Gc18_505 0 n36 ns505 0 -0.00152329902153
Gc18_506 0 n36 ns506 0 -0.000702648492055
Gc18_507 0 n36 ns507 0 0.000602707229832
Gc18_508 0 n36 ns508 0 0.000290172652601
Gc18_509 0 n36 ns509 0 0.000223356579035
Gc18_510 0 n36 ns510 0 -0.000958213238384
Gc18_511 0 n36 ns511 0 -0.000943500055619
Gc18_512 0 n36 ns512 0 0.000161036506423
Gc18_513 0 n36 ns513 0 0.000827915227827
Gc18_514 0 n36 ns514 0 0.000149929166722
Gc18_515 0 n36 ns515 0 -0.000135220021948
Gc18_516 0 n36 ns516 0 -0.000116969336447
Gc18_517 0 n36 ns517 0 -0.00127445245131
Gc18_518 0 n36 ns518 0 -0.00137936699527
Gc18_519 0 n36 ns519 0 -0.000316184935785
Gc18_520 0 n36 ns520 0 0.000711350601583
Gc18_521 0 n36 ns521 0 0.000667482701701
Gc18_522 0 n36 ns522 0 -0.0034897766413
Gc18_523 0 n36 ns523 0 -0.000882282915198
Gc18_524 0 n36 ns524 0 0.000585738372668
Gc18_525 0 n36 ns525 0 0.00135296030738
Gc18_526 0 n36 ns526 0 0.00041281099465
Gc18_527 0 n36 ns527 0 -0.000452035337525
Gc18_528 0 n36 ns528 0 -0.0109341954065
Gc18_529 0 n36 ns529 0 0.00883925703564
Gc18_530 0 n36 ns530 0 -0.000322834738355
Gc18_531 0 n36 ns531 0 6.34168830894e-06
Gc18_532 0 n36 ns532 0 -2.39422193425e-05
Gc18_533 0 n36 ns533 0 0.000176662310153
Gc18_534 0 n36 ns534 0 -0.000319229598292
Gc18_535 0 n36 ns535 0 -0.000170142726099
Gc18_536 0 n36 ns536 0 -0.000249302127274
Gc18_537 0 n36 ns537 0 0.000165892372086
Gc18_538 0 n36 ns538 0 3.11593797147e-05
Gc18_539 0 n36 ns539 0 0.000175301430825
Gc18_540 0 n36 ns540 0 2.95500514067e-05
Gc18_541 0 n36 ns541 0 4.74152172171e-06
Gc18_542 0 n36 ns542 0 -7.01523713358e-06
Gc18_543 0 n36 ns543 0 -0.000885511216678
Gc18_544 0 n36 ns544 0 4.26939482129e-05
Gc18_545 0 n36 ns545 0 0.000623069848576
Gc18_546 0 n36 ns546 0 0.000199104398388
Gc18_547 0 n36 ns547 0 -6.09169988356e-05
Gc18_548 0 n36 ns548 0 -0.000406956537647
Gc18_549 0 n36 ns549 0 0.000620481436686
Gc18_550 0 n36 ns550 0 0.000583105209893
Gc18_551 0 n36 ns551 0 -4.62602484805e-05
Gc18_552 0 n36 ns552 0 -3.75230955633e-05
Gc18_553 0 n36 ns553 0 -0.000186075968635
Gc18_554 0 n36 ns554 0 0.00037894051006
Gc18_555 0 n36 ns555 0 -0.00056979144259
Gc18_556 0 n36 ns556 0 -0.000656382729155
Gc18_557 0 n36 ns557 0 9.32163452018e-05
Gc18_558 0 n36 ns558 0 0.000407316492956
Gc18_559 0 n36 ns559 0 0.000127294713498
Gc18_560 0 n36 ns560 0 -0.00042042664673
Gc18_561 0 n36 ns561 0 0.000772562185861
Gc18_562 0 n36 ns562 0 0.000483026294754
Gc18_563 0 n36 ns563 0 0.000133681703528
Gc18_564 0 n36 ns564 0 -1.9297603883e-06
Gc18_565 0 n36 ns565 0 -0.000290431910664
Gc18_566 0 n36 ns566 0 0.00658035666902
Gc18_567 0 n36 ns567 0 -0.00565971030035
Gc18_568 0 n36 ns568 0 0.000133941681611
Gc18_569 0 n36 ns569 0 5.62041446443e-06
Gc18_570 0 n36 ns570 0 -3.0882796775e-05
Gc18_571 0 n36 ns571 0 8.37238299654e-05
Gc18_572 0 n36 ns572 0 -0.000399808533902
Gc18_573 0 n36 ns573 0 -0.000722226504796
Gc18_574 0 n36 ns574 0 -0.000122014570886
Gc18_575 0 n36 ns575 0 -2.42338092719e-05
Gc18_576 0 n36 ns576 0 -6.21074549778e-06
Gc18_577 0 n36 ns577 0 0.000104540883226
Gc18_578 0 n36 ns578 0 3.34387574303e-05
Gc18_579 0 n36 ns579 0 -1.63903987071e-05
Gc18_580 0 n36 ns580 0 -0.000432346779566
Gc18_581 0 n36 ns581 0 0.00043969261051
Gc18_582 0 n36 ns582 0 0.00032566076696
Gc18_583 0 n36 ns583 0 -5.43243116887e-05
Gc18_584 0 n36 ns584 0 -3.40538084359e-05
Gc18_585 0 n36 ns585 0 -0.000141176774414
Gc18_586 0 n36 ns586 0 0.000248510981297
Gc18_587 0 n36 ns587 0 0.00072072984318
Gc18_588 0 n36 ns588 0 0.000275609499223
Gc18_589 0 n36 ns589 0 -0.000347842261354
Gc18_590 0 n36 ns590 0 -8.98570700756e-05
Gc18_591 0 n36 ns591 0 -8.10316707611e-05
Gc18_592 0 n36 ns592 0 0.000247270568127
Gc18_593 0 n36 ns593 0 -6.83759707474e-05
Gc18_594 0 n36 ns594 0 -0.000110553696208
Gc18_595 0 n36 ns595 0 0.000174082464594
Gc18_596 0 n36 ns596 0 0.000127567128191
Gc18_597 0 n36 ns597 0 -9.05799736743e-05
Gc18_598 0 n36 ns598 0 0.000593385768211
Gc18_599 0 n36 ns599 0 0.00105132095255
Gc18_600 0 n36 ns600 0 0.000303520915066
Gc18_601 0 n36 ns601 0 -0.000235969396256
Gc18_602 0 n36 ns602 0 -0.000106464772078
Gc18_603 0 n36 ns603 0 -0.000167367475935
Gc18_604 0 n36 ns604 0 0.00957413130559
Gc18_605 0 n36 ns605 0 -0.00804056277579
Gc18_606 0 n36 ns606 0 0.000201067978207
Gc18_607 0 n36 ns607 0 4.98582489412e-06
Gc18_608 0 n36 ns608 0 -2.8415361393e-05
Gc18_609 0 n36 ns609 0 -0.00570950171313
Gc18_610 0 n36 ns610 0 -0.00338269345108
Gc18_611 0 n36 ns611 0 -0.00387217460263
Gc18_612 0 n36 ns612 0 0.000384964631456
Gc18_613 0 n36 ns613 0 -0.00151765307484
Gc18_614 0 n36 ns614 0 -0.000770350976495
Gc18_615 0 n36 ns615 0 0.000738710321411
Gc18_616 0 n36 ns616 0 -2.97197547227e-05
Gc18_617 0 n36 ns617 0 -6.1841444095e-05
Gc18_618 0 n36 ns618 0 -0.000412261870995
Gc18_619 0 n36 ns619 0 0.00266646329615
Gc18_620 0 n36 ns620 0 0.00057587734969
Gc18_621 0 n36 ns621 0 -0.000283507732585
Gc18_622 0 n36 ns622 0 0.00018931718913
Gc18_623 0 n36 ns623 0 -0.000101824512834
Gc18_624 0 n36 ns624 0 0.00153341819341
Gc18_625 0 n36 ns625 0 0.000778443392151
Gc18_626 0 n36 ns626 0 0.000750119859222
Gc18_627 0 n36 ns627 0 -9.10003449872e-05
Gc18_628 0 n36 ns628 0 0.000177752371118
Gc18_629 0 n36 ns629 0 0.000133672744832
Gc18_630 0 n36 ns630 0 0.00125731543835
Gc18_631 0 n36 ns631 0 -0.00113617247971
Gc18_632 0 n36 ns632 0 0.00113433121396
Gc18_633 0 n36 ns633 0 0.00202865082662
Gc18_634 0 n36 ns634 0 0.00119604255889
Gc18_635 0 n36 ns635 0 -0.00113632424479
Gc18_636 0 n36 ns636 0 0.000922843766511
Gc18_637 0 n36 ns637 0 -0.00194086274027
Gc18_638 0 n36 ns638 0 0.00314164881534
Gc18_639 0 n36 ns639 0 -0.000140555613537
Gc18_640 0 n36 ns640 0 0.00217597558875
Gc18_641 0 n36 ns641 0 0.000419060130417
Gc18_642 0 n36 ns642 0 -0.0408923186505
Gc18_643 0 n36 ns643 0 0.0422058437908
Gc18_644 0 n36 ns644 0 0.00599255781381
Gc18_645 0 n36 ns645 0 -4.81473106572e-06
Gc18_646 0 n36 ns646 0 2.19413866849e-05
Gc18_647 0 n36 ns647 0 -0.00361541601775
Gc18_648 0 n36 ns648 0 -0.00179061585788
Gc18_649 0 n36 ns649 0 0.000644841706029
Gc18_650 0 n36 ns650 0 0.000775573192294
Gc18_651 0 n36 ns651 0 -0.000378900295458
Gc18_652 0 n36 ns652 0 0.000133076226147
Gc18_653 0 n36 ns653 0 0.00034307113118
Gc18_654 0 n36 ns654 0 -0.000192314872164
Gc18_655 0 n36 ns655 0 -0.00014011764305
Gc18_656 0 n36 ns656 0 -0.00254196087435
Gc18_657 0 n36 ns657 0 0.000728663770565
Gc18_658 0 n36 ns658 0 0.00141758374932
Gc18_659 0 n36 ns659 0 -8.49898843265e-05
Gc18_660 0 n36 ns660 0 0.000414438279857
Gc18_661 0 n36 ns661 0 -0.00026804196582
Gc18_662 0 n36 ns662 0 0.00050404317305
Gc18_663 0 n36 ns663 0 -0.000463217317388
Gc18_664 0 n36 ns664 0 0.000488770803321
Gc18_665 0 n36 ns665 0 0.000298182346651
Gc18_666 0 n36 ns666 0 0.000276474881472
Gc18_667 0 n36 ns667 0 0.000304332455849
Gc18_668 0 n36 ns668 0 -0.00140177494568
Gc18_669 0 n36 ns669 0 -0.00142391079032
Gc18_670 0 n36 ns670 0 0.00111493702573
Gc18_671 0 n36 ns671 0 0.00247160314864
Gc18_672 0 n36 ns672 0 0.00149841964819
Gc18_673 0 n36 ns673 0 -0.00137354146226
Gc18_674 0 n36 ns674 0 -0.0030754375787
Gc18_675 0 n36 ns675 0 -0.00264292968222
Gc18_676 0 n36 ns676 0 0.00270369098873
Gc18_677 0 n36 ns677 0 0.000533308420964
Gc18_678 0 n36 ns678 0 0.00273536530063
Gc18_679 0 n36 ns679 0 0.000601783215349
Gc18_680 0 n36 ns680 0 -0.0471932989875
Gc18_681 0 n36 ns681 0 0.0436184083679
Gc18_682 0 n36 ns682 0 0.00647629088058
Gc18_683 0 n36 ns683 0 9.17043300395e-06
Gc18_684 0 n36 ns684 0 2.9686433674e-05
Gc18_685 0 n36 ns685 0 -0.00176367799359
Gc18_686 0 n36 ns686 0 -0.00236315477956
Gc18_687 0 n36 ns687 0 0.00561424837333
Gc18_688 0 n36 ns688 0 0.000693951055636
Gc18_689 0 n36 ns689 0 -0.000457362162579
Gc18_690 0 n36 ns690 0 0.00073806754643
Gc18_691 0 n36 ns691 0 0.000342600022749
Gc18_692 0 n36 ns692 0 -0.000148662877281
Gc18_693 0 n36 ns693 0 -8.576588499e-05
Gc18_694 0 n36 ns694 0 -0.00189265561512
Gc18_695 0 n36 ns695 0 -0.00103324014251
Gc18_696 0 n36 ns696 0 0.000890950967705
Gc18_697 0 n36 ns697 0 -0.000165565025329
Gc18_698 0 n36 ns698 0 0.000490367645445
Gc18_699 0 n36 ns699 0 -0.000284934203734
Gc18_700 0 n36 ns700 0 -0.000830436523933
Gc18_701 0 n36 ns701 0 -0.00160393944877
Gc18_702 0 n36 ns702 0 -7.90937926422e-06
Gc18_703 0 n36 ns703 0 -0.000249709107642
Gc18_704 0 n36 ns704 0 0.000245874486599
Gc18_705 0 n36 ns705 0 0.000343133704709
Gc18_706 0 n36 ns706 0 -0.00419695838838
Gc18_707 0 n36 ns707 0 -0.000470587080408
Gc18_708 0 n36 ns708 0 0.000255631402533
Gc18_709 0 n36 ns709 0 0.000773594690349
Gc18_710 0 n36 ns710 0 0.00118132620275
Gc18_711 0 n36 ns711 0 -0.000963269398413
Gc18_712 0 n36 ns712 0 -0.00505755952843
Gc18_713 0 n36 ns713 0 -0.000695687658961
Gc18_714 0 n36 ns714 0 -0.00177267673507
Gc18_715 0 n36 ns715 0 -8.37363620851e-05
Gc18_716 0 n36 ns716 0 0.00234729044805
Gc18_717 0 n36 ns717 0 0.000739101658955
Gc18_718 0 n36 ns718 0 0.0137149755064
Gc18_719 0 n36 ns719 0 -0.0224052360762
Gc18_720 0 n36 ns720 0 0.00536863191698
Gc18_721 0 n36 ns721 0 2.41108952209e-06
Gc18_722 0 n36 ns722 0 3.31420059379e-05
Gc18_723 0 n36 ns723 0 -0.00147601510005
Gc18_724 0 n36 ns724 0 0.00169496739321
Gc18_725 0 n36 ns725 0 -0.00274309777126
Gc18_726 0 n36 ns726 0 0.00047293805598
Gc18_727 0 n36 ns727 0 -0.000697503389531
Gc18_728 0 n36 ns728 0 0.000262758453388
Gc18_729 0 n36 ns729 0 -0.000244440152711
Gc18_730 0 n36 ns730 0 -6.44227945363e-05
Gc18_731 0 n36 ns731 0 -1.03032402113e-05
Gc18_732 0 n36 ns732 0 -0.00178222521298
Gc18_733 0 n36 ns733 0 0.000835913377258
Gc18_734 0 n36 ns734 0 -6.64547155298e-05
Gc18_735 0 n36 ns735 0 -0.000323980881281
Gc18_736 0 n36 ns736 0 0.000247152686686
Gc18_737 0 n36 ns737 0 -0.000359858654094
Gc18_738 0 n36 ns738 0 -0.0008069948536
Gc18_739 0 n36 ns739 0 0.0015741289242
Gc18_740 0 n36 ns740 0 -9.00940512771e-05
Gc18_741 0 n36 ns741 0 -0.000569617355901
Gc18_742 0 n36 ns742 0 0.000317025937416
Gc18_743 0 n36 ns743 0 0.000110713029697
Gc18_744 0 n36 ns744 0 0.000699835421894
Gc18_745 0 n36 ns745 0 0.00288785517426
Gc18_746 0 n36 ns746 0 -0.000245209022822
Gc18_747 0 n36 ns747 0 0.000372548766196
Gc18_748 0 n36 ns748 0 0.000615393839327
Gc18_749 0 n36 ns749 0 -0.000994022119919
Gc18_750 0 n36 ns750 0 0.00289656048906
Gc18_751 0 n36 ns751 0 0.00141349749971
Gc18_752 0 n36 ns752 0 -0.00203553007482
Gc18_753 0 n36 ns753 0 0.000527974873543
Gc18_754 0 n36 ns754 0 0.00143529174923
Gc18_755 0 n36 ns755 0 -0.000209037601376
Gc18_756 0 n36 ns756 0 0.0451369907353
Gc18_757 0 n36 ns757 0 -0.0426250820946
Gc18_758 0 n36 ns758 0 0.00272448851022
Gc18_759 0 n36 ns759 0 -3.02078574551e-06
Gc18_760 0 n36 ns760 0 2.20657410358e-05
Gc18_761 0 n36 ns761 0 -0.000881472282777
Gc18_762 0 n36 ns762 0 0.00216253056634
Gc18_763 0 n36 ns763 0 -0.00241218555779
Gc18_764 0 n36 ns764 0 -0.000175655878035
Gc18_765 0 n36 ns765 0 -0.000148150715817
Gc18_766 0 n36 ns766 0 -0.000267997316066
Gc18_767 0 n36 ns767 0 -9.05672167409e-05
Gc18_768 0 n36 ns768 0 -1.94929098796e-05
Gc18_769 0 n36 ns769 0 1.68683652903e-05
Gc18_770 0 n36 ns770 0 0.000230936666841
Gc18_771 0 n36 ns771 0 0.000969667231609
Gc18_772 0 n36 ns772 0 -9.50468704727e-05
Gc18_773 0 n36 ns773 0 0.000404899218988
Gc18_774 0 n36 ns774 0 3.79982258726e-05
Gc18_775 0 n36 ns775 0 -0.000346345979318
Gc18_776 0 n36 ns776 0 0.00147076321118
Gc18_777 0 n36 ns777 0 5.9166703369e-05
Gc18_778 0 n36 ns778 0 -0.000963070994216
Gc18_779 0 n36 ns779 0 -8.1629227671e-05
Gc18_780 0 n36 ns780 0 0.000227531138813
Gc18_781 0 n36 ns781 0 3.69894750819e-05
Gc18_782 0 n36 ns782 0 0.000516428454548
Gc18_783 0 n36 ns783 0 -0.000406717412675
Gc18_784 0 n36 ns784 0 -0.000255913963829
Gc18_785 0 n36 ns785 0 0.00134391569105
Gc18_786 0 n36 ns786 0 0.000356392371518
Gc18_787 0 n36 ns787 0 -0.00109009593993
Gc18_788 0 n36 ns788 0 -0.000196221892043
Gc18_789 0 n36 ns789 0 -0.000865131851267
Gc18_790 0 n36 ns790 0 -0.000441698903121
Gc18_791 0 n36 ns791 0 0.00172941227105
Gc18_792 0 n36 ns792 0 0.000924428288148
Gc18_793 0 n36 ns793 0 -0.000629341815343
Gc18_794 0 n36 ns794 0 0.0192145556493
Gc18_795 0 n36 ns795 0 -0.018209949654
Gc18_796 0 n36 ns796 0 0.00108210322646
Gc18_797 0 n36 ns797 0 -8.19885395889e-06
Gc18_798 0 n36 ns798 0 4.44495646639e-06
Gc18_799 0 n36 ns799 0 9.76564876745e-05
Gc18_800 0 n36 ns800 0 -0.000701788550359
Gc18_801 0 n36 ns801 0 0.00271103275708
Gc18_802 0 n36 ns802 0 0.000121652447391
Gc18_803 0 n36 ns803 0 3.53471703826e-05
Gc18_804 0 n36 ns804 0 2.49559514701e-05
Gc18_805 0 n36 ns805 0 8.86974128569e-05
Gc18_806 0 n36 ns806 0 1.25619986055e-05
Gc18_807 0 n36 ns807 0 9.14423436461e-06
Gc18_808 0 n36 ns808 0 -0.000718683386734
Gc18_809 0 n36 ns809 0 -0.000688682032623
Gc18_810 0 n36 ns810 0 0.000754849521729
Gc18_811 0 n36 ns811 0 0.000347670337441
Gc18_812 0 n36 ns812 0 -8.62436763941e-05
Gc18_813 0 n36 ns813 0 -0.000270014052182
Gc18_814 0 n36 ns814 0 -0.000573336580659
Gc18_815 0 n36 ns815 0 -0.0014372440959
Gc18_816 0 n36 ns816 0 -0.000415025291536
Gc18_817 0 n36 ns817 0 0.00106487438577
Gc18_818 0 n36 ns818 0 0.000257301269308
Gc18_819 0 n36 ns819 0 -2.33831236789e-05
Gc18_820 0 n36 ns820 0 -0.00146129688305
Gc18_821 0 n36 ns821 0 0.000342011584444
Gc18_822 0 n36 ns822 0 0.00081836555966
Gc18_823 0 n36 ns823 0 0.00112322646072
Gc18_824 0 n36 ns824 0 -0.00025266802903
Gc18_825 0 n36 ns825 0 -0.000909786728699
Gc18_826 0 n36 ns826 0 -0.00203287585836
Gc18_827 0 n36 ns827 0 8.16549786251e-05
Gc18_828 0 n36 ns828 0 0.000508830850531
Gc18_829 0 n36 ns829 0 0.00127897636269
Gc18_830 0 n36 ns830 0 0.000456135568689
Gc18_831 0 n36 ns831 0 -0.000588038991322
Gc18_832 0 n36 ns832 0 0.004140600046
Gc18_833 0 n36 ns833 0 -0.00489098934493
Gc18_834 0 n36 ns834 0 0.000422257065518
Gc18_835 0 n36 ns835 0 -5.24173299171e-06
Gc18_836 0 n36 ns836 0 -1.84491151627e-05
Gc18_837 0 n36 ns837 0 0.000348809919378
Gc18_838 0 n36 ns838 0 -0.000998136010751
Gc18_839 0 n36 ns839 0 0.000925894382747
Gc18_840 0 n36 ns840 0 9.19073124799e-05
Gc18_841 0 n36 ns841 0 -8.8381683726e-05
Gc18_842 0 n36 ns842 0 8.49814570877e-05
Gc18_843 0 n36 ns843 0 -5.14786168553e-05
Gc18_844 0 n36 ns844 0 1.06629915334e-05
Gc18_845 0 n36 ns845 0 -2.0776473188e-05
Gc18_846 0 n36 ns846 0 -0.0009723205249
Gc18_847 0 n36 ns847 0 0.000399817339091
Gc18_848 0 n36 ns848 0 0.000484090564839
Gc18_849 0 n36 ns849 0 -0.000415030319902
Gc18_850 0 n36 ns850 0 -0.000172232214367
Gc18_851 0 n36 ns851 0 -6.43897324392e-05
Gc18_852 0 n36 ns852 0 -0.00111124313561
Gc18_853 0 n36 ns853 0 0.00020343696925
Gc18_854 0 n36 ns854 0 0.000569220756531
Gc18_855 0 n36 ns855 0 0.000535810011027
Gc18_856 0 n36 ns856 0 0.000109457551469
Gc18_857 0 n36 ns857 0 -0.000168281573841
Gc18_858 0 n36 ns858 0 0.000134840633353
Gc18_859 0 n36 ns859 0 0.00128158219521
Gc18_860 0 n36 ns860 0 0.000972404976136
Gc18_861 0 n36 ns861 0 -0.000125280012564
Gc18_862 0 n36 ns862 0 -0.000614894356099
Gc18_863 0 n36 ns863 0 -0.000254733768181
Gc18_864 0 n36 ns864 0 0.000119058249821
Gc18_865 0 n36 ns865 0 0.000737001716998
Gc18_866 0 n36 ns866 0 0.000408670061041
Gc18_867 0 n36 ns867 0 0.000274933969363
Gc18_868 0 n36 ns868 0 5.40698578649e-05
Gc18_869 0 n36 ns869 0 -0.000352148872385
Gc18_870 0 n36 ns870 0 0.0100698611743
Gc18_871 0 n36 ns871 0 -0.00903101228199
Gc18_872 0 n36 ns872 0 0.000389281479489
Gc18_873 0 n36 ns873 0 -3.94056700827e-06
Gc18_874 0 n36 ns874 0 -3.07219551134e-05
Gc18_875 0 n36 ns875 0 -4.08137038649e-05
Gc18_876 0 n36 ns876 0 0.000221819972069
Gc18_877 0 n36 ns877 0 -0.00296848420488
Gc18_878 0 n36 ns878 0 -0.000249348784415
Gc18_879 0 n36 ns879 0 -0.000178405708676
Gc18_880 0 n36 ns880 0 -0.000161405753876
Gc18_881 0 n36 ns881 0 2.14272133802e-05
Gc18_882 0 n36 ns882 0 6.37774176738e-07
Gc18_883 0 n36 ns883 0 1.26078957401e-05
Gc18_884 0 n36 ns884 0 0.000649953811599
Gc18_885 0 n36 ns885 0 0.00129181471833
Gc18_886 0 n36 ns886 0 -0.000371164471904
Gc18_887 0 n36 ns887 0 -0.000471723678412
Gc18_888 0 n36 ns888 0 -0.000124853636981
Gc18_889 0 n36 ns889 0 0.000112505712924
Gc18_890 0 n36 ns890 0 6.99979306316e-05
Gc18_891 0 n36 ns891 0 0.0010094956202
Gc18_892 0 n36 ns892 0 0.000530520677363
Gc18_893 0 n36 ns893 0 -0.000275801297495
Gc18_894 0 n36 ns894 0 -5.55604737972e-05
Gc18_895 0 n36 ns895 0 -0.000147379604803
Gc18_896 0 n36 ns896 0 0.0014449184594
Gc18_897 0 n36 ns897 0 0.0007797276099
Gc18_898 0 n36 ns898 0 0.000482434845813
Gc18_899 0 n36 ns899 0 -0.000678559446691
Gc18_900 0 n36 ns900 0 -0.000493488990038
Gc18_901 0 n36 ns901 0 0.00016239492362
Gc18_902 0 n36 ns902 0 0.00176764636449
Gc18_903 0 n36 ns903 0 0.000819289559074
Gc18_904 0 n36 ns904 0 0.000191185605607
Gc18_905 0 n36 ns905 0 -0.000324099993966
Gc18_906 0 n36 ns906 0 -0.000145084932871
Gc18_907 0 n36 ns907 0 -0.000184778852392
Gc18_908 0 n36 ns908 0 0.0172908992149
Gc18_909 0 n36 ns909 0 -0.0145965083648
Gc18_910 0 n36 ns910 0 0.000495396793835
Gc18_911 0 n36 ns911 0 -5.19366844745e-06
Gc18_912 0 n36 ns912 0 -2.80877544254e-05
Gc18_913 0 n36 ns913 0 -0.000153430084722
Gc18_914 0 n36 ns914 0 0.00077081263707
Gc18_915 0 n36 ns915 0 -0.00342303216161
Gc18_916 0 n36 ns916 0 -0.000312731874425
Gc18_917 0 n36 ns917 0 -0.000119941476575
Gc18_918 0 n36 ns918 0 -0.000220939686098
Gc18_919 0 n36 ns919 0 9.58210928236e-05
Gc18_920 0 n36 ns920 0 1.32479301069e-05
Gc18_921 0 n36 ns921 0 4.29993401468e-05
Gc18_922 0 n36 ns922 0 0.00115242168207
Gc18_923 0 n36 ns923 0 0.00078717818433
Gc18_924 0 n36 ns924 0 -0.000523172844796
Gc18_925 0 n36 ns925 0 -0.000125703494004
Gc18_926 0 n36 ns926 0 -3.50379388515e-05
Gc18_927 0 n36 ns927 0 0.000119934225041
Gc18_928 0 n36 ns928 0 0.000426677751318
Gc18_929 0 n36 ns929 0 0.000589763078226
Gc18_930 0 n36 ns930 0 0.000180668581096
Gc18_931 0 n36 ns931 0 -0.000318551961326
Gc18_932 0 n36 ns932 0 -6.19755953487e-05
Gc18_933 0 n36 ns933 0 -5.31160958326e-05
Gc18_934 0 n36 ns934 0 0.00111331743882
Gc18_935 0 n36 ns935 0 0.000371919457342
Gc18_936 0 n36 ns936 0 0.000189783345956
Gc18_937 0 n36 ns937 0 -0.000503964469161
Gc18_938 0 n36 ns938 0 -0.000262716590822
Gc18_939 0 n36 ns939 0 0.000174347887012
Gc18_940 0 n36 ns940 0 0.00155867939498
Gc18_941 0 n36 ns941 0 0.000857832185595
Gc18_942 0 n36 ns942 0 0.000167473249489
Gc18_943 0 n36 ns943 0 -0.000411479881329
Gc18_944 0 n36 ns944 0 -0.000157564718137
Gc18_945 0 n36 ns945 0 -0.000117837007648
Gc18_946 0 n36 ns946 0 0.0157892862765
Gc18_947 0 n36 ns947 0 -0.0133486088296
Gc18_948 0 n36 ns948 0 0.000466893972024
Gc18_949 0 n36 ns949 0 -8.12550007912e-06
Gc18_950 0 n36 ns950 0 -2.24881241072e-05
Gc18_951 0 n36 ns951 0 -0.00454056125704
Gc18_952 0 n36 ns952 0 -0.00245192368973
Gc18_953 0 n36 ns953 0 -0.00107606808801
Gc18_954 0 n36 ns954 0 0.000840623048428
Gc18_955 0 n36 ns955 0 -0.00137507581434
Gc18_956 0 n36 ns956 0 -2.60281141426e-05
Gc18_957 0 n36 ns957 0 0.000934483168121
Gc18_958 0 n36 ns958 0 -9.29652176051e-05
Gc18_959 0 n36 ns959 0 -5.71573774213e-05
Gc18_960 0 n36 ns960 0 -0.00092336110277
Gc18_961 0 n36 ns961 0 0.000609036256444
Gc18_962 0 n36 ns962 0 0.000859894130294
Gc18_963 0 n36 ns963 0 -0.000561157714592
Gc18_964 0 n36 ns964 0 0.000336132018127
Gc18_965 0 n36 ns965 0 -0.000233039620827
Gc18_966 0 n36 ns966 0 -0.000823425829759
Gc18_967 0 n36 ns967 0 -0.00117451082002
Gc18_968 0 n36 ns968 0 0.000486785000432
Gc18_969 0 n36 ns969 0 -1.95875258028e-05
Gc18_970 0 n36 ns970 0 0.000272163600259
Gc18_971 0 n36 ns971 0 0.00029203152709
Gc18_972 0 n36 ns972 0 -0.00277400362861
Gc18_973 0 n36 ns973 0 0.00135658928612
Gc18_974 0 n36 ns974 0 0.00122733723536
Gc18_975 0 n36 ns975 0 0.00118227795731
Gc18_976 0 n36 ns976 0 0.00109175400675
Gc18_977 0 n36 ns977 0 -0.00126085517183
Gc18_978 0 n36 ns978 0 0.000387926232537
Gc18_979 0 n36 ns979 0 0.00210519756263
Gc18_980 0 n36 ns980 0 -1.09330947513e-05
Gc18_981 0 n36 ns981 0 -0.00128139434115
Gc18_982 0 n36 ns982 0 0.00223369077359
Gc18_983 0 n36 ns983 0 0.000643018362574
Gc18_984 0 n36 ns984 0 0.0167669445656
Gc18_985 0 n36 ns985 0 -0.0174577820016
Gc18_986 0 n36 ns986 0 0.00648923195668
Gc18_987 0 n36 ns987 0 -2.55106882665e-06
Gc18_988 0 n36 ns988 0 2.66537744927e-05
Gc18_989 0 n36 ns989 0 -0.0015726428223
Gc18_990 0 n36 ns990 0 0.000933933004068
Gc18_991 0 n36 ns991 0 -0.00147213622259
Gc18_992 0 n36 ns992 0 0.000691162328605
Gc18_993 0 n36 ns993 0 -0.000749922764618
Gc18_994 0 n36 ns994 0 0.000548874912861
Gc18_995 0 n36 ns995 0 -0.000123179694879
Gc18_996 0 n36 ns996 0 -0.000121356779147
Gc18_997 0 n36 ns997 0 -2.06654985969e-05
Gc18_998 0 n36 ns998 0 -0.00240284810746
Gc18_999 0 n36 ns999 0 0.000399146725692
Gc18_1000 0 n36 ns1000 0 0.000335772556928
Gc18_1001 0 n36 ns1001 0 -0.000581488332809
Gc18_1002 0 n36 ns1002 0 0.000338586200813
Gc18_1003 0 n36 ns1003 0 -0.00036882009593
Gc18_1004 0 n36 ns1004 0 -0.00163696844894
Gc18_1005 0 n36 ns1005 0 0.00102044206951
Gc18_1006 0 n36 ns1006 0 0.000243834692728
Gc18_1007 0 n36 ns1007 0 -0.000535871532362
Gc18_1008 0 n36 ns1008 0 0.000338182778282
Gc18_1009 0 n36 ns1009 0 0.000163826661037
Gc18_1010 0 n36 ns1010 0 -0.000563674537827
Gc18_1011 0 n36 ns1011 0 0.00321415983966
Gc18_1012 0 n36 ns1012 0 2.94434116802e-05
Gc18_1013 0 n36 ns1013 0 0.00011741595379
Gc18_1014 0 n36 ns1014 0 0.000695392640548
Gc18_1015 0 n36 ns1015 0 -0.000963229396006
Gc18_1016 0 n36 ns1016 0 0.00206860508853
Gc18_1017 0 n36 ns1017 0 0.00197202848566
Gc18_1018 0 n36 ns1018 0 -0.00230243614546
Gc18_1019 0 n36 ns1019 0 -5.0866643476e-05
Gc18_1020 0 n36 ns1020 0 0.00166802663026
Gc18_1021 0 n36 ns1021 0 6.26736013772e-05
Gc18_1022 0 n36 ns1022 0 0.0471105787933
Gc18_1023 0 n36 ns1023 0 -0.0462599405224
Gc18_1024 0 n36 ns1024 0 0.00365170518385
Gc18_1025 0 n36 ns1025 0 -4.55087060506e-07
Gc18_1026 0 n36 ns1026 0 2.80916945579e-05
Gc18_1027 0 n36 ns1027 0 -0.00129571768378
Gc18_1028 0 n36 ns1028 0 0.00260535095327
Gc18_1029 0 n36 ns1029 0 -0.00363919445736
Gc18_1030 0 n36 ns1030 0 -5.52200356076e-05
Gc18_1031 0 n36 ns1031 0 -0.000321100355871
Gc18_1032 0 n36 ns1032 0 -0.000163327414961
Gc18_1033 0 n36 ns1033 0 -0.00023448804265
Gc18_1034 0 n36 ns1034 0 -3.56596554683e-05
Gc18_1035 0 n36 ns1035 0 6.58207456132e-06
Gc18_1036 0 n36 ns1036 0 -0.000171648749984
Gc18_1037 0 n36 ns1037 0 0.00142961402688
Gc18_1038 0 n36 ns1038 0 -0.000348552336138
Gc18_1039 0 n36 ns1039 0 0.000158062633018
Gc18_1040 0 n36 ns1040 0 0.000124361521695
Gc18_1041 0 n36 ns1041 0 -0.000353070277955
Gc18_1042 0 n36 ns1042 0 0.00137434536574
Gc18_1043 0 n36 ns1043 0 0.00107961538403
Gc18_1044 0 n36 ns1044 0 -0.000801880248204
Gc18_1045 0 n36 ns1045 0 -0.00056744061789
Gc18_1046 0 n36 ns1046 0 0.000233288967084
Gc18_1047 0 n36 ns1047 0 5.11771458624e-05
Gc18_1048 0 n36 ns1048 0 0.00131206350873
Gc18_1049 0 n36 ns1049 0 0.000246860564375
Gc18_1050 0 n36 ns1050 0 -0.000547457959828
Gc18_1051 0 n36 ns1051 0 0.0010585895042
Gc18_1052 0 n36 ns1052 0 0.000532015463482
Gc18_1053 0 n36 ns1053 0 -0.00105571873622
Gc18_1054 0 n36 ns1054 0 0.00105932494998
Gc18_1055 0 n36 ns1055 0 -0.000692732959324
Gc18_1056 0 n36 ns1056 0 -0.00102095001265
Gc18_1057 0 n36 ns1057 0 0.00158702645855
Gc18_1058 0 n36 ns1058 0 0.00112348442136
Gc18_1059 0 n36 ns1059 0 -0.000555197066932
Gc18_1060 0 n36 ns1060 0 0.0277652473049
Gc18_1061 0 n36 ns1061 0 -0.0259186123942
Gc18_1062 0 n36 ns1062 0 0.00152060780045
Gc18_1063 0 n36 ns1063 0 -7.34884812591e-06
Gc18_1064 0 n36 ns1064 0 1.55521740823e-05
Gc18_1065 0 n36 ns1065 0 -0.00038272342567
Gc18_1066 0 n36 ns1066 0 0.000611811847505
Gc18_1067 0 n36 ns1067 0 0.00104021588424
Gc18_1068 0 n36 ns1068 0 -4.19115180447e-05
Gc18_1069 0 n36 ns1069 0 0.000131631739229
Gc18_1070 0 n36 ns1070 0 -3.94523490932e-05
Gc18_1071 0 n36 ns1071 0 0.000137305336431
Gc18_1072 0 n36 ns1072 0 -3.20691717576e-06
Gc18_1073 0 n36 ns1073 0 3.40574404949e-06
Gc18_1074 0 n36 ns1074 0 5.72705367278e-06
Gc18_1075 0 n36 ns1075 0 -0.000591131173242
Gc18_1076 0 n36 ns1076 0 0.000485194171059
Gc18_1077 0 n36 ns1077 0 0.000626261815382
Gc18_1078 0 n36 ns1078 0 -2.55296322039e-05
Gc18_1079 0 n36 ns1079 0 -0.000319530447216
Gc18_1080 0 n36 ns1080 0 0.000425502458385
Gc18_1081 0 n36 ns1081 0 -0.00154697190754
Gc18_1082 0 n36 ns1082 0 -0.000906491731372
Gc18_1083 0 n36 ns1083 0 0.000800071440629
Gc18_1084 0 n36 ns1084 0 0.000253989946487
Gc18_1085 0 n36 ns1085 0 3.36066587946e-05
Gc18_1086 0 n36 ns1086 0 -0.00127802228451
Gc18_1087 0 n36 ns1087 0 -0.000446111670924
Gc18_1088 0 n36 ns1088 0 0.000426209273317
Gc18_1089 0 n36 ns1089 0 0.00148855941275
Gc18_1090 0 n36 ns1090 0 8.13644077901e-06
Gc18_1091 0 n36 ns1091 0 -0.00107981554733
Gc18_1092 0 n36 ns1092 0 -0.00215540642932
Gc18_1093 0 n36 ns1093 0 -0.000582764759031
Gc18_1094 0 n36 ns1094 0 0.000305933158223
Gc18_1095 0 n36 ns1095 0 0.00167020088637
Gc18_1096 0 n36 ns1096 0 0.000653762803918
Gc18_1097 0 n36 ns1097 0 -0.00064622208841
Gc18_1098 0 n36 ns1098 0 0.00546844149633
Gc18_1099 0 n36 ns1099 0 -0.00623365796006
Gc18_1100 0 n36 ns1100 0 0.000541584864155
Gc18_1101 0 n36 ns1101 0 -6.50826084536e-06
Gc18_1102 0 n36 ns1102 0 -6.81351365051e-06
Gc18_1103 0 n36 ns1103 0 0.000373743433996
Gc18_1104 0 n36 ns1104 0 -0.000869786771416
Gc18_1105 0 n36 ns1105 0 0.00249774470027
Gc18_1106 0 n36 ns1106 0 6.09701607678e-05
Gc18_1107 0 n36 ns1107 0 0.000198905087654
Gc18_1108 0 n36 ns1108 0 0.000282301604379
Gc18_1109 0 n36 ns1109 0 -9.07573876535e-08
Gc18_1110 0 n36 ns1110 0 2.64867329541e-06
Gc18_1111 0 n36 ns1111 0 -3.43695307841e-05
Gc18_1112 0 n36 ns1112 0 -0.00120979752166
Gc18_1113 0 n36 ns1113 0 -0.000505621447599
Gc18_1114 0 n36 ns1114 0 0.000812325712834
Gc18_1115 0 n36 ns1115 0 -8.09833752456e-05
Gc18_1116 0 n36 ns1116 0 -0.000144961098873
Gc18_1117 0 n36 ns1117 0 -0.000162767190978
Gc18_1118 0 n36 ns1118 0 -0.00125779776412
Gc18_1119 0 n36 ns1119 0 -0.000659231157856
Gc18_1120 0 n36 ns1120 0 0.000243026612351
Gc18_1121 0 n36 ns1121 0 0.000920891023205
Gc18_1122 0 n36 ns1122 0 0.000184191562341
Gc18_1123 0 n36 ns1123 0 -0.000117617052645
Gc18_1124 0 n36 ns1124 0 -0.00080545487792
Gc18_1125 0 n36 ns1125 0 0.00100667302536
Gc18_1126 0 n36 ns1126 0 0.00103967296671
Gc18_1127 0 n36 ns1127 0 0.000384999500474
Gc18_1128 0 n36 ns1128 0 -0.000532906349464
Gc18_1129 0 n36 ns1129 0 -0.000533048158243
Gc18_1130 0 n36 ns1130 0 -0.00107155820954
Gc18_1131 0 n36 ns1131 0 0.000164007697102
Gc18_1132 0 n36 ns1132 0 0.000370821972557
Gc18_1133 0 n36 ns1133 0 0.000765198053344
Gc18_1134 0 n36 ns1134 0 0.000245977632637
Gc18_1135 0 n36 ns1135 0 -0.000394940335366
Gc18_1136 0 n36 ns1136 0 0.00259199289392
Gc18_1137 0 n36 ns1137 0 -0.0029793600604
Gc18_1138 0 n36 ns1138 0 0.000246389980467
Gc18_1139 0 n36 ns1139 0 -3.98520232168e-06
Gc18_1140 0 n36 ns1140 0 -2.56477494532e-05
Gc18_1141 0 n36 ns1141 0 0.000122779704797
Gc18_1142 0 n36 ns1142 0 -0.000232222216312
Gc18_1143 0 n36 ns1143 0 -0.00141987990695
Gc18_1144 0 n36 ns1144 0 -0.000128578115067
Gc18_1145 0 n36 ns1145 0 -8.63615156692e-05
Gc18_1146 0 n36 ns1146 0 1.34976440871e-06
Gc18_1147 0 n36 ns1147 0 -4.93951314239e-05
Gc18_1148 0 n36 ns1148 0 -1.18338808347e-05
Gc18_1149 0 n36 ns1149 0 -1.44765131118e-05
Gc18_1150 0 n36 ns1150 0 -8.25958419045e-05
Gc18_1151 0 n36 ns1151 0 0.00108106518142
Gc18_1152 0 n36 ns1152 0 -2.98478116995e-05
Gc18_1153 0 n36 ns1153 0 -0.000553912053237
Gc18_1154 0 n36 ns1154 0 -0.000160189151146
Gc18_1155 0 n36 ns1155 0 5.27526852153e-05
Gc18_1156 0 n36 ns1156 0 -0.000388395976984
Gc18_1157 0 n36 ns1157 0 0.000872195031749
Gc18_1158 0 n36 ns1158 0 0.000631722689042
Gc18_1159 0 n36 ns1159 0 -3.55018670372e-05
Gc18_1160 0 n36 ns1160 0 -1.16049379206e-05
Gc18_1161 0 n36 ns1161 0 -0.000174149359276
Gc18_1162 0 n36 ns1162 0 0.00108801422107
Gc18_1163 0 n36 ns1163 0 0.000944872398844
Gc18_1164 0 n36 ns1164 0 0.000641466872068
Gc18_1165 0 n36 ns1165 0 -0.00056389501818
Gc18_1166 0 n36 ns1166 0 -0.000555791902716
Gc18_1167 0 n36 ns1167 0 6.4709858828e-05
Gc18_1168 0 n36 ns1168 0 0.00112538063915
Gc18_1169 0 n36 ns1169 0 0.00063451872136
Gc18_1170 0 n36 ns1170 0 0.000241554179993
Gc18_1171 0 n36 ns1171 0 -6.80091997292e-05
Gc18_1172 0 n36 ns1172 0 -6.22252529211e-05
Gc18_1173 0 n36 ns1173 0 -0.000232017659185
Gc18_1174 0 n36 ns1174 0 0.0137290758837
Gc18_1175 0 n36 ns1175 0 -0.0117572474508
Gc18_1176 0 n36 ns1176 0 0.000426913769603
Gc18_1177 0 n36 ns1177 0 -4.86926249134e-06
Gc18_1178 0 n36 ns1178 0 -3.05379343198e-05
Gc18_1179 0 n36 ns1179 0 -9.81983445822e-05
Gc18_1180 0 n36 ns1180 0 0.000670664480657
Gc18_1181 0 n36 ns1181 0 -0.00349476555049
Gc18_1182 0 n36 ns1182 0 -0.000346876289538
Gc18_1183 0 n36 ns1183 0 -0.0001323847497
Gc18_1184 0 n36 ns1184 0 -0.000232357718265
Gc18_1185 0 n36 ns1185 0 5.63286562869e-05
Gc18_1186 0 n36 ns1186 0 6.45768868631e-06
Gc18_1187 0 n36 ns1187 0 4.63096432418e-05
Gc18_1188 0 n36 ns1188 0 0.00120370268741
Gc18_1189 0 n36 ns1189 0 0.0010748760788
Gc18_1190 0 n36 ns1190 0 -0.000577851014944
Gc18_1191 0 n36 ns1191 0 -0.000259226919498
Gc18_1192 0 n36 ns1192 0 -6.89343849086e-05
Gc18_1193 0 n36 ns1193 0 0.000141166896452
Gc18_1194 0 n36 ns1194 0 0.000437142656044
Gc18_1195 0 n36 ns1195 0 0.000788482228581
Gc18_1196 0 n36 ns1196 0 0.000292324507899
Gc18_1197 0 n36 ns1197 0 -0.000380981367545
Gc18_1198 0 n36 ns1198 0 -7.81095579105e-05
Gc18_1199 0 n36 ns1199 0 -8.68619208947e-05
Gc18_1200 0 n36 ns1200 0 0.00134118719918
Gc18_1201 0 n36 ns1201 0 0.000391305628911
Gc18_1202 0 n36 ns1202 0 0.000227927178152
Gc18_1203 0 n36 ns1203 0 -0.000616192198448
Gc18_1204 0 n36 ns1204 0 -0.000330574888088
Gc18_1205 0 n36 ns1205 0 0.00021783831562
Gc18_1206 0 n36 ns1206 0 0.00162597768591
Gc18_1207 0 n36 ns1207 0 0.000748632045195
Gc18_1208 0 n36 ns1208 0 0.000172407488468
Gc18_1209 0 n36 ns1209 0 -0.000367447025659
Gc18_1210 0 n36 ns1210 0 -0.000154738973204
Gc18_1211 0 n36 ns1211 0 -0.000139572484819
Gc18_1212 0 n36 ns1212 0 0.0162102806449
Gc18_1213 0 n36 ns1213 0 -0.0136702064483
Gc18_1214 0 n36 ns1214 0 0.000470321907965
Gc18_1215 0 n36 ns1215 0 -6.00706976809e-06
Gc18_1216 0 n36 ns1216 0 -2.47461497791e-05
Gd18_1 0 n36 ni1 0 -0.00313862162866
Gd18_2 0 n36 ni2 0 -0.00652419050407
Gd18_3 0 n36 ni3 0 -0.000504433866781
Gd18_4 0 n36 ni4 0 0.000564920467513
Gd18_5 0 n36 ni5 0 0.000144148589436
Gd18_6 0 n36 ni6 0 7.52088235493e-05
Gd18_7 0 n36 ni7 0 -2.49048153995e-05
Gd18_8 0 n36 ni8 0 -1.35950055479e-05
Gd18_9 0 n36 ni9 0 -0.000124651054487
Gd18_10 0 n36 ni10 0 -0.00151246325849
Gd18_11 0 n36 ni11 0 -6.66929892359e-05
Gd18_12 0 n36 ni12 0 0.000240791588235
Gd18_13 0 n36 ni13 0 4.9469939405e-05
Gd18_14 0 n36 ni14 0 -7.42392958535e-05
Gd18_15 0 n36 ni15 0 -7.7104360815e-06
Gd18_16 0 n36 ni16 0 -0.000120725365898
Gd18_17 0 n36 ni17 0 -0.00271624012929
Gd18_18 0 n36 ni18 0 -0.000247544574508
Gd18_19 0 n36 ni19 0 -0.00171135369751
Gd18_20 0 n36 ni20 0 -0.000206375649823
Gd18_21 0 n36 ni21 0 0.000339036541529
Gd18_22 0 n36 ni22 0 3.1791271875e-05
Gd18_23 0 n36 ni23 0 -6.72281731269e-05
Gd18_24 0 n36 ni24 0 -8.17675049674e-05
Gd18_25 0 n36 ni25 0 1.096818707e-05
Gd18_26 0 n36 ni26 0 -0.00288761202446
Gd18_27 0 n36 ni27 0 -0.000625187378338
Gd18_28 0 n36 ni28 0 0.000228167915453
Gd18_29 0 n36 ni29 0 0.000178916702292
Gd18_30 0 n36 ni30 0 0.000123030940579
Gd18_31 0 n36 ni31 0 -4.21044084266e-05
Gd18_32 0 n36 ni32 0 8.29686851148e-06
Gc19_1 0 n38 ns1 0 0.000238164812308
Gc19_2 0 n38 ns2 0 -0.00030605822909
Gc19_3 0 n38 ns3 0 0.00744982299164
Gc19_4 0 n38 ns4 0 -9.85834858844e-05
Gc19_5 0 n38 ns5 0 -6.77610161951e-05
Gc19_6 0 n38 ns6 0 0.000257048044486
Gc19_7 0 n38 ns7 0 -0.000756561554505
Gc19_8 0 n38 ns8 0 -0.000134401542215
Gc19_9 0 n38 ns9 0 1.61122952895e-05
Gc19_10 0 n38 ns10 0 0.00186912259602
Gc19_11 0 n38 ns11 0 -0.00170423505384
Gc19_12 0 n38 ns12 0 -0.000449139802616
Gc19_13 0 n38 ns13 0 0.000757395396789
Gc19_14 0 n38 ns14 0 -0.000259230792075
Gc19_15 0 n38 ns15 0 0.000210606273882
Gc19_16 0 n38 ns16 0 -0.0022414645287
Gc19_17 0 n38 ns17 0 -0.00175399558448
Gc19_18 0 n38 ns18 0 0.000123162587653
Gc19_19 0 n38 ns19 0 0.000152705400615
Gc19_20 0 n38 ns20 0 0.000249763598585
Gc19_21 0 n38 ns21 0 0.0003201893998
Gc19_22 0 n38 ns22 0 -0.000286076202309
Gc19_23 0 n38 ns23 0 -0.00556459436135
Gc19_24 0 n38 ns24 0 -0.00204990619624
Gc19_25 0 n38 ns25 0 0.000798504788366
Gc19_26 0 n38 ns26 0 0.000214292667045
Gc19_27 0 n38 ns27 0 0.000994372051174
Gc19_28 0 n38 ns28 0 -0.00777587738767
Gc19_29 0 n38 ns29 0 -0.00317453961935
Gc19_30 0 n38 ns30 0 -0.00218566757323
Gc19_31 0 n38 ns31 0 0.000912785622626
Gc19_32 0 n38 ns32 0 0.00223372766047
Gc19_33 0 n38 ns33 0 0.000665559232669
Gc19_34 0 n38 ns34 0 -0.0776557476503
Gc19_35 0 n38 ns35 0 0.0720926630517
Gc19_36 0 n38 ns36 0 -0.00506663140462
Gc19_37 0 n38 ns37 0 -6.68404631829e-06
Gc19_38 0 n38 ns38 0 2.33535302102e-05
Gc19_39 0 n38 ns39 0 -0.000359365859048
Gc19_40 0 n38 ns40 0 -0.000473129609785
Gc19_41 0 n38 ns41 0 0.00564626050562
Gc19_42 0 n38 ns42 0 -0.000850670428924
Gc19_43 0 n38 ns43 0 -0.000926000505598
Gc19_44 0 n38 ns44 0 0.00140953377736
Gc19_45 0 n38 ns45 0 0.000414098681724
Gc19_46 0 n38 ns46 0 -0.000191180074249
Gc19_47 0 n38 ns47 0 -0.000147719921703
Gc19_48 0 n38 ns48 0 0.00155697904897
Gc19_49 0 n38 ns49 0 -0.00188110575619
Gc19_50 0 n38 ns50 0 -0.00038818125707
Gc19_51 0 n38 ns51 0 0.00101021776885
Gc19_52 0 n38 ns52 0 -0.000253615601692
Gc19_53 0 n38 ns53 0 0.000270837413335
Gc19_54 0 n38 ns54 0 -0.000988776370733
Gc19_55 0 n38 ns55 0 -0.00234366120905
Gc19_56 0 n38 ns56 0 -0.00027555931035
Gc19_57 0 n38 ns57 0 -0.00023401584476
Gc19_58 0 n38 ns58 0 0.00019147592113
Gc19_59 0 n38 ns59 0 0.000390407144547
Gc19_60 0 n38 ns60 0 0.000667942679338
Gc19_61 0 n38 ns61 0 -0.00465746887798
Gc19_62 0 n38 ns62 0 -0.00188520760124
Gc19_63 0 n38 ns63 0 7.97887388261e-05
Gc19_64 0 n38 ns64 0 -0.000227132245997
Gc19_65 0 n38 ns65 0 0.00126901085958
Gc19_66 0 n38 ns66 0 -0.00970286061405
Gc19_67 0 n38 ns67 0 -0.00419406695397
Gc19_68 0 n38 ns68 0 -0.00169565870291
Gc19_69 0 n38 ns69 0 0.00150526182974
Gc19_70 0 n38 ns70 0 0.00281779435656
Gc19_71 0 n38 ns71 0 0.000788684934598
Gc19_72 0 n38 ns72 0 -0.0651283786981
Gc19_73 0 n38 ns73 0 0.0629946154041
Gc19_74 0 n38 ns74 0 -0.00647871000763
Gc19_75 0 n38 ns75 0 -9.2147004791e-06
Gc19_76 0 n38 ns76 0 2.94633510286e-05
Gc19_77 0 n38 ns77 0 -0.0175123213257
Gc19_78 0 n38 ns78 0 -0.000546618076169
Gc19_79 0 n38 ns79 0 0.0192151033722
Gc19_80 0 n38 ns80 0 0.00635254319961
Gc19_81 0 n38 ns81 0 0.0101912778924
Gc19_82 0 n38 ns82 0 0.00150890395012
Gc19_83 0 n38 ns83 0 -0.00324412421567
Gc19_84 0 n38 ns84 0 -0.000495792651368
Gc19_85 0 n38 ns85 0 4.36660876648e-05
Gc19_86 0 n38 ns86 0 -0.00207522480016
Gc19_87 0 n38 ns87 0 -0.0140078312756
Gc19_88 0 n38 ns88 0 0.00171836332123
Gc19_89 0 n38 ns89 0 0.00176952450211
Gc19_90 0 n38 ns90 0 6.20937042488e-05
Gc19_91 0 n38 ns91 0 0.000240044621922
Gc19_92 0 n38 ns92 0 0.00109822403977
Gc19_93 0 n38 ns93 0 0.00111951220796
Gc19_94 0 n38 ns94 0 -0.000261280438303
Gc19_95 0 n38 ns95 0 -0.000231055073042
Gc19_96 0 n38 ns96 0 0.000393225160612
Gc19_97 0 n38 ns97 0 0.000483131615413
Gc19_98 0 n38 ns98 0 -0.011897375088
Gc19_99 0 n38 ns99 0 -0.00718895716917
Gc19_100 0 n38 ns100 0 -0.00258166792284
Gc19_101 0 n38 ns101 0 -0.00120616289601
Gc19_102 0 n38 ns102 0 -0.000495910473986
Gc19_103 0 n38 ns103 0 0.00219979662544
Gc19_104 0 n38 ns104 0 0.00994004868873
Gc19_105 0 n38 ns105 0 -0.00597819576112
Gc19_106 0 n38 ns106 0 0.00109600630829
Gc19_107 0 n38 ns107 0 0.00157019958524
Gc19_108 0 n38 ns108 0 0.00334860878899
Gc19_109 0 n38 ns109 0 0.000277856257729
Gc19_110 0 n38 ns110 0 -0.107735032718
Gc19_111 0 n38 ns111 0 0.0701459682889
Gc19_112 0 n38 ns112 0 -0.00884454250815
Gc19_113 0 n38 ns113 0 -1.45081471411e-05
Gc19_114 0 n38 ns114 0 2.92989025151e-05
Gc19_115 0 n38 ns115 0 -0.000361344991074
Gc19_116 0 n38 ns116 0 -6.23173379558e-05
Gc19_117 0 n38 ns117 0 0.00636319929423
Gc19_118 0 n38 ns118 0 -0.00111316091978
Gc19_119 0 n38 ns119 0 -0.000592722085956
Gc19_120 0 n38 ns120 0 0.00183350125715
Gc19_121 0 n38 ns121 0 0.000428929180516
Gc19_122 0 n38 ns122 0 -0.000177588718891
Gc19_123 0 n38 ns123 0 -0.000203051271468
Gc19_124 0 n38 ns124 0 0.00189785515859
Gc19_125 0 n38 ns125 0 -0.00158002605511
Gc19_126 0 n38 ns126 0 -0.00060997259099
Gc19_127 0 n38 ns127 0 0.000376807582652
Gc19_128 0 n38 ns128 0 -0.000271805388807
Gc19_129 0 n38 ns129 0 0.000519487573655
Gc19_130 0 n38 ns130 0 5.8716942803e-05
Gc19_131 0 n38 ns131 0 -0.00385908827537
Gc19_132 0 n38 ns132 0 -0.00139834186196
Gc19_133 0 n38 ns133 0 0.00027752248435
Gc19_134 0 n38 ns134 0 0.000335039437731
Gc19_135 0 n38 ns135 0 0.000496295329533
Gc19_136 0 n38 ns136 0 0.000822133701449
Gc19_137 0 n38 ns137 0 -0.00495839837643
Gc19_138 0 n38 ns138 0 -0.00248286620707
Gc19_139 0 n38 ns139 0 -0.0012207809805
Gc19_140 0 n38 ns140 0 -0.000132380612995
Gc19_141 0 n38 ns141 0 0.00225317620933
Gc19_142 0 n38 ns142 0 -0.0123824400024
Gc19_143 0 n38 ns143 0 -0.00600902248109
Gc19_144 0 n38 ns144 0 -0.00118163087137
Gc19_145 0 n38 ns145 0 0.00308772183821
Gc19_146 0 n38 ns146 0 0.00315323403466
Gc19_147 0 n38 ns147 0 0.000335504449469
Gc19_148 0 n38 ns148 0 -0.0721326660034
Gc19_149 0 n38 ns149 0 0.0682289610297
Gc19_150 0 n38 ns150 0 -0.00649476801245
Gc19_151 0 n38 ns151 0 -1.1735694086e-05
Gc19_152 0 n38 ns152 0 2.56689396364e-05
Gc19_153 0 n38 ns153 0 0.000754834962076
Gc19_154 0 n38 ns154 0 -0.00107597521029
Gc19_155 0 n38 ns155 0 0.0115012968411
Gc19_156 0 n38 ns156 0 0.000241405720043
Gc19_157 0 n38 ns157 0 0.000653746153386
Gc19_158 0 n38 ns158 0 0.000372418651924
Gc19_159 0 n38 ns159 0 -0.000248589385092
Gc19_160 0 n38 ns160 0 -0.000116622361075
Gc19_161 0 n38 ns161 0 -6.74765849115e-06
Gc19_162 0 n38 ns162 0 0.000377420661993
Gc19_163 0 n38 ns163 0 -0.00445432342151
Gc19_164 0 n38 ns164 0 -0.000112298832896
Gc19_165 0 n38 ns165 0 0.00106937650403
Gc19_166 0 n38 ns166 0 0.000148904343395
Gc19_167 0 n38 ns167 0 0.000555375270662
Gc19_168 0 n38 ns168 0 -0.00126455530469
Gc19_169 0 n38 ns169 0 -0.00120119243106
Gc19_170 0 n38 ns170 0 -0.000644715317486
Gc19_171 0 n38 ns171 0 0.000237519809318
Gc19_172 0 n38 ns172 0 0.000353281180379
Gc19_173 0 n38 ns173 0 0.000127895072948
Gc19_174 0 n38 ns174 0 -0.00250730182001
Gc19_175 0 n38 ns175 0 -0.00502043622613
Gc19_176 0 n38 ns176 0 -0.00159289541511
Gc19_177 0 n38 ns177 0 -0.000201011959453
Gc19_178 0 n38 ns178 0 0.000417329799885
Gc19_179 0 n38 ns179 0 0.00161713961841
Gc19_180 0 n38 ns180 0 -0.009900434966
Gc19_181 0 n38 ns181 0 -0.00608853183131
Gc19_182 0 n38 ns182 0 -0.00164290185806
Gc19_183 0 n38 ns183 0 0.00420470781547
Gc19_184 0 n38 ns184 0 0.00242644183157
Gc19_185 0 n38 ns185 0 -0.000294635838266
Gc19_186 0 n38 ns186 0 -0.0774197318775
Gc19_187 0 n38 ns187 0 0.0672428568148
Gc19_188 0 n38 ns188 0 -0.0031149649573
Gc19_189 0 n38 ns189 0 -9.34558739498e-06
Gc19_190 0 n38 ns190 0 -2.25325322673e-07
Gc19_191 0 n38 ns191 0 0.00030853171676
Gc19_192 0 n38 ns192 0 -0.000640674926657
Gc19_193 0 n38 ns193 0 0.00557030172267
Gc19_194 0 n38 ns194 0 -5.10181301435e-05
Gc19_195 0 n38 ns195 0 0.000379350322273
Gc19_196 0 n38 ns196 0 0.00037635923483
Gc19_197 0 n38 ns197 0 0.00017374402375
Gc19_198 0 n38 ns198 0 2.42526399256e-05
Gc19_199 0 n38 ns199 0 -3.52386481047e-06
Gc19_200 0 n38 ns200 0 -0.000427763215152
Gc19_201 0 n38 ns201 0 -0.00209394019167
Gc19_202 0 n38 ns202 0 0.00015702730908
Gc19_203 0 n38 ns203 0 0.000360558033563
Gc19_204 0 n38 ns204 0 0.000229647673449
Gc19_205 0 n38 ns205 0 0.000298842299114
Gc19_206 0 n38 ns206 0 0.000759666297167
Gc19_207 0 n38 ns207 0 -0.000733340954609
Gc19_208 0 n38 ns208 0 -0.000919838352401
Gc19_209 0 n38 ns209 0 5.81851504667e-05
Gc19_210 0 n38 ns210 0 0.000128992393527
Gc19_211 0 n38 ns211 0 3.03614620886e-06
Gc19_212 0 n38 ns212 0 -0.00101745635303
Gc19_213 0 n38 ns213 0 -0.00245978343999
Gc19_214 0 n38 ns214 0 -0.00114006107775
Gc19_215 0 n38 ns215 0 -0.00110738166516
Gc19_216 0 n38 ns216 0 0.000341728403477
Gc19_217 0 n38 ns217 0 0.00145175847027
Gc19_218 0 n38 ns218 0 -0.00625323716153
Gc19_219 0 n38 ns219 0 -0.00388647037941
Gc19_220 0 n38 ns220 0 -0.000187325577461
Gc19_221 0 n38 ns221 0 0.00333579261446
Gc19_222 0 n38 ns222 0 0.00136370708244
Gc19_223 0 n38 ns223 0 -0.000662495107493
Gc19_224 0 n38 ns224 0 -0.0326694083238
Gc19_225 0 n38 ns225 0 0.0274346213516
Gc19_226 0 n38 ns226 0 -0.00108136477417
Gc19_227 0 n38 ns227 0 -4.72225953822e-06
Gc19_228 0 n38 ns228 0 -2.09102434258e-05
Gc19_229 0 n38 ns229 0 0.000592386660079
Gc19_230 0 n38 ns230 0 -0.000753625235391
Gc19_231 0 n38 ns231 0 0.00341036694239
Gc19_232 0 n38 ns232 0 -0.000174774659916
Gc19_233 0 n38 ns233 0 0.000332702632808
Gc19_234 0 n38 ns234 0 0.000255572908187
Gc19_235 0 n38 ns235 0 -3.85645631828e-05
Gc19_236 0 n38 ns236 0 3.59931990368e-06
Gc19_237 0 n38 ns237 0 -4.8239005586e-05
Gc19_238 0 n38 ns238 0 0.000488312308197
Gc19_239 0 n38 ns239 0 -0.000551843735859
Gc19_240 0 n38 ns240 0 -0.000403255629723
Gc19_241 0 n38 ns241 0 -2.37770491954e-05
Gc19_242 0 n38 ns242 0 0.00013120792778
Gc19_243 0 n38 ns243 0 0.000181800369956
Gc19_244 0 n38 ns244 0 -1.36627411089e-05
Gc19_245 0 n38 ns245 0 -0.00123982726107
Gc19_246 0 n38 ns246 0 -0.000405825729545
Gc19_247 0 n38 ns247 0 0.000674497750277
Gc19_248 0 n38 ns248 0 0.000133913757745
Gc19_249 0 n38 ns249 0 -5.01244306275e-05
Gc19_250 0 n38 ns250 0 -0.000317535927424
Gc19_251 0 n38 ns251 0 -0.00140479415341
Gc19_252 0 n38 ns252 0 -0.00136359837898
Gc19_253 0 n38 ns253 0 -0.000596592253546
Gc19_254 0 n38 ns254 0 0.000661684870955
Gc19_255 0 n38 ns255 0 0.000893941480594
Gc19_256 0 n38 ns256 0 -0.00416837157198
Gc19_257 0 n38 ns257 0 -0.0012559995991
Gc19_258 0 n38 ns258 0 0.000635648538798
Gc19_259 0 n38 ns259 0 0.00186565592318
Gc19_260 0 n38 ns260 0 0.000605757593588
Gc19_261 0 n38 ns261 0 -0.000621028830677
Gc19_262 0 n38 ns262 0 -0.0114874614444
Gc19_263 0 n38 ns263 0 0.0091317999849
Gc19_264 0 n38 ns264 0 -0.000325787844279
Gc19_265 0 n38 ns265 0 3.58996974891e-06
Gc19_266 0 n38 ns266 0 -3.48132866864e-05
Gc19_267 0 n38 ns267 0 0.000519970862265
Gc19_268 0 n38 ns268 0 -0.00105213136937
Gc19_269 0 n38 ns269 0 0.00193168558769
Gc19_270 0 n38 ns270 0 -0.000114848247105
Gc19_271 0 n38 ns271 0 0.000142269109769
Gc19_272 0 n38 ns272 0 2.78644103103e-05
Gc19_273 0 n38 ns273 0 3.69954562386e-05
Gc19_274 0 n38 ns274 0 -5.10797729909e-06
Gc19_275 0 n38 ns275 0 -4.58570908078e-07
Gc19_276 0 n38 ns276 0 0.00028752983369
Gc19_277 0 n38 ns277 0 -0.000900089166366
Gc19_278 0 n38 ns278 0 -0.000253497746064
Gc19_279 0 n38 ns279 0 0.00051009693275
Gc19_280 0 n38 ns280 0 0.000200808693275
Gc19_281 0 n38 ns281 0 3.51197927063e-05
Gc19_282 0 n38 ns282 0 -0.000649712706875
Gc19_283 0 n38 ns283 0 -5.66749175897e-05
Gc19_284 0 n38 ns284 0 0.000417414160586
Gc19_285 0 n38 ns285 0 0.000325917614458
Gc19_286 0 n38 ns286 0 3.19930673902e-05
Gc19_287 0 n38 ns287 0 -0.000166850858515
Gc19_288 0 n38 ns288 0 -2.65602035314e-05
Gc19_289 0 n38 ns289 0 -0.000931798305429
Gc19_290 0 n38 ns290 0 -0.00103966972346
Gc19_291 0 n38 ns291 0 7.56770759432e-05
Gc19_292 0 n38 ns292 0 0.000635033231161
Gc19_293 0 n38 ns293 0 0.000295704588214
Gc19_294 0 n38 ns294 0 -0.00198180251521
Gc19_295 0 n38 ns295 0 0.000358530807232
Gc19_296 0 n38 ns296 0 0.000693850505736
Gc19_297 0 n38 ns297 0 0.000678041628504
Gc19_298 0 n38 ns298 0 0.000160289205478
Gc19_299 0 n38 ns299 0 -0.000431891490228
Gc19_300 0 n38 ns300 0 -0.000337399004149
Gc19_301 0 n38 ns301 0 -2.23765327458e-05
Gc19_302 0 n38 ns302 0 -4.18202063779e-05
Gc19_303 0 n38 ns303 0 7.33064992371e-06
Gc19_304 0 n38 ns304 0 -3.41244487088e-05
Gc19_305 0 n38 ns305 0 -5.1329125135e-05
Gc19_306 0 n38 ns306 0 2.75088025212e-05
Gc19_307 0 n38 ns307 0 -0.000873377393282
Gc19_308 0 n38 ns308 0 -0.00023295405963
Gc19_309 0 n38 ns309 0 0.000174758270982
Gc19_310 0 n38 ns310 0 5.97596265284e-05
Gc19_311 0 n38 ns311 0 0.000202499507401
Gc19_312 0 n38 ns312 0 3.73410308424e-05
Gc19_313 0 n38 ns313 0 -5.82415535459e-06
Gc19_314 0 n38 ns314 0 -0.000169850067382
Gc19_315 0 n38 ns315 0 -0.000769787822808
Gc19_316 0 n38 ns316 0 0.00017481764063
Gc19_317 0 n38 ns317 0 0.000546155463634
Gc19_318 0 n38 ns318 0 0.000164175512795
Gc19_319 0 n38 ns319 0 -8.91316647047e-05
Gc19_320 0 n38 ns320 0 -0.000242797361365
Gc19_321 0 n38 ns321 0 0.000715948016527
Gc19_322 0 n38 ns322 0 0.000521306223057
Gc19_323 0 n38 ns323 0 -0.000156669154917
Gc19_324 0 n38 ns324 0 -5.29242967225e-05
Gc19_325 0 n38 ns325 0 -0.000157737439633
Gc19_326 0 n38 ns326 0 0.000451890904053
Gc19_327 0 n38 ns327 0 -0.000382801115078
Gc19_328 0 n38 ns328 0 -0.000450805185352
Gc19_329 0 n38 ns329 0 5.80493843176e-05
Gc19_330 0 n38 ns330 0 0.00027490495097
Gc19_331 0 n38 ns331 0 7.75147707158e-05
Gc19_332 0 n38 ns332 0 4.75060440819e-05
Gc19_333 0 n38 ns333 0 0.000814355859198
Gc19_334 0 n38 ns334 0 0.00038394163996
Gc19_335 0 n38 ns335 0 -1.49536110982e-05
Gc19_336 0 n38 ns336 0 -3.78204851534e-05
Gc19_337 0 n38 ns337 0 -0.000230278698249
Gc19_338 0 n38 ns338 0 0.00841765243432
Gc19_339 0 n38 ns339 0 -0.00717327075533
Gc19_340 0 n38 ns340 0 0.000187709828927
Gc19_341 0 n38 ns341 0 6.253584976e-06
Gc19_342 0 n38 ns342 0 -2.74467399324e-05
Gc19_343 0 n38 ns343 0 -0.00565745004295
Gc19_344 0 n38 ns344 0 -0.00427662418599
Gc19_345 0 n38 ns345 0 0.00658199886634
Gc19_346 0 n38 ns346 0 0.00243046805533
Gc19_347 0 n38 ns347 0 -0.00223000105435
Gc19_348 0 n38 ns348 0 0.000620049210349
Gc19_349 0 n38 ns349 0 0.00296855098006
Gc19_350 0 n38 ns350 0 1.56264079744e-05
Gc19_351 0 n38 ns351 0 -0.000274744774922
Gc19_352 0 n38 ns352 0 -0.00203230763415
Gc19_353 0 n38 ns353 0 -0.00115725189438
Gc19_354 0 n38 ns354 0 -4.71211692213e-05
Gc19_355 0 n38 ns355 0 0.000673302125421
Gc19_356 0 n38 ns356 0 -0.000256805866574
Gc19_357 0 n38 ns357 0 0.00028565778631
Gc19_358 0 n38 ns358 0 0.00329085382016
Gc19_359 0 n38 ns359 0 -0.000926894731221
Gc19_360 0 n38 ns360 0 -0.000523010624199
Gc19_361 0 n38 ns361 0 -0.00163014280257
Gc19_362 0 n38 ns362 0 -4.00357622238e-06
Gc19_363 0 n38 ns363 0 0.000200679728902
Gc19_364 0 n38 ns364 0 0.002447576254
Gc19_365 0 n38 ns365 0 0.00201131196286
Gc19_366 0 n38 ns366 0 -6.44348362968e-05
Gc19_367 0 n38 ns367 0 -0.00212564822881
Gc19_368 0 n38 ns368 0 -0.00167576712376
Gc19_369 0 n38 ns369 0 0.00143900251111
Gc19_370 0 n38 ns370 0 -0.0116469160117
Gc19_371 0 n38 ns371 0 -0.00488123678359
Gc19_372 0 n38 ns372 0 0.00127899566777
Gc19_373 0 n38 ns373 0 0.00285859072186
Gc19_374 0 n38 ns374 0 0.00354500343739
Gc19_375 0 n38 ns375 0 0.000521768121867
Gc19_376 0 n38 ns376 0 0.017379368049
Gc19_377 0 n38 ns377 0 -0.00761574420354
Gc19_378 0 n38 ns378 0 -0.00777339179134
Gc19_379 0 n38 ns379 0 -1.47707203937e-05
Gc19_380 0 n38 ns380 0 2.60113304252e-05
Gc19_381 0 n38 ns381 0 -0.00262026755672
Gc19_382 0 n38 ns382 0 -0.00256198043981
Gc19_383 0 n38 ns383 0 0.00686566840255
Gc19_384 0 n38 ns384 0 0.000999823411664
Gc19_385 0 n38 ns385 0 -0.00184326658278
Gc19_386 0 n38 ns386 0 0.000703197586817
Gc19_387 0 n38 ns387 0 0.00192246255812
Gc19_388 0 n38 ns388 0 3.6345090773e-05
Gc19_389 0 n38 ns389 0 -0.000236387455816
Gc19_390 0 n38 ns390 0 0.000308500356389
Gc19_391 0 n38 ns391 0 -0.000194414741135
Gc19_392 0 n38 ns392 0 -0.000647766019381
Gc19_393 0 n38 ns393 0 -4.91139397723e-05
Gc19_394 0 n38 ns394 0 -0.000409441820104
Gc19_395 0 n38 ns395 0 0.000449799760687
Gc19_396 0 n38 ns396 0 0.00211304930315
Gc19_397 0 n38 ns397 0 -0.00289366984294
Gc19_398 0 n38 ns398 0 -0.00115867652297
Gc19_399 0 n38 ns399 0 -0.000446911486973
Gc19_400 0 n38 ns400 0 0.000246942752723
Gc19_401 0 n38 ns401 0 0.000407456285458
Gc19_402 0 n38 ns402 0 0.00200656579894
Gc19_403 0 n38 ns403 0 -0.0016233943083
Gc19_404 0 n38 ns404 0 -0.00185832156144
Gc19_405 0 n38 ns405 0 -0.00200877157758
Gc19_406 0 n38 ns406 0 -0.000792415036485
Gc19_407 0 n38 ns407 0 0.00226496453455
Gc19_408 0 n38 ns408 0 -0.0110756157952
Gc19_409 0 n38 ns409 0 -0.00518722899026
Gc19_410 0 n38 ns410 0 -0.000127586225707
Gc19_411 0 n38 ns411 0 0.00237384416315
Gc19_412 0 n38 ns412 0 0.00319741775797
Gc19_413 0 n38 ns413 0 0.00034507339386
Gc19_414 0 n38 ns414 0 -0.0367943247964
Gc19_415 0 n38 ns415 0 0.0386671900097
Gc19_416 0 n38 ns416 0 -0.00709632688915
Gc19_417 0 n38 ns417 0 -1.32290396619e-05
Gc19_418 0 n38 ns418 0 2.90935760844e-05
Gc19_419 0 n38 ns419 0 0.000220793150195
Gc19_420 0 n38 ns420 0 -0.00151144063221
Gc19_421 0 n38 ns421 0 0.0116526524132
Gc19_422 0 n38 ns422 0 0.000160089345656
Gc19_423 0 n38 ns423 0 0.000360454613807
Gc19_424 0 n38 ns424 0 0.000521131597294
Gc19_425 0 n38 ns425 0 -0.000469638253332
Gc19_426 0 n38 ns426 0 -0.000155132616195
Gc19_427 0 n38 ns427 0 -2.66304089942e-05
Gc19_428 0 n38 ns428 0 0.00129152079581
Gc19_429 0 n38 ns429 0 -0.00363566506196
Gc19_430 0 n38 ns430 0 -0.000456673373073
Gc19_431 0 n38 ns431 0 0.000851686941279
Gc19_432 0 n38 ns432 0 -4.73295758918e-05
Gc19_433 0 n38 ns433 0 0.000605768348649
Gc19_434 0 n38 ns434 0 -0.00152362525611
Gc19_435 0 n38 ns435 0 -0.00199198916065
Gc19_436 0 n38 ns436 0 -0.000710787296094
Gc19_437 0 n38 ns437 0 0.000356346121341
Gc19_438 0 n38 ns438 0 0.00041829495859
Gc19_439 0 n38 ns439 0 0.000241292101966
Gc19_440 0 n38 ns440 0 -0.00177867587841
Gc19_441 0 n38 ns441 0 -0.00566206511574
Gc19_442 0 n38 ns442 0 -0.00202270884624
Gc19_443 0 n38 ns443 0 -0.00027128330828
Gc19_444 0 n38 ns444 0 0.000344016915654
Gc19_445 0 n38 ns445 0 0.00185581434864
Gc19_446 0 n38 ns446 0 -0.010693200788
Gc19_447 0 n38 ns447 0 -0.00615912461724
Gc19_448 0 n38 ns448 0 -0.00187771467544
Gc19_449 0 n38 ns449 0 0.00382921166167
Gc19_450 0 n38 ns450 0 0.00270029978435
Gc19_451 0 n38 ns451 0 -9.43854941553e-05
Gc19_452 0 n38 ns452 0 -0.0862513232939
Gc19_453 0 n38 ns453 0 0.0764792679871
Gc19_454 0 n38 ns454 0 -0.00417919270603
Gc19_455 0 n38 ns455 0 -9.55346867654e-06
Gc19_456 0 n38 ns456 0 1.24447690635e-05
Gc19_457 0 n38 ns457 0 0.000649775816086
Gc19_458 0 n38 ns458 0 -0.00152663255558
Gc19_459 0 n38 ns459 0 0.00807618606244
Gc19_460 0 n38 ns460 0 0.000189397788126
Gc19_461 0 n38 ns461 0 9.10449302825e-06
Gc19_462 0 n38 ns462 0 4.86063098422e-05
Gc19_463 0 n38 ns463 0 0.000146164622498
Gc19_464 0 n38 ns464 0 1.43292011101e-05
Gc19_465 0 n38 ns465 0 5.00780147948e-05
Gc19_466 0 n38 ns466 0 -0.000450370991111
Gc19_467 0 n38 ns467 0 -0.00259991489147
Gc19_468 0 n38 ns468 0 0.00013506269323
Gc19_469 0 n38 ns469 0 0.000565138861742
Gc19_470 0 n38 ns470 0 0.000200866655096
Gc19_471 0 n38 ns471 0 0.0003999114155
Gc19_472 0 n38 ns472 0 0.000275071730842
Gc19_473 0 n38 ns473 0 -0.000355509157465
Gc19_474 0 n38 ns474 0 -0.000811264122355
Gc19_475 0 n38 ns475 0 -8.40903828236e-05
Gc19_476 0 n38 ns476 0 0.000195118834988
Gc19_477 0 n38 ns477 0 9.71418880873e-06
Gc19_478 0 n38 ns478 0 -0.00157465939971
Gc19_479 0 n38 ns479 0 -0.0029494953006
Gc19_480 0 n38 ns480 0 -0.00103189135521
Gc19_481 0 n38 ns481 0 -0.000940855337649
Gc19_482 0 n38 ns482 0 0.000254823758189
Gc19_483 0 n38 ns483 0 0.00152953612493
Gc19_484 0 n38 ns484 0 -0.00719770097704
Gc19_485 0 n38 ns485 0 -0.00446488117319
Gc19_486 0 n38 ns486 0 -0.000631868750565
Gc19_487 0 n38 ns487 0 0.00371119580294
Gc19_488 0 n38 ns488 0 0.00170610527315
Gc19_489 0 n38 ns489 0 -0.000612402593598
Gc19_490 0 n38 ns490 0 -0.0439776169687
Gc19_491 0 n38 ns491 0 0.0373231569368
Gc19_492 0 n38 ns492 0 -0.001553012851
Gc19_493 0 n38 ns493 0 -6.95687064547e-06
Gc19_494 0 n38 ns494 0 -1.14384908228e-05
Gc19_495 0 n38 ns495 0 0.00049754420986
Gc19_496 0 n38 ns496 0 -0.000796638678235
Gc19_497 0 n38 ns497 0 0.00420712218655
Gc19_498 0 n38 ns498 0 -9.95893346974e-05
Gc19_499 0 n38 ns499 0 0.000292135415187
Gc19_500 0 n38 ns500 0 0.000292745106498
Gc19_501 0 n38 ns501 0 2.5229784083e-06
Gc19_502 0 n38 ns502 0 2.80540396601e-05
Gc19_503 0 n38 ns503 0 -3.38251365396e-05
Gc19_504 0 n38 ns504 0 8.00868414665e-05
Gc19_505 0 n38 ns505 0 -0.000751340458142
Gc19_506 0 n38 ns506 0 -0.000209239943532
Gc19_507 0 n38 ns507 0 -8.35719048692e-05
Gc19_508 0 n38 ns508 0 0.000145390242259
Gc19_509 0 n38 ns509 0 0.000225046780344
Gc19_510 0 n38 ns510 0 0.000362145675866
Gc19_511 0 n38 ns511 0 -0.00128695700009
Gc19_512 0 n38 ns512 0 -0.000718454126673
Gc19_513 0 n38 ns513 0 0.000585317482679
Gc19_514 0 n38 ns514 0 0.000156485454917
Gc19_515 0 n38 ns515 0 -1.53473890997e-05
Gc19_516 0 n38 ns516 0 -0.000476402099942
Gc19_517 0 n38 ns517 0 -0.00164026915954
Gc19_518 0 n38 ns518 0 -0.00136633483309
Gc19_519 0 n38 ns519 0 -0.000944500271117
Gc19_520 0 n38 ns520 0 0.000572715979394
Gc19_521 0 n38 ns521 0 0.00119174061347
Gc19_522 0 n38 ns522 0 -0.00508894736448
Gc19_523 0 n38 ns523 0 -0.00201158287934
Gc19_524 0 n38 ns524 0 0.000542970937675
Gc19_525 0 n38 ns525 0 0.00241161231223
Gc19_526 0 n38 ns526 0 0.000835095217374
Gc19_527 0 n38 ns527 0 -0.000705764957003
Gc19_528 0 n38 ns528 0 -0.0169596869322
Gc19_529 0 n38 ns529 0 0.0137145038422
Gc19_530 0 n38 ns530 0 -0.000491907925828
Gc19_531 0 n38 ns531 0 4.10401230335e-07
Gc19_532 0 n38 ns532 0 -3.01338509226e-05
Gc19_533 0 n38 ns533 0 0.000615761785589
Gc19_534 0 n38 ns534 0 -0.00137436802505
Gc19_535 0 n38 ns535 0 0.00339275189017
Gc19_536 0 n38 ns536 0 8.22216641588e-06
Gc19_537 0 n38 ns537 0 0.000189811836287
Gc19_538 0 n38 ns538 0 0.000102628001951
Gc19_539 0 n38 ns539 0 -6.70966699811e-05
Gc19_540 0 n38 ns540 0 -2.33965982758e-05
Gc19_541 0 n38 ns541 0 -1.98200253799e-05
Gc19_542 0 n38 ns542 0 0.000375964038517
Gc19_543 0 n38 ns543 0 -0.000941550985278
Gc19_544 0 n38 ns544 0 -0.000406852374715
Gc19_545 0 n38 ns545 0 0.000355392637428
Gc19_546 0 n38 ns546 0 0.000201206062569
Gc19_547 0 n38 ns547 0 0.000112866925233
Gc19_548 0 n38 ns548 0 -0.000682144809505
Gc19_549 0 n38 ns549 0 -0.00068270560432
Gc19_550 0 n38 ns550 0 0.000160709922102
Gc19_551 0 n38 ns551 0 0.000611755596364
Gc19_552 0 n38 ns552 0 9.19707460626e-05
Gc19_553 0 n38 ns553 0 -0.000131332777201
Gc19_554 0 n38 ns554 0 -0.000291657903255
Gc19_555 0 n38 ns555 0 -0.00123966478229
Gc19_556 0 n38 ns556 0 -0.00130946305821
Gc19_557 0 n38 ns557 0 -8.88952011288e-05
Gc19_558 0 n38 ns558 0 0.000750686603614
Gc19_559 0 n38 ns559 0 0.000515611630623
Gc19_560 0 n38 ns560 0 -0.00324809947362
Gc19_561 0 n38 ns561 0 -0.000409963413861
Gc19_562 0 n38 ns562 0 0.000684574222163
Gc19_563 0 n38 ns563 0 0.00121409951034
Gc19_564 0 n38 ns564 0 0.00035390805467
Gc19_565 0 n38 ns565 0 -0.000488815969544
Gc19_566 0 n38 ns566 0 -0.00798755550581
Gc19_567 0 n38 ns567 0 0.0062934515002
Gc19_568 0 n38 ns568 0 -0.000230474986827
Gc19_569 0 n38 ns569 0 7.78395656853e-06
Gc19_570 0 n38 ns570 0 -3.71063661512e-05
Gc19_571 0 n38 ns571 0 0.000186537941203
Gc19_572 0 n38 ns572 0 -0.00034130983067
Gc19_573 0 n38 ns573 0 -0.000128157007777
Gc19_574 0 n38 ns574 0 -0.00024281518232
Gc19_575 0 n38 ns575 0 0.000162815442455
Gc19_576 0 n38 ns576 0 3.11490629781e-05
Gc19_577 0 n38 ns577 0 0.000170597010564
Gc19_578 0 n38 ns578 0 2.86532629329e-05
Gc19_579 0 n38 ns579 0 5.21897939897e-06
Gc19_580 0 n38 ns580 0 -2.54545085373e-05
Gc19_581 0 n38 ns581 0 -0.000882354025864
Gc19_582 0 n38 ns582 0 4.77525180981e-05
Gc19_583 0 n38 ns583 0 0.000620825341429
Gc19_584 0 n38 ns584 0 0.000199139390485
Gc19_585 0 n38 ns585 0 -6.24945798474e-05
Gc19_586 0 n38 ns586 0 -0.000412966368031
Gc19_587 0 n38 ns587 0 0.000620822441121
Gc19_588 0 n38 ns588 0 0.000583736616411
Gc19_589 0 n38 ns589 0 -4.42979328035e-05
Gc19_590 0 n38 ns590 0 -3.70495579112e-05
Gc19_591 0 n38 ns591 0 -0.000185806948408
Gc19_592 0 n38 ns592 0 0.00036884794696
Gc19_593 0 n38 ns593 0 -0.000567456417037
Gc19_594 0 n38 ns594 0 -0.000656656398596
Gc19_595 0 n38 ns595 0 9.7282512931e-05
Gc19_596 0 n38 ns596 0 0.000409045605117
Gc19_597 0 n38 ns597 0 0.000125652361948
Gc19_598 0 n38 ns598 0 -0.000433953133341
Gc19_599 0 n38 ns599 0 0.000780096101083
Gc19_600 0 n38 ns600 0 0.00048669019734
Gc19_601 0 n38 ns601 0 0.000134566087515
Gc19_602 0 n38 ns602 0 -1.71545039596e-06
Gc19_603 0 n38 ns603 0 -0.000291331400856
Gc19_604 0 n38 ns604 0 0.00653498744971
Gc19_605 0 n38 ns605 0 -0.00562567127738
Gc19_606 0 n38 ns606 0 0.000133239603642
Gc19_607 0 n38 ns607 0 5.72004216694e-06
Gc19_608 0 n38 ns608 0 -3.0534282242e-05
Gc19_609 0 n38 ns609 0 -0.00159532549259
Gc19_610 0 n38 ns610 0 -0.00163052549028
Gc19_611 0 n38 ns611 0 0.0047851073395
Gc19_612 0 n38 ns612 0 0.00105202228611
Gc19_613 0 n38 ns613 0 -0.000411814700864
Gc19_614 0 n38 ns614 0 0.000841981136748
Gc19_615 0 n38 ns615 0 0.000535851864519
Gc19_616 0 n38 ns616 0 -0.000136197805006
Gc19_617 0 n38 ns617 0 -4.8129462857e-05
Gc19_618 0 n38 ns618 0 -0.00141251033812
Gc19_619 0 n38 ns619 0 -0.00206830509145
Gc19_620 0 n38 ns620 0 0.00083717094473
Gc19_621 0 n38 ns621 0 -0.000310098070042
Gc19_622 0 n38 ns622 0 0.000346242050859
Gc19_623 0 n38 ns623 0 -0.000225691595587
Gc19_624 0 n38 ns624 0 -0.00235082774956
Gc19_625 0 n38 ns625 0 -0.00234894064567
Gc19_626 0 n38 ns626 0 -4.38955276698e-05
Gc19_627 0 n38 ns627 0 0.000171112759084
Gc19_628 0 n38 ns628 0 0.000222972379039
Gc19_629 0 n38 ns629 0 0.000331672965617
Gc19_630 0 n38 ns630 0 -0.00505245487227
Gc19_631 0 n38 ns631 0 0.00181452090251
Gc19_632 0 n38 ns632 0 0.000472053876967
Gc19_633 0 n38 ns633 0 0.000414936414783
Gc19_634 0 n38 ns634 0 0.000842765440934
Gc19_635 0 n38 ns635 0 -0.000817213878343
Gc19_636 0 n38 ns636 0 -0.00258548414574
Gc19_637 0 n38 ns637 0 0.00264262582981
Gc19_638 0 n38 ns638 0 -0.00187131634711
Gc19_639 0 n38 ns639 0 -0.000758875491033
Gc19_640 0 n38 ns640 0 0.00176486640196
Gc19_641 0 n38 ns641 0 0.000530601200241
Gc19_642 0 n38 ns642 0 0.029878787182
Gc19_643 0 n38 ns643 0 -0.0345822988763
Gc19_644 0 n38 ns644 0 0.0042890387858
Gc19_645 0 n38 ns645 0 2.56260247014e-06
Gc19_646 0 n38 ns646 0 2.87601885039e-05
Gc19_647 0 n38 ns647 0 -0.00176367744208
Gc19_648 0 n38 ns648 0 -0.00236315516608
Gc19_649 0 n38 ns649 0 0.00561425169787
Gc19_650 0 n38 ns650 0 0.000693951093824
Gc19_651 0 n38 ns651 0 -0.000457361587597
Gc19_652 0 n38 ns652 0 0.000738067924168
Gc19_653 0 n38 ns653 0 0.00034259981267
Gc19_654 0 n38 ns654 0 -0.000148662930299
Gc19_655 0 n38 ns655 0 -8.57658981309e-05
Gc19_656 0 n38 ns656 0 -0.00189265591659
Gc19_657 0 n38 ns657 0 -0.00103324111581
Gc19_658 0 n38 ns658 0 0.000890951167033
Gc19_659 0 n38 ns659 0 -0.000165564853699
Gc19_660 0 n38 ns660 0 0.000490367680868
Gc19_661 0 n38 ns661 0 -0.000284934219362
Gc19_662 0 n38 ns662 0 -0.000830436478512
Gc19_663 0 n38 ns663 0 -0.00160394020328
Gc19_664 0 n38 ns664 0 -7.90970331604e-06
Gc19_665 0 n38 ns665 0 -0.000249708998171
Gc19_666 0 n38 ns666 0 0.000245874476846
Gc19_667 0 n38 ns667 0 0.000343133774244
Gc19_668 0 n38 ns668 0 -0.00419695932095
Gc19_669 0 n38 ns669 0 -0.000470588362781
Gc19_670 0 n38 ns670 0 0.000255630883867
Gc19_671 0 n38 ns671 0 0.000773595003362
Gc19_672 0 n38 ns672 0 0.00118132651942
Gc19_673 0 n38 ns673 0 -0.000963269343067
Gc19_674 0 n38 ns674 0 -0.00505756238548
Gc19_675 0 n38 ns675 0 -0.00069568997841
Gc19_676 0 n38 ns676 0 -0.00177267697375
Gc19_677 0 n38 ns677 0 -8.37352151314e-05
Gc19_678 0 n38 ns678 0 0.00234729085117
Gc19_679 0 n38 ns679 0 0.000739101732541
Gc19_680 0 n38 ns680 0 0.0137149523406
Gc19_681 0 n38 ns681 0 -0.0224052165815
Gc19_682 0 n38 ns682 0 0.00536863124968
Gc19_683 0 n38 ns683 0 2.41109726159e-06
Gc19_684 0 n38 ns684 0 3.31420048172e-05
Gc19_685 0 n38 ns685 0 -0.00293779827572
Gc19_686 0 n38 ns686 0 0.00102527556124
Gc19_687 0 n38 ns687 0 -0.00360157399103
Gc19_688 0 n38 ns688 0 0.000110872249831
Gc19_689 0 n38 ns689 0 -0.000386398372585
Gc19_690 0 n38 ns690 0 0.000301199782265
Gc19_691 0 n38 ns691 0 -0.000304567778592
Gc19_692 0 n38 ns692 0 -0.000240956550392
Gc19_693 0 n38 ns693 0 -8.59762696094e-05
Gc19_694 0 n38 ns694 0 -0.00364018899624
Gc19_695 0 n38 ns695 0 0.00240277448537
Gc19_696 0 n38 ns696 0 0.00100673440118
Gc19_697 0 n38 ns697 0 -0.000205808214111
Gc19_698 0 n38 ns698 0 0.000552917089017
Gc19_699 0 n38 ns699 0 -0.000537585780499
Gc19_700 0 n38 ns700 0 0.000811179818345
Gc19_701 0 n38 ns701 0 0.00205647225386
Gc19_702 0 n38 ns702 0 0.000395274136251
Gc19_703 0 n38 ns703 0 -0.000340042048302
Gc19_704 0 n38 ns704 0 0.000495285331703
Gc19_705 0 n38 ns705 0 0.000275071196807
Gc19_706 0 n38 ns706 0 0.00145113775839
Gc19_707 0 n38 ns707 0 0.000217890673174
Gc19_708 0 n38 ns708 0 0.000532632746475
Gc19_709 0 n38 ns709 0 0.00265528202009
Gc19_710 0 n38 ns710 0 0.00174942037399
Gc19_711 0 n38 ns711 0 -0.00189957762737
Gc19_712 0 n38 ns712 0 0.00015807993015
Gc19_713 0 n38 ns713 0 -0.00317593074191
Gc19_714 0 n38 ns714 0 0.00157854609351
Gc19_715 0 n38 ns715 0 0.0016505939239
Gc19_716 0 n38 ns716 0 0.00328571534379
Gc19_717 0 n38 ns717 0 0.000249494220308
Gc19_718 0 n38 ns718 0 -0.0226070408321
Gc19_719 0 n38 ns719 0 0.0225086751964
Gc19_720 0 n38 ns720 0 0.00699773123574
Gc19_721 0 n38 ns721 0 9.94733161962e-06
Gc19_722 0 n38 ns722 0 3.81213698688e-05
Gc19_723 0 n38 ns723 0 -0.00197619868612
Gc19_724 0 n38 ns724 0 -0.0018576605319
Gc19_725 0 n38 ns725 0 0.0051878466295
Gc19_726 0 n38 ns726 0 0.000378033908842
Gc19_727 0 n38 ns727 0 -0.000412539318826
Gc19_728 0 n38 ns728 0 0.000486467069522
Gc19_729 0 n38 ns729 0 0.000424693142675
Gc19_730 0 n38 ns730 0 -0.000169169781897
Gc19_731 0 n38 ns731 0 -3.99167652084e-05
Gc19_732 0 n38 ns732 0 -0.00104911816334
Gc19_733 0 n38 ns733 0 -0.000644317093809
Gc19_734 0 n38 ns734 0 0.000969716692507
Gc19_735 0 n38 ns735 0 0.000353901036037
Gc19_736 0 n38 ns736 0 0.000455173293075
Gc19_737 0 n38 ns737 0 -0.000544556698034
Gc19_738 0 n38 ns738 0 0.000568018272414
Gc19_739 0 n38 ns739 0 -0.00265166099333
Gc19_740 0 n38 ns740 0 -0.000934015921598
Gc19_741 0 n38 ns741 0 8.4514288153e-05
Gc19_742 0 n38 ns742 0 0.000394453585521
Gc19_743 0 n38 ns743 0 0.000362898745396
Gc19_744 0 n38 ns744 0 -0.0046267305681
Gc19_745 0 n38 ns745 0 -0.00171168350108
Gc19_746 0 n38 ns746 0 0.000361146560537
Gc19_747 0 n38 ns747 0 0.00196694010645
Gc19_748 0 n38 ns748 0 0.00122729580328
Gc19_749 0 n38 ns749 0 -0.00169870511091
Gc19_750 0 n38 ns750 0 -0.00655291855077
Gc19_751 0 n38 ns751 0 -0.00153726356622
Gc19_752 0 n38 ns752 0 -0.00123008600229
Gc19_753 0 n38 ns753 0 0.00109951321223
Gc19_754 0 n38 ns754 0 0.0025677475003
Gc19_755 0 n38 ns755 0 0.000260844404344
Gc19_756 0 n38 ns756 0 0.0148676062743
Gc19_757 0 n38 ns757 0 -0.0236540159854
Gc19_758 0 n38 ns758 0 0.00537087478761
Gc19_759 0 n38 ns759 0 2.37464203233e-06
Gc19_760 0 n38 ns760 0 2.6587708314e-05
Gc19_761 0 n38 ns761 0 -0.00111254410628
Gc19_762 0 n38 ns762 0 0.000379879967883
Gc19_763 0 n38 ns763 0 0.000107170230937
Gc19_764 0 n38 ns764 0 0.00058471464515
Gc19_765 0 n38 ns765 0 -0.000522783441489
Gc19_766 0 n38 ns766 0 0.000467888976772
Gc19_767 0 n38 ns767 0 -0.000208958711327
Gc19_768 0 n38 ns768 0 -4.42225330613e-05
Gc19_769 0 n38 ns769 0 -1.09271185576e-06
Gc19_770 0 n38 ns770 0 -0.00257950877053
Gc19_771 0 n38 ns771 0 -4.08413574108e-06
Gc19_772 0 n38 ns772 0 0.000661613008667
Gc19_773 0 n38 ns773 0 -0.000244719187444
Gc19_774 0 n38 ns774 0 0.000118811586618
Gc19_775 0 n38 ns775 0 -0.000505803159633
Gc19_776 0 n38 ns776 0 -0.00195187672028
Gc19_777 0 n38 ns777 0 0.000456013913158
Gc19_778 0 n38 ns778 0 -4.36825328401e-05
Gc19_779 0 n38 ns779 0 0.0003947479997
Gc19_780 0 n38 ns780 0 0.000487240673296
Gc19_781 0 n38 ns781 0 5.31077966059e-05
Gc19_782 0 n38 ns782 0 -0.000530501649168
Gc19_783 0 n38 ns783 0 0.00364146785595
Gc19_784 0 n38 ns784 0 0.000682188509486
Gc19_785 0 n38 ns785 0 0.000787828998001
Gc19_786 0 n38 ns786 0 0.000187182682662
Gc19_787 0 n38 ns787 0 -0.00143449705006
Gc19_788 0 n38 ns788 0 0.00175871837774
Gc19_789 0 n38 ns789 0 0.0017166020764
Gc19_790 0 n38 ns790 0 -0.0015629555123
Gc19_791 0 n38 ns791 0 0.000898006004965
Gc19_792 0 n38 ns792 0 0.00144985910613
Gc19_793 0 n38 ns793 0 -0.000435819739506
Gc19_794 0 n38 ns794 0 0.0419304997927
Gc19_795 0 n38 ns795 0 -0.0401375171653
Gc19_796 0 n38 ns796 0 0.00262883555245
Gc19_797 0 n38 ns797 0 -2.08628989688e-06
Gc19_798 0 n38 ns798 0 4.85185641795e-07
Gc19_799 0 n38 ns799 0 -0.000774994412686
Gc19_800 0 n38 ns800 0 0.00172095191832
Gc19_801 0 n38 ns801 0 -0.00349692580926
Gc19_802 0 n38 ns802 0 -0.000249371376963
Gc19_803 0 n38 ns803 0 -0.000149841731379
Gc19_804 0 n38 ns804 0 -0.000192533833794
Gc19_805 0 n38 ns805 0 -0.000149860094499
Gc19_806 0 n38 ns806 0 -2.33883425299e-05
Gc19_807 0 n38 ns807 0 -1.16245381692e-05
Gc19_808 0 n38 ns808 0 -6.40267348991e-05
Gc19_809 0 n38 ns809 0 0.00186150332736
Gc19_810 0 n38 ns810 0 -2.42904904409e-06
Gc19_811 0 n38 ns811 0 -0.000143077721901
Gc19_812 0 n38 ns812 0 -0.000125842491459
Gc19_813 0 n38 ns813 0 -0.000312802255816
Gc19_814 0 n38 ns814 0 0.000999054966784
Gc19_815 0 n38 ns815 0 0.000894378089162
Gc19_816 0 n38 ns816 0 -0.000330797416768
Gc19_817 0 n38 ns817 0 -9.57862521223e-05
Gc19_818 0 n38 ns818 0 0.000221988263083
Gc19_819 0 n38 ns819 0 -0.000127925987557
Gc19_820 0 n38 ns820 0 0.00156830461899
Gc19_821 0 n38 ns821 0 0.000522213759928
Gc19_822 0 n38 ns822 0 0.000301805339603
Gc19_823 0 n38 ns823 0 0.00075607187163
Gc19_824 0 n38 ns824 0 -0.000133258683336
Gc19_825 0 n38 ns825 0 -0.000979827385586
Gc19_826 0 n38 ns826 0 0.00120669762306
Gc19_827 0 n38 ns827 0 -0.000515320433663
Gc19_828 0 n38 ns828 0 -0.000424595121538
Gc19_829 0 n38 ns829 0 0.00143730194334
Gc19_830 0 n38 ns830 0 0.00077942871224
Gc19_831 0 n38 ns831 0 -0.000667038245313
Gc19_832 0 n38 ns832 0 0.0272916148691
Gc19_833 0 n38 ns833 0 -0.0247257288692
Gc19_834 0 n38 ns834 0 0.00122766019267
Gc19_835 0 n38 ns835 0 -7.11741634648e-06
Gc19_836 0 n38 ns836 0 -1.90138931673e-05
Gc19_837 0 n38 ns837 0 -0.000180290115985
Gc19_838 0 n38 ns838 0 5.52985651336e-05
Gc19_839 0 n38 ns839 0 -0.000751902525002
Gc19_840 0 n38 ns840 0 -0.00015982427344
Gc19_841 0 n38 ns841 0 7.72012487283e-05
Gc19_842 0 n38 ns842 0 -8.04016690191e-05
Gc19_843 0 n38 ns843 0 0.000120608619973
Gc19_844 0 n38 ns844 0 3.35283176911e-06
Gc19_845 0 n38 ns845 0 3.40607274974e-05
Gc19_846 0 n38 ns846 0 0.000389218352268
Gc19_847 0 n38 ns847 0 9.4351024361e-05
Gc19_848 0 n38 ns848 0 0.000242327506259
Gc19_849 0 n38 ns849 0 0.000144974338585
Gc19_850 0 n38 ns850 0 -0.000135416585984
Gc19_851 0 n38 ns851 0 -0.000134758557111
Gc19_852 0 n38 ns852 0 -7.07415456056e-05
Gc19_853 0 n38 ns853 0 -0.000728559056063
Gc19_854 0 n38 ns854 0 -0.000176375620709
Gc19_855 0 n38 ns855 0 0.000658775338161
Gc19_856 0 n38 ns856 0 0.00017150066524
Gc19_857 0 n38 ns857 0 -9.95547536115e-05
Gc19_858 0 n38 ns858 0 -0.000150564866089
Gc19_859 0 n38 ns859 0 0.000475043995633
Gc19_860 0 n38 ns860 0 0.000897545654998
Gc19_861 0 n38 ns861 0 0.00053970385752
Gc19_862 0 n38 ns862 0 -0.000491452189958
Gc19_863 0 n38 ns863 0 -0.000663692137412
Gc19_864 0 n38 ns864 0 -0.000419975249275
Gc19_865 0 n38 ns865 0 0.000322947125387
Gc19_866 0 n38 ns866 0 0.000481036628005
Gc19_867 0 n38 ns867 0 0.000892452255367
Gc19_868 0 n38 ns868 0 0.000293135099859
Gc19_869 0 n38 ns869 0 -0.000595099416495
Gc19_870 0 n38 ns870 0 0.0147925324471
Gc19_871 0 n38 ns871 0 -0.0135145448035
Gc19_872 0 n38 ns872 0 0.000641515550799
Gc19_873 0 n38 ns873 0 -3.97554637606e-06
Gc19_874 0 n38 ns874 0 -3.2996230964e-05
Gc19_875 0 n38 ns875 0 0.000188377164328
Gc19_876 0 n38 ns876 0 -0.0004288741603
Gc19_877 0 n38 ns877 0 -0.001410316022
Gc19_878 0 n38 ns878 0 -0.000111010013049
Gc19_879 0 n38 ns879 0 -0.000129361675876
Gc19_880 0 n38 ns880 0 -5.71147018315e-05
Gc19_881 0 n38 ns881 0 5.02119947605e-05
Gc19_882 0 n38 ns882 0 2.93451726648e-05
Gc19_883 0 n38 ns883 0 9.41395236928e-06
Gc19_884 0 n38 ns884 0 -0.000111710587142
Gc19_885 0 n38 ns885 0 0.000671677364874
Gc19_886 0 n38 ns886 0 0.000135369683015
Gc19_887 0 n38 ns887 0 -0.000383780506099
Gc19_888 0 n38 ns888 0 -0.000170337707971
Gc19_889 0 n38 ns889 0 1.46598350757e-05
Gc19_890 0 n38 ns890 0 -0.000784493753329
Gc19_891 0 n38 ns891 0 0.000451135009393
Gc19_892 0 n38 ns892 0 0.000611408499279
Gc19_893 0 n38 ns893 0 0.000348171579151
Gc19_894 0 n38 ns894 0 7.41301847171e-05
Gc19_895 0 n38 ns895 0 -0.000187138157432
Gc19_896 0 n38 ns896 0 0.000787773829477
Gc19_897 0 n38 ns897 0 0.00139885070066
Gc19_898 0 n38 ns898 0 0.00102543343628
Gc19_899 0 n38 ns899 0 -0.000397974888257
Gc19_900 0 n38 ns900 0 -0.000727921852791
Gc19_901 0 n38 ns901 0 -0.000149253278795
Gc19_902 0 n38 ns902 0 0.00120210453188
Gc19_903 0 n38 ns903 0 0.0011162997668
Gc19_904 0 n38 ns904 0 0.000417699624224
Gc19_905 0 n38 ns905 0 -5.44113479755e-05
Gc19_906 0 n38 ns906 0 -7.20800485069e-05
Gc19_907 0 n38 ns907 0 -0.000358535639334
Gc19_908 0 n38 ns908 0 0.0176186358709
Gc19_909 0 n38 ns909 0 -0.015186406691
Gc19_910 0 n38 ns910 0 0.000554292480886
Gc19_911 0 n38 ns911 0 -3.74339347507e-06
Gc19_912 0 n38 ns912 0 -3.35379267264e-05
Gc19_913 0 n38 ns913 0 5.42858935755e-06
Gc19_914 0 n38 ns914 0 -0.000150968615199
Gc19_915 0 n38 ns915 0 -0.00139028829053
Gc19_916 0 n38 ns916 0 -0.000113100630529
Gc19_917 0 n38 ns917 0 -0.000107568576112
Gc19_918 0 n38 ns918 0 -2.57699931292e-05
Gc19_919 0 n38 ns919 0 -3.39683142346e-05
Gc19_920 0 n38 ns920 0 -1.57821162357e-05
Gc19_921 0 n38 ns921 0 -1.99856437833e-05
Gc19_922 0 n38 ns922 0 5.41620422314e-05
Gc19_923 0 n38 ns923 0 0.00106404327445
Gc19_924 0 n38 ns924 0 -0.00011817156342
Gc19_925 0 n38 ns925 0 -0.000495140936109
Gc19_926 0 n38 ns926 0 -0.000127019862974
Gc19_927 0 n38 ns927 0 5.96252947804e-05
Gc19_928 0 n38 ns928 0 -0.000138551451959
Gc19_929 0 n38 ns929 0 0.000858691513534
Gc19_930 0 n38 ns930 0 0.00051429309358
Gc19_931 0 n38 ns931 0 -0.000164753183484
Gc19_932 0 n38 ns932 0 -3.79262510143e-05
Gc19_933 0 n38 ns933 0 -0.000139781450261
Gc19_934 0 n38 ns934 0 0.00103773231897
Gc19_935 0 n38 ns935 0 0.000652446080001
Gc19_936 0 n38 ns936 0 0.000430928828068
Gc19_937 0 n38 ns937 0 -0.000518623109086
Gc19_938 0 n38 ns938 0 -0.000420090693826
Gc19_939 0 n38 ns939 0 0.000109978975526
Gc19_940 0 n38 ns940 0 0.00098288118473
Gc19_941 0 n38 ns941 0 0.000474121422445
Gc19_942 0 n38 ns942 0 0.000183756077398
Gc19_943 0 n38 ns943 0 -6.83557615409e-05
Gc19_944 0 n38 ns944 0 -5.1745210368e-05
Gc19_945 0 n38 ns945 0 -0.000181274070941
Gc19_946 0 n38 ns946 0 0.0116591290662
Gc19_947 0 n38 ns947 0 -0.00995686213694
Gc19_948 0 n38 ns948 0 0.000362193261869
Gc19_949 0 n38 ns949 0 -7.74174445976e-06
Gc19_950 0 n38 ns950 0 -2.69446059675e-05
Gc19_951 0 n38 ns951 0 -0.00483759027769
Gc19_952 0 n38 ns952 0 -3.01964222135e-05
Gc19_953 0 n38 ns953 0 -0.00637966137657
Gc19_954 0 n38 ns954 0 0.000159949149446
Gc19_955 0 n38 ns955 0 -0.00129927850422
Gc19_956 0 n38 ns956 0 -0.000195536155672
Gc19_957 0 n38 ns957 0 0.000106821347529
Gc19_958 0 n38 ns958 0 -0.000105621235562
Gc19_959 0 n38 ns959 0 -2.52965344954e-05
Gc19_960 0 n38 ns960 0 -0.00220304468464
Gc19_961 0 n38 ns961 0 0.0033263390182
Gc19_962 0 n38 ns962 0 0.000377872603541
Gc19_963 0 n38 ns963 0 -0.000702650148591
Gc19_964 0 n38 ns964 0 0.000385806519572
Gc19_965 0 n38 ns965 0 -0.000361597072367
Gc19_966 0 n38 ns966 0 0.000465548312389
Gc19_967 0 n38 ns967 0 0.00283212630756
Gc19_968 0 n38 ns968 0 0.000788141744846
Gc19_969 0 n38 ns969 0 -0.000696548959433
Gc19_970 0 n38 ns970 0 0.000399911880894
Gc19_971 0 n38 ns971 0 0.000181390314162
Gc19_972 0 n38 ns972 0 0.00269281146224
Gc19_973 0 n38 ns973 0 0.00162732291841
Gc19_974 0 n38 ns974 0 0.000463569417284
Gc19_975 0 n38 ns975 0 0.00197337435193
Gc19_976 0 n38 ns976 0 0.00159429527772
Gc19_977 0 n38 ns977 0 -0.00157280902131
Gc19_978 0 n38 ns978 0 0.00396209591011
Gc19_979 0 n38 ns979 0 -0.00133624296068
Gc19_980 0 n38 ns980 0 0.00128325666933
Gc19_981 0 n38 ns981 0 0.000683453307534
Gc19_982 0 n38 ns982 0 0.00294638446718
Gc19_983 0 n38 ns983 0 0.000322541497847
Gc19_984 0 n38 ns984 0 -0.00937590733789
Gc19_985 0 n38 ns985 0 0.0132083606971
Gc19_986 0 n38 ns986 0 0.00707475130921
Gc19_987 0 n38 ns987 0 -1.31793646293e-06
Gc19_988 0 n38 ns988 0 2.97716718414e-05
Gc19_989 0 n38 ns989 0 -0.00499950657781
Gc19_990 0 n38 ns990 0 -0.000763705213972
Gc19_991 0 n38 ns991 0 -0.00404265220103
Gc19_992 0 n38 ns992 0 0.00036239393682
Gc19_993 0 n38 ns993 0 -0.00139684308395
Gc19_994 0 n38 ns994 0 -0.000330118207047
Gc19_995 0 n38 ns995 0 0.000801427586958
Gc19_996 0 n38 ns996 0 -0.00012888772043
Gc19_997 0 n38 ns997 0 -1.92085645767e-05
Gc19_998 0 n38 ns998 0 -5.78842295134e-05
Gc19_999 0 n38 ns999 0 0.00198985790836
Gc19_1000 0 n38 ns1000 0 0.000527042426188
Gc19_1001 0 n38 ns1001 0 -0.000172846855112
Gc19_1002 0 n38 ns1002 0 0.000359629010903
Gc19_1003 0 n38 ns1003 0 -0.000505977971644
Gc19_1004 0 n38 ns1004 0 0.00127995466196
Gc19_1005 0 n38 ns1005 0 -0.000949737638999
Gc19_1006 0 n38 ns1006 0 -0.000437392105622
Gc19_1007 0 n38 ns1007 0 -0.000288376618589
Gc19_1008 0 n38 ns1008 0 0.000400497239416
Gc19_1009 0 n38 ns1009 0 0.000292710500672
Gc19_1010 0 n38 ns1010 0 -0.00169799273565
Gc19_1011 0 n38 ns1011 0 0.000109899002181
Gc19_1012 0 n38 ns1012 0 0.000874302105195
Gc19_1013 0 n38 ns1013 0 0.00221316469224
Gc19_1014 0 n38 ns1014 0 0.00129308706084
Gc19_1015 0 n38 ns1015 0 -0.00195105288602
Gc19_1016 0 n38 ns1016 0 0.000277356761521
Gc19_1017 0 n38 ns1017 0 0.000806590330954
Gc19_1018 0 n38 ns1018 0 0.00011973591753
Gc19_1019 0 n38 ns1019 0 5.13058737993e-05
Gc19_1020 0 n38 ns1020 0 0.00254968010703
Gc19_1021 0 n38 ns1021 0 0.000143458597038
Gc19_1022 0 n38 ns1022 0 0.0249871685832
Gc19_1023 0 n38 ns1023 0 -0.0244548462243
Gc19_1024 0 n38 ns1024 0 0.00661558153099
Gc19_1025 0 n38 ns1025 0 -3.41632018598e-06
Gc19_1026 0 n38 ns1026 0 2.82033983252e-05
Gc19_1027 0 n38 ns1027 0 -0.0013920695374
Gc19_1028 0 n38 ns1028 0 -1.77704565746e-07
Gc19_1029 0 n38 ns1029 0 0.00145501598408
Gc19_1030 0 n38 ns1030 0 0.000737045590624
Gc19_1031 0 n38 ns1031 0 -0.000529271400604
Gc19_1032 0 n38 ns1032 0 0.000680506236214
Gc19_1033 0 n38 ns1033 0 -8.20400058855e-06
Gc19_1034 0 n38 ns1034 0 -0.000117766210355
Gc19_1035 0 n38 ns1035 0 7.38802493206e-06
Gc19_1036 0 n38 ns1036 0 -0.00268212769196
Gc19_1037 0 n38 ns1037 0 -0.00072076879112
Gc19_1038 0 n38 ns1038 0 0.00101875544423
Gc19_1039 0 n38 ns1039 0 -0.000142067055696
Gc19_1040 0 n38 ns1040 0 0.000256868779388
Gc19_1041 0 n38 ns1041 0 -0.00058756056319
Gc19_1042 0 n38 ns1042 0 -0.00215953905893
Gc19_1043 0 n38 ns1043 0 -0.000805630283083
Gc19_1044 0 n38 ns1044 0 -0.000223403030839
Gc19_1045 0 n38 ns1045 0 0.000518959187922
Gc19_1046 0 n38 ns1046 0 0.000535850240265
Gc19_1047 0 n38 ns1047 0 0.000173734152108
Gc19_1048 0 n38 ns1048 0 -0.00236730764627
Gc19_1049 0 n38 ns1049 0 0.00321074358264
Gc19_1050 0 n38 ns1050 0 0.00079992130861
Gc19_1051 0 n38 ns1051 0 0.00105131337949
Gc19_1052 0 n38 ns1052 0 0.000442174270814
Gc19_1053 0 n38 ns1053 0 -0.00162255525695
Gc19_1054 0 n38 ns1054 0 4.88116181191e-06
Gc19_1055 0 n38 ns1055 0 0.00191953981966
Gc19_1056 0 n38 ns1056 0 -0.00169138260583
Gc19_1057 0 n38 ns1057 0 0.000698699393062
Gc19_1058 0 n38 ns1058 0 0.00178014012711
Gc19_1059 0 n38 ns1059 0 -0.000260901887739
Gc19_1060 0 n38 ns1060 0 0.0410775561957
Gc19_1061 0 n38 ns1061 0 -0.0415606697945
Gc19_1062 0 n38 ns1062 0 0.00350167884322
Gc19_1063 0 n38 ns1063 0 5.64728921832e-08
Gc19_1064 0 n38 ns1064 0 1.27907577217e-05
Gc19_1065 0 n38 ns1065 0 -0.000925976905102
Gc19_1066 0 n38 ns1066 0 0.00160278144446
Gc19_1067 0 n38 ns1067 0 -0.00265615843771
Gc19_1068 0 n38 ns1068 0 -1.98794438599e-05
Gc19_1069 0 n38 ns1069 0 -0.000225392351008
Gc19_1070 0 n38 ns1070 0 5.90525664747e-05
Gc19_1071 0 n38 ns1071 0 -0.000320065107316
Gc19_1072 0 n38 ns1072 0 -3.68119390766e-05
Gc19_1073 0 n38 ns1073 0 -2.53074420152e-05
Gc19_1074 0 n38 ns1074 0 -0.00115766548946
Gc19_1075 0 n38 ns1075 0 0.00170399001331
Gc19_1076 0 n38 ns1076 0 0.000155859233589
Gc19_1077 0 n38 ns1077 0 -0.000278913441036
Gc19_1078 0 n38 ns1078 0 -4.93134943027e-05
Gc19_1079 0 n38 ns1079 0 -0.000406490068097
Gc19_1080 0 n38 ns1080 0 0.000323675640459
Gc19_1081 0 n38 ns1081 0 0.00136914545534
Gc19_1082 0 n38 ns1082 0 -0.000210772497924
Gc19_1083 0 n38 ns1083 0 -0.000160549425961
Gc19_1084 0 n38 ns1084 0 0.000304733116946
Gc19_1085 0 n38 ns1085 0 -0.000102067653076
Gc19_1086 0 n38 ns1086 0 0.0015595936759
Gc19_1087 0 n38 ns1087 0 0.00137991487345
Gc19_1088 0 n38 ns1088 0 0.00022804132844
Gc19_1089 0 n38 ns1089 0 0.000744269113016
Gc19_1090 0 n38 ns1090 0 7.0045310107e-06
Gc19_1091 0 n38 ns1091 0 -0.00112103011334
Gc19_1092 0 n38 ns1092 0 0.00155364107611
Gc19_1093 0 n38 ns1093 0 -0.000337979469239
Gc19_1094 0 n38 ns1094 0 -0.000872745726553
Gc19_1095 0 n38 ns1095 0 0.00151669913739
Gc19_1096 0 n38 ns1096 0 0.00103853050045
Gc19_1097 0 n38 ns1097 0 -0.000640257044482
Gc19_1098 0 n38 ns1098 0 0.0307945182425
Gc19_1099 0 n38 ns1099 0 -0.028366943449
Gc19_1100 0 n38 ns1100 0 0.00155402561594
Gc19_1101 0 n38 ns1101 0 -5.61739268807e-06
Gc19_1102 0 n38 ns1102 0 -8.59175180216e-06
Gc19_1103 0 n38 ns1103 0 -0.000506846741664
Gc19_1104 0 n38 ns1104 0 0.000885041160875
Gc19_1105 0 n38 ns1105 0 -0.00181440647926
Gc19_1106 0 n38 ns1106 0 -0.000312114513479
Gc19_1107 0 n38 ns1107 0 0.000114521126028
Gc19_1108 0 n38 ns1108 0 -0.000135951923337
Gc19_1109 0 n38 ns1109 0 0.000130011824828
Gc19_1110 0 n38 ns1110 0 -9.76510239297e-06
Gc19_1111 0 n38 ns1111 0 1.31419807017e-05
Gc19_1112 0 n38 ns1112 0 0.000795451759798
Gc19_1113 0 n38 ns1113 0 0.000581760694393
Gc19_1114 0 n38 ns1114 0 8.42360262807e-05
Gc19_1115 0 n38 ns1115 0 0.000190547448798
Gc19_1116 0 n38 ns1116 0 -0.000141982167103
Gc19_1117 0 n38 ns1117 0 -0.000200060320252
Gc19_1118 0 n38 ns1118 0 0.000739436832109
Gc19_1119 0 n38 ns1119 0 -0.000598202571741
Gc19_1120 0 n38 ns1120 0 -0.000484518833408
Gc19_1121 0 n38 ns1121 0 0.000412871095709
Gc19_1122 0 n38 ns1122 0 0.000172446607687
Gc19_1123 0 n38 ns1123 0 -8.92797614537e-05
Gc19_1124 0 n38 ns1124 0 0.000160495705424
Gc19_1125 0 n38 ns1125 0 -7.15536914308e-05
Gc19_1126 0 n38 ns1126 0 0.000636339928932
Gc19_1127 0 n38 ns1127 0 0.000843737440948
Gc19_1128 0 n38 ns1128 0 -0.000318650959831
Gc19_1129 0 n38 ns1129 0 -0.000848564065715
Gc19_1130 0 n38 ns1130 0 -0.000397610475066
Gc19_1131 0 n38 ns1131 0 -0.000317040981802
Gc19_1132 0 n38 ns1132 0 0.000256738630778
Gc19_1133 0 n38 ns1133 0 0.0012809409359
Gc19_1134 0 n38 ns1134 0 0.000489512067851
Gc19_1135 0 n38 ns1135 0 -0.000655097617632
Gc19_1136 0 n38 ns1136 0 0.0163985248394
Gc19_1137 0 n38 ns1137 0 -0.0150839504414
Gc19_1138 0 n38 ns1138 0 0.000762884651311
Gc19_1139 0 n38 ns1139 0 -4.9681025214e-06
Gc19_1140 0 n38 ns1140 0 -2.60259791759e-05
Gc19_1141 0 n38 ns1141 0 0.000149742531979
Gc19_1142 0 n38 ns1142 0 -0.000141357311805
Gc19_1143 0 n38 ns1143 0 -0.000874023829557
Gc19_1144 0 n38 ns1144 0 -0.000244479532071
Gc19_1145 0 n38 ns1145 0 0.000107690653483
Gc19_1146 0 n38 ns1146 0 3.67132967578e-05
Gc19_1147 0 n38 ns1147 0 0.000120989561883
Gc19_1148 0 n38 ns1148 0 3.03411361381e-05
Gc19_1149 0 n38 ns1149 0 1.60921740736e-05
Gc19_1150 0 n38 ns1150 0 0.000102951010333
Gc19_1151 0 n38 ns1151 0 0.000111442526448
Gc19_1152 0 n38 ns1152 0 0.000255598255796
Gc19_1153 0 n38 ns1153 0 -0.000121118100076
Gc19_1154 0 n38 ns1154 0 -0.000164276817089
Gc19_1155 0 n38 ns1155 0 -3.54903143325e-05
Gc19_1156 0 n38 ns1156 0 -0.000740016822205
Gc19_1157 0 n38 ns1157 0 -0.000190179625421
Gc19_1158 0 n38 ns1158 0 0.000348258527202
Gc19_1159 0 n38 ns1159 0 0.000600084506203
Gc19_1160 0 n38 ns1160 0 0.000122239899131
Gc19_1161 0 n38 ns1161 0 -0.000158834972735
Gc19_1162 0 n38 ns1162 0 0.000247911153975
Gc19_1163 0 n38 ns1163 0 0.00117652542676
Gc19_1164 0 n38 ns1164 0 0.00111904370991
Gc19_1165 0 n38 ns1165 0 -4.24956755287e-05
Gc19_1166 0 n38 ns1166 0 -0.000710543975106
Gc19_1167 0 n38 ns1167 0 -0.000368269422842
Gc19_1168 0 n38 ns1168 0 0.000590048403573
Gc19_1169 0 n38 ns1169 0 0.000676198471873
Gc19_1170 0 n38 ns1170 0 0.000358453171384
Gc19_1171 0 n38 ns1171 0 0.000281003040015
Gc19_1172 0 n38 ns1172 0 6.26638946652e-05
Gc19_1173 0 n38 ns1173 0 -0.000396496434445
Gc19_1174 0 n38 ns1174 0 0.0137836795285
Gc19_1175 0 n38 ns1175 0 -0.0120920801074
Gc19_1176 0 n38 ns1176 0 0.000488606670016
Gc19_1177 0 n38 ns1177 0 -3.61792011059e-06
Gc19_1178 0 n38 ns1178 0 -3.46825109694e-05
Gc19_1179 0 n38 ns1179 0 0.000127402514364
Gc19_1180 0 n38 ns1180 0 -0.000235953821474
Gc19_1181 0 n38 ns1181 0 -0.00142351747961
Gc19_1182 0 n38 ns1182 0 -0.000129160197131
Gc19_1183 0 n38 ns1183 0 -8.5134372752e-05
Gc19_1184 0 n38 ns1184 0 2.35485442175e-06
Gc19_1185 0 n38 ns1185 0 -4.95152444376e-05
Gc19_1186 0 n38 ns1186 0 -1.20582683067e-05
Gc19_1187 0 n38 ns1187 0 -1.46380426712e-05
Gc19_1188 0 n38 ns1188 0 -8.23055656135e-05
Gc19_1189 0 n38 ns1189 0 0.00108071549673
Gc19_1190 0 n38 ns1190 0 -3.01563238882e-05
Gc19_1191 0 n38 ns1191 0 -0.000554068778392
Gc19_1192 0 n38 ns1192 0 -0.000160112984907
Gc19_1193 0 n38 ns1193 0 5.29787751851e-05
Gc19_1194 0 n38 ns1194 0 -0.000388342667499
Gc19_1195 0 n38 ns1195 0 0.000873475524845
Gc19_1196 0 n38 ns1196 0 0.000632336703621
Gc19_1197 0 n38 ns1197 0 -3.60650592071e-05
Gc19_1198 0 n38 ns1198 0 -1.17699762602e-05
Gc19_1199 0 n38 ns1199 0 -0.000174266828008
Gc19_1200 0 n38 ns1200 0 0.00108948033227
Gc19_1201 0 n38 ns1201 0 0.000945434022337
Gc19_1202 0 n38 ns1202 0 0.000641436877491
Gc19_1203 0 n38 ns1203 0 -0.000564826578742
Gc19_1204 0 n38 ns1204 0 -0.000556024221485
Gc19_1205 0 n38 ns1205 0 6.52269611141e-05
Gc19_1206 0 n38 ns1206 0 0.00112751426405
Gc19_1207 0 n38 ns1207 0 0.000637521433498
Gc19_1208 0 n38 ns1208 0 0.000242700170486
Gc19_1209 0 n38 ns1209 0 -6.94823946212e-05
Gc19_1210 0 n38 ns1210 0 -6.30303381387e-05
Gc19_1211 0 n38 ns1211 0 -0.000232326313737
Gc19_1212 0 n38 ns1212 0 0.0137505408806
Gc19_1213 0 n38 ns1213 0 -0.0117744831119
Gc19_1214 0 n38 ns1214 0 0.000427244953886
Gc19_1215 0 n38 ns1215 0 -4.91599174423e-06
Gc19_1216 0 n38 ns1216 0 -3.03465688916e-05
Gd19_1 0 n38 ni1 0 2.18743126029e-05
Gd19_2 0 n38 ni2 0 -0.000511386498396
Gd19_3 0 n38 ni3 0 -0.00686366180786
Gd19_4 0 n38 ni4 0 -0.000390131370414
Gd19_5 0 n38 ni5 0 0.000499618171045
Gd19_6 0 n38 ni6 0 0.000190125345712
Gd19_7 0 n38 ni7 0 0.000249567025937
Gd19_8 0 n38 ni8 0 4.34815883411e-05
Gd19_9 0 n38 ni9 0 -5.64624504646e-05
Gd19_10 0 n38 ni10 0 -0.00313526362036
Gd19_11 0 n38 ni11 0 -0.00158432791063
Gd19_12 0 n38 ni12 0 -7.99350075853e-05
Gd19_13 0 n38 ni13 0 0.000185390829003
Gd19_14 0 n38 ni14 0 0.000197158238548
Gd19_15 0 n38 ni15 0 3.23183540691e-05
Gd19_16 0 n38 ni16 0 -7.31497823948e-06
Gd19_17 0 n38 ni17 0 -0.00124870793225
Gd19_18 0 n38 ni18 0 -0.00171135336434
Gd19_19 0 n38 ni19 0 0.00105257370057
Gd19_20 0 n38 ni20 0 -0.00167087426372
Gd19_21 0 n38 ni21 0 -0.000325277116031
Gd19_22 0 n38 ni22 0 0.000200043518429
Gd19_23 0 n38 ni23 0 -5.8208254045e-05
Gd19_24 0 n38 ni24 0 -9.74490858841e-05
Gd19_25 0 n38 ni25 0 -8.51004563156e-05
Gd19_26 0 n38 ni26 0 -0.000822134074748
Gd19_27 0 n38 ni27 0 -0.0026760574162
Gd19_28 0 n38 ni28 0 -0.00071371701227
Gd19_29 0 n38 ni29 0 0.000161614787665
Gd19_30 0 n38 ni30 0 6.33578772816e-05
Gd19_31 0 n38 ni31 0 5.39355739206e-05
Gd19_32 0 n38 ni32 0 -4.09258359612e-05
Gc20_1 0 n40 ns1 0 0.000363916017893
Gc20_2 0 n40 ns2 0 -0.00123676212557
Gc20_3 0 n40 ns3 0 0.00845544069566
Gc20_4 0 n40 ns4 0 0.000501759481855
Gc20_5 0 n40 ns5 0 -0.000156570128716
Gc20_6 0 n40 ns6 0 -9.84944503853e-05
Gc20_7 0 n40 ns7 0 0.000171715397713
Gc20_8 0 n40 ns8 0 -1.00906731774e-05
Gc20_9 0 n40 ns9 0 4.93546348958e-05
Gc20_10 0 n40 ns10 0 -0.00136670321561
Gc20_11 0 n40 ns11 0 -0.00283695790898
Gc20_12 0 n40 ns12 0 0.000836728733591
Gc20_13 0 n40 ns13 0 0.000700080239772
Gc20_14 0 n40 ns14 0 1.9718745218e-05
Gc20_15 0 n40 ns15 0 0.000214884782688
Gc20_16 0 n40 ns16 0 0.000227720435131
Gc20_17 0 n40 ns17 0 0.000809025817731
Gc20_18 0 n40 ns18 0 -0.000570711679058
Gc20_19 0 n40 ns19 0 -0.000960060764729
Gc20_20 0 n40 ns20 0 6.622097681e-05
Gc20_21 0 n40 ns21 0 0.000111387800718
Gc20_22 0 n40 ns22 0 -0.002471782203
Gc20_23 0 n40 ns23 0 -0.00298107001488
Gc20_24 0 n40 ns24 0 9.8577299801e-05
Gc20_25 0 n40 ns25 0 -1.5576575265e-05
Gc20_26 0 n40 ns26 0 -0.000279418938718
Gc20_27 0 n40 ns27 0 0.000823625089254
Gc20_28 0 n40 ns28 0 -0.00568300597946
Gc20_29 0 n40 ns29 0 -0.00472887460866
Gc20_30 0 n40 ns30 0 -0.00189543508323
Gc20_31 0 n40 ns31 0 0.00314118758207
Gc20_32 0 n40 ns32 0 0.0019087423996
Gc20_33 0 n40 ns33 0 -0.000105783762669
Gc20_34 0 n40 ns34 0 -0.0526768112593
Gc20_35 0 n40 ns35 0 0.0456757966782
Gc20_36 0 n40 ns36 0 -0.00207812589162
Gc20_37 0 n40 ns37 0 -7.3717369791e-06
Gc20_38 0 n40 ns38 0 1.64494223121e-05
Gc20_39 0 n40 ns39 0 0.000425851236206
Gc20_40 0 n40 ns40 0 -0.000233297840996
Gc20_41 0 n40 ns41 0 0.00961856060917
Gc20_42 0 n40 ns42 0 0.000186568704436
Gc20_43 0 n40 ns43 0 0.000522748592007
Gc20_44 0 n40 ns44 0 0.000374134295432
Gc20_45 0 n40 ns45 0 -0.00021157885689
Gc20_46 0 n40 ns46 0 -9.21373049127e-05
Gc20_47 0 n40 ns47 0 1.80837742966e-05
Gc20_48 0 n40 ns48 0 -0.000863569666238
Gc20_49 0 n40 ns49 0 -0.00348386151035
Gc20_50 0 n40 ns50 0 0.000752892428062
Gc20_51 0 n40 ns51 0 0.000743798750921
Gc20_52 0 n40 ns52 0 -4.53329387493e-05
Gc20_53 0 n40 ns53 0 0.000297131011663
Gc20_54 0 n40 ns54 0 -0.000379161985902
Gc20_55 0 n40 ns55 0 -0.000106065887145
Gc20_56 0 n40 ns56 0 -0.000726219191738
Gc20_57 0 n40 ns57 0 -0.000630239852596
Gc20_58 0 n40 ns58 0 0.000194289884029
Gc20_59 0 n40 ns59 0 0.00021640269958
Gc20_60 0 n40 ns60 0 -0.00253542048407
Gc20_61 0 n40 ns61 0 -0.0042176118128
Gc20_62 0 n40 ns62 0 -0.000501452626219
Gc20_63 0 n40 ns63 0 -5.41430682492e-06
Gc20_64 0 n40 ns64 0 -0.000162564017703
Gc20_65 0 n40 ns65 0 0.00117591149535
Gc20_66 0 n40 ns66 0 -0.00764615517014
Gc20_67 0 n40 ns67 0 -0.00577542212198
Gc20_68 0 n40 ns68 0 -0.00226968526435
Gc20_69 0 n40 ns69 0 0.00356626379405
Gc20_70 0 n40 ns70 0 0.00235143517436
Gc20_71 0 n40 ns71 0 -2.77244293076e-05
Gc20_72 0 n40 ns72 0 -0.0713686240991
Gc20_73 0 n40 ns73 0 0.0625603108402
Gc20_74 0 n40 ns74 0 -0.00303380544137
Gc20_75 0 n40 ns75 0 -1.10283428447e-05
Gc20_76 0 n40 ns76 0 1.71173070108e-05
Gc20_77 0 n40 ns77 0 -0.000372137446063
Gc20_78 0 n40 ns78 0 -5.10968585361e-05
Gc20_79 0 n40 ns79 0 0.00639630216601
Gc20_80 0 n40 ns80 0 -0.00111572017402
Gc20_81 0 n40 ns81 0 -0.000582450581132
Gc20_82 0 n40 ns82 0 0.00184176760738
Gc20_83 0 n40 ns83 0 0.00043135609592
Gc20_84 0 n40 ns84 0 -0.000178117908179
Gc20_85 0 n40 ns85 0 -0.000204969311164
Gc20_86 0 n40 ns86 0 0.00189460377199
Gc20_87 0 n40 ns87 0 -0.00160277748192
Gc20_88 0 n40 ns88 0 -0.000606067917516
Gc20_89 0 n40 ns89 0 0.000382811987817
Gc20_90 0 n40 ns90 0 -0.000270116794664
Gc20_91 0 n40 ns91 0 0.000519078722643
Gc20_92 0 n40 ns92 0 5.75388289326e-05
Gc20_93 0 n40 ns93 0 -0.00386935337771
Gc20_94 0 n40 ns94 0 -0.00140211976764
Gc20_95 0 n40 ns95 0 0.000279199388751
Gc20_96 0 n40 ns96 0 0.000334878591502
Gc20_97 0 n40 ns97 0 0.00049774428358
Gc20_98 0 n40 ns98 0 0.000811647563437
Gc20_99 0 n40 ns99 0 -0.0049734014839
Gc20_100 0 n40 ns100 0 -0.00248908941343
Gc20_101 0 n40 ns101 0 -0.00121872198225
Gc20_102 0 n40 ns102 0 -0.000129547529665
Gc20_103 0 n40 ns103 0 0.00225526992967
Gc20_104 0 n40 ns104 0 -0.0124144376225
Gc20_105 0 n40 ns105 0 -0.0060286327965
Gc20_106 0 n40 ns106 0 -0.00118305473736
Gc20_107 0 n40 ns107 0 0.00309835116132
Gc20_108 0 n40 ns108 0 0.00315733846661
Gc20_109 0 n40 ns109 0 0.000335823672691
Gc20_110 0 n40 ns110 0 -0.0723727962085
Gc20_111 0 n40 ns111 0 0.0684312172378
Gc20_112 0 n40 ns112 0 -0.00650126881299
Gc20_113 0 n40 ns113 0 -1.17508191882e-05
Gc20_114 0 n40 ns114 0 2.60583792709e-05
Gc20_115 0 n40 ns115 0 -0.0169250027622
Gc20_116 0 n40 ns116 0 -0.00135672651389
Gc20_117 0 n40 ns117 0 0.021414912897
Gc20_118 0 n40 ns118 0 0.00638114511033
Gc20_119 0 n40 ns119 0 0.0102319397071
Gc20_120 0 n40 ns120 0 0.00149394676839
Gc20_121 0 n40 ns121 0 -0.0034020330691
Gc20_122 0 n40 ns122 0 -0.000540825412112
Gc20_123 0 n40 ns123 0 4.23195041961e-05
Gc20_124 0 n40 ns124 0 -0.00110335868046
Gc20_125 0 n40 ns125 0 -0.0146786050199
Gc20_126 0 n40 ns126 0 0.000914744812549
Gc20_127 0 n40 ns127 0 0.00199135559497
Gc20_128 0 n40 ns128 0 0.000239573813044
Gc20_129 0 n40 ns129 0 0.000464237211118
Gc20_130 0 n40 ns130 0 9.07478112522e-05
Gc20_131 0 n40 ns131 0 0.000127330111913
Gc20_132 0 n40 ns132 0 -0.000126449000331
Gc20_133 0 n40 ns133 0 0.000659834081287
Gc20_134 0 n40 ns134 0 0.000556902733172
Gc20_135 0 n40 ns135 0 0.000390129069773
Gc20_136 0 n40 ns136 0 -0.0119221849981
Gc20_137 0 n40 ns137 0 -0.00787532688039
Gc20_138 0 n40 ns138 0 -0.00362740033782
Gc20_139 0 n40 ns139 0 -0.00137300868357
Gc20_140 0 n40 ns140 0 7.60690231866e-05
Gc20_141 0 n40 ns141 0 0.00260359734212
Gc20_142 0 n40 ns142 0 0.00751001517942
Gc20_143 0 n40 ns143 0 -0.00601146698373
Gc20_144 0 n40 ns144 0 0.0018498368145
Gc20_145 0 n40 ns145 0 0.00219123097865
Gc20_146 0 n40 ns146 0 0.00340652209779
Gc20_147 0 n40 ns147 0 -1.63875334742e-05
Gc20_148 0 n40 ns148 0 -0.112777477284
Gc20_149 0 n40 ns149 0 0.0739231675589
Gc20_150 0 n40 ns150 0 -0.00890621983949
Gc20_151 0 n40 ns151 0 -1.12480594126e-05
Gc20_152 0 n40 ns152 0 1.26475896996e-05
Gc20_153 0 n40 ns153 0 -0.00036502624293
Gc20_154 0 n40 ns154 0 3.08840833692e-05
Gc20_155 0 n40 ns155 0 0.00569154468714
Gc20_156 0 n40 ns156 0 -0.00132358804933
Gc20_157 0 n40 ns157 0 -0.000357121295618
Gc20_158 0 n40 ns158 0 0.00186815543654
Gc20_159 0 n40 ns159 0 0.000585780438252
Gc20_160 0 n40 ns160 0 -0.000159329898169
Gc20_161 0 n40 ns161 0 -0.000186337125966
Gc20_162 0 n40 ns162 0 0.00210831544994
Gc20_163 0 n40 ns163 0 -0.00275982980661
Gc20_164 0 n40 ns164 0 -0.000676121786672
Gc20_165 0 n40 ns165 0 0.00111380669222
Gc20_166 0 n40 ns166 0 -4.49656098365e-05
Gc20_167 0 n40 ns167 0 0.000500144545479
Gc20_168 0 n40 ns168 0 -0.000395366477412
Gc20_169 0 n40 ns169 0 -0.00333988555158
Gc20_170 0 n40 ns170 0 -0.000846267432472
Gc20_171 0 n40 ns171 0 0.000246526810199
Gc20_172 0 n40 ns172 0 0.000298811983515
Gc20_173 0 n40 ns173 0 0.00033064475609
Gc20_174 0 n40 ns174 0 0.00110446263606
Gc20_175 0 n40 ns175 0 -0.00545934074453
Gc20_176 0 n40 ns176 0 -0.00296157569308
Gc20_177 0 n40 ns177 0 -0.00100668766857
Gc20_178 0 n40 ns178 0 0.000190091825565
Gc20_179 0 n40 ns179 0 0.00224713263953
Gc20_180 0 n40 ns180 0 -0.0123170880322
Gc20_181 0 n40 ns181 0 -0.00540690799203
Gc20_182 0 n40 ns182 0 -0.000899137460773
Gc20_183 0 n40 ns183 0 0.00290556086941
Gc20_184 0 n40 ns184 0 0.00303711013414
Gc20_185 0 n40 ns185 0 0.000247535165225
Gc20_186 0 n40 ns186 0 -0.0677147622354
Gc20_187 0 n40 ns187 0 0.0644507129497
Gc20_188 0 n40 ns188 0 -0.00636423585462
Gc20_189 0 n40 ns189 0 -9.86317726922e-06
Gc20_190 0 n40 ns190 0 2.67941393089e-06
Gc20_191 0 n40 ns191 0 0.000906417249331
Gc20_192 0 n40 ns192 0 -0.000915596979309
Gc20_193 0 n40 ns193 0 0.0103586933995
Gc20_194 0 n40 ns194 0 -1.06847715984e-05
Gc20_195 0 n40 ns195 0 0.000764064282583
Gc20_196 0 n40 ns196 0 0.000456136809444
Gc20_197 0 n40 ns197 0 -0.000146679631214
Gc20_198 0 n40 ns198 0 -8.9316340201e-05
Gc20_199 0 n40 ns199 0 -2.1428481186e-05
Gc20_200 0 n40 ns200 0 -5.23322966784e-06
Gc20_201 0 n40 ns201 0 -0.00416936072572
Gc20_202 0 n40 ns202 0 0.000233985427153
Gc20_203 0 n40 ns203 0 0.00106599406412
Gc20_204 0 n40 ns204 0 0.000121811790067
Gc20_205 0 n40 ns205 0 0.000413736977666
Gc20_206 0 n40 ns206 0 -0.000968683775042
Gc20_207 0 n40 ns207 0 -0.000588300330328
Gc20_208 0 n40 ns208 0 -0.000451747693374
Gc20_209 0 n40 ns209 0 -0.000103170510253
Gc20_210 0 n40 ns210 0 0.000266285031307
Gc20_211 0 n40 ns211 0 7.23806550898e-05
Gc20_212 0 n40 ns212 0 -0.00234930279515
Gc20_213 0 n40 ns213 0 -0.00499474191581
Gc20_214 0 n40 ns214 0 -0.00154758870522
Gc20_215 0 n40 ns215 0 1.09199449223e-05
Gc20_216 0 n40 ns216 0 0.000463207620493
Gc20_217 0 n40 ns217 0 0.00145705516536
Gc20_218 0 n40 ns218 0 -0.00901237949204
Gc20_219 0 n40 ns219 0 -0.00527806443249
Gc20_220 0 n40 ns220 0 -0.00153794337256
Gc20_221 0 n40 ns221 0 0.00383884817543
Gc20_222 0 n40 ns222 0 0.0022908766355
Gc20_223 0 n40 ns223 0 -0.000327772841546
Gc20_224 0 n40 ns224 0 -0.0694481836499
Gc20_225 0 n40 ns225 0 0.0605009713948
Gc20_226 0 n40 ns226 0 -0.00288836688541
Gc20_227 0 n40 ns227 0 -8.81037049374e-06
Gc20_228 0 n40 ns228 0 -2.16790949385e-05
Gc20_229 0 n40 ns229 0 0.000513058552408
Gc20_230 0 n40 ns230 0 -0.000959058244838
Gc20_231 0 n40 ns231 0 0.00582622160223
Gc20_232 0 n40 ns232 0 -7.44786139843e-05
Gc20_233 0 n40 ns233 0 0.000337724621721
Gc20_234 0 n40 ns234 0 0.000372479252302
Gc20_235 0 n40 ns235 0 0.000137172488901
Gc20_236 0 n40 ns236 0 2.58744593515e-05
Gc20_237 0 n40 ns237 0 -6.84765223369e-06
Gc20_238 0 n40 ns238 0 -0.000638368786834
Gc20_239 0 n40 ns239 0 -0.00156919744467
Gc20_240 0 n40 ns240 0 0.000297816203987
Gc20_241 0 n40 ns241 0 0.000135565930013
Gc20_242 0 n40 ns242 0 0.000147929006675
Gc20_243 0 n40 ns243 0 0.000240233287321
Gc20_244 0 n40 ns244 0 0.000986231282843
Gc20_245 0 n40 ns245 0 -0.000609822053837
Gc20_246 0 n40 ns246 0 -0.000956137921368
Gc20_247 0 n40 ns247 0 -8.56564916258e-05
Gc20_248 0 n40 ns248 0 8.99301123485e-05
Gc20_249 0 n40 ns249 0 1.55292448054e-05
Gc20_250 0 n40 ns250 0 -0.00116387582728
Gc20_251 0 n40 ns251 0 -0.00243920638776
Gc20_252 0 n40 ns252 0 -0.00108256473997
Gc20_253 0 n40 ns253 0 -0.000949491694917
Gc20_254 0 n40 ns254 0 0.000362418183364
Gc20_255 0 n40 ns255 0 0.00134572424051
Gc20_256 0 n40 ns256 0 -0.00612739065456
Gc20_257 0 n40 ns257 0 -0.00359526980024
Gc20_258 0 n40 ns258 0 -0.000132519659343
Gc20_259 0 n40 ns259 0 0.00325262371176
Gc20_260 0 n40 ns260 0 0.00133270723764
Gc20_261 0 n40 ns261 0 -0.000680243016493
Gc20_262 0 n40 ns262 0 -0.0310280252067
Gc20_263 0 n40 ns263 0 0.0260071870326
Gc20_264 0 n40 ns264 0 -0.00103176613144
Gc20_265 0 n40 ns265 0 -4.1139995877e-06
Gc20_266 0 n40 ns266 0 -2.89252548575e-05
Gc20_267 0 n40 ns267 0 0.000412896822719
Gc20_268 0 n40 ns268 0 -0.000546513186312
Gc20_269 0 n40 ns269 0 0.00318752876987
Gc20_270 0 n40 ns270 0 -0.000158892342473
Gc20_271 0 n40 ns271 0 0.000330580267638
Gc20_272 0 n40 ns272 0 0.000227444021944
Gc20_273 0 n40 ns273 0 6.58737130954e-06
Gc20_274 0 n40 ns274 0 9.06363664172e-06
Gc20_275 0 n40 ns275 0 -4.39789192854e-05
Gc20_276 0 n40 ns276 0 0.000679584595639
Gc20_277 0 n40 ns277 0 -0.000902203672766
Gc20_278 0 n40 ns278 0 -0.000519307323686
Gc20_279 0 n40 ns279 0 0.000143437500753
Gc20_280 0 n40 ns280 0 0.000189322240597
Gc20_281 0 n40 ns281 0 0.00022534947125
Gc20_282 0 n40 ns282 0 -0.000169797029949
Gc20_283 0 n40 ns283 0 -0.00130111274692
Gc20_284 0 n40 ns284 0 -0.000369159229584
Gc20_285 0 n40 ns285 0 0.000764276228023
Gc20_286 0 n40 ns286 0 0.000158810832769
Gc20_287 0 n40 ns287 0 -6.04622752301e-05
Gc20_288 0 n40 ns288 0 -0.000201299207941
Gc20_289 0 n40 ns289 0 -0.00139326514758
Gc20_290 0 n40 ns290 0 -0.00138975035929
Gc20_291 0 n40 ns291 0 -0.000701891159124
Gc20_292 0 n40 ns292 0 0.00064160745402
Gc20_293 0 n40 ns293 0 0.000959604143101
Gc20_294 0 n40 ns294 0 -0.00416815937175
Gc20_295 0 n40 ns295 0 -0.00139018425785
Gc20_296 0 n40 ns296 0 0.000594799540503
Gc20_297 0 n40 ns297 0 0.00188185644582
Gc20_298 0 n40 ns298 0 0.000615647401906
Gc20_299 0 n40 ns299 0 -0.000603811299946
Gc20_300 0 n40 ns300 0 -0.0120708889134
Gc20_301 0 n40 ns301 0 0.00965951437289
Gc20_302 0 n40 ns302 0 -0.000346783961285
Gc20_303 0 n40 ns303 0 2.59405400149e-06
Gc20_304 0 n40 ns304 0 -2.66859858155e-05
Gc20_305 0 n40 ns305 0 0.000123476359641
Gc20_306 0 n40 ns306 0 -0.000923945767307
Gc20_307 0 n40 ns307 0 0.00255516369084
Gc20_308 0 n40 ns308 0 0.000104780942825
Gc20_309 0 n40 ns309 0 9.0849082578e-05
Gc20_310 0 n40 ns310 0 -3.73459429338e-05
Gc20_311 0 n40 ns311 0 -1.82837886892e-05
Gc20_312 0 n40 ns312 0 -2.62168341555e-05
Gc20_313 0 n40 ns313 0 1.32685344004e-05
Gc20_314 0 n40 ns314 0 0.00070527361217
Gc20_315 0 n40 ns315 0 -0.00145197457488
Gc20_316 0 n40 ns316 0 -0.000603578598254
Gc20_317 0 n40 ns317 0 0.000667845889444
Gc20_318 0 n40 ns318 0 0.000278227303621
Gc20_319 0 n40 ns319 0 0.000175063128367
Gc20_320 0 n40 ns320 0 -0.00102215313882
Gc20_321 0 n40 ns321 0 -0.000544283629521
Gc20_322 0 n40 ns322 0 0.000332455929279
Gc20_323 0 n40 ns323 0 0.000657016383239
Gc20_324 0 n40 ns324 0 0.000115991101224
Gc20_325 0 n40 ns325 0 -0.000144016304938
Gc20_326 0 n40 ns326 0 -1.2293552011e-05
Gc20_327 0 n40 ns327 0 -0.000990128510082
Gc20_328 0 n40 ns328 0 -0.00113537198946
Gc20_329 0 n40 ns329 0 -0.000182198922365
Gc20_330 0 n40 ns330 0 0.000599636386956
Gc20_331 0 n40 ns331 0 0.000486807420905
Gc20_332 0 n40 ns332 0 -0.00274536924968
Gc20_333 0 n40 ns333 0 -0.000346220176772
Gc20_334 0 n40 ns334 0 0.000619349649983
Gc20_335 0 n40 ns335 0 0.000995118513673
Gc20_336 0 n40 ns336 0 0.000279957730052
Gc20_337 0 n40 ns337 0 -0.000406805613323
Gc20_338 0 n40 ns338 0 -0.00594519090267
Gc20_339 0 n40 ns339 0 0.00464207391998
Gc20_340 0 n40 ns340 0 -0.00018474526623
Gc20_341 0 n40 ns341 0 8.19464210309e-06
Gc20_342 0 n40 ns342 0 -2.11484282178e-05
Gc20_343 0 n40 ns343 0 5.84266636733e-05
Gc20_344 0 n40 ns344 0 -0.000591574367242
Gc20_345 0 n40 ns345 0 0.00924899947341
Gc20_346 0 n40 ns346 0 -0.000209332802116
Gc20_347 0 n40 ns347 0 5.75421743098e-05
Gc20_348 0 n40 ns348 0 0.000553944771212
Gc20_349 0 n40 ns349 0 -0.000579622186832
Gc20_350 0 n40 ns350 0 -8.15628277947e-05
Gc20_351 0 n40 ns351 0 7.07837528676e-06
Gc20_352 0 n40 ns352 0 0.00137980953164
Gc20_353 0 n40 ns353 0 -0.00141747412991
Gc20_354 0 n40 ns354 0 -0.000182865599485
Gc20_355 0 n40 ns355 0 8.45286006717e-05
Gc20_356 0 n40 ns356 0 -0.000318869240154
Gc20_357 0 n40 ns357 0 0.000422760543587
Gc20_358 0 n40 ns358 0 -0.000507503955403
Gc20_359 0 n40 ns359 0 -0.00251287963135
Gc20_360 0 n40 ns360 0 -0.0011728268125
Gc20_361 0 n40 ns361 0 0.000128251236983
Gc20_362 0 n40 ns362 0 0.000331519834415
Gc20_363 0 n40 ns363 0 0.000437360703664
Gc20_364 0 n40 ns364 0 -0.000405528544771
Gc20_365 0 n40 ns365 0 -0.00576202182377
Gc20_366 0 n40 ns366 0 -0.00214733877512
Gc20_367 0 n40 ns367 0 -0.000642361716224
Gc20_368 0 n40 ns368 0 2.3511859791e-05
Gc20_369 0 n40 ns369 0 0.00198264350442
Gc20_370 0 n40 ns370 0 -0.0100653906507
Gc20_371 0 n40 ns371 0 -0.00595454905092
Gc20_372 0 n40 ns372 0 -0.00226247726445
Gc20_373 0 n40 ns373 0 0.00284735670685
Gc20_374 0 n40 ns374 0 0.00276511783199
Gc20_375 0 n40 ns375 0 0.000307716519064
Gc20_376 0 n40 ns376 0 -0.0912551746545
Gc20_377 0 n40 ns377 0 0.0832135212964
Gc20_378 0 n40 ns378 0 -0.0052889386161
Gc20_379 0 n40 ns379 0 -1.2578790133e-05
Gc20_380 0 n40 ns380 0 2.04798645598e-05
Gc20_381 0 n40 ns381 0 -0.00546324252513
Gc20_382 0 n40 ns382 0 -0.00514551677676
Gc20_383 0 n40 ns383 0 0.00924492419602
Gc20_384 0 n40 ns384 0 0.00262746822482
Gc20_385 0 n40 ns385 0 -0.00211929216334
Gc20_386 0 n40 ns386 0 0.000659135277486
Gc20_387 0 n40 ns387 0 0.00279512322078
Gc20_388 0 n40 ns388 0 -1.61571778889e-06
Gc20_389 0 n40 ns389 0 -0.000307575556487
Gc20_390 0 n40 ns390 0 -0.00100834083033
Gc20_391 0 n40 ns391 0 -0.00145151344907
Gc20_392 0 n40 ns392 0 -0.000881565067942
Gc20_393 0 n40 ns393 0 0.000483350674739
Gc20_394 0 n40 ns394 0 -0.000157599703823
Gc20_395 0 n40 ns395 0 0.000583612063582
Gc20_396 0 n40 ns396 0 0.00278230947002
Gc20_397 0 n40 ns397 0 -0.00258094089459
Gc20_398 0 n40 ns398 0 -0.000892600570747
Gc20_399 0 n40 ns399 0 -0.000590275758118
Gc20_400 0 n40 ns400 0 0.000202424438765
Gc20_401 0 n40 ns401 0 0.000194981299296
Gc20_402 0 n40 ns402 0 0.00238146829914
Gc20_403 0 n40 ns403 0 0.00135002583782
Gc20_404 0 n40 ns404 0 -0.00116515856063
Gc20_405 0 n40 ns405 0 -0.00268106853929
Gc20_406 0 n40 ns406 0 -0.00115710373187
Gc20_407 0 n40 ns407 0 0.00210186295585
Gc20_408 0 n40 ns408 0 -0.0147193365155
Gc20_409 0 n40 ns409 0 -0.00568421097545
Gc20_410 0 n40 ns410 0 0.00202370147503
Gc20_411 0 n40 ns411 0 0.00390785656863
Gc20_412 0 n40 ns412 0 0.0037225430279
Gc20_413 0 n40 ns413 0 0.000172898288145
Gc20_414 0 n40 ns414 0 0.00883061842567
Gc20_415 0 n40 ns415 0 -0.00107910581448
Gc20_416 0 n40 ns416 0 -0.0078754995151
Gc20_417 0 n40 ns417 0 -1.3151329488e-05
Gc20_418 0 n40 ns418 0 1.55030504985e-05
Gc20_419 0 n40 ns419 0 -0.00256780256136
Gc20_420 0 n40 ns420 0 -0.00296336945587
Gc20_421 0 n40 ns421 0 0.00738952261228
Gc20_422 0 n40 ns422 0 0.000986057932043
Gc20_423 0 n40 ns423 0 -0.0017190264298
Gc20_424 0 n40 ns424 0 0.00063793019055
Gc20_425 0 n40 ns425 0 0.00198997441451
Gc20_426 0 n40 ns426 0 3.42386513675e-05
Gc20_427 0 n40 ns427 0 -0.000211424499048
Gc20_428 0 n40 ns428 0 0.000930377582266
Gc20_429 0 n40 ns429 0 -0.00157670823825
Gc20_430 0 n40 ns430 0 -0.00108751436094
Gc20_431 0 n40 ns431 0 0.00072263929195
Gc20_432 0 n40 ns432 0 -0.000135508551585
Gc20_433 0 n40 ns433 0 0.000546537322197
Gc20_434 0 n40 ns434 0 0.00127109781598
Gc20_435 0 n40 ns435 0 -0.00283949834573
Gc20_436 0 n40 ns436 0 -0.000617916228316
Gc20_437 0 n40 ns437 0 -0.00013437841808
Gc20_438 0 n40 ns438 0 0.000278843588286
Gc20_439 0 n40 ns439 0 0.000233917838269
Gc20_440 0 n40 ns440 0 0.00215451400948
Gc20_441 0 n40 ns441 0 -0.00232496425434
Gc20_442 0 n40 ns442 0 -0.00262150394958
Gc20_443 0 n40 ns443 0 -0.00183564125887
Gc20_444 0 n40 ns444 0 -0.00031837107259
Gc20_445 0 n40 ns445 0 0.00237808046652
Gc20_446 0 n40 ns446 0 -0.0119217791993
Gc20_447 0 n40 ns447 0 -0.00484722847959
Gc20_448 0 n40 ns448 0 0.000289912003214
Gc20_449 0 n40 ns449 0 0.0024500169142
Gc20_450 0 n40 ns450 0 0.00314174142879
Gc20_451 0 n40 ns451 0 0.000207156351989
Gc20_452 0 n40 ns452 0 -0.0367424082454
Gc20_453 0 n40 ns453 0 0.0384506520634
Gc20_454 0 n40 ns454 0 -0.00706898870443
Gc20_455 0 n40 ns455 0 -9.8746894297e-06
Gc20_456 0 n40 ns456 0 8.50291335171e-06
Gc20_457 0 n40 ns457 0 0.000286720019938
Gc20_458 0 n40 ns458 0 -0.00115819719972
Gc20_459 0 n40 ns459 0 0.0101585940419
Gc20_460 0 n40 ns460 0 -0.000150940943199
Gc20_461 0 n40 ns461 0 0.000536637752074
Gc20_462 0 n40 ns462 0 0.000600083307889
Gc20_463 0 n40 ns463 0 -0.000314541840635
Gc20_464 0 n40 ns464 0 -0.000121153521015
Gc20_465 0 n40 ns465 0 -2.68212629383e-05
Gc20_466 0 n40 ns466 0 0.00103503664863
Gc20_467 0 n40 ns467 0 -0.00385502314331
Gc20_468 0 n40 ns468 0 -0.000175526008942
Gc20_469 0 n40 ns469 0 0.00114905162857
Gc20_470 0 n40 ns470 0 2.20587889737e-05
Gc20_471 0 n40 ns471 0 0.000474981279264
Gc20_472 0 n40 ns472 0 -0.00142016479667
Gc20_473 0 n40 ns473 0 -0.00123444844098
Gc20_474 0 n40 ns474 0 -0.000339436362942
Gc20_475 0 n40 ns475 0 3.20340971727e-05
Gc20_476 0 n40 ns476 0 0.00032879551715
Gc20_477 0 n40 ns477 0 0.000133940917931
Gc20_478 0 n40 ns478 0 -0.00148207631379
Gc20_479 0 n40 ns479 0 -0.00576587893786
Gc20_480 0 n40 ns480 0 -0.00210651438373
Gc20_481 0 n40 ns481 0 -5.13197851853e-05
Gc20_482 0 n40 ns482 0 0.000458366637821
Gc20_483 0 n40 ns483 0 0.00172109314229
Gc20_484 0 n40 ns484 0 -0.00976739113656
Gc20_485 0 n40 ns485 0 -0.00527038519038
Gc20_486 0 n40 ns486 0 -0.00172743767675
Gc20_487 0 n40 ns487 0 0.00342056776562
Gc20_488 0 n40 ns488 0 0.00253892551106
Gc20_489 0 n40 ns489 0 -0.000138628782356
Gc20_490 0 n40 ns490 0 -0.0774532693976
Gc20_491 0 n40 ns491 0 0.0690583431247
Gc20_492 0 n40 ns492 0 -0.00393353451878
Gc20_493 0 n40 ns493 0 -9.16024386144e-06
Gc20_494 0 n40 ns494 0 -1.21128130296e-05
Gc20_495 0 n40 ns495 0 0.000895236465615
Gc20_496 0 n40 ns496 0 -0.00172498288443
Gc20_497 0 n40 ns497 0 0.00790319843538
Gc20_498 0 n40 ns498 0 8.28439356768e-05
Gc20_499 0 n40 ns499 0 2.00300408441e-05
Gc20_500 0 n40 ns500 0 8.56537998967e-05
Gc20_501 0 n40 ns501 0 0.000139644188204
Gc20_502 0 n40 ns502 0 2.28238223402e-05
Gc20_503 0 n40 ns503 0 3.87538896165e-05
Gc20_504 0 n40 ns504 0 -0.000755275067201
Gc20_505 0 n40 ns505 0 -0.00197764967878
Gc20_506 0 n40 ns506 0 0.000378829467493
Gc20_507 0 n40 ns507 0 0.000319789829247
Gc20_508 0 n40 ns508 0 0.000104154095209
Gc20_509 0 n40 ns509 0 0.000301367858109
Gc20_510 0 n40 ns510 0 0.000623101971602
Gc20_511 0 n40 ns511 0 -8.74890937447e-05
Gc20_512 0 n40 ns512 0 -0.000818844933478
Gc20_513 0 n40 ns513 0 -0.000328274647478
Gc20_514 0 n40 ns514 0 0.000130309625799
Gc20_515 0 n40 ns515 0 1.2031726368e-05
Gc20_516 0 n40 ns516 0 -0.00167637010431
Gc20_517 0 n40 ns517 0 -0.0029286212736
Gc20_518 0 n40 ns518 0 -0.000953786172735
Gc20_519 0 n40 ns519 0 -0.000730694108902
Gc20_520 0 n40 ns520 0 0.000281389876048
Gc20_521 0 n40 ns521 0 0.00138034045602
Gc20_522 0 n40 ns522 0 -0.0068123702631
Gc20_523 0 n40 ns523 0 -0.00398591489921
Gc20_524 0 n40 ns524 0 -0.000558928274146
Gc20_525 0 n40 ns525 0 0.00353439180558
Gc20_526 0 n40 ns526 0 0.00164035905911
Gc20_527 0 n40 ns527 0 -0.000637271404775
Gc20_528 0 n40 ns528 0 -0.0402059408452
Gc20_529 0 n40 ns529 0 0.0341080940535
Gc20_530 0 n40 ns530 0 -0.00144494304317
Gc20_531 0 n40 ns531 0 -6.00703177309e-06
Gc20_532 0 n40 ns532 0 -2.72931007053e-05
Gc20_533 0 n40 ns533 0 0.000498331451299
Gc20_534 0 n40 ns534 0 -0.00080692175591
Gc20_535 0 n40 ns535 0 0.00421134551708
Gc20_536 0 n40 ns536 0 -9.83635590775e-05
Gc20_537 0 n40 ns537 0 0.000291232088526
Gc20_538 0 n40 ns538 0 0.000291732921408
Gc20_539 0 n40 ns539 0 2.45873075519e-06
Gc20_540 0 n40 ns540 0 2.80045930942e-05
Gc20_541 0 n40 ns541 0 -3.36896932353e-05
Gc20_542 0 n40 ns542 0 7.95907379813e-05
Gc20_543 0 n40 ns543 0 -0.000748113811569
Gc20_544 0 n40 ns544 0 -0.00020869912688
Gc20_545 0 n40 ns545 0 -8.44151807345e-05
Gc20_546 0 n40 ns546 0 0.000144834696367
Gc20_547 0 n40 ns547 0 0.000224740597537
Gc20_548 0 n40 ns548 0 0.000362905659151
Gc20_549 0 n40 ns549 0 -0.00128431579478
Gc20_550 0 n40 ns550 0 -0.000717929090997
Gc20_551 0 n40 ns551 0 0.000583691496033
Gc20_552 0 n40 ns552 0 0.000156201325522
Gc20_553 0 n40 ns553 0 -1.51924210897e-05
Gc20_554 0 n40 ns554 0 -0.000476166298728
Gc20_555 0 n40 ns555 0 -0.00163717285932
Gc20_556 0 n40 ns556 0 -0.0013632611334
Gc20_557 0 n40 ns557 0 -0.000943743541209
Gc20_558 0 n40 ns558 0 0.00057105935217
Gc20_559 0 n40 ns559 0 0.00119034982966
Gc20_560 0 n40 ns560 0 -0.00508086846699
Gc20_561 0 n40 ns561 0 -0.00200807769735
Gc20_562 0 n40 ns562 0 0.00054110117708
Gc20_563 0 n40 ns563 0 0.00240799165595
Gc20_564 0 n40 ns564 0 0.000834543839298
Gc20_565 0 n40 ns565 0 -0.000704674295758
Gc20_566 0 n40 ns566 0 -0.0169494992699
Gc20_567 0 n40 ns567 0 0.0137092927907
Gc20_568 0 n40 ns568 0 -0.00049247401668
Gc20_569 0 n40 ns569 0 3.44439718463e-07
Gc20_570 0 n40 ns570 0 -3.00079897126e-05
Gc20_571 0 n40 ns571 0 0.000247139986097
Gc20_572 0 n40 ns572 0 -0.00103052536898
Gc20_573 0 n40 ns573 0 0.00325499748253
Gc20_574 0 n40 ns574 0 6.55302996839e-05
Gc20_575 0 n40 ns575 0 0.000177883602218
Gc20_576 0 n40 ns576 0 4.07035272515e-05
Gc20_577 0 n40 ns577 0 -1.2630014916e-05
Gc20_578 0 n40 ns578 0 -2.04995866506e-05
Gc20_579 0 n40 ns579 0 -1.11859911582e-05
Gc20_580 0 n40 ns580 0 0.000861084491724
Gc20_581 0 n40 ns581 0 -0.00153505468637
Gc20_582 0 n40 ns582 0 -0.000700947942395
Gc20_583 0 n40 ns583 0 0.000606446880601
Gc20_584 0 n40 ns584 0 0.000291150496309
Gc20_585 0 n40 ns585 0 0.000223355429407
Gc20_586 0 n40 ns586 0 -0.000958302387201
Gc20_587 0 n40 ns587 0 -0.000946130249531
Gc20_588 0 n40 ns588 0 0.000159731225274
Gc20_589 0 n40 ns589 0 0.000828054705312
Gc20_590 0 n40 ns590 0 0.000149873545112
Gc20_591 0 n40 ns591 0 -0.000134782091376
Gc20_592 0 n40 ns592 0 -0.000119968266179
Gc20_593 0 n40 ns593 0 -0.00127630993174
Gc20_594 0 n40 ns594 0 -0.00137955489967
Gc20_595 0 n40 ns595 0 -0.000314741300007
Gc20_596 0 n40 ns596 0 0.000711802869601
Gc20_597 0 n40 ns597 0 0.000666957362847
Gc20_598 0 n40 ns598 0 -0.00349066379719
Gc20_599 0 n40 ns599 0 -0.000881454278951
Gc20_600 0 n40 ns600 0 0.000585792774622
Gc20_601 0 n40 ns601 0 0.001352260444
Gc20_602 0 n40 ns602 0 0.000412841043867
Gc20_603 0 n40 ns603 0 -0.00045179656394
Gc20_604 0 n40 ns604 0 -0.0109515221938
Gc20_605 0 n40 ns605 0 0.00885700921955
Gc20_606 0 n40 ns606 0 -0.000324372578628
Gc20_607 0 n40 ns607 0 6.37842528024e-06
Gc20_608 0 n40 ns608 0 -2.35140221018e-05
Gc20_609 0 n40 ns609 0 -0.00117571687249
Gc20_610 0 n40 ns610 0 0.00251234643403
Gc20_611 0 n40 ns611 0 -0.00398552779395
Gc20_612 0 n40 ns612 0 0.000222406128948
Gc20_613 0 n40 ns613 0 -0.000503098095028
Gc20_614 0 n40 ns614 0 7.59821996444e-05
Gc20_615 0 n40 ns615 0 -0.000536175174295
Gc20_616 0 n40 ns616 0 -3.34151170025e-05
Gc20_617 0 n40 ns617 0 -7.22289476201e-06
Gc20_618 0 n40 ns618 0 -0.0015872039176
Gc20_619 0 n40 ns619 0 0.0016876628395
Gc20_620 0 n40 ns620 0 -0.000365310991914
Gc20_621 0 n40 ns621 0 -0.00044806619338
Gc20_622 0 n40 ns622 0 0.000149595522103
Gc20_623 0 n40 ns623 0 -0.00023758884531
Gc20_624 0 n40 ns624 0 -0.000156369323821
Gc20_625 0 n40 ns625 0 0.00268130675718
Gc20_626 0 n40 ns626 0 0.000132332993664
Gc20_627 0 n40 ns627 0 -0.000882043056116
Gc20_628 0 n40 ns628 0 0.000209312957683
Gc20_629 0 n40 ns629 0 1.03163871116e-05
Gc20_630 0 n40 ns630 0 0.00235615694473
Gc20_631 0 n40 ns631 0 0.0023447228439
Gc20_632 0 n40 ns632 0 -0.000514274761346
Gc20_633 0 n40 ns633 0 7.55373282891e-06
Gc20_634 0 n40 ns634 0 0.00046517782756
Gc20_635 0 n40 ns635 0 -0.000647036484737
Gc20_636 0 n40 ns636 0 0.00358467993088
Gc20_637 0 n40 ns637 0 0.000269414949594
Gc20_638 0 n40 ns638 0 -0.00189281685659
Gc20_639 0 n40 ns639 0 0.00067206468743
Gc20_640 0 n40 ns640 0 0.00113506118979
Gc20_641 0 n40 ns641 0 -0.000210603903275
Gc20_642 0 n40 ns642 0 0.0366407597832
Gc20_643 0 n40 ns643 0 -0.033583284438
Gc20_644 0 n40 ns644 0 0.0019027271485
Gc20_645 0 n40 ns645 0 -6.36518105489e-06
Gc20_646 0 n40 ns646 0 1.80548664932e-05
Gc20_647 0 n40 ns647 0 -0.00147601467516
Gc20_648 0 n40 ns648 0 0.00169496689892
Gc20_649 0 n40 ns649 0 -0.00274309499456
Gc20_650 0 n40 ns650 0 0.000472938203556
Gc20_651 0 n40 ns651 0 -0.000697503109512
Gc20_652 0 n40 ns652 0 0.000262758664732
Gc20_653 0 n40 ns653 0 -0.000244440374778
Gc20_654 0 n40 ns654 0 -6.44228375103e-05
Gc20_655 0 n40 ns655 0 -1.0303233317e-05
Gc20_656 0 n40 ns656 0 -0.00178222572863
Gc20_657 0 n40 ns657 0 0.000835912851169
Gc20_658 0 n40 ns658 0 -6.64545075419e-05
Gc20_659 0 n40 ns659 0 -0.000323980818337
Gc20_660 0 n40 ns660 0 0.000247152709666
Gc20_661 0 n40 ns661 0 -0.000359858691181
Gc20_662 0 n40 ns662 0 -0.000806994929757
Gc20_663 0 n40 ns663 0 0.00157412846527
Gc20_664 0 n40 ns664 0 -9.00942395051e-05
Gc20_665 0 n40 ns665 0 -0.000569617253468
Gc20_666 0 n40 ns666 0 0.000317025939269
Gc20_667 0 n40 ns667 0 0.000110713075978
Gc20_668 0 n40 ns668 0 0.000699834669606
Gc20_669 0 n40 ns669 0 0.00288785440675
Gc20_670 0 n40 ns670 0 -0.000245209355325
Gc20_671 0 n40 ns671 0 0.000372549022114
Gc20_672 0 n40 ns672 0 0.000615394064394
Gc20_673 0 n40 ns673 0 -0.000994022105821
Gc20_674 0 n40 ns674 0 0.00289655844379
Gc20_675 0 n40 ns675 0 0.00141349619489
Gc20_676 0 n40 ns676 0 -0.00203553014173
Gc20_677 0 n40 ns677 0 0.000527975598044
Gc20_678 0 n40 ns678 0 0.00143529199849
Gc20_679 0 n40 ns679 0 -0.000209037575332
Gc20_680 0 n40 ns680 0 0.0451369753592
Gc20_681 0 n40 ns681 0 -0.0426250692155
Gc20_682 0 n40 ns682 0 0.00272448807633
Gc20_683 0 n40 ns683 0 -3.02078087848e-06
Gc20_684 0 n40 ns684 0 2.20657411732e-05
Gc20_685 0 n40 ns685 0 -0.00197619880836
Gc20_686 0 n40 ns686 0 -0.00185766027855
Gc20_687 0 n40 ns687 0 0.00518784659886
Gc20_688 0 n40 ns688 0 0.000378033883291
Gc20_689 0 n40 ns689 0 -0.000412539168855
Gc20_690 0 n40 ns690 0 0.000486467203627
Gc20_691 0 n40 ns691 0 0.000424693214598
Gc20_692 0 n40 ns692 0 -0.000169169788103
Gc20_693 0 n40 ns693 0 -3.9916802286e-05
Gc20_694 0 n40 ns694 0 -0.00104911817712
Gc20_695 0 n40 ns695 0 -0.000644317526898
Gc20_696 0 n40 ns696 0 0.000969716743835
Gc20_697 0 n40 ns697 0 0.000353901161588
Gc20_698 0 n40 ns698 0 0.00045517332784
Gc20_699 0 n40 ns699 0 -0.00054455669466
Gc20_700 0 n40 ns700 0 0.000568018258664
Gc20_701 0 n40 ns701 0 -0.00265166113271
Gc20_702 0 n40 ns702 0 -0.000934015971542
Gc20_703 0 n40 ns703 0 8.45143141207e-05
Gc20_704 0 n40 ns704 0 0.000394453585601
Gc20_705 0 n40 ns705 0 0.000362898757592
Gc20_706 0 n40 ns706 0 -0.00462673064208
Gc20_707 0 n40 ns707 0 -0.00171168365991
Gc20_708 0 n40 ns708 0 0.000361146516376
Gc20_709 0 n40 ns709 0 0.00196694009159
Gc20_710 0 n40 ns710 0 0.00122729581202
Gc20_711 0 n40 ns711 0 -0.00169870507658
Gc20_712 0 n40 ns712 0 -0.00655291878835
Gc20_713 0 n40 ns713 0 -0.00153726390536
Gc20_714 0 n40 ns714 0 -0.00123008606829
Gc20_715 0 n40 ns715 0 0.00109951331695
Gc20_716 0 n40 ns716 0 0.00256774753932
Gc20_717 0 n40 ns717 0 0.000260844430912
Gc20_718 0 n40 ns718 0 0.0148676031462
Gc20_719 0 n40 ns719 0 -0.0236540132339
Gc20_720 0 n40 ns720 0 0.0053708746667
Gc20_721 0 n40 ns721 0 2.37464166974e-06
Gc20_722 0 n40 ns722 0 2.65877141926e-05
Gc20_723 0 n40 ns723 0 -0.00308328529892
Gc20_724 0 n40 ns724 0 -0.000271104409564
Gc20_725 0 n40 ns725 0 -0.00101899541148
Gc20_726 0 n40 ns726 0 0.000288472786051
Gc20_727 0 n40 ns727 0 -0.00024128789792
Gc20_728 0 n40 ns728 0 0.000473758774934
Gc20_729 0 n40 ns729 0 -0.000143432536135
Gc20_730 0 n40 ns730 0 -0.000193149277401
Gc20_731 0 n40 ns731 0 -0.000102082331749
Gc20_732 0 n40 ns732 0 -0.00422845886023
Gc20_733 0 n40 ns733 0 0.00135459263441
Gc20_734 0 n40 ns734 0 0.00168927978516
Gc20_735 0 n40 ns735 0 -5.60933138813e-05
Gc20_736 0 n40 ns736 0 0.000430813177692
Gc20_737 0 n40 ns737 0 -0.000658345530668
Gc20_738 0 n40 ns738 0 -0.000250566362324
Gc20_739 0 n40 ns739 0 0.000895304460774
Gc20_740 0 n40 ns740 0 0.000413651071552
Gc20_741 0 n40 ns741 0 0.000584230746549
Gc20_742 0 n40 ns742 0 0.00064487860453
Gc20_743 0 n40 ns743 0 0.000221586398603
Gc20_744 0 n40 ns744 0 0.000269990049074
Gc20_745 0 n40 ns745 0 0.000845024800167
Gc20_746 0 n40 ns746 0 0.00141222847516
Gc20_747 0 n40 ns747 0 0.00304631623534
Gc20_748 0 n40 ns748 0 0.00133165227258
Gc20_749 0 n40 ns749 0 -0.00230279417233
Gc20_750 0 n40 ns750 0 -0.000931635573222
Gc20_751 0 n40 ns751 0 -0.00293379649819
Gc20_752 0 n40 ns752 0 0.00206261731868
Gc20_753 0 n40 ns753 0 0.00198942479433
Gc20_754 0 n40 ns754 0 0.00327599594713
Gc20_755 0 n40 ns755 0 3.87135407525e-05
Gc20_756 0 n40 ns756 0 -0.0259975563674
Gc20_757 0 n40 ns757 0 0.0252359747917
Gc20_758 0 n40 ns758 0 0.00689561511502
Gc20_759 0 n40 ns759 0 1.10453761669e-05
Gc20_760 0 n40 ns760 0 1.93052949127e-05
Gc20_761 0 n40 ns761 0 -0.00209204014474
Gc20_762 0 n40 ns762 0 -0.00201595952945
Gc20_763 0 n40 ns763 0 0.00395177185511
Gc20_764 0 n40 ns764 0 0.000349703098905
Gc20_765 0 n40 ns765 0 -0.000397461385848
Gc20_766 0 n40 ns766 0 0.000575423744231
Gc20_767 0 n40 ns767 0 0.000389131451711
Gc20_768 0 n40 ns768 0 -0.000169483024398
Gc20_769 0 n40 ns769 0 -8.11463878159e-05
Gc20_770 0 n40 ns770 0 -0.00134723592013
Gc20_771 0 n40 ns771 0 0.000112099494242
Gc20_772 0 n40 ns772 0 0.00107303089528
Gc20_773 0 n40 ns773 0 -0.000157928820465
Gc20_774 0 n40 ns774 0 0.000301378678002
Gc20_775 0 n40 ns775 0 -0.000507256674857
Gc20_776 0 n40 ns776 0 0.000134233118114
Gc20_777 0 n40 ns777 0 -0.00186771741904
Gc20_778 0 n40 ns778 0 -0.000333101547777
Gc20_779 0 n40 ns779 0 5.41408037903e-05
Gc20_780 0 n40 ns780 0 0.000379596549412
Gc20_781 0 n40 ns781 0 0.000206181869854
Gc20_782 0 n40 ns782 0 -0.00362425368595
Gc20_783 0 n40 ns783 0 -0.000904631166069
Gc20_784 0 n40 ns784 0 0.000865003777571
Gc20_785 0 n40 ns785 0 0.00139382069341
Gc20_786 0 n40 ns786 0 0.000768779725873
Gc20_787 0 n40 ns787 0 -0.00157332451881
Gc20_788 0 n40 ns788 0 -0.00525574668629
Gc20_789 0 n40 ns789 0 -0.00129416492253
Gc20_790 0 n40 ns790 0 -0.00123063894448
Gc20_791 0 n40 ns791 0 0.000819307672646
Gc20_792 0 n40 ns792 0 0.00242876544267
Gc20_793 0 n40 ns793 0 0.000244591398888
Gc20_794 0 n40 ns794 0 0.0219862137859
Gc20_795 0 n40 ns795 0 -0.0293748255615
Gc20_796 0 n40 ns796 0 0.00550428753437
Gc20_797 0 n40 ns797 0 2.03797613915e-06
Gc20_798 0 n40 ns798 0 3.46069439981e-06
Gc20_799 0 n40 ns799 0 -0.00148890545535
Gc20_800 0 n40 ns800 0 0.00114385182749
Gc20_801 0 n40 ns801 0 -0.00344430974393
Gc20_802 0 n40 ns802 0 0.000331320532133
Gc20_803 0 n40 ns803 0 -0.000583681516887
Gc20_804 0 n40 ns804 0 0.00028101595732
Gc20_805 0 n40 ns805 0 -0.000181420450407
Gc20_806 0 n40 ns806 0 -4.67488734533e-05
Gc20_807 0 n40 ns807 0 3.50409710819e-05
Gc20_808 0 n40 ns808 0 -0.00143454840817
Gc20_809 0 n40 ns809 0 0.000989624309797
Gc20_810 0 n40 ns810 0 0.000117761518263
Gc20_811 0 n40 ns811 0 -0.000505190524619
Gc20_812 0 n40 ns812 0 5.19378248949e-05
Gc20_813 0 n40 ns813 0 -0.000370522087177
Gc20_814 0 n40 ns814 0 -0.0014221331897
Gc20_815 0 n40 ns815 0 0.00121916513871
Gc20_816 0 n40 ns816 0 0.000208597880157
Gc20_817 0 n40 ns817 0 -2.65913261391e-05
Gc20_818 0 n40 ns818 0 0.000400786132283
Gc20_819 0 n40 ns819 0 -2.67489190758e-05
Gc20_820 0 n40 ns820 0 0.000820530240133
Gc20_821 0 n40 ns821 0 0.00384379182913
Gc20_822 0 n40 ns822 0 0.000783022748993
Gc20_823 0 n40 ns823 0 0.000211332767535
Gc20_824 0 n40 ns824 0 -5.53950366251e-05
Gc20_825 0 n40 ns825 0 -0.00120371032043
Gc20_826 0 n40 ns826 0 0.00356520757648
Gc20_827 0 n40 ns827 0 0.00211964740747
Gc20_828 0 n40 ns828 0 -0.00158844905242
Gc20_829 0 n40 ns829 0 0.000423204706877
Gc20_830 0 n40 ns830 0 0.00126138286031
Gc20_831 0 n40 ns831 0 -0.000439161387903
Gc20_832 0 n40 ns832 0 0.0538342596942
Gc20_833 0 n40 ns833 0 -0.0498084524959
Gc20_834 0 n40 ns834 0 0.00288449757691
Gc20_835 0 n40 ns835 0 -3.00387832281e-06
Gc20_836 0 n40 ns836 0 -1.79217994795e-05
Gc20_837 0 n40 ns837 0 -0.0009594707907
Gc20_838 0 n40 ns838 0 0.00227181133994
Gc20_839 0 n40 ns839 0 -0.00578341535617
Gc20_840 0 n40 ns840 0 -0.000431313220521
Gc20_841 0 n40 ns841 0 -0.000222525495269
Gc20_842 0 n40 ns842 0 -0.000361359430077
Gc20_843 0 n40 ns843 0 -6.4361647627e-05
Gc20_844 0 n40 ns844 0 -3.12491281297e-06
Gc20_845 0 n40 ns845 0 2.54446939155e-05
Gc20_846 0 n40 ns846 0 0.000773937054704
Gc20_847 0 n40 ns847 0 0.00219437764829
Gc20_848 0 n40 ns848 0 -0.000355122717572
Gc20_849 0 n40 ns849 0 -0.000132063590352
Gc20_850 0 n40 ns850 0 -0.000127431302708
Gc20_851 0 n40 ns851 0 -0.00023415756996
Gc20_852 0 n40 ns852 0 0.00131010974829
Gc20_853 0 n40 ns853 0 0.00116175568482
Gc20_854 0 n40 ns854 0 -0.000279285868463
Gc20_855 0 n40 ns855 0 -0.000282504529452
Gc20_856 0 n40 ns856 0 0.000188263755343
Gc20_857 0 n40 ns857 0 -0.000146564368555
Gc20_858 0 n40 ns858 0 0.00221405807155
Gc20_859 0 n40 ns859 0 0.000677696495656
Gc20_860 0 n40 ns860 0 0.000363647611274
Gc20_861 0 n40 ns861 0 0.000493079276165
Gc20_862 0 n40 ns862 0 -0.000244042593319
Gc20_863 0 n40 ns863 0 -0.000883475127959
Gc20_864 0 n40 ns864 0 0.00233909311002
Gc20_865 0 n40 ns865 0 -6.42618745781e-05
Gc20_866 0 n40 ns866 0 -0.000411684176616
Gc20_867 0 n40 ns867 0 0.00107450638728
Gc20_868 0 n40 ns868 0 0.000644395348477
Gc20_869 0 n40 ns869 0 -0.000670670540913
Gc20_870 0 n40 ns870 0 0.0351669571369
Gc20_871 0 n40 ns871 0 -0.0311622691639
Gc20_872 0 n40 ns872 0 0.00140540040028
Gc20_873 0 n40 ns873 0 -7.0805470449e-06
Gc20_874 0 n40 ns874 0 -2.50277681947e-05
Gc20_875 0 n40 ns875 0 -1.18730852878e-05
Gc20_876 0 n40 ns876 0 -0.000389880902555
Gc20_877 0 n40 ns877 0 0.00103731519313
Gc20_878 0 n40 ns878 0 -4.56612535556e-05
Gc20_879 0 n40 ns879 0 0.000156524102032
Gc20_880 0 n40 ns880 0 6.64946362552e-05
Gc20_881 0 n40 ns881 0 4.88035550448e-05
Gc20_882 0 n40 ns882 0 -1.5772283276e-05
Gc20_883 0 n40 ns883 0 5.65395990876e-06
Gc20_884 0 n40 ns884 0 -0.000250517927942
Gc20_885 0 n40 ns885 0 -0.000150309558814
Gc20_886 0 n40 ns886 0 0.00051020328496
Gc20_887 0 n40 ns887 0 0.0001307522776
Gc20_888 0 n40 ns888 0 -0.00013398840779
Gc20_889 0 n40 ns889 0 -0.000193535901607
Gc20_890 0 n40 ns890 0 -0.000304774649027
Gc20_891 0 n40 ns891 0 -0.000910000172856
Gc20_892 0 n40 ns892 0 -0.000207464335716
Gc20_893 0 n40 ns893 0 0.000790400204577
Gc20_894 0 n40 ns894 0 0.000195144896426
Gc20_895 0 n40 ns895 0 -8.61326603192e-05
Gc20_896 0 n40 ns896 0 -0.000625697932846
Gc20_897 0 n40 ns897 0 0.000359432779377
Gc20_898 0 n40 ns898 0 0.000846394917797
Gc20_899 0 n40 ns899 0 0.000730416374054
Gc20_900 0 n40 ns900 0 -0.000406507400002
Gc20_901 0 n40 ns901 0 -0.000731207225264
Gc20_902 0 n40 ns902 0 -0.00127994538379
Gc20_903 0 n40 ns903 0 -3.50716135872e-05
Gc20_904 0 n40 ns904 0 0.000463485306229
Gc20_905 0 n40 ns905 0 0.00117230021843
Gc20_906 0 n40 ns906 0 0.000399300848746
Gc20_907 0 n40 ns907 0 -0.000588667829825
Gc20_908 0 n40 ns908 0 0.00877749263561
Gc20_909 0 n40 ns909 0 -0.00860813922912
Gc20_910 0 n40 ns910 0 0.000509905022907
Gc20_911 0 n40 ns911 0 -3.37425557533e-06
Gc20_912 0 n40 ns912 0 -2.60843344304e-05
Gc20_913 0 n40 ns913 0 0.000410591705308
Gc20_914 0 n40 ns914 0 -0.00127705755929
Gc20_915 0 n40 ns915 0 0.00221812104226
Gc20_916 0 n40 ns916 0 0.000187339110475
Gc20_917 0 n40 ns917 0 -0.000136464233528
Gc20_918 0 n40 ns918 0 9.56579985138e-05
Gc20_919 0 n40 ns919 0 1.90547623252e-05
Gc20_920 0 n40 ns920 0 3.51432428924e-05
Gc20_921 0 n40 ns921 0 -3.5708868104e-05
Gc20_922 0 n40 ns922 0 -0.00136652883422
Gc20_923 0 n40 ns923 0 -5.10324342306e-05
Gc20_924 0 n40 ns924 0 0.000713268852399
Gc20_925 0 n40 ns925 0 -0.000252030203412
Gc20_926 0 n40 ns926 0 -0.000140387322887
Gc20_927 0 n40 ns927 0 -0.000128026637206
Gc20_928 0 n40 ns928 0 -0.00134653732032
Gc20_929 0 n40 ns929 0 -0.000147015772999
Gc20_930 0 n40 ns930 0 0.000457516038044
Gc20_931 0 n40 ns931 0 0.000742137779122
Gc20_932 0 n40 ns932 0 0.000154092273857
Gc20_933 0 n40 ns933 0 -0.000134921858811
Gc20_934 0 n40 ns934 0 -0.000439802653921
Gc20_935 0 n40 ns935 0 0.00128919256676
Gc20_936 0 n40 ns936 0 0.00097272714396
Gc20_937 0 n40 ns937 0 0.000138203629932
Gc20_938 0 n40 ns938 0 -0.000522859568252
Gc20_939 0 n40 ns939 0 -0.000378630128881
Gc20_940 0 n40 ns940 0 -0.000420535819565
Gc20_941 0 n40 ns941 0 0.000805628611926
Gc20_942 0 n40 ns942 0 0.000448201413007
Gc20_943 0 n40 ns943 0 0.000356835863642
Gc20_944 0 n40 ns944 0 9.30876452669e-05
Gc20_945 0 n40 ns945 0 -0.000353383044476
Gc20_946 0 n40 ns946 0 0.00657862296583
Gc20_947 0 n40 ns947 0 -0.00619569976963
Gc20_948 0 n40 ns948 0 0.000315725205163
Gc20_949 0 n40 ns949 0 -7.17366453964e-06
Gc20_950 0 n40 ns950 0 -2.33887609405e-05
Gc20_951 0 n40 ns951 0 -0.00204867105206
Gc20_952 0 n40 ns952 0 0.00015719054874
Gc20_953 0 n40 ns953 0 0.00172278046314
Gc20_954 0 n40 ns954 0 0.000626278436365
Gc20_955 0 n40 ns955 0 -0.00040115024223
Gc20_956 0 n40 ns956 0 0.000502490910431
Gc20_957 0 n40 ns957 0 0.00038387251266
Gc20_958 0 n40 ns958 0 -0.000165039927154
Gc20_959 0 n40 ns959 0 -1.84388097437e-05
Gc20_960 0 n40 ns960 0 -0.00054715068213
Gc20_961 0 n40 ns961 0 -0.000771779140967
Gc20_962 0 n40 ns962 0 0.000520784156914
Gc20_963 0 n40 ns963 0 0.000127218587476
Gc20_964 0 n40 ns964 0 0.000361311722056
Gc20_965 0 n40 ns965 0 -0.000491207713305
Gc20_966 0 n40 ns966 0 -0.000191397193031
Gc20_967 0 n40 ns967 0 -0.00222040535756
Gc20_968 0 n40 ns968 0 -0.000992114151104
Gc20_969 0 n40 ns969 0 -5.90758514561e-05
Gc20_970 0 n40 ns970 0 0.000334491716561
Gc20_971 0 n40 ns971 0 0.000333288175456
Gc20_972 0 n40 ns972 0 -0.00408352545091
Gc20_973 0 n40 ns973 0 0.000438301063791
Gc20_974 0 n40 ns974 0 9.24101974767e-05
Gc20_975 0 n40 ns975 0 0.0014618932178
Gc20_976 0 n40 ns976 0 0.00106695133791
Gc20_977 0 n40 ns977 0 -0.00146341894517
Gc20_978 0 n40 ns978 0 -0.00273115171588
Gc20_979 0 n40 ns979 0 0.0013558347055
Gc20_980 0 n40 ns980 0 -0.00181645947798
Gc20_981 0 n40 ns981 0 0.000527305879712
Gc20_982 0 n40 ns982 0 0.00209620081354
Gc20_983 0 n40 ns983 0 9.08482564258e-05
Gc20_984 0 n40 ns984 0 0.0385738267339
Gc20_985 0 n40 ns985 0 -0.0421729910712
Gc20_986 0 n40 ns986 0 0.00446354955492
Gc20_987 0 n40 ns987 0 3.04749511296e-06
Gc20_988 0 n40 ns988 0 2.63861281662e-05
Gc20_989 0 n40 ns989 0 -0.00475174286701
Gc20_990 0 n40 ns990 0 -0.000715104136682
Gc20_991 0 n40 ns991 0 -0.00363000868659
Gc20_992 0 n40 ns992 0 0.000144737553533
Gc20_993 0 n40 ns993 0 -0.000994362207446
Gc20_994 0 n40 ns994 0 -2.45903822529e-05
Gc20_995 0 n40 ns995 0 0.000291155234519
Gc20_996 0 n40 ns996 0 -9.09467020514e-05
Gc20_997 0 n40 ns997 0 -1.49414924195e-05
Gc20_998 0 n40 ns998 0 -0.00235246706945
Gc20_999 0 n40 ns999 0 0.00198779719124
Gc20_1000 0 n40 ns1000 0 0.00104955423734
Gc20_1001 0 n40 ns1001 0 -0.000188170015428
Gc20_1002 0 n40 ns1002 0 0.000316027305207
Gc20_1003 0 n40 ns1003 0 -0.000564952046778
Gc20_1004 0 n40 ns1004 0 -2.49126287087e-05
Gc20_1005 0 n40 ns1005 0 0.000952548965768
Gc20_1006 0 n40 ns1006 0 0.000302206428239
Gc20_1007 0 n40 ns1007 0 0.00034446488737
Gc20_1008 0 n40 ns1008 0 0.000585654092781
Gc20_1009 0 n40 ns1009 0 0.000196513550793
Gc20_1010 0 n40 ns1010 0 0.000899311400766
Gc20_1011 0 n40 ns1011 0 0.0015197660757
Gc20_1012 0 n40 ns1012 0 0.00119887553135
Gc20_1013 0 n40 ns1013 0 0.00288796387666
Gc20_1014 0 n40 ns1014 0 0.00134921380309
Gc20_1015 0 n40 ns1015 0 -0.00220366130911
Gc20_1016 0 n40 ns1016 0 0.00183728553512
Gc20_1017 0 n40 ns1017 0 -0.00158117942848
Gc20_1018 0 n40 ns1018 0 0.00186127552838
Gc20_1019 0 n40 ns1019 0 0.00145616768302
Gc20_1020 0 n40 ns1020 0 0.00306136575955
Gc20_1021 0 n40 ns1021 0 3.15844951289e-05
Gc20_1022 0 n40 ns1022 0 -0.0166772687823
Gc20_1023 0 n40 ns1023 0 0.0190092905432
Gc20_1024 0 n40 ns1024 0 0.0069003964763
Gc20_1025 0 n40 ns1025 0 1.5228450827e-07
Gc20_1026 0 n40 ns1026 0 1.75608044022e-05
Gc20_1027 0 n40 ns1027 0 -0.00491628552136
Gc20_1028 0 n40 ns1028 0 -0.00122689504401
Gc20_1029 0 n40 ns1029 0 -0.00369171185006
Gc20_1030 0 n40 ns1030 0 0.000358721991344
Gc20_1031 0 n40 ns1031 0 -0.00123055909296
Gc20_1032 0 n40 ns1032 0 -6.87308945992e-05
Gc20_1033 0 n40 ns1033 0 0.000814923942756
Gc20_1034 0 n40 ns1034 0 -0.000116326263349
Gc20_1035 0 n40 ns1035 0 -7.7861889107e-05
Gc20_1036 0 n40 ns1036 0 -0.000870926958699
Gc20_1037 0 n40 ns1037 0 0.00201641745145
Gc20_1038 0 n40 ns1038 0 0.00101017921456
Gc20_1039 0 n40 ns1039 0 -0.000521273357734
Gc20_1040 0 n40 ns1040 0 0.00020358353904
Gc20_1041 0 n40 ns1041 0 -0.000542982312538
Gc20_1042 0 n40 ns1042 0 0.000332005344259
Gc20_1043 0 n40 ns1043 0 -0.000716667259061
Gc20_1044 0 n40 ns1044 0 0.000116389074716
Gc20_1045 0 n40 ns1045 0 7.56482674259e-05
Gc20_1046 0 n40 ns1046 0 0.000455715339328
Gc20_1047 0 n40 ns1047 0 0.000144766653684
Gc20_1048 0 n40 ns1048 0 -0.00140227545252
Gc20_1049 0 n40 ns1049 0 0.00106049466126
Gc20_1050 0 n40 ns1050 0 0.00158693959739
Gc20_1051 0 n40 ns1051 0 0.00187624233643
Gc20_1052 0 n40 ns1052 0 0.000787721420618
Gc20_1053 0 n40 ns1053 0 -0.00198254861589
Gc20_1054 0 n40 ns1054 0 0.000770700255146
Gc20_1055 0 n40 ns1055 0 0.000948894259355
Gc20_1056 0 n40 ns1056 0 0.000218880060669
Gc20_1057 0 n40 ns1057 0 -1.30216669773e-05
Gc20_1058 0 n40 ns1058 0 0.00246685407803
Gc20_1059 0 n40 ns1059 0 9.01520096474e-05
Gc20_1060 0 n40 ns1060 0 0.0272146914057
Gc20_1061 0 n40 ns1061 0 -0.0261866000144
Gc20_1062 0 n40 ns1062 0 0.00663617044244
Gc20_1063 0 n40 ns1063 0 -3.442805571e-06
Gc20_1064 0 n40 ns1064 0 7.34483081045e-06
Gc20_1065 0 n40 ns1065 0 -0.0017510517711
Gc20_1066 0 n40 ns1066 0 0.000593996377591
Gc20_1067 0 n40 ns1067 0 -0.00168289601821
Gc20_1068 0 n40 ns1068 0 0.000500416438342
Gc20_1069 0 n40 ns1069 0 -0.000504078896685
Gc20_1070 0 n40 ns1070 0 0.000618993684481
Gc20_1071 0 n40 ns1071 0 1.26614195717e-06
Gc20_1072 0 n40 ns1072 0 -0.000127672257089
Gc20_1073 0 n40 ns1073 0 5.13706015991e-06
Gc20_1074 0 n40 ns1074 0 -0.00189204133052
Gc20_1075 0 n40 ns1075 0 0.000308196911592
Gc20_1076 0 n40 ns1076 0 0.000631100854671
Gc20_1077 0 n40 ns1077 0 -0.000538670289464
Gc20_1078 0 n40 ns1078 0 0.000151263429395
Gc20_1079 0 n40 ns1079 0 -0.000465070128039
Gc20_1080 0 n40 ns1080 0 -0.00182276178926
Gc20_1081 0 n40 ns1081 0 9.1341937351e-05
Gc20_1082 0 n40 ns1082 0 0.000173306046941
Gc20_1083 0 n40 ns1083 0 0.000129377307779
Gc20_1084 0 n40 ns1084 0 0.000450392562309
Gc20_1085 0 n40 ns1085 0 5.79155061837e-05
Gc20_1086 0 n40 ns1086 0 -0.000933060118209
Gc20_1087 0 n40 ns1087 0 0.00350936636509
Gc20_1088 0 n40 ns1088 0 0.000977045608541
Gc20_1089 0 n40 ns1089 0 0.000397661748977
Gc20_1090 0 n40 ns1090 0 0.000128967513154
Gc20_1091 0 n40 ns1091 0 -0.00137324511096
Gc20_1092 0 n40 ns1092 0 0.00172660487183
Gc20_1093 0 n40 ns1093 0 0.00210413294319
Gc20_1094 0 n40 ns1094 0 -0.00175526841313
Gc20_1095 0 n40 ns1095 0 0.000315586961278
Gc20_1096 0 n40 ns1096 0 0.00161983477052
Gc20_1097 0 n40 ns1097 0 -0.000256838536083
Gc20_1098 0 n40 ns1098 0 0.0516518741312
Gc20_1099 0 n40 ns1099 0 -0.0501128938395
Gc20_1100 0 n40 ns1100 0 0.00372242998894
Gc20_1101 0 n40 ns1101 0 -7.44948913776e-07
Gc20_1102 0 n40 ns1102 0 -8.63673861818e-06
Gc20_1103 0 n40 ns1103 0 -0.00126676072346
Gc20_1104 0 n40 ns1104 0 0.00246578355431
Gc20_1105 0 n40 ns1105 0 -0.00605642160427
Gc20_1106 0 n40 ns1106 0 -0.000264338805921
Gc20_1107 0 n40 ns1107 0 -0.000307822306439
Gc20_1108 0 n40 ns1108 0 -0.000167570617648
Gc20_1109 0 n40 ns1109 0 -0.000229643724298
Gc20_1110 0 n40 ns1110 0 -1.85189180195e-05
Gc20_1111 0 n40 ns1111 0 2.53155340242e-05
Gc20_1112 0 n40 ns1112 0 6.03535284857e-05
Gc20_1113 0 n40 ns1113 0 0.00228629422979
Gc20_1114 0 n40 ns1114 0 -0.000372275484113
Gc20_1115 0 n40 ns1115 0 -0.000323217957783
Gc20_1116 0 n40 ns1116 0 -6.56917982771e-05
Gc20_1117 0 n40 ns1117 0 -0.000285019724135
Gc20_1118 0 n40 ns1118 0 0.000820842903026
Gc20_1119 0 n40 ns1119 0 0.00181657723469
Gc20_1120 0 n40 ns1120 0 -0.000113323680552
Gc20_1121 0 n40 ns1121 0 -0.000471625330004
Gc20_1122 0 n40 ns1122 0 0.000244392528329
Gc20_1123 0 n40 ns1123 0 -0.000138591656925
Gc20_1124 0 n40 ns1124 0 0.00257721779699
Gc20_1125 0 n40 ns1125 0 0.00153931018428
Gc20_1126 0 n40 ns1126 0 0.000297789539054
Gc20_1127 0 n40 ns1127 0 0.000324282589173
Gc20_1128 0 n40 ns1128 0 -0.000161967508438
Gc20_1129 0 n40 ns1129 0 -0.000955248321079
Gc20_1130 0 n40 ns1130 0 0.00315608345831
Gc20_1131 0 n40 ns1131 0 0.00018403087425
Gc20_1132 0 n40 ns1132 0 -0.000867388920231
Gc20_1133 0 n40 ns1133 0 0.00103779809471
Gc20_1134 0 n40 ns1134 0 0.000855214276183
Gc20_1135 0 n40 ns1135 0 -0.000645685688454
Gc20_1136 0 n40 ns1136 0 0.0418630843289
Gc20_1137 0 n40 ns1137 0 -0.0373942274528
Gc20_1138 0 n40 ns1138 0 0.00179957115316
Gc20_1139 0 n40 ns1139 0 -6.52598361015e-06
Gc20_1140 0 n40 ns1140 0 -2.19140169087e-05
Gc20_1141 0 n40 ns1141 0 -0.000500094006213
Gc20_1142 0 n40 ns1142 0 0.000870818260576
Gc20_1143 0 n40 ns1143 0 -0.00181264599119
Gc20_1144 0 n40 ns1144 0 -0.000312159077224
Gc20_1145 0 n40 ns1145 0 0.000111277353981
Gc20_1146 0 n40 ns1146 0 -0.000137895620975
Gc20_1147 0 n40 ns1147 0 0.000130929210388
Gc20_1148 0 n40 ns1148 0 -9.34928678487e-06
Gc20_1149 0 n40 ns1149 0 1.30432809605e-05
Gc20_1150 0 n40 ns1150 0 0.000794154157322
Gc20_1151 0 n40 ns1151 0 0.000586413993308
Gc20_1152 0 n40 ns1152 0 8.33929616823e-05
Gc20_1153 0 n40 ns1153 0 0.000189500911618
Gc20_1154 0 n40 ns1154 0 -0.000141745382
Gc20_1155 0 n40 ns1155 0 -0.000199908745806
Gc20_1156 0 n40 ns1156 0 0.000738175880799
Gc20_1157 0 n40 ns1157 0 -0.000592468702231
Gc20_1158 0 n40 ns1158 0 -0.000482357576323
Gc20_1159 0 n40 ns1159 0 0.000411496651746
Gc20_1160 0 n40 ns1160 0 0.000172488820288
Gc20_1161 0 n40 ns1161 0 -8.94362265632e-05
Gc20_1162 0 n40 ns1162 0 0.000165316784511
Gc20_1163 0 n40 ns1163 0 -6.64490011683e-05
Gc20_1164 0 n40 ns1164 0 0.000636198281908
Gc20_1165 0 n40 ns1165 0 0.000841620276399
Gc20_1166 0 n40 ns1166 0 -0.000318574393699
Gc20_1167 0 n40 ns1167 0 -0.000847748669312
Gc20_1168 0 n40 ns1168 0 -0.000388297478947
Gc20_1169 0 n40 ns1169 0 -0.000310084031256
Gc20_1170 0 n40 ns1170 0 0.000256284282158
Gc20_1171 0 n40 ns1171 0 0.0012770203176
Gc20_1172 0 n40 ns1172 0 0.00048861901569
Gc20_1173 0 n40 ns1173 0 -0.000654595156227
Gc20_1174 0 n40 ns1174 0 0.0164615992953
Gc20_1175 0 n40 ns1175 0 -0.015137287595
Gc20_1176 0 n40 ns1176 0 0.00076459959535
Gc20_1177 0 n40 ns1177 0 -4.96679361856e-06
Gc20_1178 0 n40 ns1178 0 -2.56588328001e-05
Gc20_1179 0 n40 ns1179 0 0.00037824488416
Gc20_1180 0 n40 ns1180 0 -0.000870699325691
Gc20_1181 0 n40 ns1181 0 0.00248447832493
Gc20_1182 0 n40 ns1182 0 5.9427792264e-05
Gc20_1183 0 n40 ns1183 0 0.000203718242465
Gc20_1184 0 n40 ns1184 0 0.000284250177777
Gc20_1185 0 n40 ns1185 0 2.03690940587e-06
Gc20_1186 0 n40 ns1186 0 2.93457605387e-06
Gc20_1187 0 n40 ns1187 0 -3.50435882881e-05
Gc20_1188 0 n40 ns1188 0 -0.00120412892229
Gc20_1189 0 n40 ns1189 0 -0.000512941085868
Gc20_1190 0 n40 ns1190 0 0.000811792800492
Gc20_1191 0 n40 ns1191 0 -7.86908184288e-05
Gc20_1192 0 n40 ns1192 0 -0.000144621422532
Gc20_1193 0 n40 ns1193 0 -0.000162271660476
Gc20_1194 0 n40 ns1194 0 -0.0012558542566
Gc20_1195 0 n40 ns1195 0 -0.00066129287589
Gc20_1196 0 n40 ns1196 0 0.000241927515628
Gc20_1197 0 n40 ns1197 0 0.00092045636032
Gc20_1198 0 n40 ns1198 0 0.000183998290064
Gc20_1199 0 n40 ns1199 0 -0.000117381309593
Gc20_1200 0 n40 ns1200 0 -0.00080363639126
Gc20_1201 0 n40 ns1201 0 0.00100553179679
Gc20_1202 0 n40 ns1202 0 0.00103922425448
Gc20_1203 0 n40 ns1203 0 0.000384364143798
Gc20_1204 0 n40 ns1204 0 -0.000532765119035
Gc20_1205 0 n40 ns1205 0 -0.000532704406059
Gc20_1206 0 n40 ns1206 0 -0.00106478346953
Gc20_1207 0 n40 ns1207 0 0.000159767056596
Gc20_1208 0 n40 ns1208 0 0.000366167704617
Gc20_1209 0 n40 ns1209 0 0.000764305248727
Gc20_1210 0 n40 ns1210 0 0.000246850137909
Gc20_1211 0 n40 ns1211 0 -0.000393154402468
Gc20_1212 0 n40 ns1212 0 0.00260671269092
Gc20_1213 0 n40 ns1213 0 -0.00299253870818
Gc20_1214 0 n40 ns1214 0 0.000247322281777
Gc20_1215 0 n40 ns1215 0 -3.93968085531e-06
Gc20_1216 0 n40 ns1216 0 -2.51695560602e-05
Gd20_1 0 n40 ni1 0 0.000195716679418
Gd20_2 0 n40 ni2 0 0.000562173956139
Gd20_3 0 n40 ni3 0 -0.000388776980392
Gd20_4 0 n40 ni4 0 -0.00675642726026
Gd20_5 0 n40 ni5 0 -0.000389735920454
Gd20_6 0 n40 ni6 0 0.000609591727239
Gd20_7 0 n40 ni7 0 0.000224783550949
Gd20_8 0 n40 ni8 0 0.000207581985846
Gd20_9 0 n40 ni9 0 -0.000135304529319
Gd20_10 0 n40 ni10 0 -0.000103079825263
Gd20_11 0 n40 ni11 0 -0.00323329572706
Gd20_12 0 n40 ni12 0 -0.00169005083191
Gd20_13 0 n40 ni13 0 2.67559222001e-05
Gd20_14 0 n40 ni14 0 0.00026420951025
Gd20_15 0 n40 ni15 0 0.000194843369462
Gd20_16 0 n40 ni16 0 -7.59773883271e-05
Gd20_17 0 n40 ni17 0 0.000295714657963
Gd20_18 0 n40 ni18 0 -0.000206375443768
Gd20_19 0 n40 ni19 0 -0.00167087424994
Gd20_20 0 n40 ni20 0 0.000612179424702
Gd20_21 0 n40 ni21 0 -0.00185473564443
Gd20_22 0 n40 ni22 0 -0.000467956249582
Gd20_23 0 n40 ni23 0 0.000154272485292
Gd20_24 0 n40 ni24 0 -1.80551392444e-06
Gd20_25 0 n40 ni25 0 -4.26819953687e-05
Gd20_26 0 n40 ni26 0 -0.00104083867667
Gd20_27 0 n40 ni27 0 -0.000869386400625
Gd20_28 0 n40 ni28 0 -0.00275765171046
Gd20_29 0 n40 ni29 0 -0.000875706665609
Gd20_30 0 n40 ni30 0 6.63505609689e-05
Gd20_31 0 n40 ni31 0 6.24151794909e-05
Gd20_32 0 n40 ni32 0 0.00012543178825
Gc21_1 0 n42 ns1 0 -2.71986654811e-05
Gc21_2 0 n42 ns2 0 0.000227550329993
Gc21_3 0 n42 ns3 0 0.0041030581284
Gc21_4 0 n42 ns4 0 -7.13560026817e-05
Gc21_5 0 n42 ns5 0 0.000297431952884
Gc21_6 0 n42 ns6 0 0.000423961411624
Gc21_7 0 n42 ns7 0 -1.26930347757e-05
Gc21_8 0 n42 ns8 0 3.3635534992e-05
Gc21_9 0 n42 ns9 0 -4.25300011629e-05
Gc21_10 0 n42 ns10 0 -0.000485318829593
Gc21_11 0 n42 ns11 0 -0.000102346240551
Gc21_12 0 n42 ns12 0 0.000224357139263
Gc21_13 0 n42 ns13 0 -0.000621016167286
Gc21_14 0 n42 ns14 0 -4.91820273839e-05
Gc21_15 0 n42 ns15 0 0.000205064567746
Gc21_16 0 n42 ns16 0 0.00146395137435
Gc21_17 0 n42 ns17 0 -0.00145471640957
Gc21_18 0 n42 ns18 0 -0.00148609347619
Gc21_19 0 n42 ns19 0 0.000155962224942
Gc21_20 0 n42 ns20 0 0.000114605241394
Gc21_21 0 n42 ns21 0 0.000192702780815
Gc21_22 0 n42 ns22 0 -0.000842565593606
Gc21_23 0 n42 ns23 0 -0.00137838490196
Gc21_24 0 n42 ns24 0 -0.00058403500526
Gc21_25 0 n42 ns25 0 -0.00131394530272
Gc21_26 0 n42 ns26 0 3.66332243437e-06
Gc21_27 0 n42 ns27 0 0.00126762271064
Gc21_28 0 n42 ns28 0 -0.00514453720067
Gc21_29 0 n42 ns29 0 -0.00356667984441
Gc21_30 0 n42 ns30 0 -0.00017128515919
Gc21_31 0 n42 ns31 0 0.00289548523433
Gc21_32 0 n42 ns32 0 0.00115439571854
Gc21_33 0 n42 ns33 0 -0.000535464726064
Gc21_34 0 n42 ns34 0 -0.0257972983512
Gc21_35 0 n42 ns35 0 0.0214797808081
Gc21_36 0 n42 ns36 0 -0.000820797677997
Gc21_37 0 n42 ns37 0 -1.28331676357e-06
Gc21_38 0 n42 ns38 0 3.29738707757e-06
Gc21_39 0 n42 ns39 0 7.61876425604e-05
Gc21_40 0 n42 ns40 0 -0.000480493155907
Gc21_41 0 n42 ns41 0 0.00619605056492
Gc21_42 0 n42 ns42 0 0.000227945319966
Gc21_43 0 n42 ns43 0 0.000166932253645
Gc21_44 0 n42 ns44 0 0.000349134468533
Gc21_45 0 n42 ns45 0 5.51394661698e-06
Gc21_46 0 n42 ns46 0 5.87542643556e-06
Gc21_47 0 n42 ns47 0 -2.32391365179e-05
Gc21_48 0 n42 ns48 0 -0.000715893220449
Gc21_49 0 n42 ns49 0 -0.00100489859008
Gc21_50 0 n42 ns50 0 0.000259129219062
Gc21_51 0 n42 ns51 0 -0.000356480726804
Gc21_52 0 n42 ns52 0 9.94471872545e-06
Gc21_53 0 n42 ns53 0 0.000309679396828
Gc21_54 0 n42 ns54 0 0.00122485497888
Gc21_55 0 n42 ns55 0 -0.00128502572004
Gc21_56 0 n42 ns56 0 -0.00149134161461
Gc21_57 0 n42 ns57 0 8.1733340204e-05
Gc21_58 0 n42 ns58 0 0.000158715578696
Gc21_59 0 n42 ns59 0 0.000175927142189
Gc21_60 0 n42 ns60 0 -0.00136082776966
Gc21_61 0 n42 ns61 0 -0.0020191885848
Gc21_62 0 n42 ns62 0 -0.000673846264045
Gc21_63 0 n42 ns63 0 -0.00129951779143
Gc21_64 0 n42 ns64 0 2.71585539446e-05
Gc21_65 0 n42 ns65 0 0.00145222461211
Gc21_66 0 n42 ns66 0 -0.00642763915306
Gc21_67 0 n42 ns67 0 -0.00452542517404
Gc21_68 0 n42 ns68 0 -0.00046547032035
Gc21_69 0 n42 ns69 0 0.00352786567772
Gc21_70 0 n42 ns70 0 0.00148727393786
Gc21_71 0 n42 ns71 0 -0.000564759707315
Gc21_72 0 n42 ns72 0 -0.0376522423055
Gc21_73 0 n42 ns73 0 0.0316940952556
Gc21_74 0 n42 ns74 0 -0.0012366630469
Gc21_75 0 n42 ns75 0 -5.80469747588e-06
Gc21_76 0 n42 ns76 0 1.99985458526e-06
Gc21_77 0 n42 ns77 0 0.000752765467361
Gc21_78 0 n42 ns78 0 -0.00109216637401
Gc21_79 0 n42 ns79 0 0.0115177829581
Gc21_80 0 n42 ns80 0 0.000244719247835
Gc21_81 0 n42 ns81 0 0.00064442363083
Gc21_82 0 n42 ns82 0 0.000366441334482
Gc21_83 0 n42 ns83 0 -0.000248469172669
Gc21_84 0 n42 ns84 0 -0.000116259486913
Gc21_85 0 n42 ns85 0 -6.32030902606e-06
Gc21_86 0 n42 ns86 0 0.000375229479968
Gc21_87 0 n42 ns87 0 -0.00444069911251
Gc21_88 0 n42 ns88 0 -0.000113494008515
Gc21_89 0 n42 ns89 0 0.00106569082566
Gc21_90 0 n42 ns90 0 0.000147819792732
Gc21_91 0 n42 ns91 0 0.000555218035972
Gc21_92 0 n42 ns92 0 -0.00126692793901
Gc21_93 0 n42 ns93 0 -0.0011948122923
Gc21_94 0 n42 ns94 0 -0.00064190734361
Gc21_95 0 n42 ns95 0 0.000236937862325
Gc21_96 0 n42 ns96 0 0.000353595084692
Gc21_97 0 n42 ns97 0 0.000127387945707
Gc21_98 0 n42 ns98 0 -0.00250559964808
Gc21_99 0 n42 ns99 0 -0.00501335303327
Gc21_100 0 n42 ns100 0 -0.00159014433028
Gc21_101 0 n42 ns101 0 -0.000201597707694
Gc21_102 0 n42 ns102 0 0.000416006433463
Gc21_103 0 n42 ns103 0 0.001616673229
Gc21_104 0 n42 ns104 0 -0.00989223870301
Gc21_105 0 n42 ns105 0 -0.00607769420397
Gc21_106 0 n42 ns106 0 -0.0016418251899
Gc21_107 0 n42 ns107 0 0.00420076129973
Gc21_108 0 n42 ns108 0 0.00242520373195
Gc21_109 0 n42 ns109 0 -0.000295115215015
Gc21_110 0 n42 ns110 0 -0.0773657724361
Gc21_111 0 n42 ns111 0 0.0671980487204
Gc21_112 0 n42 ns112 0 -0.00311375665583
Gc21_113 0 n42 ns113 0 -9.38604155607e-06
Gc21_114 0 n42 ns114 0 -1.35229029794e-07
Gc21_115 0 n42 ns115 0 -0.000366699125114
Gc21_116 0 n42 ns116 0 2.42309832705e-05
Gc21_117 0 n42 ns117 0 0.00568028094306
Gc21_118 0 n42 ns118 0 -0.00132167948262
Gc21_119 0 n42 ns119 0 -0.000360292358282
Gc21_120 0 n42 ns120 0 0.00186528070333
Gc21_121 0 n42 ns121 0 0.000585890781561
Gc21_122 0 n42 ns122 0 -0.000158944145003
Gc21_123 0 n42 ns123 0 -0.000185965527401
Gc21_124 0 n42 ns124 0 0.00211007763907
Gc21_125 0 n42 ns125 0 -0.00275166874169
Gc21_126 0 n42 ns126 0 -0.000677167013401
Gc21_127 0 n42 ns127 0 0.00111158456844
Gc21_128 0 n42 ns128 0 -4.559723803e-05
Gc21_129 0 n42 ns129 0 0.000499981056247
Gc21_130 0 n42 ns130 0 -0.000393436214301
Gc21_131 0 n42 ns131 0 -0.00333655229399
Gc21_132 0 n42 ns132 0 -0.000844998213812
Gc21_133 0 n42 ns133 0 0.000245396451556
Gc21_134 0 n42 ns134 0 0.000298545816571
Gc21_135 0 n42 ns135 0 0.000330282465949
Gc21_136 0 n42 ns136 0 0.00111007855959
Gc21_137 0 n42 ns137 0 -0.00545507155097
Gc21_138 0 n42 ns138 0 -0.00295981833339
Gc21_139 0 n42 ns139 0 -0.00100825238842
Gc21_140 0 n42 ns140 0 0.000188705323903
Gc21_141 0 n42 ns141 0 0.00224686996161
Gc21_142 0 n42 ns142 0 -0.0123036658171
Gc21_143 0 n42 ns143 0 -0.00540029198156
Gc21_144 0 n42 ns144 0 -0.00089946580807
Gc21_145 0 n42 ns145 0 0.00290060238547
Gc21_146 0 n42 ns146 0 0.00303557960193
Gc21_147 0 n42 ns147 0 0.000247881781825
Gc21_148 0 n42 ns148 0 -0.0676447480133
Gc21_149 0 n42 ns149 0 0.0643951994991
Gc21_150 0 n42 ns150 0 -0.00636306110859
Gc21_151 0 n42 ns151 0 -9.86452222812e-06
Gc21_152 0 n42 ns152 0 2.75661143451e-06
Gc21_153 0 n42 ns153 0 -0.0168107360466
Gc21_154 0 n42 ns154 0 -0.00160933057625
Gc21_155 0 n42 ns155 0 0.0209244785231
Gc21_156 0 n42 ns156 0 0.00623084009279
Gc21_157 0 n42 ns157 0 0.0102886658914
Gc21_158 0 n42 ns158 0 0.0015254587405
Gc21_159 0 n42 ns159 0 -0.00330583744171
Gc21_160 0 n42 ns160 0 -0.000508413497141
Gc21_161 0 n42 ns161 0 2.92034370432e-05
Gc21_162 0 n42 ns162 0 -0.00155258889857
Gc21_163 0 n42 ns163 0 -0.0143778287935
Gc21_164 0 n42 ns164 0 0.00127156417284
Gc21_165 0 n42 ns165 0 0.00197633221235
Gc21_166 0 n42 ns166 0 0.000209814540111
Gc21_167 0 n42 ns167 0 0.000320673175154
Gc21_168 0 n42 ns168 0 0.000385103822728
Gc21_169 0 n42 ns169 0 0.000734947565522
Gc21_170 0 n42 ns170 0 6.2360745938e-05
Gc21_171 0 n42 ns171 0 0.000313655048759
Gc21_172 0 n42 ns172 0 0.000468125365203
Gc21_173 0 n42 ns173 0 0.000335506321094
Gc21_174 0 n42 ns174 0 -0.011855579368
Gc21_175 0 n42 ns175 0 -0.00792126451917
Gc21_176 0 n42 ns176 0 -0.00364080337134
Gc21_177 0 n42 ns177 0 -0.00112807725596
Gc21_178 0 n42 ns178 0 0.000165400771823
Gc21_179 0 n42 ns179 0 0.00245519818695
Gc21_180 0 n42 ns180 0 0.00827077874788
Gc21_181 0 n42 ns181 0 -0.00526010053466
Gc21_182 0 n42 ns182 0 0.00194794813419
Gc21_183 0 n42 ns183 0 0.0018273999746
Gc21_184 0 n42 ns184 0 0.00326850489364
Gc21_185 0 n42 ns185 0 -4.22308434961e-05
Gc21_186 0 n42 ns186 0 -0.107296940771
Gc21_187 0 n42 ns187 0 0.0694006983958
Gc21_188 0 n42 ns188 0 -0.00877785865225
Gc21_189 0 n42 ns189 0 -1.07498700421e-05
Gc21_190 0 n42 ns190 0 -8.29342173886e-06
Gc21_191 0 n42 ns191 0 -0.00016199850255
Gc21_192 0 n42 ns192 0 -0.0002439819681
Gc21_193 0 n42 ns193 0 0.00598812949765
Gc21_194 0 n42 ns194 0 -0.00132656811656
Gc21_195 0 n42 ns195 0 -0.00041557986442
Gc21_196 0 n42 ns196 0 0.00186489985058
Gc21_197 0 n42 ns197 0 0.000525537410883
Gc21_198 0 n42 ns198 0 -0.000162565617739
Gc21_199 0 n42 ns199 0 -0.000185901953213
Gc21_200 0 n42 ns200 0 0.00184512945404
Gc21_201 0 n42 ns201 0 -0.00221300710082
Gc21_202 0 n42 ns202 0 -0.000526369032522
Gc21_203 0 n42 ns203 0 0.000872390249095
Gc21_204 0 n42 ns204 0 -0.000128686577666
Gc21_205 0 n42 ns205 0 0.000441525487415
Gc21_206 0 n42 ns206 0 -0.000185959019699
Gc21_207 0 n42 ns207 0 -0.00321876906361
Gc21_208 0 n42 ns208 0 -0.000884431182147
Gc21_209 0 n42 ns209 0 0.000110987171422
Gc21_210 0 n42 ns210 0 0.000263534275508
Gc21_211 0 n42 ns211 0 0.000342477559117
Gc21_212 0 n42 ns212 0 0.000929886321388
Gc21_213 0 n42 ns213 0 -0.00544566689222
Gc21_214 0 n42 ns214 0 -0.00291192041965
Gc21_215 0 n42 ns215 0 -0.000846742672083
Gc21_216 0 n42 ns216 0 0.000217687574601
Gc21_217 0 n42 ns217 0 0.0021478189167
Gc21_218 0 n42 ns218 0 -0.0122571182827
Gc21_219 0 n42 ns219 0 -0.00509736173246
Gc21_220 0 n42 ns220 0 -0.000826049558302
Gc21_221 0 n42 ns221 0 0.00284176444668
Gc21_222 0 n42 ns222 0 0.00301192994899
Gc21_223 0 n42 ns223 0 0.000218071627275
Gc21_224 0 n42 ns224 0 -0.066106400099
Gc21_225 0 n42 ns225 0 0.0630285117195
Gc21_226 0 n42 ns226 0 -0.00631264084393
Gc21_227 0 n42 ns227 0 -8.34709485291e-06
Gc21_228 0 n42 ns228 0 -6.71658492542e-06
Gc21_229 0 n42 ns229 0 0.000785567742607
Gc21_230 0 n42 ns230 0 -0.000799295601888
Gc21_231 0 n42 ns231 0 0.0102711127494
Gc21_232 0 n42 ns232 0 1.5296389376e-05
Gc21_233 0 n42 ns233 0 0.000737818561404
Gc21_234 0 n42 ns234 0 0.000414778907427
Gc21_235 0 n42 ns235 0 -0.000125179357159
Gc21_236 0 n42 ns236 0 -8.57709708561e-05
Gc21_237 0 n42 ns237 0 -1.07795821351e-05
Gc21_238 0 n42 ns238 0 0.000144658883221
Gc21_239 0 n42 ns239 0 -0.00445434292719
Gc21_240 0 n42 ns240 0 0.000119371051386
Gc21_241 0 n42 ns241 0 0.00121037302027
Gc21_242 0 n42 ns242 0 0.000176701288721
Gc21_243 0 n42 ns243 0 0.000454063217696
Gc21_244 0 n42 ns244 0 -0.00114585855122
Gc21_245 0 n42 ns245 0 -0.000632614984058
Gc21_246 0 n42 ns246 0 -0.000403514692858
Gc21_247 0 n42 ns247 0 -6.21149019534e-06
Gc21_248 0 n42 ns248 0 0.000293392069521
Gc21_249 0 n42 ns249 0 6.02101956201e-05
Gc21_250 0 n42 ns250 0 -0.00223519810419
Gc21_251 0 n42 ns251 0 -0.00495444066251
Gc21_252 0 n42 ns252 0 -0.00156883744728
Gc21_253 0 n42 ns253 0 -9.33061991858e-05
Gc21_254 0 n42 ns254 0 0.000442538660857
Gc21_255 0 n42 ns255 0 0.00151927903888
Gc21_256 0 n42 ns256 0 -0.00902438988893
Gc21_257 0 n42 ns257 0 -0.00539723626842
Gc21_258 0 n42 ns258 0 -0.0015726969154
Gc21_259 0 n42 ns259 0 0.00385789997985
Gc21_260 0 n42 ns260 0 0.00230059816327
Gc21_261 0 n42 ns261 0 -0.000313363077274
Gc21_262 0 n42 ns262 0 -0.0701110683659
Gc21_263 0 n42 ns263 0 0.0610893125433
Gc21_264 0 n42 ns264 0 -0.00291082881298
Gc21_265 0 n42 ns265 0 -9.75554233552e-06
Gc21_266 0 n42 ns266 0 -1.28814812517e-05
Gc21_267 0 n42 ns267 0 0.000266089725136
Gc21_268 0 n42 ns268 0 -0.000964949580642
Gc21_269 0 n42 ns269 0 0.00672866104671
Gc21_270 0 n42 ns270 0 0.00014777772629
Gc21_271 0 n42 ns271 0 0.000297273890882
Gc21_272 0 n42 ns272 0 0.000332703564334
Gc21_273 0 n42 ns273 0 6.83507158028e-05
Gc21_274 0 n42 ns274 0 -2.65371723425e-07
Gc21_275 0 n42 ns275 0 2.84134285904e-06
Gc21_276 0 n42 ns276 0 -0.000307186360459
Gc21_277 0 n42 ns277 0 -0.00210198113683
Gc21_278 0 n42 ns278 0 -1.06464377813e-05
Gc21_279 0 n42 ns279 0 0.000265099028707
Gc21_280 0 n42 ns280 0 0.0002158341597
Gc21_281 0 n42 ns281 0 0.000370814832495
Gc21_282 0 n42 ns282 0 0.000622514849799
Gc21_283 0 n42 ns283 0 -0.00113236472884
Gc21_284 0 n42 ns284 0 -0.00107092127442
Gc21_285 0 n42 ns285 0 0.000248173004049
Gc21_286 0 n42 ns286 0 0.000174274804162
Gc21_287 0 n42 ns287 0 4.83118196729e-05
Gc21_288 0 n42 ns288 0 -0.00123508183405
Gc21_289 0 n42 ns289 0 -0.00250984158436
Gc21_290 0 n42 ns290 0 -0.00117362261285
Gc21_291 0 n42 ns291 0 -0.00117344380598
Gc21_292 0 n42 ns292 0 0.000335458456414
Gc21_293 0 n42 ns293 0 0.00152110034448
Gc21_294 0 n42 ns294 0 -0.00695713713664
Gc21_295 0 n42 ns295 0 -0.00438936437151
Gc21_296 0 n42 ns296 0 -0.000237804539363
Gc21_297 0 n42 ns297 0 0.00359463055112
Gc21_298 0 n42 ns298 0 0.00146018444919
Gc21_299 0 n42 ns299 0 -0.000644011566205
Gc21_300 0 n42 ns300 0 -0.0383921320363
Gc21_301 0 n42 ns301 0 0.0322272289463
Gc21_302 0 n42 ns302 0 -0.00123571057918
Gc21_303 0 n42 ns303 0 -4.91577265945e-06
Gc21_304 0 n42 ns304 0 -7.62449956358e-06
Gc21_305 0 n42 ns305 0 0.000138453292608
Gc21_306 0 n42 ns306 0 -0.000580785782717
Gc21_307 0 n42 ns307 0 0.00436665586582
Gc21_308 0 n42 ns308 0 0.00019102180462
Gc21_309 0 n42 ns309 0 0.000176559477664
Gc21_310 0 n42 ns310 0 0.000217633291619
Gc21_311 0 n42 ns311 0 -0.00016910202698
Gc21_312 0 n42 ns312 0 -1.88900601382e-05
Gc21_313 0 n42 ns313 0 -7.09133144902e-05
Gc21_314 0 n42 ns314 0 0.000608460330598
Gc21_315 0 n42 ns315 0 -0.000252839683323
Gc21_316 0 n42 ns316 0 -0.000586670450521
Gc21_317 0 n42 ns317 0 -0.00043266337651
Gc21_318 0 n42 ns318 0 2.9254765129e-05
Gc21_319 0 n42 ns319 0 0.000304035508191
Gc21_320 0 n42 ns320 0 2.53718238165e-05
Gc21_321 0 n42 ns321 0 -0.00210062258218
Gc21_322 0 n42 ns322 0 -0.00091754796073
Gc21_323 0 n42 ns323 0 0.0009890760102
Gc21_324 0 n42 ns324 0 0.000229571634681
Gc21_325 0 n42 ns325 0 9.83326379719e-05
Gc21_326 0 n42 ns326 0 -0.000578887504177
Gc21_327 0 n42 ns327 0 -0.00114529238537
Gc21_328 0 n42 ns328 0 -0.00114341807524
Gc21_329 0 n42 ns329 0 -0.000945000146614
Gc21_330 0 n42 ns330 0 0.000434092307798
Gc21_331 0 n42 ns331 0 0.00106376897255
Gc21_332 0 n42 ns332 0 -0.0049598612952
Gc21_333 0 n42 ns333 0 -0.00218661336474
Gc21_334 0 n42 ns334 0 0.000434664565746
Gc21_335 0 n42 ns335 0 0.00224552776749
Gc21_336 0 n42 ns336 0 0.000774948384239
Gc21_337 0 n42 ns337 0 -0.000550585180859
Gc21_338 0 n42 ns338 0 -0.0190943065135
Gc21_339 0 n42 ns339 0 0.0155012312561
Gc21_340 0 n42 ns340 0 -0.000532299908255
Gc21_341 0 n42 ns341 0 3.6813632826e-06
Gc21_342 0 n42 ns342 0 -5.94013775228e-06
Gc21_343 0 n42 ns343 0 0.000599638464873
Gc21_344 0 n42 ns344 0 -0.00201914237026
Gc21_345 0 n42 ns345 0 0.0107609858771
Gc21_346 0 n42 ns346 0 0.000567758320471
Gc21_347 0 n42 ns347 0 8.29395949014e-05
Gc21_348 0 n42 ns348 0 6.89391351189e-05
Gc21_349 0 n42 ns349 0 -2.81976083031e-05
Gc21_350 0 n42 ns350 0 -4.85692980736e-05
Gc21_351 0 n42 ns351 0 8.36422537887e-06
Gc21_352 0 n42 ns352 0 -0.000278830913311
Gc21_353 0 n42 ns353 0 -0.00310956052964
Gc21_354 0 n42 ns354 0 -1.41198340127e-05
Gc21_355 0 n42 ns355 0 0.000507672007065
Gc21_356 0 n42 ns356 0 0.00012040907283
Gc21_357 0 n42 ns357 0 0.000504289657825
Gc21_358 0 n42 ns358 0 -0.000303117808441
Gc21_359 0 n42 ns359 0 -0.000826207292543
Gc21_360 0 n42 ns360 0 -0.000883182511869
Gc21_361 0 n42 ns361 0 9.16002532397e-05
Gc21_362 0 n42 ns362 0 0.000271942721048
Gc21_363 0 n42 ns363 0 9.48614634035e-05
Gc21_364 0 n42 ns364 0 -0.00236136441877
Gc21_365 0 n42 ns365 0 -0.00360844502628
Gc21_366 0 n42 ns366 0 -0.00097882659054
Gc21_367 0 n42 ns367 0 -0.00059587566924
Gc21_368 0 n42 ns368 0 0.000205083770791
Gc21_369 0 n42 ns369 0 0.00147271039588
Gc21_370 0 n42 ns370 0 -0.0083936235187
Gc21_371 0 n42 ns371 0 -0.00567933119815
Gc21_372 0 n42 ns372 0 -0.00130409729546
Gc21_373 0 n42 ns373 0 0.00414658210455
Gc21_374 0 n42 ns374 0 0.00209106494793
Gc21_375 0 n42 ns375 0 -0.000415720908607
Gc21_376 0 n42 ns376 0 -0.0623065352947
Gc21_377 0 n42 ns377 0 0.0533871791851
Gc21_378 0 n42 ns378 0 -0.00224861748588
Gc21_379 0 n42 ns379 0 -8.73222655804e-06
Gc21_380 0 n42 ns380 0 2.56283474578e-07
Gc21_381 0 n42 ns381 0 0.000215481386172
Gc21_382 0 n42 ns382 0 -0.00110229990234
Gc21_383 0 n42 ns383 0 0.009902096949
Gc21_384 0 n42 ns384 0 -0.000245605867568
Gc21_385 0 n42 ns385 0 0.00017435461017
Gc21_386 0 n42 ns386 0 0.000488306369803
Gc21_387 0 n42 ns387 0 -0.000517912294707
Gc21_388 0 n42 ns388 0 -8.52067228102e-05
Gc21_389 0 n42 ns389 0 3.4286529026e-05
Gc21_390 0 n42 ns390 0 0.00200718205701
Gc21_391 0 n42 ns391 0 -0.00275990632131
Gc21_392 0 n42 ns392 0 -0.00062881829069
Gc21_393 0 n42 ns393 0 0.000844010092208
Gc21_394 0 n42 ns394 0 -4.9051772503e-05
Gc21_395 0 n42 ns395 0 0.000520824074723
Gc21_396 0 n42 ns396 0 -0.00135445696498
Gc21_397 0 n42 ns397 0 -0.00245103572325
Gc21_398 0 n42 ns398 0 -0.000629149636051
Gc21_399 0 n42 ns399 0 0.000442309805698
Gc21_400 0 n42 ns400 0 0.00036627646451
Gc21_401 0 n42 ns401 0 0.000262713518504
Gc21_402 0 n42 ns402 0 -0.000257072242129
Gc21_403 0 n42 ns403 0 -0.00646274690843
Gc21_404 0 n42 ns404 0 -0.00291757291311
Gc21_405 0 n42 ns405 0 -0.000475704165838
Gc21_406 0 n42 ns406 0 0.000500533471575
Gc21_407 0 n42 ns407 0 0.00210504546504
Gc21_408 0 n42 ns408 0 -0.0109308887306
Gc21_409 0 n42 ns409 0 -0.00562927240569
Gc21_410 0 n42 ns410 0 -0.00184843993246
Gc21_411 0 n42 ns411 0 0.00293710139203
Gc21_412 0 n42 ns412 0 0.00271326883184
Gc21_413 0 n42 ns413 0 0.00016548292392
Gc21_414 0 n42 ns414 0 -0.0915210988455
Gc21_415 0 n42 ns415 0 0.0832646292896
Gc21_416 0 n42 ns416 0 -0.0052677592362
Gc21_417 0 n42 ns417 0 -1.00291741614e-05
Gc21_418 0 n42 ns418 0 -5.89438394783e-07
Gc21_419 0 n42 ns419 0 -0.00536647790013
Gc21_420 0 n42 ns420 0 -0.00436927676484
Gc21_421 0 n42 ns421 0 0.00722447908907
Gc21_422 0 n42 ns422 0 0.00220189288865
Gc21_423 0 n42 ns423 0 -0.0018879274359
Gc21_424 0 n42 ns424 0 0.00082147682095
Gc21_425 0 n42 ns425 0 0.00299178718949
Gc21_426 0 n42 ns426 0 2.78447652771e-05
Gc21_427 0 n42 ns427 0 -0.000322963881701
Gc21_428 0 n42 ns428 0 -0.00120432485085
Gc21_429 0 n42 ns429 0 -0.00182001168449
Gc21_430 0 n42 ns430 0 -0.000595900677548
Gc21_431 0 n42 ns431 0 0.00083234044228
Gc21_432 0 n42 ns432 0 -7.80258778602e-05
Gc21_433 0 n42 ns433 0 0.000460232102193
Gc21_434 0 n42 ns434 0 0.00287542553916
Gc21_435 0 n42 ns435 0 -0.00186856693322
Gc21_436 0 n42 ns436 0 -0.000537530345428
Gc21_437 0 n42 ns437 0 -0.000905203199899
Gc21_438 0 n42 ns438 0 0.000116604790653
Gc21_439 0 n42 ns439 0 9.12056818989e-05
Gc21_440 0 n42 ns440 0 0.00268433086639
Gc21_441 0 n42 ns441 0 0.001198051912
Gc21_442 0 n42 ns442 0 -0.00126498591624
Gc21_443 0 n42 ns443 0 -0.00246514987322
Gc21_444 0 n42 ns444 0 -0.00103765136255
Gc21_445 0 n42 ns445 0 0.00198014700496
Gc21_446 0 n42 ns446 0 -0.013803357551
Gc21_447 0 n42 ns447 0 -0.00473160946294
Gc21_448 0 n42 ns448 0 0.00220341851086
Gc21_449 0 n42 ns449 0 0.00349467055198
Gc21_450 0 n42 ns450 0 0.00355913394353
Gc21_451 0 n42 ns451 0 0.000111868954676
Gc21_452 0 n42 ns452 0 0.0184912377237
Gc21_453 0 n42 ns453 0 -0.00924040650135
Gc21_454 0 n42 ns454 0 -0.00760207008566
Gc21_455 0 n42 ns455 0 -1.14235780399e-05
Gc21_456 0 n42 ns456 0 -7.80684333376e-06
Gc21_457 0 n42 ns457 0 -0.00243792406897
Gc21_458 0 n42 ns458 0 -0.0030749961063
Gc21_459 0 n42 ns459 0 0.00713885354427
Gc21_460 0 n42 ns460 0 0.000926298956924
Gc21_461 0 n42 ns461 0 -0.00170494874251
Gc21_462 0 n42 ns462 0 0.000680547178531
Gc21_463 0 n42 ns463 0 0.00198111297147
Gc21_464 0 n42 ns464 0 4.03640584475e-05
Gc21_465 0 n42 ns465 0 -0.000226187232987
Gc21_466 0 n42 ns466 0 0.000576111140305
Gc21_467 0 n42 ns467 0 -0.00100161398932
Gc21_468 0 n42 ns468 0 -0.000826096324792
Gc21_469 0 n42 ns469 0 0.00048401299086
Gc21_470 0 n42 ns470 0 -0.000228721132446
Gc21_471 0 n42 ns471 0 0.00044698599465
Gc21_472 0 n42 ns472 0 0.00160982661829
Gc21_473 0 n42 ns473 0 -0.00257804845403
Gc21_474 0 n42 ns474 0 -0.000629295224013
Gc21_475 0 n42 ns475 0 -0.00037481279816
Gc21_476 0 n42 ns476 0 0.000215878507709
Gc21_477 0 n42 ns477 0 0.00023693620218
Gc21_478 0 n42 ns478 0 0.00203313973574
Gc21_479 0 n42 ns479 0 -0.00230187141465
Gc21_480 0 n42 ns480 0 -0.00254372713657
Gc21_481 0 n42 ns481 0 -0.00162662753233
Gc21_482 0 n42 ns482 0 -0.000290778522106
Gc21_483 0 n42 ns483 0 0.00223409982463
Gc21_484 0 n42 ns484 0 -0.0115396877147
Gc21_485 0 n42 ns485 0 -0.0043143991194
Gc21_486 0 n42 ns486 0 0.000385165531614
Gc21_487 0 n42 ns487 0 0.00226497630178
Gc21_488 0 n42 ns488 0 0.00307202756488
Gc21_489 0 n42 ns489 0 0.000170488983385
Gc21_490 0 n42 ns490 0 -0.032574211661
Gc21_491 0 n42 ns491 0 0.0348848879942
Gc21_492 0 n42 ns492 0 -0.00694735275272
Gc21_493 0 n42 ns493 0 -8.560619809e-06
Gc21_494 0 n42 ns494 0 -8.32552127069e-06
Gc21_495 0 n42 ns495 0 0.000299480801024
Gc21_496 0 n42 ns496 0 -0.00114738068033
Gc21_497 0 n42 ns497 0 0.0101510553247
Gc21_498 0 n42 ns498 0 -0.000154221754547
Gc21_499 0 n42 ns499 0 0.000534559193838
Gc21_500 0 n42 ns500 0 0.000600889341841
Gc21_501 0 n42 ns501 0 -0.000314332378707
Gc21_502 0 n42 ns502 0 -0.000121374471905
Gc21_503 0 n42 ns503 0 -2.673575316e-05
Gc21_504 0 n42 ns504 0 0.001028572908
Gc21_505 0 n42 ns505 0 -0.00385659944176
Gc21_506 0 n42 ns506 0 -0.00017324459534
Gc21_507 0 n42 ns507 0 0.00114887128814
Gc21_508 0 n42 ns508 0 2.24121659196e-05
Gc21_509 0 n42 ns509 0 0.000475402549249
Gc21_510 0 n42 ns510 0 -0.00142109137393
Gc21_511 0 n42 ns511 0 -0.00123167401086
Gc21_512 0 n42 ns512 0 -0.000340191076644
Gc21_513 0 n42 ns513 0 3.2023865512e-05
Gc21_514 0 n42 ns514 0 0.000329429408579
Gc21_515 0 n42 ns515 0 0.000133565430862
Gc21_516 0 n42 ns516 0 -0.00148572718032
Gc21_517 0 n42 ns517 0 -0.00576652731476
Gc21_518 0 n42 ns518 0 -0.00210727374295
Gc21_519 0 n42 ns519 0 -5.28147996508e-05
Gc21_520 0 n42 ns520 0 0.000459221695275
Gc21_521 0 n42 ns521 0 0.00172340908823
Gc21_522 0 n42 ns522 0 -0.00977559421312
Gc21_523 0 n42 ns523 0 -0.00526349410539
Gc21_524 0 n42 ns524 0 -0.00172242676006
Gc21_525 0 n42 ns525 0 0.00342364274751
Gc21_526 0 n42 ns526 0 0.00253910284954
Gc21_527 0 n42 ns527 0 -0.00014199429183
Gc21_528 0 n42 ns528 0 -0.0774126604384
Gc21_529 0 n42 ns529 0 0.0690197941424
Gc21_530 0 n42 ns530 0 -0.00393157267336
Gc21_531 0 n42 ns531 0 -9.18893135584e-06
Gc21_532 0 n42 ns532 0 -1.20317039352e-05
Gc21_533 0 n42 ns533 0 0.000648827296729
Gc21_534 0 n42 ns534 0 -0.00152051385799
Gc21_535 0 n42 ns535 0 0.00805469045883
Gc21_536 0 n42 ns536 0 0.000184592832469
Gc21_537 0 n42 ns537 0 1.05095864537e-05
Gc21_538 0 n42 ns538 0 4.78112113797e-05
Gc21_539 0 n42 ns539 0 0.000149622911439
Gc21_540 0 n42 ns540 0 1.53001206914e-05
Gc21_541 0 n42 ns541 0 4.98127737457e-05
Gc21_542 0 n42 ns542 0 -0.000438495781797
Gc21_543 0 n42 ns543 0 -0.0026008092454
Gc21_544 0 n42 ns544 0 0.000131386632357
Gc21_545 0 n42 ns545 0 0.000566636533156
Gc21_546 0 n42 ns546 0 0.000201209196183
Gc21_547 0 n42 ns547 0 0.000400826639057
Gc21_548 0 n42 ns548 0 0.000277706263763
Gc21_549 0 n42 ns549 0 -0.000356536633416
Gc21_550 0 n42 ns550 0 -0.000811294158085
Gc21_551 0 n42 ns551 0 -8.39801796018e-05
Gc21_552 0 n42 ns552 0 0.000194972427855
Gc21_553 0 n42 ns553 0 9.46223189594e-06
Gc21_554 0 n42 ns554 0 -0.00156889974853
Gc21_555 0 n42 ns555 0 -0.00294878276702
Gc21_556 0 n42 ns556 0 -0.00103198855721
Gc21_557 0 n42 ns557 0 -0.000942032193695
Gc21_558 0 n42 ns558 0 0.000254442626492
Gc21_559 0 n42 ns559 0 0.00152951353702
Gc21_560 0 n42 ns560 0 -0.00718636422684
Gc21_561 0 n42 ns561 0 -0.00446194197546
Gc21_562 0 n42 ns562 0 -0.00063252803799
Gc21_563 0 n42 ns563 0 0.00370694835834
Gc21_564 0 n42 ns564 0 0.00170469798011
Gc21_565 0 n42 ns565 0 -0.000611716811418
Gc21_566 0 n42 ns566 0 -0.0439263718397
Gc21_567 0 n42 ns567 0 0.0372841274918
Gc21_568 0 n42 ns568 0 -0.00155251144458
Gc21_569 0 n42 ns569 0 -7.03994527411e-06
Gc21_570 0 n42 ns570 0 -1.12013610904e-05
Gc21_571 0 n42 ns571 0 0.000234927982692
Gc21_572 0 n42 ns572 0 -0.000944845378912
Gc21_573 0 n42 ns573 0 0.00557106791544
Gc21_574 0 n42 ns574 0 0.000238604400205
Gc21_575 0 n42 ns575 0 0.000133437104418
Gc21_576 0 n42 ns576 0 0.000214107880253
Gc21_577 0 n42 ns577 0 -0.000139996580739
Gc21_578 0 n42 ns578 0 -2.46808585387e-06
Gc21_579 0 n42 ns579 0 -3.88549033312e-05
Gc21_580 0 n42 ns580 0 0.000375509333397
Gc21_581 0 n42 ns581 0 -0.000562501028384
Gc21_582 0 n42 ns582 0 -0.000490922091322
Gc21_583 0 n42 ns583 0 -0.000378042464377
Gc21_584 0 n42 ns584 0 7.29067571063e-05
Gc21_585 0 n42 ns585 0 0.000355743187557
Gc21_586 0 n42 ns586 0 0.000314439811722
Gc21_587 0 n42 ns587 0 -0.0020869714836
Gc21_588 0 n42 ns588 0 -0.00111747043091
Gc21_589 0 n42 ns589 0 0.00089217692234
Gc21_590 0 n42 ns590 0 0.000236920097652
Gc21_591 0 n42 ns591 0 9.74329022061e-05
Gc21_592 0 n42 ns592 0 -0.00081140681377
Gc21_593 0 n42 ns593 0 -0.00160810833261
Gc21_594 0 n42 ns594 0 -0.00129485693521
Gc21_595 0 n42 ns595 0 -0.0011350785074
Gc21_596 0 n42 ns596 0 0.000469014358467
Gc21_597 0 n42 ns597 0 0.00131530241797
Gc21_598 0 n42 ns598 0 -0.00602866002638
Gc21_599 0 n42 ns599 0 -0.00294872289174
Gc21_600 0 n42 ns600 0 0.000366001721071
Gc21_601 0 n42 ns601 0 0.00281263698032
Gc21_602 0 n42 ns602 0 0.00100265482385
Gc21_603 0 n42 ns603 0 -0.000642665722181
Gc21_604 0 n42 ns604 0 -0.0261519368438
Gc21_605 0 n42 ns605 0 0.0214956320582
Gc21_606 0 n42 ns606 0 -0.000759033170894
Gc21_607 0 n42 ns607 0 2.93384675694e-08
Gc21_608 0 n42 ns608 0 -7.11292387282e-06
Gc21_609 0 n42 ns609 0 -0.000862700156515
Gc21_610 0 n42 ns610 0 0.00178371068112
Gc21_611 0 n42 ns611 0 -0.00172757117664
Gc21_612 0 n42 ns612 0 -9.13452878125e-05
Gc21_613 0 n42 ns613 0 -0.000131629384473
Gc21_614 0 n42 ns614 0 -0.000324770772687
Gc21_615 0 n42 ns615 0 3.85479243999e-05
Gc21_616 0 n42 ns616 0 -4.06094205413e-05
Gc21_617 0 n42 ns617 0 1.1522879057e-05
Gc21_618 0 n42 ns618 0 0.000621069327659
Gc21_619 0 n42 ns619 0 0.000654475771914
Gc21_620 0 n42 ns620 0 -9.08332047795e-05
Gc21_621 0 n42 ns621 0 0.000516085542001
Gc21_622 0 n42 ns622 0 4.39755634445e-05
Gc21_623 0 n42 ns623 0 -0.000282167141309
Gc21_624 0 n42 ns624 0 0.00170221762923
Gc21_625 0 n42 ns625 0 -0.000515527389487
Gc21_626 0 n42 ns626 0 -0.00107041710774
Gc21_627 0 n42 ns627 0 -7.23524106076e-06
Gc21_628 0 n42 ns628 0 0.000158279912003
Gc21_629 0 n42 ns629 0 6.32138809095e-05
Gc21_630 0 n42 ns630 0 -7.43659667089e-06
Gc21_631 0 n42 ns631 0 -0.00110930483872
Gc21_632 0 n42 ns632 0 -0.000307463331899
Gc21_633 0 n42 ns633 0 0.0013613037146
Gc21_634 0 n42 ns634 0 0.000360493059553
Gc21_635 0 n42 ns635 0 -0.000920437996618
Gc21_636 0 n42 ns636 0 -0.00109775470193
Gc21_637 0 n42 ns637 0 -0.000988334445008
Gc21_638 0 n42 ns638 0 -9.83115883378e-05
Gc21_639 0 n42 ns639 0 0.00164792428177
Gc21_640 0 n42 ns640 0 0.000754258989191
Gc21_641 0 n42 ns641 0 -0.000585860389657
Gc21_642 0 n42 ns642 0 0.0117669904981
Gc21_643 0 n42 ns643 0 -0.0115224768891
Gc21_644 0 n42 ns644 0 0.000749084422873
Gc21_645 0 n42 ns645 0 -1.01178156488e-05
Gc21_646 0 n42 ns646 0 3.56708687468e-06
Gc21_647 0 n42 ns647 0 -0.000881472459649
Gc21_648 0 n42 ns648 0 0.00216253081561
Gc21_649 0 n42 ns649 0 -0.00241218576072
Gc21_650 0 n42 ns650 0 -0.000175655796015
Gc21_651 0 n42 ns651 0 -0.000148150622119
Gc21_652 0 n42 ns652 0 -0.000267997219549
Gc21_653 0 n42 ns653 0 -9.05672411097e-05
Gc21_654 0 n42 ns654 0 -1.94929303893e-05
Gc21_655 0 n42 ns655 0 1.68683518757e-05
Gc21_656 0 n42 ns656 0 0.000230936535917
Gc21_657 0 n42 ns657 0 0.000969666989314
Gc21_658 0 n42 ns658 0 -9.50468150935e-05
Gc21_659 0 n42 ns659 0 0.000404899266605
Gc21_660 0 n42 ns660 0 3.7998245158e-05
Gc21_661 0 n42 ns661 0 -0.000346345983381
Gc21_662 0 n42 ns662 0 0.00147076317287
Gc21_663 0 n42 ns663 0 5.91666246451e-05
Gc21_664 0 n42 ns664 0 -0.000963071017372
Gc21_665 0 n42 ns665 0 -8.16292076034e-05
Gc21_666 0 n42 ns666 0 0.000227531137675
Gc21_667 0 n42 ns667 0 3.6989483475e-05
Gc21_668 0 n42 ns668 0 0.000516428341375
Gc21_669 0 n42 ns669 0 -0.000406717465031
Gc21_670 0 n42 ns670 0 -0.000255913982562
Gc21_671 0 n42 ns671 0 0.00134391572763
Gc21_672 0 n42 ns672 0 0.000356392393051
Gc21_673 0 n42 ns673 0 -0.00109009594451
Gc21_674 0 n42 ns674 0 -0.000196221964981
Gc21_675 0 n42 ns675 0 -0.00086513175856
Gc21_676 0 n42 ns676 0 -0.000441698852049
Gc21_677 0 n42 ns677 0 0.00172941223929
Gc21_678 0 n42 ns678 0 0.000924428269023
Gc21_679 0 n42 ns679 0 -0.000629341826293
Gc21_680 0 n42 ns680 0 0.0192145555024
Gc21_681 0 n42 ns681 0 -0.0182099494983
Gc21_682 0 n42 ns682 0 0.00108210321054
Gc21_683 0 n42 ns683 0 -8.19885304407e-06
Gc21_684 0 n42 ns684 0 4.4449542834e-06
Gc21_685 0 n42 ns685 0 -0.00111254417641
Gc21_686 0 n42 ns686 0 0.000379880098986
Gc21_687 0 n42 ns687 0 0.000107170899088
Gc21_688 0 n42 ns688 0 0.000584714758943
Gc21_689 0 n42 ns689 0 -0.000522783260134
Gc21_690 0 n42 ns690 0 0.000467889160632
Gc21_691 0 n42 ns691 0 -0.000208958783527
Gc21_692 0 n42 ns692 0 -4.42225675197e-05
Gc21_693 0 n42 ns693 0 -1.09273406517e-06
Gc21_694 0 n42 ns694 0 -0.00257950913238
Gc21_695 0 n42 ns695 0 -4.08455876551e-06
Gc21_696 0 n42 ns696 0 0.000661613166008
Gc21_697 0 n42 ns697 0 -0.000244719114994
Gc21_698 0 n42 ns698 0 0.00011881161554
Gc21_699 0 n42 ns699 0 -0.000505803186019
Gc21_700 0 n42 ns700 0 -0.00195187679576
Gc21_701 0 n42 ns701 0 0.000456013713949
Gc21_702 0 n42 ns702 0 -4.36826044394e-05
Gc21_703 0 n42 ns703 0 0.000394748051131
Gc21_704 0 n42 ns704 0 0.000487240673798
Gc21_705 0 n42 ns705 0 5.31078173098e-05
Gc21_706 0 n42 ns706 0 -0.000530501996625
Gc21_707 0 n42 ns707 0 0.00364146758121
Gc21_708 0 n42 ns708 0 0.000682188397568
Gc21_709 0 n42 ns709 0 0.000787829119507
Gc21_710 0 n42 ns710 0 0.000187182770113
Gc21_711 0 n42 ns711 0 -0.00143449705805
Gc21_712 0 n42 ns712 0 0.00175871761003
Gc21_713 0 n42 ns713 0 0.00171660176489
Gc21_714 0 n42 ns714 0 -0.0015629554711
Gc21_715 0 n42 ns715 0 0.000898006248628
Gc21_716 0 n42 ns716 0 0.00144985918692
Gc21_717 0 n42 ns717 0 -0.000435819755638
Gc21_718 0 n42 ns718 0 0.0419304959441
Gc21_719 0 n42 ns719 0 -0.0401375140923
Gc21_720 0 n42 ns720 0 0.00262883548821
Gc21_721 0 n42 ns721 0 -2.08628862985e-06
Gc21_722 0 n42 ns722 0 4.85184444058e-07
Gc21_723 0 n42 ns723 0 -0.00209203981928
Gc21_724 0 n42 ns724 0 -0.00201595973823
Gc21_725 0 n42 ns725 0 0.00395177505052
Gc21_726 0 n42 ns726 0 0.000349703263008
Gc21_727 0 n42 ns727 0 -0.000397460823888
Gc21_728 0 n42 ns728 0 0.000575424194338
Gc21_729 0 n42 ns729 0 0.000389131246173
Gc21_730 0 n42 ns730 0 -0.000169483089876
Gc21_731 0 n42 ns731 0 -8.11464250108e-05
Gc21_732 0 n42 ns732 0 -0.00134723662502
Gc21_733 0 n42 ns733 0 0.00011209832728
Gc21_734 0 n42 ns734 0 0.00107303125057
Gc21_735 0 n42 ns735 0 -0.00015792860655
Gc21_736 0 n42 ns736 0 0.000301378739792
Gc21_737 0 n42 ns737 0 -0.000507256727618
Gc21_738 0 n42 ns738 0 0.00013423303867
Gc21_739 0 n42 ns739 0 -0.00186771816328
Gc21_740 0 n42 ns740 0 -0.000333101854548
Gc21_741 0 n42 ns741 0 5.41409377187e-05
Gc21_742 0 n42 ns742 0 0.000379596539326
Gc21_743 0 n42 ns743 0 0.000206181946411
Gc21_744 0 n42 ns744 0 -0.00362425485692
Gc21_745 0 n42 ns745 0 -0.000904632308458
Gc21_746 0 n42 ns746 0 0.000865003304196
Gc21_747 0 n42 ns747 0 0.00139382113368
Gc21_748 0 n42 ns748 0 0.000768780072011
Gc21_749 0 n42 ns749 0 -0.00157332453819
Gc21_750 0 n42 ns750 0 -0.00525574952376
Gc21_751 0 n42 ns751 0 -0.00129416655978
Gc21_752 0 n42 ns752 0 -0.00123063897257
Gc21_753 0 n42 ns753 0 0.00081930865972
Gc21_754 0 n42 ns754 0 0.00242876578069
Gc21_755 0 n42 ns755 0 0.000244591406458
Gc21_756 0 n42 ns756 0 0.0219861950229
Gc21_757 0 n42 ns757 0 -0.0293748100709
Gc21_758 0 n42 ns758 0 0.00550428707825
Gc21_759 0 n42 ns759 0 2.03798225401e-06
Gc21_760 0 n42 ns760 0 3.46069438741e-06
Gc21_761 0 n42 ns761 0 -0.00332416350005
Gc21_762 0 n42 ns762 0 0.000492724581862
Gc21_763 0 n42 ns763 0 -0.0044039521031
Gc21_764 0 n42 ns764 0 3.96635103088e-05
Gc21_765 0 n42 ns765 0 -0.000333851978485
Gc21_766 0 n42 ns766 0 0.000288942379608
Gc21_767 0 n42 ns767 0 -0.000161050299405
Gc21_768 0 n42 ns768 0 -0.000207003895296
Gc21_769 0 n42 ns769 0 -5.76677763325e-05
Gc21_770 0 n42 ns770 0 -0.00321328948258
Gc21_771 0 n42 ns771 0 0.00245219249925
Gc21_772 0 n42 ns772 0 0.00117382621813
Gc21_773 0 n42 ns773 0 -0.000356482809843
Gc21_774 0 n42 ns774 0 0.000359051565228
Gc21_775 0 n42 ns775 0 -0.000536629407983
Gc21_776 0 n42 ns776 0 0.000227284798264
Gc21_777 0 n42 ns777 0 0.00169955493527
Gc21_778 0 n42 ns778 0 0.000689525361655
Gc21_779 0 n42 ns779 0 0.00017507766719
Gc21_780 0 n42 ns780 0 0.00056611255522
Gc21_781 0 n42 ns781 0 0.000137708128169
Gc21_782 0 n42 ns782 0 0.00161922359171
Gc21_783 0 n42 ns783 0 0.00109944810689
Gc21_784 0 n42 ns784 0 0.0015232635639
Gc21_785 0 n42 ns785 0 0.00246252168006
Gc21_786 0 n42 ns786 0 0.00108371070774
Gc21_787 0 n42 ns787 0 -0.00207537211479
Gc21_788 0 n42 ns788 0 0.00084202986282
Gc21_789 0 n42 ns789 0 -0.00254055187207
Gc21_790 0 n42 ns790 0 0.00203226124747
Gc21_791 0 n42 ns791 0 0.00152332091382
Gc21_792 0 n42 ns792 0 0.00309229439227
Gc21_793 0 n42 ns793 0 3.45578802705e-05
Gc21_794 0 n42 ns794 0 -0.0147043487665
Gc21_795 0 n42 ns795 0 0.016096916884
Gc21_796 0 n42 ns796 0 0.00713150658623
Gc21_797 0 n42 ns797 0 1.04883225765e-05
Gc21_798 0 n42 ns798 0 8.08493512783e-07
Gc21_799 0 n42 ns799 0 -0.00236188387647
Gc21_800 0 n42 ns800 0 -0.00131645898796
Gc21_801 0 n42 ns801 0 0.00148333901326
Gc21_802 0 n42 ns802 0 0.000152438525122
Gc21_803 0 n42 ns803 0 -0.000435580118369
Gc21_804 0 n42 ns804 0 0.000429003972635
Gc21_805 0 n42 ns805 0 0.000495515707161
Gc21_806 0 n42 ns806 0 -0.000149440021323
Gc21_807 0 n42 ns807 0 -5.13705581648e-05
Gc21_808 0 n42 ns808 0 -0.000456163353164
Gc21_809 0 n42 ns809 0 0.000389597243595
Gc21_810 0 n42 ns810 0 0.000716126121595
Gc21_811 0 n42 ns811 0 -0.000127667361438
Gc21_812 0 n42 ns812 0 0.000301852515911
Gc21_813 0 n42 ns813 0 -0.000427956748821
Gc21_814 0 n42 ns814 0 0.000480767745963
Gc21_815 0 n42 ns815 0 -0.00162158629446
Gc21_816 0 n42 ns816 0 -0.000297160646927
Gc21_817 0 n42 ns817 0 -0.000140500309549
Gc21_818 0 n42 ns818 0 0.000344662170062
Gc21_819 0 n42 ns819 0 0.000187438585707
Gc21_820 0 n42 ns820 0 -0.00295237197653
Gc21_821 0 n42 ns821 0 -0.00080207190081
Gc21_822 0 n42 ns822 0 0.000911180101669
Gc21_823 0 n42 ns823 0 0.00112518532057
Gc21_824 0 n42 ns824 0 0.000659649930767
Gc21_825 0 n42 ns825 0 -0.00147254844339
Gc21_826 0 n42 ns826 0 -0.00413952408384
Gc21_827 0 n42 ns827 0 -0.000915454264272
Gc21_828 0 n42 ns828 0 -0.00122592418028
Gc21_829 0 n42 ns829 0 0.000482001663753
Gc21_830 0 n42 ns830 0 0.00230164023898
Gc21_831 0 n42 ns831 0 0.00023750580913
Gc21_832 0 n42 ns832 0 0.0297395758103
Gc21_833 0 n42 ns833 0 -0.0356989170094
Gc21_834 0 n42 ns834 0 0.00567858664184
Gc21_835 0 n42 ns835 0 1.12680017481e-06
Gc21_836 0 n42 ns836 0 -2.93699994045e-06
Gc21_837 0 n42 ns837 0 -0.00134388320643
Gc21_838 0 n42 ns838 0 0.000769806198022
Gc21_839 0 n42 ns839 0 -0.00186082321878
Gc21_840 0 n42 ns840 0 0.000411824855085
Gc21_841 0 n42 ns841 0 -0.00047789677228
Gc21_842 0 n42 ns842 0 0.000438951997806
Gc21_843 0 n42 ns843 0 -0.000212800089729
Gc21_844 0 n42 ns844 0 -5.99344711768e-05
Gc21_845 0 n42 ns845 0 -1.25843719697e-06
Gc21_846 0 n42 ns846 0 -0.0019970246596
Gc21_847 0 n42 ns847 0 0.000669725358096
Gc21_848 0 n42 ns848 0 0.000376005643532
Gc21_849 0 n42 ns849 0 -0.000486378716718
Gc21_850 0 n42 ns850 0 5.84641503203e-05
Gc21_851 0 n42 ns851 0 -0.000423840641404
Gc21_852 0 n42 ns852 0 -0.00163840833312
Gc21_853 0 n42 ns853 0 0.00102190864715
Gc21_854 0 n42 ns854 0 0.00017256638037
Gc21_855 0 n42 ns855 0 0.000102855568177
Gc21_856 0 n42 ns856 0 0.00042276099869
Gc21_857 0 n42 ns857 0 -1.35869826537e-05
Gc21_858 0 n42 ns858 0 0.000373022214119
Gc21_859 0 n42 ns859 0 0.0037200984132
Gc21_860 0 n42 ns860 0 0.000736536055399
Gc21_861 0 n42 ns861 0 0.000391879493691
Gc21_862 0 n42 ns862 0 2.28245434142e-05
Gc21_863 0 n42 ns863 0 -0.00126784710335
Gc21_864 0 n42 ns864 0 0.00276859908366
Gc21_865 0 n42 ns865 0 0.00176182209731
Gc21_866 0 n42 ns866 0 -0.0016109390969
Gc21_867 0 n42 ns867 0 0.000689976666026
Gc21_868 0 n42 ns868 0 0.00136222433134
Gc21_869 0 n42 ns869 0 -0.000432001321729
Gc21_870 0 n42 ns870 0 0.0482024750409
Gc21_871 0 n42 ns871 0 -0.0452071936692
Gc21_872 0 n42 ns872 0 0.00276015140504
Gc21_873 0 n42 ns873 0 -1.97321904086e-06
Gc21_874 0 n42 ns874 0 -9.35831542778e-06
Gc21_875 0 n42 ns875 0 -0.000605781948927
Gc21_876 0 n42 ns876 0 0.0014499887161
Gc21_877 0 n42 ns877 0 -0.0021559773812
Gc21_878 0 n42 ns878 0 -0.000159223873204
Gc21_879 0 n42 ns879 0 -0.000179616306983
Gc21_880 0 n42 ns880 0 -0.000162364372565
Gc21_881 0 n42 ns881 0 -0.0001242087129
Gc21_882 0 n42 ns882 0 -8.88074982467e-06
Gc21_883 0 n42 ns883 0 -1.73348980768e-05
Gc21_884 0 n42 ns884 0 -0.000509775596837
Gc21_885 0 n42 ns885 0 0.00139042896197
Gc21_886 0 n42 ns886 0 0.000225030036344
Gc21_887 0 n42 ns887 0 2.81078640322e-05
Gc21_888 0 n42 ns888 0 -8.41261944953e-05
Gc21_889 0 n42 ns889 0 -0.000376685324657
Gc21_890 0 n42 ns890 0 0.00074092998331
Gc21_891 0 n42 ns891 0 0.000529245890867
Gc21_892 0 n42 ns892 0 -0.000456558597627
Gc21_893 0 n42 ns893 0 0.000120172839917
Gc21_894 0 n42 ns894 0 0.00027131190521
Gc21_895 0 n42 ns895 0 -8.5715297708e-05
Gc21_896 0 n42 ns896 0 0.000950430123442
Gc21_897 0 n42 ns897 0 0.000552001689061
Gc21_898 0 n42 ns898 0 0.000300938016438
Gc21_899 0 n42 ns899 0 0.00103250662363
Gc21_900 0 n42 ns900 0 -3.31547876396e-05
Gc21_901 0 n42 ns901 0 -0.00110927783056
Gc21_902 0 n42 ns902 0 0.000632444642345
Gc21_903 0 n42 ns903 0 -0.000427088276455
Gc21_904 0 n42 ns904 0 -0.000387039584258
Gc21_905 0 n42 ns905 0 0.00152269043873
Gc21_906 0 n42 ns906 0 0.000822766737788
Gc21_907 0 n42 ns907 0 -0.000666904619063
Gc21_908 0 n42 ns908 0 0.0237573754341
Gc21_909 0 n42 ns909 0 -0.0218927071349
Gc21_910 0 n42 ns910 0 0.00115911052308
Gc21_911 0 n42 ns911 0 -6.26506000642e-06
Gc21_912 0 n42 ns912 0 -7.18275861894e-06
Gc21_913 0 n42 ns913 0 -0.000134305093562
Gc21_914 0 n42 ns914 0 -0.000296656437877
Gc21_915 0 n42 ns915 0 0.00257886484273
Gc21_916 0 n42 ns916 0 7.86186953262e-05
Gc21_917 0 n42 ns917 0 1.44041742679e-05
Gc21_918 0 n42 ns918 0 -8.60073818728e-05
Gc21_919 0 n42 ns919 0 0.000181911652028
Gc21_920 0 n42 ns920 0 1.88195849218e-05
Gc21_921 0 n42 ns921 0 3.34060903813e-05
Gc21_922 0 n42 ns922 0 -9.84436154425e-05
Gc21_923 0 n42 ns923 0 -0.00103093872598
Gc21_924 0 n42 ns924 0 0.000531140977864
Gc21_925 0 n42 ns925 0 0.000664565129945
Gc21_926 0 n42 ns926 0 -1.51548867918e-06
Gc21_927 0 n42 ns927 0 -0.000256170317935
Gc21_928 0 n42 ns928 0 -9.80214515598e-05
Gc21_929 0 n42 ns929 0 -0.00184243597542
Gc21_930 0 n42 ns930 0 -0.000779645965356
Gc21_931 0 n42 ns931 0 0.000986236889774
Gc21_932 0 n42 ns932 0 0.000240958697718
Gc21_933 0 n42 ns933 0 5.82609970164e-05
Gc21_934 0 n42 ns934 0 -0.00180379473751
Gc21_935 0 n42 ns935 0 -0.000219590206228
Gc21_936 0 n42 ns936 0 0.000532097497285
Gc21_937 0 n42 ns937 0 0.00137050049866
Gc21_938 0 n42 ns938 0 -2.89272307679e-05
Gc21_939 0 n42 ns939 0 -0.000945177591695
Gc21_940 0 n42 ns940 0 -0.00245874721096
Gc21_941 0 n42 ns941 0 -0.000141688465414
Gc21_942 0 n42 ns942 0 0.000471036532928
Gc21_943 0 n42 ns943 0 0.00136396214969
Gc21_944 0 n42 ns944 0 0.000503008971227
Gc21_945 0 n42 ns945 0 -0.000558732645004
Gc21_946 0 n42 ns946 0 0.00107869941512
Gc21_947 0 n42 ns947 0 -0.00230932895828
Gc21_948 0 n42 ns948 0 0.000348105862081
Gc21_949 0 n42 ns949 0 -7.48245123956e-06
Gc21_950 0 n42 ns950 0 -7.17850115304e-06
Gc21_951 0 n42 ns951 0 -0.000873013212154
Gc21_952 0 n42 ns952 0 0.00173683605315
Gc21_953 0 n42 ns953 0 -0.00181018155424
Gc21_954 0 n42 ns954 0 0.000170562327115
Gc21_955 0 n42 ns955 0 -0.000287548048927
Gc21_956 0 n42 ns956 0 0.000163655526038
Gc21_957 0 n42 ns957 0 -0.000328337422464
Gc21_958 0 n42 ns958 0 -3.00878456476e-06
Gc21_959 0 n42 ns959 0 1.58302773799e-05
Gc21_960 0 n42 ns960 0 -0.00171067378772
Gc21_961 0 n42 ns961 0 0.000466741005607
Gc21_962 0 n42 ns962 0 0.000301512801315
Gc21_963 0 n42 ns963 0 4.50401516723e-05
Gc21_964 0 n42 ns964 0 7.11406438614e-05
Gc21_965 0 n42 ns965 0 -0.000432109896524
Gc21_966 0 n42 ns966 0 -0.000769633478672
Gc21_967 0 n42 ns967 0 0.000859292426065
Gc21_968 0 n42 ns968 0 -0.000270804782755
Gc21_969 0 n42 ns969 0 0.000206499244319
Gc21_970 0 n42 ns970 0 0.000404371809752
Gc21_971 0 n42 ns971 0 1.611011737e-05
Gc21_972 0 n42 ns972 0 0.000613088357508
Gc21_973 0 n42 ns973 0 0.00254359223267
Gc21_974 0 n42 ns974 0 0.00031890106285
Gc21_975 0 n42 ns975 0 0.000891810571519
Gc21_976 0 n42 ns976 0 0.000189338870311
Gc21_977 0 n42 ns977 0 -0.00129261710952
Gc21_978 0 n42 ns978 0 0.00198615831712
Gc21_979 0 n42 ns979 0 0.000624571457692
Gc21_980 0 n42 ns980 0 -0.00128953107884
Gc21_981 0 n42 ns981 0 0.0012369477317
Gc21_982 0 n42 ns982 0 0.00120486102429
Gc21_983 0 n42 ns983 0 -0.000527217311196
Gc21_984 0 n42 ns984 0 0.0351134820294
Gc21_985 0 n42 ns985 0 -0.0327863763358
Gc21_986 0 n42 ns986 0 0.00189301622896
Gc21_987 0 n42 ns987 0 -4.56470888887e-06
Gc21_988 0 n42 ns988 0 1.69623778851e-06
Gc21_989 0 n42 ns989 0 -0.00189918417661
Gc21_990 0 n42 ns990 0 -0.000545749102601
Gc21_991 0 n42 ns991 0 0.00224211801713
Gc21_992 0 n42 ns992 0 0.000632461640928
Gc21_993 0 n42 ns993 0 -0.000294794354325
Gc21_994 0 n42 ns994 0 0.000721431501281
Gc21_995 0 n42 ns995 0 0.000382952475967
Gc21_996 0 n42 ns996 0 -0.000150697908852
Gc21_997 0 n42 ns997 0 -6.63811150483e-05
Gc21_998 0 n42 ns998 0 -0.00136799941416
Gc21_999 0 n42 ns999 0 -0.000611680348303
Gc21_1000 0 n42 ns1000 0 0.000991976801567
Gc21_1001 0 n42 ns1001 0 -0.000258244438017
Gc21_1002 0 n42 ns1002 0 0.000196412003467
Gc21_1003 0 n42 ns1003 0 -0.00053211349904
Gc21_1004 0 n42 ns1004 0 -0.00115603783878
Gc21_1005 0 n42 ns1005 0 -0.00194987876348
Gc21_1006 0 n42 ns1006 0 -0.000423308486501
Gc21_1007 0 n42 ns1007 0 0.000309622803007
Gc21_1008 0 n42 ns1008 0 0.000395348911816
Gc21_1009 0 n42 ns1009 0 0.000181798746797
Gc21_1010 0 n42 ns1010 0 -0.00377363052871
Gc21_1011 0 n42 ns1011 0 0.00146982173212
Gc21_1012 0 n42 ns1012 0 0.000833630015069
Gc21_1013 0 n42 ns1013 0 0.00112902089194
Gc21_1014 0 n42 ns1014 0 0.000550450030537
Gc21_1015 0 n42 ns1015 0 -0.00151085918979
Gc21_1016 0 n42 ns1016 0 -0.00216473376685
Gc21_1017 0 n42 ns1017 0 0.00162021457758
Gc21_1018 0 n42 ns1018 0 -0.00169404421082
Gc21_1019 0 n42 ns1019 0 0.000434321089444
Gc21_1020 0 n42 ns1020 0 0.00200248364369
Gc21_1021 0 n42 ns1021 0 2.27967492917e-05
Gc21_1022 0 n42 ns1022 0 0.0415544471216
Gc21_1023 0 n42 ns1023 0 -0.0445347591675
Gc21_1024 0 n42 ns1024 0 0.0044974042123
Gc21_1025 0 n42 ns1025 0 3.08407689229e-06
Gc21_1026 0 n42 ns1026 0 4.1926573984e-06
Gc21_1027 0 n42 ns1027 0 -0.00518081848625
Gc21_1028 0 n42 ns1028 0 -0.000117896399264
Gc21_1029 0 n42 ns1029 0 -0.00664647960761
Gc21_1030 0 n42 ns1030 0 -2.50303330802e-05
Gc21_1031 0 n42 ns1031 0 -0.000999476852148
Gc21_1032 0 n42 ns1032 0 -9.06877777318e-05
Gc21_1033 0 n42 ns1033 0 0.000278882706285
Gc21_1034 0 n42 ns1034 0 -0.000105219346173
Gc21_1035 0 n42 ns1035 0 -1.55583736815e-05
Gc21_1036 0 n42 ns1036 0 -0.0016589247275
Gc21_1037 0 n42 ns1037 0 0.00302465126809
Gc21_1038 0 n42 ns1038 0 0.000687493395695
Gc21_1039 0 n42 ns1039 0 -0.000600278643337
Gc21_1040 0 n42 ns1040 0 0.000211182579114
Gc21_1041 0 n42 ns1041 0 -0.000451459641154
Gc21_1042 0 n42 ns1042 0 0.000285631819818
Gc21_1043 0 n42 ns1043 0 0.0018399700859
Gc21_1044 0 n42 ns1044 0 0.000697370138953
Gc21_1045 0 n42 ns1045 0 -3.64538823883e-05
Gc21_1046 0 n42 ns1046 0 0.000504633415842
Gc21_1047 0 n42 ns1047 0 8.15576438215e-05
Gc21_1048 0 n42 ns1048 0 0.00229753725245
Gc21_1049 0 n42 ns1049 0 0.00180728232029
Gc21_1050 0 n42 ns1050 0 0.00137340700685
Gc21_1051 0 n42 ns1051 0 0.00224385916625
Gc21_1052 0 n42 ns1052 0 0.00104002770655
Gc21_1053 0 n42 ns1053 0 -0.00196138228677
Gc21_1054 0 n42 ns1054 0 0.00345730969687
Gc21_1055 0 n42 ns1055 0 -0.00144820637113
Gc21_1056 0 n42 ns1056 0 0.0017994802665
Gc21_1057 0 n42 ns1057 0 0.00111129287465
Gc21_1058 0 n42 ns1058 0 0.00291624947434
Gc21_1059 0 n42 ns1059 0 2.80281820969e-05
Gc21_1060 0 n42 ns1060 0 -0.00670363594246
Gc21_1061 0 n42 ns1061 0 0.0109444577385
Gc21_1062 0 n42 ns1062 0 0.00710969598981
Gc21_1063 0 n42 ns1063 0 -1.25528574068e-06
Gc21_1064 0 n42 ns1064 0 -3.98652822709e-06
Gc21_1065 0 n42 ns1065 0 -0.00528685109366
Gc21_1066 0 n42 ns1066 0 -0.00036346670726
Gc21_1067 0 n42 ns1067 0 -0.00702660050664
Gc21_1068 0 n42 ns1068 0 0.000138233780023
Gc21_1069 0 n42 ns1069 0 -0.00132777813515
Gc21_1070 0 n42 ns1070 0 -0.000301451121122
Gc21_1071 0 n42 ns1071 0 0.000893685579034
Gc21_1072 0 n42 ns1072 0 -9.95666496471e-05
Gc21_1073 0 n42 ns1073 0 -2.66703306401e-05
Gc21_1074 0 n42 ns1074 0 0.000311733473247
Gc21_1075 0 n42 ns1075 0 0.00262647562709
Gc21_1076 0 n42 ns1076 0 0.000489073082841
Gc21_1077 0 n42 ns1077 0 -0.000578308382991
Gc21_1078 0 n42 ns1078 0 0.000184212016711
Gc21_1079 0 n42 ns1079 0 -0.000426159711463
Gc21_1080 0 n42 ns1080 0 0.000827580507608
Gc21_1081 0 n42 ns1081 0 -0.000262801412982
Gc21_1082 0 n42 ns1082 0 0.000213011094544
Gc21_1083 0 n42 ns1083 0 -0.000235767351524
Gc21_1084 0 n42 ns1084 0 0.000396662426091
Gc21_1085 0 n42 ns1085 0 0.000107333981621
Gc21_1086 0 n42 ns1086 0 -0.000389621164559
Gc21_1087 0 n42 ns1087 0 0.0012077764083
Gc21_1088 0 n42 ns1088 0 0.00164801872811
Gc21_1089 0 n42 ns1089 0 0.001462119727
Gc21_1090 0 n42 ns1090 0 0.000623466629059
Gc21_1091 0 n42 ns1091 0 -0.00181913552859
Gc21_1092 0 n42 ns1092 0 0.00232652577323
Gc21_1093 0 n42 ns1093 0 0.0014550611623
Gc21_1094 0 n42 ns1094 0 0.000230191838872
Gc21_1095 0 n42 ns1095 0 -0.000474514880659
Gc21_1096 0 n42 ns1096 0 0.00228918688714
Gc21_1097 0 n42 ns1097 0 7.86008949464e-05
Gc21_1098 0 n42 ns1098 0 0.038061274101
Gc21_1099 0 n42 ns1099 0 -0.0350331919771
Gc21_1100 0 n42 ns1100 0 0.0068760423886
Gc21_1101 0 n42 ns1101 0 -4.21018859682e-06
Gc21_1102 0 n42 ns1102 0 -6.70948526244e-06
Gc21_1103 0 n42 ns1103 0 -0.00175288565796
Gc21_1104 0 n42 ns1104 0 0.000598712310528
Gc21_1105 0 n42 ns1105 0 -0.00167649709845
Gc21_1106 0 n42 ns1106 0 0.000500674186456
Gc21_1107 0 n42 ns1107 0 -0.000502061203428
Gc21_1108 0 n42 ns1108 0 0.000621277237993
Gc21_1109 0 n42 ns1109 0 -1.1468497458e-07
Gc21_1110 0 n42 ns1110 0 -0.000128203706792
Gc21_1111 0 n42 ns1111 0 4.88376953349e-06
Gc21_1112 0 n42 ns1112 0 -0.00189485331245
Gc21_1113 0 n42 ns1113 0 0.000308515950588
Gc21_1114 0 n42 ns1114 0 0.000631745729531
Gc21_1115 0 n42 ns1115 0 -0.000539075856776
Gc21_1116 0 n42 ns1116 0 0.000151194584153
Gc21_1117 0 n42 ns1117 0 -0.000466118922196
Gc21_1118 0 n42 ns1118 0 -0.00182081071219
Gc21_1119 0 n42 ns1119 0 9.1150076353e-05
Gc21_1120 0 n42 ns1120 0 0.00017097239016
Gc21_1121 0 n42 ns1121 0 0.000128915920332
Gc21_1122 0 n42 ns1122 0 0.00045090459015
Gc21_1123 0 n42 ns1123 0 5.78942503068e-05
Gc21_1124 0 n42 ns1124 0 -0.000933393980104
Gc21_1125 0 n42 ns1125 0 0.00350540122749
Gc21_1126 0 n42 ns1126 0 0.000974953941536
Gc21_1127 0 n42 ns1127 0 0.000400298716772
Gc21_1128 0 n42 ns1128 0 0.000129888547719
Gc21_1129 0 n42 ns1129 0 -0.00137500662866
Gc21_1130 0 n42 ns1130 0 0.0017169260696
Gc21_1131 0 n42 ns1131 0 0.00209601429877
Gc21_1132 0 n42 ns1132 0 -0.00175514827623
Gc21_1133 0 n42 ns1133 0 0.000322304886874
Gc21_1134 0 n42 ns1134 0 0.00162169443397
Gc21_1135 0 n42 ns1135 0 -0.000258638263194
Gc21_1136 0 n42 ns1136 0 0.0516017982379
Gc21_1137 0 n42 ns1137 0 -0.0500715723571
Gc21_1138 0 n42 ns1138 0 0.00372094711156
Gc21_1139 0 n42 ns1139 0 -8.16224914455e-07
Gc21_1140 0 n42 ns1140 0 -8.4225259042e-06
Gc21_1141 0 n42 ns1141 0 -0.000919559008679
Gc21_1142 0 n42 ns1142 0 0.00159443010316
Gc21_1143 0 n42 ns1143 0 -0.00264393115851
Gc21_1144 0 n42 ns1144 0 -1.82848800826e-05
Gc21_1145 0 n42 ns1145 0 -0.000226569536025
Gc21_1146 0 n42 ns1146 0 5.83390596661e-05
Gc21_1147 0 n42 ns1147 0 -0.00032236807182
Gc21_1148 0 n42 ns1148 0 -3.72172062726e-05
Gc21_1149 0 n42 ns1149 0 -2.47072413688e-05
Gc21_1150 0 n42 ns1150 0 -0.00116270095157
Gc21_1151 0 n42 ns1151 0 0.00170860717331
Gc21_1152 0 n42 ns1152 0 0.000157614631621
Gc21_1153 0 n42 ns1153 0 -0.000280694826382
Gc21_1154 0 n42 ns1154 0 -4.9898259312e-05
Gc21_1155 0 n42 ns1155 0 -0.000407110159742
Gc21_1156 0 n42 ns1156 0 0.000321349055774
Gc21_1157 0 n42 ns1157 0 0.00136878988505
Gc21_1158 0 n42 ns1158 0 -0.000209990784301
Gc21_1159 0 n42 ns1159 0 -0.000158952146308
Gc21_1160 0 n42 ns1160 0 0.000305001967979
Gc21_1161 0 n42 ns1161 0 -0.000102221142074
Gc21_1162 0 n42 ns1162 0 0.00155688834958
Gc21_1163 0 n42 ns1163 0 0.00138278665233
Gc21_1164 0 n42 ns1164 0 0.000229681359096
Gc21_1165 0 n42 ns1165 0 0.000744804387876
Gc21_1166 0 n42 ns1166 0 6.55140820295e-06
Gc21_1167 0 n42 ns1167 0 -0.00112146304074
Gc21_1168 0 n42 ns1168 0 0.00155288655332
Gc21_1169 0 n42 ns1169 0 -0.000333817425354
Gc21_1170 0 n42 ns1170 0 -0.00087174432069
Gc21_1171 0 n42 ns1171 0 0.00151511676745
Gc21_1172 0 n42 ns1172 0 0.0010379412192
Gc21_1173 0 n42 ns1173 0 -0.000640011469769
Gc21_1174 0 n42 ns1174 0 0.0307948948637
Gc21_1175 0 n42 ns1175 0 -0.02836838295
Gc21_1176 0 n42 ns1176 0 0.00155415383861
Gc21_1177 0 n42 ns1177 0 -5.64791668649e-06
Gc21_1178 0 n42 ns1178 0 -8.26581865567e-06
Gc21_1179 0 n42 ns1179 0 -0.000373002372086
Gc21_1180 0 n42 ns1180 0 0.000611534923216
Gc21_1181 0 n42 ns1181 0 0.00103361270714
Gc21_1182 0 n42 ns1182 0 -4.85897237849e-05
Gc21_1183 0 n42 ns1183 0 0.000139837542101
Gc21_1184 0 n42 ns1184 0 -3.41446786946e-05
Gc21_1185 0 n42 ns1185 0 0.000141768162543
Gc21_1186 0 n42 ns1186 0 -3.00539026154e-06
Gc21_1187 0 n42 ns1187 0 2.22815462435e-06
Gc21_1188 0 n42 ns1188 0 1.53721604718e-05
Gc21_1189 0 n42 ns1189 0 -0.000605675033525
Gc21_1190 0 n42 ns1190 0 0.000485758099249
Gc21_1191 0 n42 ns1191 0 0.000630400058109
Gc21_1192 0 n42 ns1192 0 -2.54832416625e-05
Gc21_1193 0 n42 ns1193 0 -0.000318940397494
Gc21_1194 0 n42 ns1194 0 0.000425923249056
Gc21_1195 0 n42 ns1195 0 -0.00155467623356
Gc21_1196 0 n42 ns1196 0 -0.000908181566309
Gc21_1197 0 n42 ns1197 0 0.000801989033283
Gc21_1198 0 n42 ns1198 0 0.000253925770576
Gc21_1199 0 n42 ns1199 0 3.37100208212e-05
Gc21_1200 0 n42 ns1200 0 -0.00127934024793
Gc21_1201 0 n42 ns1201 0 -0.000451410260767
Gc21_1202 0 n42 ns1202 0 0.000425625490851
Gc21_1203 0 n42 ns1203 0 0.00148737830525
Gc21_1204 0 n42 ns1204 0 7.68047636708e-06
Gc21_1205 0 n42 ns1205 0 -0.00107860374569
Gc21_1206 0 n42 ns1206 0 -0.00216416011029
Gc21_1207 0 n42 ns1207 0 -0.000591072465156
Gc21_1208 0 n42 ns1208 0 0.000306845421108
Gc21_1209 0 n42 ns1209 0 0.00167394683272
Gc21_1210 0 n42 ns1210 0 0.000654430851594
Gc21_1211 0 n42 ns1211 0 -0.000646509703456
Gc21_1212 0 n42 ns1212 0 0.0054354518885
Gc21_1213 0 n42 ns1213 0 -0.00620829393756
Gc21_1214 0 n42 ns1214 0 0.000541497424515
Gc21_1215 0 n42 ns1215 0 -6.50448530635e-06
Gc21_1216 0 n42 ns1216 0 -6.32684240627e-06
Gd21_1 0 n42 ni1 0 0.000266950480989
Gd21_2 0 n42 ni2 0 0.000145173269023
Gd21_3 0 n42 ni3 0 0.000494454782948
Gd21_4 0 n42 ni4 0 -0.000393645642388
Gd21_5 0 n42 ni5 0 -0.00677271476258
Gd21_6 0 n42 ni6 0 -0.000345018451737
Gd21_7 0 n42 ni7 0 0.000577689574605
Gd21_8 0 n42 ni8 0 0.000106738834273
Gd21_9 0 n42 ni9 0 7.98459634994e-05
Gd21_10 0 n42 ni10 0 0.0001212592523
Gd21_11 0 n42 ni11 0 -0.000180564357238
Gd21_12 0 n42 ni12 0 -0.00301335186747
Gd21_13 0 n42 ni13 0 -0.00165282777623
Gd21_14 0 n42 ni14 0 3.55829183336e-05
Gd21_15 0 n42 ni15 0 0.000186391599943
Gd21_16 0 n42 ni16 0 4.84948921929e-05
Gd21_17 0 n42 ni17 0 0.000206775731238
Gd21_18 0 n42 ni18 0 0.000339036505611
Gd21_19 0 n42 ni19 0 -0.000325277086422
Gd21_20 0 n42 ni20 0 -0.00185473538359
Gd21_21 0 n42 ni21 0 0.000562693371227
Gd21_22 0 n42 ni22 0 -0.00190606409177
Gd21_23 0 n42 ni23 0 -0.000411907501926
Gd21_24 0 n42 ni24 0 0.000283549394352
Gd21_25 0 n42 ni25 0 4.73552987465e-05
Gd21_26 0 n42 ni26 0 0.000251884295166
Gd21_27 0 n42 ni27 0 -0.0011593680855
Gd21_28 0 n42 ni28 0 -0.00107259065035
Gd21_29 0 n42 ni29 0 -0.0028673875378
Gd21_30 0 n42 ni30 0 -0.000873953089005
Gd21_31 0 n42 ni31 0 0.00016360292797
Gd21_32 0 n42 ni32 0 0.000184338868046
Gc22_1 0 n44 ns1 0 0.00020043836771
Gc22_2 0 n44 ns2 0 -0.000757732767094
Gc22_3 0 n44 ns3 0 0.00393266229822
Gc22_4 0 n44 ns4 0 0.00021010004076
Gc22_5 0 n44 ns5 0 0.000166374467527
Gc22_6 0 n44 ns6 0 0.000124571562617
Gc22_7 0 n44 ns7 0 -0.000184132828237
Gc22_8 0 n44 ns8 0 -5.34144079372e-05
Gc22_9 0 n44 ns9 0 -4.42911766797e-05
Gc22_10 0 n44 ns10 0 0.000838583957855
Gc22_11 0 n44 ns11 0 -0.000824353414022
Gc22_12 0 n44 ns12 0 -0.000765168533142
Gc22_13 0 n44 ns13 0 3.97509338406e-05
Gc22_14 0 n44 ns14 0 0.00014585172684
Gc22_15 0 n44 ns15 0 0.000282381515877
Gc22_16 0 n44 ns16 0 -0.000690888394869
Gc22_17 0 n44 ns17 0 -0.0017043347581
Gc22_18 0 n44 ns18 0 -0.000364617313063
Gc22_19 0 n44 ns19 0 0.00105371265314
Gc22_20 0 n44 ns20 0 0.000218178970584
Gc22_21 0 n44 ns21 0 -2.72159333399e-06
Gc22_22 0 n44 ns22 0 -0.000400774407585
Gc22_23 0 n44 ns23 0 -0.00108979888847
Gc22_24 0 n44 ns24 0 -0.00126246631697
Gc22_25 0 n44 ns25 0 -0.000626908670215
Gc22_26 0 n44 ns26 0 0.000572091988487
Gc22_27 0 n44 ns27 0 0.000855620246645
Gc22_28 0 n44 ns28 0 -0.00445916433459
Gc22_29 0 n44 ns29 0 -0.00124603107976
Gc22_30 0 n44 ns30 0 0.000686161057761
Gc22_31 0 n44 ns31 0 0.00180702240508
Gc22_32 0 n44 ns32 0 0.000586299702394
Gc22_33 0 n44 ns33 0 -0.000558004589559
Gc22_34 0 n44 ns34 0 -0.0129491457369
Gc22_35 0 n44 ns35 0 0.0102382497652
Gc22_36 0 n44 ns36 0 -0.000340043045953
Gc22_37 0 n44 ns37 0 6.48165124412e-06
Gc22_38 0 n44 ns38 0 -1.53887064912e-05
Gc22_39 0 n44 ns39 0 0.000244593164447
Gc22_40 0 n44 ns40 0 -0.000681654000852
Gc22_41 0 n44 ns41 0 0.00413380803948
Gc22_42 0 n44 ns42 0 6.93993597605e-05
Gc22_43 0 n44 ns43 0 0.000222184911378
Gc22_44 0 n44 ns44 0 0.000174058290804
Gc22_45 0 n44 ns45 0 -0.000109914241961
Gc22_46 0 n44 ns46 0 -1.99302493894e-05
Gc22_47 0 n44 ns47 0 -4.16951857773e-05
Gc22_48 0 n44 ns48 0 0.000888860593119
Gc22_49 0 n44 ns49 0 -0.000846344858419
Gc22_50 0 n44 ns50 0 -0.000748936049881
Gc22_51 0 n44 ns51 0 -9.34417112425e-06
Gc22_52 0 n44 ns52 0 0.000162293094906
Gc22_53 0 n44 ns53 0 0.000322788973234
Gc22_54 0 n44 ns54 0 -0.000308052616929
Gc22_55 0 n44 ns55 0 -0.00180732469576
Gc22_56 0 n44 ns56 0 -0.000579064127508
Gc22_57 0 n44 ns57 0 0.00100746447673
Gc22_58 0 n44 ns58 0 0.000222370684279
Gc22_59 0 n44 ns59 0 1.51255533772e-06
Gc22_60 0 n44 ns60 0 -0.000353697811027
Gc22_61 0 n44 ns61 0 -0.00135369681108
Gc22_62 0 n44 ns62 0 -0.00137157936457
Gc22_63 0 n44 ns63 0 -0.000872414932107
Gc22_64 0 n44 ns64 0 0.000575821866605
Gc22_65 0 n44 ns65 0 0.00107056537132
Gc22_66 0 n44 ns66 0 -0.00487596543689
Gc22_67 0 n44 ns67 0 -0.00199162104316
Gc22_68 0 n44 ns68 0 0.000538002033351
Gc22_69 0 n44 ns69 0 0.00218091988294
Gc22_70 0 n44 ns70 0 0.00072402452767
Gc22_71 0 n44 ns71 0 -0.000591324871384
Gc22_72 0 n44 ns72 0 -0.0178760434283
Gc22_73 0 n44 ns73 0 0.0145547880552
Gc22_74 0 n44 ns74 0 -0.000515918642818
Gc22_75 0 n44 ns75 0 2.73416751014e-06
Gc22_76 0 n44 ns76 0 -1.6638433354e-05
Gc22_77 0 n44 ns77 0 0.000305148143309
Gc22_78 0 n44 ns78 0 -0.000640809216512
Gc22_79 0 n44 ns79 0 0.00555903972563
Gc22_80 0 n44 ns80 0 -5.29666389647e-05
Gc22_81 0 n44 ns81 0 0.000371549860365
Gc22_82 0 n44 ns82 0 0.000369822817088
Gc22_83 0 n44 ns83 0 0.000175343622784
Gc22_84 0 n44 ns84 0 2.52490948601e-05
Gc22_85 0 n44 ns85 0 -2.60825825267e-06
Gc22_86 0 n44 ns86 0 -0.000420146340103
Gc22_87 0 n44 ns87 0 -0.00207893792597
Gc22_88 0 n44 ns88 0 0.000153528411058
Gc22_89 0 n44 ns89 0 0.000357665436418
Gc22_90 0 n44 ns90 0 0.000228437147656
Gc22_91 0 n44 ns91 0 0.000299178917384
Gc22_92 0 n44 ns92 0 0.000762725383938
Gc22_93 0 n44 ns93 0 -0.000726832012634
Gc22_94 0 n44 ns94 0 -0.000918040367303
Gc22_95 0 n44 ns95 0 5.58029736898e-05
Gc22_96 0 n44 ns96 0 0.000128806811824
Gc22_97 0 n44 ns97 0 2.45073898404e-06
Gc22_98 0 n44 ns98 0 -0.00101083466906
Gc22_99 0 n44 ns99 0 -0.00245448091314
Gc22_100 0 n44 ns100 0 -0.00113764312637
Gc22_101 0 n44 ns101 0 -0.00110915651463
Gc22_102 0 n44 ns102 0 0.000340089626758
Gc22_103 0 n44 ns103 0 0.00145164208836
Gc22_104 0 n44 ns104 0 -0.00623814560985
Gc22_105 0 n44 ns105 0 -0.00387668685265
Gc22_106 0 n44 ns106 0 -0.000186863207015
Gc22_107 0 n44 ns107 0 0.00333085311793
Gc22_108 0 n44 ns108 0 0.00136215144977
Gc22_109 0 n44 ns109 0 -0.00066289756675
Gc22_110 0 n44 ns110 0 -0.0325691694883
Gc22_111 0 n44 ns111 0 0.0273531560454
Gc22_112 0 n44 ns112 0 -0.00107948206982
Gc22_113 0 n44 ns113 0 -4.67348035903e-06
Gc22_114 0 n44 ns114 0 -2.08769066555e-05
Gc22_115 0 n44 ns115 0 0.000905447112272
Gc22_116 0 n44 ns116 0 -0.000914356732701
Gc22_117 0 n44 ns117 0 0.0103614996574
Gc22_118 0 n44 ns118 0 -7.75827648263e-06
Gc22_119 0 n44 ns119 0 0.000768279488691
Gc22_120 0 n44 ns120 0 0.000461584841828
Gc22_121 0 n44 ns121 0 -0.000146838344142
Gc22_122 0 n44 ns122 0 -9.02716821122e-05
Gc22_123 0 n44 ns123 0 -2.27867978533e-05
Gc22_124 0 n44 ns124 0 -1.38330471618e-05
Gc22_125 0 n44 ns125 0 -0.00417994349635
Gc22_126 0 n44 ns126 0 0.000237889092114
Gc22_127 0 n44 ns127 0 0.00106789529442
Gc22_128 0 n44 ns128 0 0.000122584372908
Gc22_129 0 n44 ns129 0 0.000412851402958
Gc22_130 0 n44 ns130 0 -0.00097200278087
Gc22_131 0 n44 ns131 0 -0.000592275379214
Gc22_132 0 n44 ns132 0 -0.000452274907446
Gc22_133 0 n44 ns133 0 -0.000101754687879
Gc22_134 0 n44 ns134 0 0.000266277129083
Gc22_135 0 n44 ns135 0 7.28827677566e-05
Gc22_136 0 n44 ns136 0 -0.00235526684736
Gc22_137 0 n44 ns137 0 -0.00499711134623
Gc22_138 0 n44 ns138 0 -0.00154836598707
Gc22_139 0 n44 ns139 0 1.34324586016e-05
Gc22_140 0 n44 ns140 0 0.000464210441322
Gc22_141 0 n44 ns141 0 0.00145631573535
Gc22_142 0 n44 ns142 0 -0.00901898674781
Gc22_143 0 n44 ns143 0 -0.00527714086102
Gc22_144 0 n44 ns144 0 -0.00153658135827
Gc22_145 0 n44 ns145 0 0.00383942550992
Gc22_146 0 n44 ns146 0 0.00229097609612
Gc22_147 0 n44 ns147 0 -0.000328142221399
Gc22_148 0 n44 ns148 0 -0.0694872407828
Gc22_149 0 n44 ns149 0 0.0605346837592
Gc22_150 0 n44 ns150 0 -0.00288968633018
Gc22_151 0 n44 ns151 0 -8.78853491118e-06
Gc22_152 0 n44 ns152 0 -2.13553186384e-05
Gc22_153 0 n44 ns153 0 -0.000166935526044
Gc22_154 0 n44 ns154 0 -0.000243786110225
Gc22_155 0 n44 ns155 0 0.00597174086095
Gc22_156 0 n44 ns156 0 -0.00132829028952
Gc22_157 0 n44 ns157 0 -0.000416915370578
Gc22_158 0 n44 ns158 0 0.00186206280491
Gc22_159 0 n44 ns159 0 0.00052782556995
Gc22_160 0 n44 ns160 0 -0.000161658503608
Gc22_161 0 n44 ns161 0 -0.000185669635332
Gc22_162 0 n44 ns162 0 0.00185322822982
Gc22_163 0 n44 ns163 0 -0.00220733355341
Gc22_164 0 n44 ns164 0 -0.000528865826436
Gc22_165 0 n44 ns165 0 0.000871659317509
Gc22_166 0 n44 ns166 0 -0.000128972500631
Gc22_167 0 n44 ns167 0 0.000441857408046
Gc22_168 0 n44 ns168 0 -0.000181742371544
Gc22_169 0 n44 ns169 0 -0.00321602196224
Gc22_170 0 n44 ns170 0 -0.000883693201306
Gc22_171 0 n44 ns171 0 0.000109276644022
Gc22_172 0 n44 ns172 0 0.000263054954093
Gc22_173 0 n44 ns173 0 0.000342154382722
Gc22_174 0 n44 ns174 0 0.000937928659573
Gc22_175 0 n44 ns175 0 -0.00544386404973
Gc22_176 0 n44 ns176 0 -0.00291097898141
Gc22_177 0 n44 ns177 0 -0.000849228410949
Gc22_178 0 n44 ns178 0 0.000216131443648
Gc22_179 0 n44 ns179 0 0.00214817498408
Gc22_180 0 n44 ns180 0 -0.0122436349995
Gc22_181 0 n44 ns181 0 -0.00509469966255
Gc22_182 0 n44 ns182 0 -0.000827520785817
Gc22_183 0 n44 ns183 0 0.00283762268247
Gc22_184 0 n44 ns184 0 0.00301085366403
Gc22_185 0 n44 ns185 0 0.000218731875976
Gc22_186 0 n44 ns186 0 -0.0660549114777
Gc22_187 0 n44 ns187 0 0.0629908704881
Gc22_188 0 n44 ns188 0 -0.00631247274402
Gc22_189 0 n44 ns189 0 -8.40567458531e-06
Gc22_190 0 n44 ns190 0 -6.58275847253e-06
Gc22_191 0 n44 ns191 0 -0.0171244147841
Gc22_192 0 n44 ns192 0 -0.00133797449727
Gc22_193 0 n44 ns193 0 0.0204700788507
Gc22_194 0 n44 ns194 0 0.0062761662724
Gc22_195 0 n44 ns195 0 0.0102875173273
Gc22_196 0 n44 ns196 0 0.00147546961876
Gc22_197 0 n44 ns197 0 -0.00322925089014
Gc22_198 0 n44 ns198 0 -0.000492544017318
Gc22_199 0 n44 ns199 0 3.209641809e-05
Gc22_200 0 n44 ns200 0 -0.00128527561347
Gc22_201 0 n44 ns201 0 -0.0147918989801
Gc22_202 0 n44 ns202 0 0.00113099955227
Gc22_203 0 n44 ns203 0 0.0021734164595
Gc22_204 0 n44 ns204 0 0.000273844499393
Gc22_205 0 n44 ns205 0 0.000373716025143
Gc22_206 0 n44 ns206 0 0.000258991896964
Gc22_207 0 n44 ns207 0 0.000666679282793
Gc22_208 0 n44 ns208 0 9.78785579266e-05
Gc22_209 0 n44 ns209 0 0.000393559080831
Gc22_210 0 n44 ns210 0 0.0004913298107
Gc22_211 0 n44 ns211 0 0.000322883640932
Gc22_212 0 n44 ns212 0 -0.0117015780616
Gc22_213 0 n44 ns213 0 -0.00792058415779
Gc22_214 0 n44 ns214 0 -0.00367385538217
Gc22_215 0 n44 ns215 0 -0.0012455491177
Gc22_216 0 n44 ns216 0 0.000142745676487
Gc22_217 0 n44 ns217 0 0.00253014600629
Gc22_218 0 n44 ns218 0 0.00834687610702
Gc22_219 0 n44 ns219 0 -0.00537871417283
Gc22_220 0 n44 ns220 0 0.00191202829504
Gc22_221 0 n44 ns221 0 0.00182874497472
Gc22_222 0 n44 ns222 0 0.00327434500939
Gc22_223 0 n44 ns223 0 -3.32589517463e-05
Gc22_224 0 n44 ns224 0 -0.107101686721
Gc22_225 0 n44 ns225 0 0.0692617213362
Gc22_226 0 n44 ns226 0 -0.00877623182501
Gc22_227 0 n44 ns227 0 -1.13153752642e-05
Gc22_228 0 n44 ns228 0 7.6993613053e-07
Gc22_229 0 n44 ns229 0 -0.000312874614228
Gc22_230 0 n44 ns230 0 -0.000432256472559
Gc22_231 0 n44 ns231 0 0.0069899082076
Gc22_232 0 n44 ns232 0 -0.00111851059399
Gc22_233 0 n44 ns233 0 -0.000489362074843
Gc22_234 0 n44 ns234 0 0.00179036905867
Gc22_235 0 n44 ns235 0 0.0004622284683
Gc22_236 0 n44 ns236 0 -0.000182741012598
Gc22_237 0 n44 ns237 0 -0.000170214255081
Gc22_238 0 n44 ns238 0 0.00221109828639
Gc22_239 0 n44 ns239 0 -0.00266726500058
Gc22_240 0 n44 ns240 0 -0.000853773526685
Gc22_241 0 n44 ns241 0 0.000988546970965
Gc22_242 0 n44 ns242 0 -6.46534483592e-05
Gc22_243 0 n44 ns243 0 0.00057298286736
Gc22_244 0 n44 ns244 0 -0.000543474703417
Gc22_245 0 n44 ns245 0 -0.00370427188012
Gc22_246 0 n44 ns246 0 -0.000983954875674
Gc22_247 0 n44 ns247 0 0.000437724655641
Gc22_248 0 n44 ns248 0 0.000347360263371
Gc22_249 0 n44 ns249 0 0.000371321447424
Gc22_250 0 n44 ns250 0 0.000898134790924
Gc22_251 0 n44 ns251 0 -0.00548147096495
Gc22_252 0 n44 ns252 0 -0.00299293695107
Gc22_253 0 n44 ns253 0 -0.00107895504514
Gc22_254 0 n44 ns254 0 0.000184258509603
Gc22_255 0 n44 ns255 0 0.00231995556269
Gc22_256 0 n44 ns256 0 -0.0130111697543
Gc22_257 0 n44 ns257 0 -0.00588988492644
Gc22_258 0 n44 ns258 0 -0.000948980001342
Gc22_259 0 n44 ns259 0 0.0031668793748
Gc22_260 0 n44 ns260 0 0.00313369414006
Gc22_261 0 n44 ns261 0 0.000261390097681
Gc22_262 0 n44 ns262 0 -0.0733840393635
Gc22_263 0 n44 ns263 0 0.0691824650325
Gc22_264 0 n44 ns264 0 -0.00651121149355
Gc22_265 0 n44 ns265 0 -9.96245338042e-06
Gc22_266 0 n44 ns266 0 1.57507030569e-05
Gc22_267 0 n44 ns267 0 0.000710841727081
Gc22_268 0 n44 ns268 0 -0.00100088785773
Gc22_269 0 n44 ns269 0 0.0115884351351
Gc22_270 0 n44 ns270 0 0.000320150670686
Gc22_271 0 n44 ns271 0 0.000589264605309
Gc22_272 0 n44 ns272 0 0.000423551529215
Gc22_273 0 n44 ns273 0 -0.000310787911426
Gc22_274 0 n44 ns274 0 -0.000121711051199
Gc22_275 0 n44 ns275 0 -3.37019263467e-05
Gc22_276 0 n44 ns276 0 3.42224312641e-05
Gc22_277 0 n44 ns277 0 -0.00373236136231
Gc22_278 0 n44 ns278 0 8.51719202074e-05
Gc22_279 0 n44 ns279 0 0.000615703447124
Gc22_280 0 n44 ns280 0 3.38834444412e-06
Gc22_281 0 n44 ns281 0 0.000517803567078
Gc22_282 0 n44 ns282 0 -0.000923580891103
Gc22_283 0 n44 ns283 0 -0.00138757661169
Gc22_284 0 n44 ns284 0 -0.000949205174037
Gc22_285 0 n44 ns285 0 0.00018632316757
Gc22_286 0 n44 ns286 0 0.000358332170051
Gc22_287 0 n44 ns287 0 0.000221480033982
Gc22_288 0 n44 ns288 0 -0.0026378664679
Gc22_289 0 n44 ns289 0 -0.00468588478142
Gc22_290 0 n44 ns290 0 -0.00128658234673
Gc22_291 0 n44 ns291 0 -0.000301595186855
Gc22_292 0 n44 ns292 0 0.000224104671301
Gc22_293 0 n44 ns293 0 0.00159232070482
Gc22_294 0 n44 ns294 0 -0.00973574873224
Gc22_295 0 n44 ns295 0 -0.0062341997176
Gc22_296 0 n44 ns296 0 -0.00177540546958
Gc22_297 0 n44 ns297 0 0.00421757165637
Gc22_298 0 n44 ns298 0 0.00246002906706
Gc22_299 0 n44 ns299 0 -0.000250534780314
Gc22_300 0 n44 ns300 0 -0.0780174719672
Gc22_301 0 n44 ns301 0 0.0677665797668
Gc22_302 0 n44 ns302 0 -0.00313334849585
Gc22_303 0 n44 ns303 0 -1.027535946e-05
Gc22_304 0 n44 ns304 0 1.16054353629e-05
Gc22_305 0 n44 ns305 0 4.99011619297e-06
Gc22_306 0 n44 ns306 0 3.50712069104e-05
Gc22_307 0 n44 ns307 0 0.00513240660055
Gc22_308 0 n44 ns308 0 9.25365477282e-05
Gc22_309 0 n44 ns309 0 0.000167963987829
Gc22_310 0 n44 ns310 0 0.000374700397489
Gc22_311 0 n44 ns311 0 0.000129876206041
Gc22_312 0 n44 ns312 0 3.63279852177e-05
Gc22_313 0 n44 ns313 0 -7.27996240254e-06
Gc22_314 0 n44 ns314 0 -0.00138657698337
Gc22_315 0 n44 ns315 0 -0.000922737209422
Gc22_316 0 n44 ns316 0 0.000797247072587
Gc22_317 0 n44 ns317 0 -0.000295830344038
Gc22_318 0 n44 ns318 0 -3.8525767106e-05
Gc22_319 0 n44 ns319 0 0.000158057474786
Gc22_320 0 n44 ns320 0 0.0016959269109
Gc22_321 0 n44 ns321 0 -0.000604298509175
Gc22_322 0 n44 ns322 0 -0.00149458248074
Gc22_323 0 n44 ns323 0 -0.000439626654793
Gc22_324 0 n44 ns324 0 5.88190840221e-05
Gc22_325 0 n44 ns325 0 0.000206347793919
Gc22_326 0 n44 ns326 0 -0.00143418677905
Gc22_327 0 n44 ns327 0 -0.00177464075079
Gc22_328 0 n44 ns328 0 -0.000212887102152
Gc22_329 0 n44 ns329 0 -0.0011410120645
Gc22_330 0 n44 ns330 0 -0.000196564943002
Gc22_331 0 n44 ns331 0 0.00123630468085
Gc22_332 0 n44 ns332 0 -0.00544348276092
Gc22_333 0 n44 ns333 0 -0.00419538507248
Gc22_334 0 n44 ns334 0 -0.000665651753072
Gc22_335 0 n44 ns335 0 0.00319162980426
Gc22_336 0 n44 ns336 0 0.00142768503964
Gc22_337 0 n44 ns337 0 -0.000466915245476
Gc22_338 0 n44 ns338 0 -0.0333166685237
Gc22_339 0 n44 ns339 0 0.0281188496136
Gc22_340 0 n44 ns340 0 -0.00113612388861
Gc22_341 0 n44 ns341 0 -4.47514032239e-06
Gc22_342 0 n44 ns342 0 1.21062717181e-05
Gc22_343 0 n44 ns343 0 0.000242122207086
Gc22_344 0 n44 ns344 0 -0.000371495127105
Gc22_345 0 n44 ns345 0 0.004364740947
Gc22_346 0 n44 ns346 0 -0.000222129331208
Gc22_347 0 n44 ns347 0 0.000433914677804
Gc22_348 0 n44 ns348 0 0.000380361483876
Gc22_349 0 n44 ns349 0 7.52772516279e-05
Gc22_350 0 n44 ns350 0 2.24133094078e-05
Gc22_351 0 n44 ns351 0 -1.66282694212e-05
Gc22_352 0 n44 ns352 0 0.000246582150219
Gc22_353 0 n44 ns353 0 -0.00134647678911
Gc22_354 0 n44 ns354 0 -0.000242234892516
Gc22_355 0 n44 ns355 0 0.000143038445022
Gc22_356 0 n44 ns356 0 0.000212488185894
Gc22_357 0 n44 ns357 0 0.000294699338043
Gc22_358 0 n44 ns358 0 0.000621598079892
Gc22_359 0 n44 ns359 0 -0.00125287018765
Gc22_360 0 n44 ns360 0 -0.000871639654945
Gc22_361 0 n44 ns361 0 0.000429529890295
Gc22_362 0 n44 ns362 0 0.000145601123063
Gc22_363 0 n44 ns363 0 4.88548675042e-06
Gc22_364 0 n44 ns364 0 -0.000484338251988
Gc22_365 0 n44 ns365 0 -0.00193082667884
Gc22_366 0 n44 ns366 0 -0.0012565545734
Gc22_367 0 n44 ns367 0 -0.00119572041713
Gc22_368 0 n44 ns368 0 0.000409036299536
Gc22_369 0 n44 ns369 0 0.00136689251214
Gc22_370 0 n44 ns370 0 -0.00553464800476
Gc22_371 0 n44 ns371 0 -0.00325743682131
Gc22_372 0 n44 ns372 0 0.000144735320818
Gc22_373 0 n44 ns373 0 0.00290706071375
Gc22_374 0 n44 ns374 0 0.00108111391933
Gc22_375 0 n44 ns375 0 -0.000656292138557
Gc22_376 0 n44 ns376 0 -0.0251287799195
Gc22_377 0 n44 ns377 0 0.0209089369226
Gc22_378 0 n44 ns378 0 -0.000795560344042
Gc22_379 0 n44 ns379 0 -1.71180932047e-06
Gc22_380 0 n44 ns380 0 -1.79197711569e-05
Gc22_381 0 n44 ns381 0 0.000717292594472
Gc22_382 0 n44 ns382 0 -0.00169869231279
Gc22_383 0 n44 ns383 0 0.00920461034099
Gc22_384 0 n44 ns384 0 0.000225714553049
Gc22_385 0 n44 ns385 0 0.000263306913919
Gc22_386 0 n44 ns386 0 0.000148488164535
Gc22_387 0 n44 ns387 0 0.000152388250738
Gc22_388 0 n44 ns388 0 -1.08837598095e-05
Gc22_389 0 n44 ns389 0 5.42886788741e-06
Gc22_390 0 n44 ns390 0 -0.000473464547114
Gc22_391 0 n44 ns391 0 -0.00336754937613
Gc22_392 0 n44 ns392 0 0.000251235517968
Gc22_393 0 n44 ns393 0 0.000824435596598
Gc22_394 0 n44 ns394 0 0.000192546855016
Gc22_395 0 n44 ns395 0 0.00038116788
Gc22_396 0 n44 ns396 0 -0.000193407040499
Gc22_397 0 n44 ns397 0 -7.71149706346e-05
Gc22_398 0 n44 ns398 0 -0.000518978962857
Gc22_399 0 n44 ns399 0 -0.000231628751829
Gc22_400 0 n44 ns400 0 0.000184524107044
Gc22_401 0 n44 ns401 0 -1.20494037709e-05
Gc22_402 0 n44 ns402 0 -0.00205723034964
Gc22_403 0 n44 ns403 0 -0.0037111965299
Gc22_404 0 n44 ns404 0 -0.00106205423755
Gc22_405 0 n44 ns405 0 -0.000380169026559
Gc22_406 0 n44 ns406 0 0.000319948296262
Gc22_407 0 n44 ns407 0 0.00134153358667
Gc22_408 0 n44 ns408 0 -0.00743494056383
Gc22_409 0 n44 ns409 0 -0.00478425669591
Gc22_410 0 n44 ns410 0 -0.00115747248249
Gc22_411 0 n44 ns411 0 0.00373602401264
Gc22_412 0 n44 ns412 0 0.00192856751486
Gc22_413 0 n44 ns413 0 -0.000462681399159
Gc22_414 0 n44 ns414 0 -0.0532933744329
Gc22_415 0 n44 ns415 0 0.0457853681264
Gc22_416 0 n44 ns416 0 -0.00199550326004
Gc22_417 0 n44 ns417 0 -8.35677456993e-06
Gc22_418 0 n44 ns418 0 -2.36577901476e-05
Gc22_419 0 n44 ns419 0 0.000439704969893
Gc22_420 0 n44 ns420 0 -0.00126567910752
Gc22_421 0 n44 ns421 0 0.00974278764419
Gc22_422 0 n44 ns422 0 -0.000330979987241
Gc22_423 0 n44 ns423 0 0.000171793966436
Gc22_424 0 n44 ns424 0 0.000521538308635
Gc22_425 0 n44 ns425 0 -0.000533967804857
Gc22_426 0 n44 ns426 0 -7.92885874675e-05
Gc22_427 0 n44 ns427 0 2.39385421422e-05
Gc22_428 0 n44 ns428 0 0.00165656441374
Gc22_429 0 n44 ns429 0 -0.00213752510861
Gc22_430 0 n44 ns430 0 -0.000372622998636
Gc22_431 0 n44 ns431 0 0.000592631066655
Gc22_432 0 n44 ns432 0 -0.000146441803535
Gc22_433 0 n44 ns433 0 0.000421874947049
Gc22_434 0 n44 ns434 0 -0.00102254405383
Gc22_435 0 n44 ns435 0 -0.00217133357876
Gc22_436 0 n44 ns436 0 -0.000634024104865
Gc22_437 0 n44 ns437 0 0.000201492712994
Gc22_438 0 n44 ns438 0 0.000304803610128
Gc22_439 0 n44 ns439 0 0.000263142439822
Gc22_440 0 n44 ns440 0 -0.000380485134094
Gc22_441 0 n44 ns441 0 -0.00644085154051
Gc22_442 0 n44 ns442 0 -0.00283982172639
Gc22_443 0 n44 ns443 0 -0.000264560614337
Gc22_444 0 n44 ns444 0 0.000529985858585
Gc22_445 0 n44 ns445 0 0.00196022749286
Gc22_446 0 n44 ns446 0 -0.0105785465939
Gc22_447 0 n44 ns447 0 -0.00511025741258
Gc22_448 0 n44 ns448 0 -0.00175515257427
Gc22_449 0 n44 ns449 0 0.00276733551057
Gc22_450 0 n44 ns450 0 0.00264817267998
Gc22_451 0 n44 ns451 0 0.000128953117293
Gc22_452 0 n44 ns452 0 -0.0875476158646
Gc22_453 0 n44 ns453 0 0.0798578217181
Gc22_454 0 n44 ns454 0 -0.00515063528027
Gc22_455 0 n44 ns455 0 -8.34256195821e-06
Gc22_456 0 n44 ns456 0 -1.74111483917e-05
Gc22_457 0 n44 ns457 0 -0.00538957573823
Gc22_458 0 n44 ns458 0 -0.00438207245864
Gc22_459 0 n44 ns459 0 0.00720875389749
Gc22_460 0 n44 ns460 0 0.00220856653664
Gc22_461 0 n44 ns461 0 -0.00190548335539
Gc22_462 0 n44 ns462 0 0.000812927547641
Gc22_463 0 n44 ns463 0 0.00299714848423
Gc22_464 0 n44 ns464 0 2.92497134302e-05
Gc22_465 0 n44 ns465 0 -0.000322909866809
Gc22_466 0 n44 ns466 0 -0.00120187098433
Gc22_467 0 n44 ns467 0 -0.0018074635616
Gc22_468 0 n44 ns468 0 -0.00059902196267
Gc22_469 0 n44 ns469 0 0.000829962365663
Gc22_470 0 n44 ns470 0 -7.85980542203e-05
Gc22_471 0 n44 ns471 0 0.000461413234361
Gc22_472 0 n44 ns472 0 0.00287714316781
Gc22_473 0 n44 ns473 0 -0.00186208447041
Gc22_474 0 n44 ns474 0 -0.000536132127024
Gc22_475 0 n44 ns475 0 -0.00090706935413
Gc22_476 0 n44 ns476 0 0.00011716894726
Gc22_477 0 n44 ns477 0 9.05537407433e-05
Gc22_478 0 n44 ns478 0 0.00269233595429
Gc22_479 0 n44 ns479 0 0.00120586147565
Gc22_480 0 n44 ns480 0 -0.00126395233587
Gc22_481 0 n44 ns481 0 -0.00247122985461
Gc22_482 0 n44 ns482 0 -0.0010399221554
Gc22_483 0 n44 ns483 0 0.00198445935477
Gc22_484 0 n44 ns484 0 -0.0137869013584
Gc22_485 0 n44 ns485 0 -0.0046997176022
Gc22_486 0 n44 ns486 0 0.00221150622188
Gc22_487 0 n44 ns487 0 0.00348497869164
Gc22_488 0 n44 ns488 0 0.00355658877221
Gc22_489 0 n44 ns489 0 0.000106739416893
Gc22_490 0 n44 ns490 0 0.0187245964181
Gc22_491 0 n44 ns491 0 -0.00943557626869
Gc22_492 0 n44 ns492 0 -0.00759691004864
Gc22_493 0 n44 ns493 0 -1.15129506979e-05
Gc22_494 0 n44 ns494 0 -7.80921672632e-06
Gc22_495 0 n44 ns495 0 -0.00258100929547
Gc22_496 0 n44 ns496 0 -0.00290864538386
Gc22_497 0 n44 ns497 0 0.00730468122451
Gc22_498 0 n44 ns498 0 0.000979673838849
Gc22_499 0 n44 ns499 0 -0.00172145243159
Gc22_500 0 n44 ns500 0 0.000647414278352
Gc22_501 0 n44 ns501 0 0.00199831664399
Gc22_502 0 n44 ns502 0 3.3776841289e-05
Gc22_503 0 n44 ns503 0 -0.000213907422356
Gc22_504 0 n44 ns504 0 0.000936678434493
Gc22_505 0 n44 ns505 0 -0.00160473493295
Gc22_506 0 n44 ns506 0 -0.00108813203938
Gc22_507 0 n44 ns507 0 0.000732603072324
Gc22_508 0 n44 ns508 0 -0.00013311201555
Gc22_509 0 n44 ns509 0 0.000549189806127
Gc22_510 0 n44 ns510 0 0.00126649222903
Gc22_511 0 n44 ns511 0 -0.00284506227151
Gc22_512 0 n44 ns512 0 -0.000618874467629
Gc22_513 0 n44 ns513 0 -0.000133204688328
Gc22_514 0 n44 ns514 0 0.000280433441424
Gc22_515 0 n44 ns515 0 0.000233636104568
Gc22_516 0 n44 ns516 0 0.00215744191236
Gc22_517 0 n44 ns517 0 -0.00233825723468
Gc22_518 0 n44 ns518 0 -0.00262894737085
Gc22_519 0 n44 ns519 0 -0.00184036302838
Gc22_520 0 n44 ns520 0 -0.000316581998476
Gc22_521 0 n44 ns521 0 0.00238679095681
Gc22_522 0 n44 ns522 0 -0.0119242313747
Gc22_523 0 n44 ns523 0 -0.0048328150943
Gc22_524 0 n44 ns524 0 0.000297033375507
Gc22_525 0 n44 ns525 0 0.00245085480536
Gc22_526 0 n44 ns526 0 0.00314238743473
Gc22_527 0 n44 ns527 0 0.000199059465172
Gc22_528 0 n44 ns528 0 -0.0366135429124
Gc22_529 0 n44 ns529 0 0.038339599494
Gc22_530 0 n44 ns530 0 -0.00706311044611
Gc22_531 0 n44 ns531 0 -1.00107469575e-05
Gc22_532 0 n44 ns532 0 8.65780168704e-06
Gc22_533 0 n44 ns533 0 0.000224857601348
Gc22_534 0 n44 ns534 0 -0.00149917973756
Gc22_535 0 n44 ns535 0 0.0116466296595
Gc22_536 0 n44 ns536 0 0.000154924801209
Gc22_537 0 n44 ns537 0 0.000355957128409
Gc22_538 0 n44 ns538 0 0.000518385247931
Gc22_539 0 n44 ns539 0 -0.000468958809148
Gc22_540 0 n44 ns540 0 -0.000154725994587
Gc22_541 0 n44 ns541 0 -2.59613194298e-05
Gc22_542 0 n44 ns542 0 0.00129319887443
Gc22_543 0 n44 ns543 0 -0.00362831875112
Gc22_544 0 n44 ns544 0 -0.000458926405333
Gc22_545 0 n44 ns545 0 0.000850043631441
Gc22_546 0 n44 ns546 0 -4.72307053442e-05
Gc22_547 0 n44 ns547 0 0.000606694431956
Gc22_548 0 n44 ns548 0 -0.00152356431913
Gc22_549 0 n44 ns549 0 -0.00198698828451
Gc22_550 0 n44 ns550 0 -0.000709484034315
Gc22_551 0 n44 ns551 0 0.000356394527909
Gc22_552 0 n44 ns552 0 0.000418830610294
Gc22_553 0 n44 ns553 0 0.000240251756742
Gc22_554 0 n44 ns554 0 -0.00177609478236
Gc22_555 0 n44 ns555 0 -0.00565966863385
Gc22_556 0 n44 ns556 0 -0.0020232141998
Gc22_557 0 n44 ns557 0 -0.000274017994751
Gc22_558 0 n44 ns558 0 0.000344342033924
Gc22_559 0 n44 ns559 0 0.00185772290311
Gc22_560 0 n44 ns560 0 -0.0106920000086
Gc22_561 0 n44 ns561 0 -0.00615426306069
Gc22_562 0 n44 ns562 0 -0.00187501802132
Gc22_563 0 n44 ns563 0 0.0038298458643
Gc22_564 0 n44 ns564 0 0.00269964340541
Gc22_565 0 n44 ns565 0 -9.62366025963e-05
Gc22_566 0 n44 ns566 0 -0.0862049294929
Gc22_567 0 n44 ns567 0 0.0764386194711
Gc22_568 0 n44 ns568 0 -0.0041775068984
Gc22_569 0 n44 ns569 0 -9.5914979487e-06
Gc22_570 0 n44 ns570 0 1.2551468309e-05
Gc22_571 0 n44 ns571 0 0.000391611710697
Gc22_572 0 n44 ns572 0 -0.000905166422928
Gc22_573 0 n44 ns573 0 0.00750157770076
Gc22_574 0 n44 ns574 0 0.000287253347905
Gc22_575 0 n44 ns575 0 -0.000137148092857
Gc22_576 0 n44 ns576 0 9.80808866325e-05
Gc22_577 0 n44 ns577 0 6.36456368505e-05
Gc22_578 0 n44 ns578 0 1.82675409894e-05
Gc22_579 0 n44 ns579 0 2.6478589453e-05
Gc22_580 0 n44 ns580 0 -0.00116473669823
Gc22_581 0 n44 ns581 0 -0.00126756260855
Gc22_582 0 n44 ns582 0 0.000605353652441
Gc22_583 0 n44 ns583 0 -0.000196878847706
Gc22_584 0 n44 ns584 0 -6.71937290159e-05
Gc22_585 0 n44 ns585 0 0.000295096126481
Gc22_586 0 n44 ns586 0 0.00111387290852
Gc22_587 0 n44 ns587 0 -0.000436891165927
Gc22_588 0 n44 ns588 0 -0.00136880909827
Gc22_589 0 n44 ns589 0 -0.000398141335831
Gc22_590 0 n44 ns590 0 0.000158372217535
Gc22_591 0 n44 ns591 0 0.000190528845583
Gc22_592 0 n44 ns592 0 -0.00179528024372
Gc22_593 0 n44 ns593 0 -0.00227452309674
Gc22_594 0 n44 ns594 0 -0.000270542636536
Gc22_595 0 n44 ns595 0 -0.00108302239845
Gc22_596 0 n44 ns596 0 -0.000211143083401
Gc22_597 0 n44 ns597 0 0.00140144597069
Gc22_598 0 n44 ns598 0 -0.00645261765748
Gc22_599 0 n44 ns599 0 -0.00476443943752
Gc22_600 0 n44 ns600 0 -0.00101644936932
Gc22_601 0 n44 ns601 0 0.00362838372459
Gc22_602 0 n44 ns602 0 0.00176044889788
Gc22_603 0 n44 ns603 0 -0.00047351616939
Gc22_604 0 n44 ns604 0 -0.0440489750921
Gc22_605 0 n44 ns605 0 0.0375444778651
Gc22_606 0 n44 ns606 0 -0.00159027607832
Gc22_607 0 n44 ns607 0 -8.50372382859e-06
Gc22_608 0 n44 ns608 0 1.02708130318e-05
Gc22_609 0 n44 ns609 0 0.000203544987642
Gc22_610 0 n44 ns610 0 -0.000419858897913
Gc22_611 0 n44 ns611 0 0.00274709917439
Gc22_612 0 n44 ns612 0 0.000156924472452
Gc22_613 0 n44 ns613 0 0.000132183489336
Gc22_614 0 n44 ns614 0 8.65407123796e-05
Gc22_615 0 n44 ns615 0 5.59457533806e-05
Gc22_616 0 n44 ns616 0 2.70290790668e-05
Gc22_617 0 n44 ns617 0 2.42989397446e-05
Gc22_618 0 n44 ns618 0 -0.000727124447033
Gc22_619 0 n44 ns619 0 -0.000994274513328
Gc22_620 0 n44 ns620 0 0.00074466414544
Gc22_621 0 n44 ns621 0 0.000292224083254
Gc22_622 0 n44 ns622 0 -8.9753213633e-05
Gc22_623 0 n44 ns623 0 -0.000203898153056
Gc22_624 0 n44 ns624 0 -0.00087730375698
Gc22_625 0 n44 ns625 0 -0.00155991857075
Gc22_626 0 n44 ns626 0 -0.000311918328433
Gc22_627 0 n44 ns627 0 0.00108769241137
Gc22_628 0 n44 ns628 0 0.00022053790008
Gc22_629 0 n44 ns629 0 -6.63186548279e-06
Gc22_630 0 n44 ns630 0 -0.00186375563501
Gc22_631 0 n44 ns631 0 0.000418739271285
Gc22_632 0 n44 ns632 0 0.000824494636262
Gc22_633 0 n44 ns633 0 0.0010962454527
Gc22_634 0 n44 ns634 0 -0.000213241679287
Gc22_635 0 n44 ns635 0 -0.000830485116112
Gc22_636 0 n44 ns636 0 -0.00222930349767
Gc22_637 0 n44 ns637 0 0.000716692847503
Gc22_638 0 n44 ns638 0 0.000762573261078
Gc22_639 0 n44 ns639 0 0.00105601781582
Gc22_640 0 n44 ns640 0 0.000356237250297
Gc22_641 0 n44 ns641 0 -0.00060293723803
Gc22_642 0 n44 ns642 0 0.00469894475119
Gc22_643 0 n44 ns643 0 -0.00526550256913
Gc22_644 0 n44 ns644 0 0.000390730440968
Gc22_645 0 n44 ns645 0 -7.98871010746e-06
Gc22_646 0 n44 ns646 0 -1.75181106364e-05
Gc22_647 0 n44 ns647 0 9.76564005302e-05
Gc22_648 0 n44 ns648 0 -0.000701788458076
Gc22_649 0 n44 ns649 0 0.00271103265415
Gc22_650 0 n44 ns650 0 0.000121652443593
Gc22_651 0 n44 ns651 0 3.53471202342e-05
Gc22_652 0 n44 ns652 0 2.49559312477e-05
Gc22_653 0 n44 ns653 0 8.8697428391e-05
Gc22_654 0 n44 ns654 0 1.25620028207e-05
Gc22_655 0 n44 ns655 0 9.14423270556e-06
Gc22_656 0 n44 ns656 0 -0.000718683430425
Gc22_657 0 n44 ns657 0 -0.000688681986894
Gc22_658 0 n44 ns658 0 0.000754849531086
Gc22_659 0 n44 ns659 0 0.000347670331707
Gc22_660 0 n44 ns660 0 -8.62436748762e-05
Gc22_661 0 n44 ns661 0 -0.000270014057195
Gc22_662 0 n44 ns662 0 -0.000573336610199
Gc22_663 0 n44 ns663 0 -0.00143724405952
Gc22_664 0 n44 ns664 0 -0.00041502527524
Gc22_665 0 n44 ns665 0 0.00106487439068
Gc22_666 0 n44 ns666 0 0.000257301272275
Gc22_667 0 n44 ns667 0 -2.33831246053e-05
Gc22_668 0 n44 ns668 0 -0.0014612968913
Gc22_669 0 n44 ns669 0 0.000342011684159
Gc22_670 0 n44 ns670 0 0.000818365595763
Gc22_671 0 n44 ns671 0 0.00112322647202
Gc22_672 0 n44 ns672 0 -0.000252668038745
Gc22_673 0 n44 ns673 0 -0.000909786747759
Gc22_674 0 n44 ns674 0 -0.00203287576225
Gc22_675 0 n44 ns675 0 8.16552166732e-05
Gc22_676 0 n44 ns676 0 0.000508830906787
Gc22_677 0 n44 ns677 0 0.00127897630203
Gc22_678 0 n44 ns678 0 0.000456135547627
Gc22_679 0 n44 ns679 0 -0.000588039012794
Gc22_680 0 n44 ns680 0 0.00414060219371
Gc22_681 0 n44 ns681 0 -0.00489099127175
Gc22_682 0 n44 ns682 0 0.000422257160862
Gc22_683 0 n44 ns683 0 -5.24173289211e-06
Gc22_684 0 n44 ns684 0 -1.84491133509e-05
Gc22_685 0 n44 ns685 0 -0.000774994954036
Gc22_686 0 n44 ns686 0 0.00172095276875
Gc22_687 0 n44 ns687 0 -0.00349692930858
Gc22_688 0 n44 ns688 0 -0.000249371756369
Gc22_689 0 n44 ns689 0 -0.00014984199463
Gc22_690 0 n44 ns690 0 -0.000192534092076
Gc22_691 0 n44 ns691 0 -0.000149859717527
Gc22_692 0 n44 ns692 0 -2.33882633605e-05
Gc22_693 0 n44 ns693 0 -1.1624556462e-05
Gc22_694 0 n44 ns694 0 -6.40257173625e-05
Gc22_695 0 n44 ns695 0 0.00186150386269
Gc22_696 0 n44 ns696 0 -2.42939428104e-06
Gc22_697 0 n44 ns697 0 -0.000143077733815
Gc22_698 0 n44 ns698 0 -0.000125842521062
Gc22_699 0 n44 ns699 0 -0.000312802183467
Gc22_700 0 n44 ns700 0 0.000999055190309
Gc22_701 0 n44 ns701 0 0.000894378539006
Gc22_702 0 n44 ns702 0 -0.000330797253217
Gc22_703 0 n44 ns703 0 -9.57863965041e-05
Gc22_704 0 n44 ns704 0 0.000221988253514
Gc22_705 0 n44 ns705 0 -0.00012792603628
Gc22_706 0 n44 ns706 0 0.00156830555064
Gc22_707 0 n44 ns707 0 0.000522214506773
Gc22_708 0 n44 ns708 0 0.000301805678603
Gc22_709 0 n44 ns709 0 0.000756071561689
Gc22_710 0 n44 ns710 0 -0.000133258931342
Gc22_711 0 n44 ns711 0 -0.000979827381979
Gc22_712 0 n44 ns712 0 0.00120669996815
Gc22_713 0 n44 ns713 0 -0.0005153191318
Gc22_714 0 n44 ns714 0 -0.000424595098022
Gc22_715 0 n44 ns715 0 0.00143730116746
Gc22_716 0 n44 ns716 0 0.000779428451286
Gc22_717 0 n44 ns717 0 -0.000667038262891
Gc22_718 0 n44 ns718 0 0.0272916320825
Gc22_719 0 n44 ns719 0 -0.0247257432439
Gc22_720 0 n44 ns720 0 0.00122766066438
Gc22_721 0 n44 ns721 0 -7.11741827008e-06
Gc22_722 0 n44 ns722 0 -1.90138904813e-05
Gc22_723 0 n44 ns723 0 -0.00148890602752
Gc22_724 0 n44 ns724 0 0.0011438525069
Gc22_725 0 n44 ns725 0 -0.00344431111206
Gc22_726 0 n44 ns726 0 0.000331320729878
Gc22_727 0 n44 ns727 0 -0.00058368154145
Gc22_728 0 n44 ns728 0 0.000281016046484
Gc22_729 0 n44 ns729 0 -0.000181420469633
Gc22_730 0 n44 ns730 0 -4.67489092458e-05
Gc22_731 0 n44 ns731 0 3.50409458932e-05
Gc22_732 0 n44 ns732 0 -0.00143454880896
Gc22_733 0 n44 ns733 0 0.000989624219289
Gc22_734 0 n44 ns734 0 0.000117761642981
Gc22_735 0 n44 ns735 0 -0.000505190520227
Gc22_736 0 n44 ns736 0 5.19378499412e-05
Gc22_737 0 n44 ns737 0 -0.000370522117808
Gc22_738 0 n44 ns738 0 -0.00142213334109
Gc22_739 0 n44 ns739 0 0.00121916530628
Gc22_740 0 n44 ns740 0 0.000208597978979
Gc22_741 0 n44 ns741 0 -2.65913145737e-05
Gc22_742 0 n44 ns742 0 0.000400786140012
Gc22_743 0 n44 ns743 0 -2.67489308712e-05
Gc22_744 0 n44 ns744 0 0.000820530401179
Gc22_745 0 n44 ns745 0 0.0038437922116
Gc22_746 0 n44 ns746 0 0.00078302290076
Gc22_747 0 n44 ns747 0 0.000211332670641
Gc22_748 0 n44 ns748 0 -5.53951290132e-05
Gc22_749 0 n44 ns749 0 -0.00120371032254
Gc22_750 0 n44 ns750 0 0.00356520822213
Gc22_751 0 n44 ns751 0 0.00211964820783
Gc22_752 0 n44 ns752 0 -0.00158844888553
Gc22_753 0 n44 ns753 0 0.000423204398436
Gc22_754 0 n44 ns754 0 0.00126138274364
Gc22_755 0 n44 ns755 0 -0.000439161447374
Gc22_756 0 n44 ns756 0 0.053834267819
Gc22_757 0 n44 ns757 0 -0.0498084595393
Gc22_758 0 n44 ns758 0 0.00288449787598
Gc22_759 0 n44 ns759 0 -3.00388203792e-06
Gc22_760 0 n44 ns760 0 -1.79218003947e-05
Gc22_761 0 n44 ns761 0 -0.00236188383735
Gc22_762 0 n44 ns762 0 -0.00131645882799
Gc22_763 0 n44 ns763 0 0.00148333999104
Gc22_764 0 n44 ns764 0 0.000152438471077
Gc22_765 0 n44 ns765 0 -0.000435579777348
Gc22_766 0 n44 ns766 0 0.000429004228623
Gc22_767 0 n44 ns767 0 0.00049551572873
Gc22_768 0 n44 ns768 0 -0.000149440042169
Gc22_769 0 n44 ns769 0 -5.13706011596e-05
Gc22_770 0 n44 ns770 0 -0.000456163424392
Gc22_771 0 n44 ns771 0 0.00038959652899
Gc22_772 0 n44 ns772 0 0.000716126232372
Gc22_773 0 n44 ns773 0 -0.00012766718166
Gc22_774 0 n44 ns774 0 0.000301852559148
Gc22_775 0 n44 ns775 0 -0.000427956752405
Gc22_776 0 n44 ns776 0 0.000480767771181
Gc22_777 0 n44 ns777 0 -0.0016215866569
Gc22_778 0 n44 ns778 0 -0.00029716079837
Gc22_779 0 n44 ns779 0 -0.000140500261081
Gc22_780 0 n44 ns780 0 0.000344662164335
Gc22_781 0 n44 ns781 0 0.000187438619113
Gc22_782 0 n44 ns782 0 -0.00295237231392
Gc22_783 0 n44 ns783 0 -0.000802072460246
Gc22_784 0 n44 ns784 0 0.000911179895246
Gc22_785 0 n44 ns785 0 0.00112518540359
Gc22_786 0 n44 ns786 0 0.000659650038263
Gc22_787 0 n44 ns787 0 -0.00147254839726
Gc22_788 0 n44 ns788 0 -0.0041395252428
Gc22_789 0 n44 ns789 0 -0.000915455343434
Gc22_790 0 n44 ns790 0 -0.00122592429975
Gc22_791 0 n44 ns791 0 0.000482002165946
Gc22_792 0 n44 ns792 0 0.00230164041305
Gc22_793 0 n44 ns793 0 0.000237505841407
Gc22_794 0 n44 ns794 0 0.0297395661294
Gc22_795 0 n44 ns795 0 -0.0356989088291
Gc22_796 0 n44 ns796 0 0.0056785863611
Gc22_797 0 n44 ns797 0 1.12680229968e-06
Gc22_798 0 n44 ns798 0 -2.93699707697e-06
Gc22_799 0 n44 ns799 0 -0.00309330509765
Gc22_800 0 n44 ns800 0 0.000140889442279
Gc22_801 0 n44 ns801 0 -0.0029443320434
Gc22_802 0 n44 ns802 0 8.98091524994e-05
Gc22_803 0 n44 ns803 0 -0.000265502789942
Gc22_804 0 n44 ns804 0 0.000426378108537
Gc22_805 0 n44 ns805 0 -0.000196689094967
Gc22_806 0 n44 ns806 0 -0.000220843083141
Gc22_807 0 n44 ns807 0 -8.86159830948e-05
Gc22_808 0 n44 ns808 0 -0.00376586044331
Gc22_809 0 n44 ns809 0 0.00225513714114
Gc22_810 0 n44 ns810 0 0.00141909883998
Gc22_811 0 n44 ns811 0 -0.000369526645588
Gc22_812 0 n44 ns812 0 0.000358887023886
Gc22_813 0 n44 ns813 0 -0.000592035994564
Gc22_814 0 n44 ns814 0 1.36159370743e-05
Gc22_815 0 n44 ns815 0 0.00155492292851
Gc22_816 0 n44 ns816 0 0.000676368294761
Gc22_817 0 n44 ns817 0 0.000298081643007
Gc22_818 0 n44 ns818 0 0.000592264760194
Gc22_819 0 n44 ns819 0 0.000144773022466
Gc22_820 0 n44 ns820 0 0.00123940844979
Gc22_821 0 n44 ns821 0 0.00103022951295
Gc22_822 0 n44 ns822 0 0.00150347076409
Gc22_823 0 n44 ns823 0 0.00261796471563
Gc22_824 0 n44 ns824 0 0.00114270013104
Gc22_825 0 n44 ns825 0 -0.0021422078336
Gc22_826 0 n44 ns826 0 0.000142834387999
Gc22_827 0 n44 ns827 0 -0.00285304369329
Gc22_828 0 n44 ns828 0 0.00201117814804
Gc22_829 0 n44 ns829 0 0.00176090246068
Gc22_830 0 n44 ns830 0 0.00318427973471
Gc22_831 0 n44 ns831 0 3.4895184347e-05
Gc22_832 0 n44 ns832 0 -0.0196386943956
Gc22_833 0 n44 ns833 0 0.0201126795379
Gc22_834 0 n44 ns834 0 0.00702227169487
Gc22_835 0 n44 ns835 0 1.0153221706e-05
Gc22_836 0 n44 ns836 0 9.6019484904e-06
Gc22_837 0 n44 ns837 0 -0.00192923634553
Gc22_838 0 n44 ns838 0 -0.00228666812831
Gc22_839 0 n44 ns839 0 0.00514070967589
Gc22_840 0 n44 ns840 0 0.000416019287424
Gc22_841 0 n44 ns841 0 -0.000424436403351
Gc22_842 0 n44 ns842 0 0.000602592361126
Gc22_843 0 n44 ns843 0 0.000436781177998
Gc22_844 0 n44 ns844 0 -0.000151666392922
Gc22_845 0 n44 ns845 0 -8.93597549274e-05
Gc22_846 0 n44 ns846 0 -0.00173014952495
Gc22_847 0 n44 ns847 0 -0.000346632409249
Gc22_848 0 n44 ns848 0 0.00128568657139
Gc22_849 0 n44 ns849 0 1.84144389191e-05
Gc22_850 0 n44 ns850 0 0.000341180381167
Gc22_851 0 n44 ns851 0 -0.00056994844011
Gc22_852 0 n44 ns852 0 -0.000102708866152
Gc22_853 0 n44 ns853 0 -0.00221878583513
Gc22_854 0 n44 ns854 0 -0.000456029018144
Gc22_855 0 n44 ns855 0 0.000264215414215
Gc22_856 0 n44 ns856 0 0.000429517680736
Gc22_857 0 n44 ns857 0 0.000244305140751
Gc22_858 0 n44 ns858 0 -0.00418766041535
Gc22_859 0 n44 ns859 0 -0.000856892756934
Gc22_860 0 n44 ns860 0 0.000876942552775
Gc22_861 0 n44 ns861 0 0.00165522505551
Gc22_862 0 n44 ns862 0 0.000855759335791
Gc22_863 0 n44 ns863 0 -0.0017033821918
Gc22_864 0 n44 ns864 0 -0.00573527166553
Gc22_865 0 n44 ns865 0 -0.00118733854537
Gc22_866 0 n44 ns866 0 -0.00119454290829
Gc22_867 0 n44 ns867 0 0.000889296013927
Gc22_868 0 n44 ns868 0 0.00246424757226
Gc22_869 0 n44 ns869 0 0.000238688109783
Gc22_870 0 n44 ns870 0 0.0189555844949
Gc22_871 0 n44 ns871 0 -0.0269271787198
Gc22_872 0 n44 ns872 0 0.00543790519104
Gc22_873 0 n44 ns873 0 2.69804442521e-06
Gc22_874 0 n44 ns874 0 1.59454348662e-05
Gc22_875 0 n44 ns875 0 -0.00122811624687
Gc22_876 0 n44 ns876 0 0.000733658247367
Gc22_877 0 n44 ns877 0 -0.00020353014317
Gc22_878 0 n44 ns878 0 0.000557635519319
Gc22_879 0 n44 ns879 0 -0.000584840610893
Gc22_880 0 n44 ns880 0 0.000328978504522
Gc22_881 0 n44 ns881 0 -0.000158474743752
Gc22_882 0 n44 ns882 0 -4.03937004393e-05
Gc22_883 0 n44 ns883 0 3.3428352977e-05
Gc22_884 0 n44 ns884 0 -0.00201228148573
Gc22_885 0 n44 ns885 0 -0.000227459382435
Gc22_886 0 n44 ns886 0 0.000417259755078
Gc22_887 0 n44 ns887 0 2.99971040279e-05
Gc22_888 0 n44 ns888 0 0.00020339980276
Gc22_889 0 n44 ns889 0 -0.000486622254067
Gc22_890 0 n44 ns890 0 -0.00149996280188
Gc22_891 0 n44 ns891 0 0.000137117960395
Gc22_892 0 n44 ns892 0 -0.000378736777752
Gc22_893 0 n44 ns893 0 0.000297159520182
Gc22_894 0 n44 ns894 0 0.000471473834416
Gc22_895 0 n44 ns895 0 0.000135172354067
Gc22_896 0 n44 ns896 0 -0.000823672153683
Gc22_897 0 n44 ns897 0 0.00317351316029
Gc22_898 0 n44 ns898 0 0.000399005436573
Gc22_899 0 n44 ns899 0 0.00101812508765
Gc22_900 0 n44 ns900 0 0.000414021065509
Gc22_901 0 n44 ns901 0 -0.00146511169554
Gc22_902 0 n44 ns902 0 0.0014766859653
Gc22_903 0 n44 ns903 0 0.00171599334504
Gc22_904 0 n44 ns904 0 -0.0015646956724
Gc22_905 0 n44 ns905 0 0.000917322699043
Gc22_906 0 n44 ns906 0 0.00147565378906
Gc22_907 0 n44 ns907 0 -0.000423228761401
Gc22_908 0 n44 ns908 0 0.0410287458505
Gc22_909 0 n44 ns909 0 -0.0394509598997
Gc22_910 0 n44 ns910 0 0.00262434233489
Gc22_911 0 n44 ns911 0 -1.66401669312e-06
Gc22_912 0 n44 ns912 0 1.3057080039e-05
Gc22_913 0 n44 ns913 0 -0.00126190178091
Gc22_914 0 n44 ns914 0 0.00270590819887
Gc22_915 0 n44 ns915 0 -0.00441754989142
Gc22_916 0 n44 ns916 0 -0.000190984517851
Gc22_917 0 n44 ns917 0 -0.000366360152986
Gc22_918 0 n44 ns918 0 -0.000453060233025
Gc22_919 0 n44 ns919 0 -0.00012078454347
Gc22_920 0 n44 ns920 0 -2.88162500396e-05
Gc22_921 0 n44 ns921 0 2.13846722339e-06
Gc22_922 0 n44 ns922 0 0.000738385505366
Gc22_923 0 n44 ns923 0 0.00194885308881
Gc22_924 0 n44 ns924 0 -0.000589531080921
Gc22_925 0 n44 ns925 0 0.000158324123484
Gc22_926 0 n44 ns926 0 6.29511663079e-05
Gc22_927 0 n44 ns927 0 -0.000247463384062
Gc22_928 0 n44 ns928 0 0.00220340120299
Gc22_929 0 n44 ns929 0 0.00101266949259
Gc22_930 0 n44 ns930 0 -0.000867328267165
Gc22_931 0 n44 ns931 0 -0.000726612498399
Gc22_932 0 n44 ns932 0 0.000121637018742
Gc22_933 0 n44 ns933 0 2.58508462597e-05
Gc22_934 0 n44 ns934 0 0.00164048567986
Gc22_935 0 n44 ns935 0 -0.000694560594301
Gc22_936 0 n44 ns936 0 -0.000666501633401
Gc22_937 0 n44 ns937 0 0.000951714735917
Gc22_938 0 n44 ns938 0 0.000471407046343
Gc22_939 0 n44 ns939 0 -0.000816036866422
Gc22_940 0 n44 ns940 0 0.00090597226728
Gc22_941 0 n44 ns941 0 -0.00108916693655
Gc22_942 0 n44 ns942 0 -0.000725003866147
Gc22_943 0 n44 ns943 0 0.00145038664082
Gc22_944 0 n44 ns944 0 0.000870841873921
Gc22_945 0 n44 ns945 0 -0.000505804885426
Gc22_946 0 n44 ns946 0 0.0225076131758
Gc22_947 0 n44 ns947 0 -0.0206371238713
Gc22_948 0 n44 ns948 0 0.00112797540606
Gc22_949 0 n44 ns949 0 -9.79938242953e-06
Gc22_950 0 n44 ns950 0 1.39355368186e-05
Gc22_951 0 n44 ns951 0 -0.000424980192599
Gc22_952 0 n44 ns952 0 0.000886338696447
Gc22_953 0 n44 ns953 0 -0.00129108977203
Gc22_954 0 n44 ns954 0 -9.56905024479e-05
Gc22_955 0 n44 ns955 0 -3.91429106244e-05
Gc22_956 0 n44 ns956 0 -0.000112097143816
Gc22_957 0 n44 ns957 0 -2.46030486055e-05
Gc22_958 0 n44 ns958 0 -2.87799250974e-05
Gc22_959 0 n44 ns959 0 -2.1928074778e-05
Gc22_960 0 n44 ns960 0 -0.000346236516652
Gc22_961 0 n44 ns961 0 0.00091715021262
Gc22_962 0 n44 ns962 0 0.000392653010761
Gc22_963 0 n44 ns963 0 7.74903242208e-05
Gc22_964 0 n44 ns964 0 -0.000120614928828
Gc22_965 0 n44 ns965 0 -0.000318618429328
Gc22_966 0 n44 ns966 0 0.000598131224771
Gc22_967 0 n44 ns967 0 -0.00011579180266
Gc22_968 0 n44 ns968 0 -0.000417454388755
Gc22_969 0 n44 ns969 0 0.000372214026234
Gc22_970 0 n44 ns970 0 0.000225837339177
Gc22_971 0 n44 ns971 0 -9.38896166763e-05
Gc22_972 0 n44 ns972 0 0.000348512816625
Gc22_973 0 n44 ns973 0 0.000160849444514
Gc22_974 0 n44 ns974 0 0.000483774675608
Gc22_975 0 n44 ns975 0 0.000999074010086
Gc22_976 0 n44 ns976 0 -0.000171236504639
Gc22_977 0 n44 ns977 0 -0.000970883242397
Gc22_978 0 n44 ns978 0 -0.000269133187388
Gc22_979 0 n44 ns979 0 -0.000353502506239
Gc22_980 0 n44 ns980 0 5.87036493951e-05
Gc22_981 0 n44 ns981 0 0.00144988821259
Gc22_982 0 n44 ns982 0 0.000633612573029
Gc22_983 0 n44 ns983 0 -0.000675856934749
Gc22_984 0 n44 ns984 0 0.0179177675631
Gc22_985 0 n44 ns985 0 -0.0166466744962
Gc22_986 0 n44 ns986 0 0.000874765517284
Gc22_987 0 n44 ns987 0 -6.63043561625e-06
Gc22_988 0 n44 ns988 0 -1.83472857442e-05
Gc22_989 0 n44 ns989 0 -0.00115055794163
Gc22_990 0 n44 ns990 0 0.00217802367464
Gc22_991 0 n44 ns991 0 -0.00466995369523
Gc22_992 0 n44 ns992 0 -3.02596262569e-05
Gc22_993 0 n44 ns993 0 -0.000276621167676
Gc22_994 0 n44 ns994 0 0.000104297970839
Gc22_995 0 n44 ns995 0 -0.000361192153083
Gc22_996 0 n44 ns996 0 -2.03425110971e-05
Gc22_997 0 n44 ns997 0 2.08473699845e-05
Gc22_998 0 n44 ns998 0 -0.00102724902715
Gc22_999 0 n44 ns999 0 0.00153965566912
Gc22_1000 0 n44 ns1000 0 -6.2984712955e-05
Gc22_1001 0 n44 ns1001 0 -0.000375393351407
Gc22_1002 0 n44 ns1002 0 -3.60032540842e-05
Gc22_1003 0 n44 ns1003 0 -0.0003193245826
Gc22_1004 0 n44 ns1004 0 -0.000471304788778
Gc22_1005 0 n44 ns1005 0 0.00176471985115
Gc22_1006 0 n44 ns1006 0 0.000131570363366
Gc22_1007 0 n44 ns1007 0 -0.000169588914239
Gc22_1008 0 n44 ns1008 0 0.000324120514298
Gc22_1009 0 n44 ns1009 0 -0.000100464382833
Gc22_1010 0 n44 ns1010 0 0.00200449251639
Gc22_1011 0 n44 ns1011 0 0.00286761705988
Gc22_1012 0 n44 ns1012 0 0.000504656669853
Gc22_1013 0 n44 ns1013 0 0.000253476387491
Gc22_1014 0 n44 ns1014 0 -0.000124065243336
Gc22_1015 0 n44 ns1015 0 -0.00105449345046
Gc22_1016 0 n44 ns1016 0 0.00362665483444
Gc22_1017 0 n44 ns1017 0 0.000811077788247
Gc22_1018 0 n44 ns1018 0 -0.00134026165656
Gc22_1019 0 n44 ns1019 0 0.000878108310372
Gc22_1020 0 n44 ns1020 0 0.00105059300415
Gc22_1021 0 n44 ns1021 0 -0.000531819679304
Gc22_1022 0 n44 ns1022 0 0.045150258154
Gc22_1023 0 n44 ns1023 0 -0.0408894939173
Gc22_1024 0 n44 ns1024 0 0.00209643607092
Gc22_1025 0 n44 ns1025 0 -5.36334312859e-06
Gc22_1026 0 n44 ns1026 0 -1.99961620816e-05
Gc22_1027 0 n44 ns1027 0 -0.00225385164863
Gc22_1028 0 n44 ns1028 0 0.000329147457856
Gc22_1029 0 n44 ns1029 0 -0.0010638890992
Gc22_1030 0 n44 ns1030 0 0.000399133324744
Gc22_1031 0 n44 ns1031 0 -0.000371475985757
Gc22_1032 0 n44 ns1032 0 0.000505433776441
Gc22_1033 0 n44 ns1033 0 0.00046136607719
Gc22_1034 0 n44 ns1034 0 -0.000135568750624
Gc22_1035 0 n44 ns1035 0 -1.64214826122e-05
Gc22_1036 0 n44 ns1036 0 -0.000183252488751
Gc22_1037 0 n44 ns1037 0 -3.14600076208e-05
Gc22_1038 0 n44 ns1038 0 0.000473937855809
Gc22_1039 0 n44 ns1039 0 -0.000308277324082
Gc22_1040 0 n44 ns1040 0 0.000178847491191
Gc22_1041 0 n44 ns1041 0 -0.00041579705297
Gc22_1042 0 n44 ns1042 0 -0.000657077895322
Gc22_1043 0 n44 ns1043 0 -0.00151142718588
Gc22_1044 0 n44 ns1044 0 -0.000336162943237
Gc22_1045 0 n44 ns1045 0 -1.96791785459e-06
Gc22_1046 0 n44 ns1046 0 0.000335812056004
Gc22_1047 0 n44 ns1047 0 0.00014670597028
Gc22_1048 0 n44 ns1048 0 -0.00277554482284
Gc22_1049 0 n44 ns1049 0 0.00159789119195
Gc22_1050 0 n44 ns1050 0 0.00088499518502
Gc22_1051 0 n44 ns1051 0 0.000720036471695
Gc22_1052 0 n44 ns1052 0 0.000391312882936
Gc22_1053 0 n44 ns1053 0 -0.00134674388683
Gc22_1054 0 n44 ns1054 0 -0.000648938264721
Gc22_1055 0 n44 ns1055 0 0.0020881029045
Gc22_1056 0 n44 ns1056 0 -0.00168891514435
Gc22_1057 0 n44 ns1057 0 -7.93531815729e-06
Gc22_1058 0 n44 ns1058 0 0.00183109603426
Gc22_1059 0 n44 ns1059 0 1.33103998195e-05
Gc22_1060 0 n44 ns1060 0 0.0520780207744
Gc22_1061 0 n44 ns1061 0 -0.0531135526927
Gc22_1062 0 n44 ns1062 0 0.00473052242541
Gc22_1063 0 n44 ns1063 0 1.47395436121e-06
Gc22_1064 0 n44 ns1064 0 -9.75155631077e-06
Gc22_1065 0 n44 ns1065 0 -0.00524277288213
Gc22_1066 0 n44 ns1066 0 -0.000164947504899
Gc22_1067 0 n44 ns1067 0 -0.00665874809564
Gc22_1068 0 n44 ns1068 0 7.51804199148e-07
Gc22_1069 0 n44 ns1069 0 -0.00103041089632
Gc22_1070 0 n44 ns1070 0 -0.000113367288584
Gc22_1071 0 n44 ns1071 0 0.000279970392512
Gc22_1072 0 n44 ns1072 0 -0.000103292878366
Gc22_1073 0 n44 ns1073 0 -1.31726968875e-05
Gc22_1074 0 n44 ns1074 0 -0.0016515050453
Gc22_1075 0 n44 ns1075 0 0.00306928218729
Gc22_1076 0 n44 ns1076 0 0.000680276626344
Gc22_1077 0 n44 ns1077 0 -0.000613494463711
Gc22_1078 0 n44 ns1078 0 0.000207317342774
Gc22_1079 0 n44 ns1079 0 -0.000452282585385
Gc22_1080 0 n44 ns1080 0 0.000288257173351
Gc22_1081 0 n44 ns1081 0 0.00185268058349
Gc22_1082 0 n44 ns1082 0 0.000700894027313
Gc22_1083 0 n44 ns1083 0 -3.91281007853e-05
Gc22_1084 0 n44 ns1084 0 0.000505335358055
Gc22_1085 0 n44 ns1085 0 8.00305439244e-05
Gc22_1086 0 n44 ns1086 0 0.00231012845749
Gc22_1087 0 n44 ns1087 0 0.00183387284151
Gc22_1088 0 n44 ns1088 0 0.00138448600709
Gc22_1089 0 n44 ns1089 0 0.00224656882463
Gc22_1090 0 n44 ns1090 0 0.00103617156299
Gc22_1091 0 n44 ns1091 0 -0.00196883999596
Gc22_1092 0 n44 ns1092 0 0.00351245206724
Gc22_1093 0 n44 ns1093 0 -0.00140277059579
Gc22_1094 0 n44 ns1094 0 0.00180692994922
Gc22_1095 0 n44 ns1095 0 0.00109661961998
Gc22_1096 0 n44 ns1096 0 0.00291213867876
Gc22_1097 0 n44 ns1097 0 2.25954473874e-05
Gc22_1098 0 n44 ns1098 0 -0.00634141733538
Gc22_1099 0 n44 ns1099 0 0.0106609902073
Gc22_1100 0 n44 ns1100 0 0.007118494701
Gc22_1101 0 n44 ns1101 0 -1.55458353484e-06
Gc22_1102 0 n44 ns1102 0 -4.10850827096e-06
Gc22_1103 0 n44 ns1103 0 -0.00494149707082
Gc22_1104 0 n44 ns1104 0 -0.00122678868428
Gc22_1105 0 n44 ns1105 0 -0.00374363330729
Gc22_1106 0 n44 ns1106 0 0.000367119951205
Gc22_1107 0 n44 ns1107 0 -0.00125025731287
Gc22_1108 0 n44 ns1108 0 -7.80300666659e-05
Gc22_1109 0 n44 ns1109 0 0.000819815221711
Gc22_1110 0 n44 ns1110 0 -0.000115253897108
Gc22_1111 0 n44 ns1111 0 -7.77579355895e-05
Gc22_1112 0 n44 ns1112 0 -0.000874968227427
Gc22_1113 0 n44 ns1113 0 0.00204316299797
Gc22_1114 0 n44 ns1114 0 0.00101099726776
Gc22_1115 0 n44 ns1115 0 -0.000529001063261
Gc22_1116 0 n44 ns1116 0 0.000201867610875
Gc22_1117 0 n44 ns1117 0 -0.000545794894521
Gc22_1118 0 n44 ns1118 0 0.00032693950094
Gc22_1119 0 n44 ns1119 0 -0.000704848881164
Gc22_1120 0 n44 ns1120 0 0.000122100479036
Gc22_1121 0 n44 ns1121 0 7.59637640201e-05
Gc22_1122 0 n44 ns1122 0 0.000458278745863
Gc22_1123 0 n44 ns1123 0 0.000142799378819
Gc22_1124 0 n44 ns1124 0 -0.00138620486484
Gc22_1125 0 n44 ns1125 0 0.0010882866687
Gc22_1126 0 n44 ns1126 0 0.00160072171109
Gc22_1127 0 n44 ns1127 0 0.00187299348214
Gc22_1128 0 n44 ns1128 0 0.000780481265338
Gc22_1129 0 n44 ns1129 0 -0.00198989431784
Gc22_1130 0 n44 ns1130 0 0.000815510879256
Gc22_1131 0 n44 ns1131 0 0.000980555171222
Gc22_1132 0 n44 ns1132 0 0.000221794294424
Gc22_1133 0 n44 ns1133 0 -2.45285023661e-05
Gc22_1134 0 n44 ns1134 0 0.00246357523172
Gc22_1135 0 n44 ns1135 0 8.32679298574e-05
Gc22_1136 0 n44 ns1136 0 0.0275789033229
Gc22_1137 0 n44 ns1137 0 -0.0264882374395
Gc22_1138 0 n44 ns1138 0 0.00664187781121
Gc22_1139 0 n44 ns1139 0 -3.73259460217e-06
Gc22_1140 0 n44 ns1140 0 7.48228306884e-06
Gc22_1141 0 n44 ns1141 0 -0.00139140071344
Gc22_1142 0 n44 ns1142 0 2.97550529023e-06
Gc22_1143 0 n44 ns1143 0 0.00144665400007
Gc22_1144 0 n44 ns1144 0 0.000729697846432
Gc22_1145 0 n44 ns1145 0 -0.000527694773332
Gc22_1146 0 n44 ns1146 0 0.000680469765852
Gc22_1147 0 n44 ns1147 0 -6.02140511598e-06
Gc22_1148 0 n44 ns1148 0 -0.00011724761134
Gc22_1149 0 n44 ns1149 0 7.36779162829e-06
Gc22_1150 0 n44 ns1150 0 -0.002669968149
Gc22_1151 0 n44 ns1151 0 -0.000718533803854
Gc22_1152 0 n44 ns1152 0 0.00101590842675
Gc22_1153 0 n44 ns1153 0 -0.000141114305012
Gc22_1154 0 n44 ns1154 0 0.00025591495858
Gc22_1155 0 n44 ns1155 0 -0.000587399799016
Gc22_1156 0 n44 ns1156 0 -0.00215441008263
Gc22_1157 0 n44 ns1157 0 -0.000806775370964
Gc22_1158 0 n44 ns1158 0 -0.000225208769483
Gc22_1159 0 n44 ns1159 0 0.000518878635557
Gc22_1160 0 n44 ns1160 0 0.000535985775671
Gc22_1161 0 n44 ns1161 0 0.000173256374202
Gc22_1162 0 n44 ns1162 0 -0.00236325592379
Gc22_1163 0 n44 ns1163 0 0.00320673538192
Gc22_1164 0 n44 ns1164 0 0.000799900697062
Gc22_1165 0 n44 ns1165 0 0.00105254647183
Gc22_1166 0 n44 ns1166 0 0.000441479246055
Gc22_1167 0 n44 ns1167 0 -0.00162368503392
Gc22_1168 0 n44 ns1168 0 4.83295860363e-06
Gc22_1169 0 n44 ns1169 0 0.00191223076598
Gc22_1170 0 n44 ns1170 0 -0.00169173906956
Gc22_1171 0 n44 ns1171 0 0.000702288896471
Gc22_1172 0 n44 ns1172 0 0.00178064593669
Gc22_1173 0 n44 ns1173 0 -0.000261662520869
Gc22_1174 0 n44 ns1174 0 0.0410742983365
Gc22_1175 0 n44 ns1175 0 -0.0415566902862
Gc22_1176 0 n44 ns1176 0 0.00350104823882
Gc22_1177 0 n44 ns1177 0 6.77264298688e-08
Gc22_1178 0 n44 ns1178 0 1.3010171356e-05
Gc22_1179 0 n44 ns1179 0 -0.00128710348105
Gc22_1180 0 n44 ns1180 0 0.00259019842846
Gc22_1181 0 n44 ns1181 0 -0.00362931469936
Gc22_1182 0 n44 ns1182 0 -5.80050173914e-05
Gc22_1183 0 n44 ns1183 0 -0.000321751403331
Gc22_1184 0 n44 ns1184 0 -0.000165628983896
Gc22_1185 0 n44 ns1185 0 -0.000235209476729
Gc22_1186 0 n44 ns1186 0 -3.58066562905e-05
Gc22_1187 0 n44 ns1187 0 7.31501815597e-06
Gc22_1188 0 n44 ns1188 0 -0.000163610311002
Gc22_1189 0 n44 ns1189 0 0.00143971116392
Gc22_1190 0 n44 ns1190 0 -0.000350331196897
Gc22_1191 0 n44 ns1191 0 0.000156862832208
Gc22_1192 0 n44 ns1192 0 0.000122910025624
Gc22_1193 0 n44 ns1193 0 -0.000353627551603
Gc22_1194 0 n44 ns1194 0 0.00138060939873
Gc22_1195 0 n44 ns1195 0 0.0010772844474
Gc22_1196 0 n44 ns1196 0 -0.000804113177825
Gc22_1197 0 n44 ns1197 0 -0.00056664729105
Gc22_1198 0 n44 ns1198 0 0.000233517372607
Gc22_1199 0 n44 ns1199 0 5.06497252846e-05
Gc22_1200 0 n44 ns1200 0 0.00131200833921
Gc22_1201 0 n44 ns1201 0 0.00024306381309
Gc22_1202 0 n44 ns1202 0 -0.000545725732107
Gc22_1203 0 n44 ns1203 0 0.00106146440452
Gc22_1204 0 n44 ns1204 0 0.000530753150852
Gc22_1205 0 n44 ns1205 0 -0.00105772855766
Gc22_1206 0 n44 ns1206 0 0.00105506286185
Gc22_1207 0 n44 ns1207 0 -0.000692256375968
Gc22_1208 0 n44 ns1208 0 -0.00101738267625
Gc22_1209 0 n44 ns1209 0 0.00158867259678
Gc22_1210 0 n44 ns1210 0 0.00112282926664
Gc22_1211 0 n44 ns1211 0 -0.000556754591798
Gc22_1212 0 n44 ns1212 0 0.0277725366554
Gc22_1213 0 n44 ns1213 0 -0.0259251784491
Gc22_1214 0 n44 ns1214 0 0.00152083139153
Gc22_1215 0 n44 ns1215 0 -7.38208501313e-06
Gc22_1216 0 n44 ns1216 0 1.56634780276e-05
Gd22_1 0 n44 ni1 0 3.14713446582e-05
Gd22_2 0 n44 ni2 0 8.35682232509e-05
Gd22_3 0 n44 ni3 0 0.000188167929706
Gd22_4 0 n44 ni4 0 0.000609404283305
Gd22_5 0 n44 ni5 0 -0.000348001043502
Gd22_6 0 n44 ni6 0 -0.00687711324397
Gd22_7 0 n44 ni7 0 -0.000461109291417
Gd22_8 0 n44 ni8 0 0.000519582525849
Gd22_9 0 n44 ni9 0 0.000270606672779
Gd22_10 0 n44 ni10 0 0.000203594610998
Gd22_11 0 n44 ni11 0 0.000238414556462
Gd22_12 0 n44 ni12 0 -0.000104448929016
Gd22_13 0 n44 ni13 0 -0.00303353522429
Gd22_14 0 n44 ni14 0 -0.00168966135202
Gd22_15 0 n44 ni15 0 -7.36329540135e-05
Gd22_16 0 n44 ni16 0 0.000246886958378
Gd22_17 0 n44 ni17 0 0.000195149314465
Gd22_18 0 n44 ni18 0 3.1791259731e-05
Gd22_19 0 n44 ni19 0 0.000200043347847
Gd22_20 0 n44 ni20 0 -0.000467956414773
Gd22_21 0 n44 ni21 0 -0.001906063968
Gd22_22 0 n44 ni22 0 0.000670608038888
Gd22_23 0 n44 ni23 0 -0.00177973499624
Gd22_24 0 n44 ni24 0 -0.000293742224784
Gd22_25 0 n44 ni25 0 0.000236254973947
Gd22_26 0 n44 ni26 0 0.000158797238699
Gd22_27 0 n44 ni27 0 9.94962509876e-05
Gd22_28 0 n44 ni28 0 -0.00125493114741
Gd22_29 0 n44 ni29 0 -0.00112468963507
Gd22_30 0 n44 ni30 0 -0.00277753622144
Gd22_31 0 n44 ni31 0 -0.000713176792903
Gd22_32 0 n44 ni32 0 0.000228911399899
Gc23_1 0 n46 ns1 0 4.83623416241e-05
Gc23_2 0 n46 ns2 0 -0.000420642535332
Gc23_3 0 n46 ns3 0 0.000853666201123
Gc23_4 0 n46 ns4 0 -0.000128023034354
Gc23_5 0 n46 ns5 0 0.000169469228422
Gc23_6 0 n46 ns6 0 7.13261011478e-06
Gc23_7 0 n46 ns7 0 0.000128118464779
Gc23_8 0 n46 ns8 0 5.86351790986e-06
Gc23_9 0 n46 ns9 0 1.60241622385e-05
Gc23_10 0 n46 ns10 0 0.000434511671048
Gc23_11 0 n46 ns11 0 -0.00144655749499
Gc23_12 0 n46 ns12 0 -0.000283832444396
Gc23_13 0 n46 ns13 0 0.000800036521833
Gc23_14 0 n46 ns14 0 0.000272261722767
Gc23_15 0 n46 ns15 0 6.00295833464e-05
Gc23_16 0 n46 ns16 0 -0.000767024371399
Gc23_17 0 n46 ns17 0 9.99267659703e-05
Gc23_18 0 n46 ns18 0 0.000505903156391
Gc23_19 0 n46 ns19 0 0.000283730602591
Gc23_20 0 n46 ns20 0 3.56562417433e-05
Gc23_21 0 n46 ns21 0 -0.000170847420282
Gc23_22 0 n46 ns22 0 0.000256238356921
Gc23_23 0 n46 ns23 0 -0.000779769267832
Gc23_24 0 n46 ns24 0 -0.000874555368572
Gc23_25 0 n46 ns25 0 -4.72735976892e-05
Gc23_26 0 n46 ns26 0 0.000482381234012
Gc23_27 0 n46 ns27 0 0.000295220483024
Gc23_28 0 n46 ns28 0 -0.00141628561512
Gc23_29 0 n46 ns29 0 0.000162939658885
Gc23_30 0 n46 ns30 0 0.000496620789842
Gc23_31 0 n46 ns31 0 0.000510103274017
Gc23_32 0 n46 ns32 0 0.000125415725555
Gc23_33 0 n46 ns33 0 -0.000316933516381
Gc23_34 0 n46 ns34 0 0.000298485664825
Gc23_35 0 n46 ns35 0 -0.000420273154209
Gc23_36 0 n46 ns36 0 -3.71072248901e-05
Gc23_37 0 n46 ns37 0 7.43656592118e-06
Gc23_38 0 n46 ns38 0 -2.56256171665e-05
Gc23_39 0 n46 ns39 0 0.00020177993479
Gc23_40 0 n46 ns40 0 -0.000607631230695
Gc23_41 0 n46 ns41 0 0.00147661777998
Gc23_42 0 n46 ns42 0 -0.000104132922072
Gc23_43 0 n46 ns43 0 0.000204835119238
Gc23_44 0 n46 ns44 0 4.13154905332e-05
Gc23_45 0 n46 ns45 0 9.78490002029e-05
Gc23_46 0 n46 ns46 0 -4.75200641797e-06
Gc23_47 0 n46 ns47 0 -2.91900702504e-06
Gc23_48 0 n46 ns48 0 0.000558188948248
Gc23_49 0 n46 ns49 0 -0.00147287117249
Gc23_50 0 n46 ns50 0 -0.000404193572135
Gc23_51 0 n46 ns51 0 0.000755871238615
Gc23_52 0 n46 ns52 0 0.000284752694133
Gc23_53 0 n46 ns53 0 9.70109438126e-05
Gc23_54 0 n46 ns54 0 -0.000856854426616
Gc23_55 0 n46 ns55 0 -0.000185125431514
Gc23_56 0 n46 ns56 0 0.00045086897121
Gc23_57 0 n46 ns57 0 0.00046016122845
Gc23_58 0 n46 ns58 0 6.82900678159e-05
Gc23_59 0 n46 ns59 0 -0.000178508236245
Gc23_60 0 n46 ns60 0 0.000160146589067
Gc23_61 0 n46 ns61 0 -0.000963144022064
Gc23_62 0 n46 ns62 0 -0.00109295352187
Gc23_63 0 n46 ns63 0 -0.000101998499653
Gc23_64 0 n46 ns64 0 0.000602563163978
Gc23_65 0 n46 ns65 0 0.000409754211999
Gc23_66 0 n46 ns66 0 -0.00206385760256
Gc23_67 0 n46 ns67 0 5.65062432247e-05
Gc23_68 0 n46 ns68 0 0.000631658199719
Gc23_69 0 n46 ns69 0 0.000750510347883
Gc23_70 0 n46 ns70 0 0.000190389121816
Gc23_71 0 n46 ns71 0 -0.000409148039919
Gc23_72 0 n46 ns72 0 -0.00155673391244
Gc23_73 0 n46 ns73 0 0.00105283614814
Gc23_74 0 n46 ns74 0 -8.22760325382e-05
Gc23_75 0 n46 ns75 0 6.12115360174e-06
Gc23_76 0 n46 ns76 0 -2.82664027117e-05
Gc23_77 0 n46 ns77 0 0.000594652631911
Gc23_78 0 n46 ns78 0 -0.000747707887142
Gc23_79 0 n46 ns79 0 0.00341819534153
Gc23_80 0 n46 ns80 0 -0.000174314275569
Gc23_81 0 n46 ns81 0 0.00033961303896
Gc23_82 0 n46 ns82 0 0.000259881419076
Gc23_83 0 n46 ns83 0 -3.9422582227e-05
Gc23_84 0 n46 ns84 0 3.20812246583e-06
Gc23_85 0 n46 ns85 0 -4.87116806219e-05
Gc23_86 0 n46 ns86 0 0.000486570870016
Gc23_87 0 n46 ns87 0 -0.000565131403442
Gc23_88 0 n46 ns88 0 -0.000401347966502
Gc23_89 0 n46 ns89 0 -2.07740904189e-05
Gc23_90 0 n46 ns90 0 0.000131929507389
Gc23_91 0 n46 ns91 0 0.000181891118333
Gc23_92 0 n46 ns92 0 -1.39259319909e-05
Gc23_93 0 n46 ns93 0 -0.00124722435921
Gc23_94 0 n46 ns94 0 -0.00040883336849
Gc23_95 0 n46 ns95 0 0.000675878717334
Gc23_96 0 n46 ns96 0 0.000133867246948
Gc23_97 0 n46 ns97 0 -4.93953730116e-05
Gc23_98 0 n46 ns98 0 -0.000326372537212
Gc23_99 0 n46 ns99 0 -0.00141263729237
Gc23_100 0 n46 ns100 0 -0.00136700585915
Gc23_101 0 n46 ns101 0 -0.000593213378328
Gc23_102 0 n46 ns102 0 0.00066442535295
Gc23_103 0 n46 ns103 0 0.000893745116692
Gc23_104 0 n46 ns104 0 -0.00418249903802
Gc23_105 0 n46 ns105 0 -0.00126330461481
Gc23_106 0 n46 ns106 0 0.000635131844884
Gc23_107 0 n46 ns107 0 0.00186916331923
Gc23_108 0 n46 ns108 0 0.000606988905904
Gc23_109 0 n46 ns109 0 -0.000620440266784
Gc23_110 0 n46 ns110 0 -0.0115868060629
Gc23_111 0 n46 ns111 0 0.00921322974855
Gc23_112 0 n46 ns112 0 -0.00032766915715
Gc23_113 0 n46 ns113 0 3.60497154394e-06
Gc23_114 0 n46 ns114 0 -3.50357474978e-05
Gc23_115 0 n46 ns115 0 0.000517199415743
Gc23_116 0 n46 ns116 0 -0.000954704567575
Gc23_117 0 n46 ns117 0 0.00580303464897
Gc23_118 0 n46 ns118 0 -7.78911391954e-05
Gc23_119 0 n46 ns119 0 0.000334092928268
Gc23_120 0 n46 ns120 0 0.000368853507761
Gc23_121 0 n46 ns121 0 0.000138172207569
Gc23_122 0 n46 ns122 0 2.64877345816e-05
Gc23_123 0 n46 ns123 0 -6.17981537273e-06
Gc23_124 0 n46 ns124 0 -0.00063039641941
Gc23_125 0 n46 ns125 0 -0.00155858080283
Gc23_126 0 n46 ns126 0 0.000294675556798
Gc23_127 0 n46 ns127 0 0.000133595701701
Gc23_128 0 n46 ns128 0 0.000147032317822
Gc23_129 0 n46 ns129 0 0.000240529579524
Gc23_130 0 n46 ns130 0 0.000989177687263
Gc23_131 0 n46 ns131 0 -0.000605202081809
Gc23_132 0 n46 ns132 0 -0.000954723853422
Gc23_133 0 n46 ns133 0 -8.74927472711e-05
Gc23_134 0 n46 ns134 0 8.97371460895e-05
Gc23_135 0 n46 ns135 0 1.50318442143e-05
Gc23_136 0 n46 ns136 0 -0.00115682661756
Gc23_137 0 n46 ns137 0 -0.00243521600429
Gc23_138 0 n46 ns138 0 -0.00108035369989
Gc23_139 0 n46 ns139 0 -0.000951292321555
Gc23_140 0 n46 ns140 0 0.000360735067001
Gc23_141 0 n46 ns141 0 0.00134555736947
Gc23_142 0 n46 ns142 0 -0.00611359797874
Gc23_143 0 n46 ns143 0 -0.00358819164571
Gc23_144 0 n46 ns144 0 -0.000132218080303
Gc23_145 0 n46 ns145 0 0.00324891251035
Gc23_146 0 n46 ns146 0 0.00133150051682
Gc23_147 0 n46 ns147 0 -0.00068062222243
Gc23_148 0 n46 ns148 0 -0.0309134092398
Gc23_149 0 n46 ns149 0 0.0259110088584
Gc23_150 0 n46 ns150 0 -0.00102872436898
Gc23_151 0 n46 ns151 0 -4.13586104831e-06
Gc23_152 0 n46 ns152 0 -2.88069633784e-05
Gc23_153 0 n46 ns153 0 0.000787249034096
Gc23_154 0 n46 ns154 0 -0.00080606225334
Gc23_155 0 n46 ns155 0 0.0102874645532
Gc23_156 0 n46 ns156 0 2.08672226739e-05
Gc23_157 0 n46 ns157 0 0.000737625849496
Gc23_158 0 n46 ns158 0 0.000415801211713
Gc23_159 0 n46 ns159 0 -0.000128560841883
Gc23_160 0 n46 ns160 0 -8.66442626125e-05
Gc23_161 0 n46 ns161 0 -1.08134822684e-05
Gc23_162 0 n46 ns162 0 0.000133578125498
Gc23_163 0 n46 ns163 0 -0.00445435517008
Gc23_164 0 n46 ns164 0 0.000122174957345
Gc23_165 0 n46 ns165 0 0.00120895141091
Gc23_166 0 n46 ns166 0 0.000176777441602
Gc23_167 0 n46 ns167 0 0.000453267781084
Gc23_168 0 n46 ns168 0 -0.00114980545476
Gc23_169 0 n46 ns169 0 -0.000633050746947
Gc23_170 0 n46 ns170 0 -0.000403100086969
Gc23_171 0 n46 ns171 0 -4.8607864767e-06
Gc23_172 0 n46 ns172 0 0.000293693564104
Gc23_173 0 n46 ns173 0 6.03658729302e-05
Gc23_174 0 n46 ns174 0 -0.00224068884552
Gc23_175 0 n46 ns175 0 -0.0049535162163
Gc23_176 0 n46 ns176 0 -0.00156865745962
Gc23_177 0 n46 ns177 0 -9.13958584085e-05
Gc23_178 0 n46 ns178 0 0.000443148747741
Gc23_179 0 n46 ns179 0 0.00151858531241
Gc23_180 0 n46 ns180 0 -0.00903094065182
Gc23_181 0 n46 ns181 0 -0.00539360128025
Gc23_182 0 n46 ns182 0 -0.00157086001594
Gc23_183 0 n46 ns183 0 0.0038584736173
Gc23_184 0 n46 ns184 0 0.00230069337511
Gc23_185 0 n46 ns185 0 -0.000313982209837
Gc23_186 0 n46 ns186 0 -0.0701337011333
Gc23_187 0 n46 ns187 0 0.0611066442767
Gc23_188 0 n46 ns188 0 -0.00291113777588
Gc23_189 0 n46 ns189 0 -9.73424332217e-06
Gc23_190 0 n46 ns190 0 -1.2785890464e-05
Gc23_191 0 n46 ns191 0 -0.000313067483076
Gc23_192 0 n46 ns192 0 -0.000420279702112
Gc23_193 0 n46 ns193 0 0.00698861733408
Gc23_194 0 n46 ns194 0 -0.00112043112526
Gc23_195 0 n46 ns195 0 -0.000486591073972
Gc23_196 0 n46 ns196 0 0.00179386177594
Gc23_197 0 n46 ns197 0 0.000462072180612
Gc23_198 0 n46 ns198 0 -0.000183103811369
Gc23_199 0 n46 ns199 0 -0.000170686329816
Gc23_200 0 n46 ns200 0 0.00220624011342
Gc23_201 0 n46 ns201 0 -0.00267297623569
Gc23_202 0 n46 ns202 0 -0.000851215064451
Gc23_203 0 n46 ns203 0 0.000989978712881
Gc23_204 0 n46 ns204 0 -6.39538949719e-05
Gc23_205 0 n46 ns205 0 0.00057245568876
Gc23_206 0 n46 ns206 0 -0.000545303967392
Gc23_207 0 n46 ns207 0 -0.0037064040532
Gc23_208 0 n46 ns208 0 -0.00098442360527
Gc23_209 0 n46 ns209 0 0.000438813367727
Gc23_210 0 n46 ns210 0 0.000347499007114
Gc23_211 0 n46 ns211 0 0.000371595375332
Gc23_212 0 n46 ns212 0 0.000896662313057
Gc23_213 0 n46 ns213 0 -0.00548418933353
Gc23_214 0 n46 ns214 0 -0.00299449845856
Gc23_215 0 n46 ns215 0 -0.00107891655389
Gc23_216 0 n46 ns216 0 0.00018475663864
Gc23_217 0 n46 ns217 0 0.00232065258041
Gc23_218 0 n46 ns218 0 -0.0130188259935
Gc23_219 0 n46 ns219 0 -0.00589175141493
Gc23_220 0 n46 ns220 0 -0.000948418352534
Gc23_221 0 n46 ns221 0 0.00316859804643
Gc23_222 0 n46 ns222 0 0.00313455049076
Gc23_223 0 n46 ns223 0 0.000261146889666
Gc23_224 0 n46 ns224 0 -0.0734263281901
Gc23_225 0 n46 ns225 0 0.069219009561
Gc23_226 0 n46 ns226 0 -0.00651269293524
Gc23_227 0 n46 ns227 0 -9.96720328315e-06
Gc23_228 0 n46 ns228 0 1.59743717878e-05
Gc23_229 0 n46 ns229 0 -0.0170654306212
Gc23_230 0 n46 ns230 0 -0.00132130545007
Gc23_231 0 n46 ns231 0 0.0213277215431
Gc23_232 0 n46 ns232 0 0.00645963931926
Gc23_233 0 n46 ns233 0 0.0101756528143
Gc23_234 0 n46 ns234 0 0.00151109698386
Gc23_235 0 n46 ns235 0 -0.00342166058889
Gc23_236 0 n46 ns236 0 -0.000531869210493
Gc23_237 0 n46 ns237 0 1.15679124507e-05
Gc23_238 0 n46 ns238 0 -0.00133137095592
Gc23_239 0 n46 ns239 0 -0.0139885329162
Gc23_240 0 n46 ns240 0 0.0010842862079
Gc23_241 0 n46 ns241 0 0.00156263521235
Gc23_242 0 n46 ns242 0 9.63936895737e-05
Gc23_243 0 n46 ns243 0 0.000435464904724
Gc23_244 0 n46 ns244 0 0.00046796090699
Gc23_245 0 n46 ns245 0 -3.95844273663e-05
Gc23_246 0 n46 ns246 0 -0.000426792077994
Gc23_247 0 n46 ns247 0 0.000592847042986
Gc23_248 0 n46 ns248 0 0.000559653392428
Gc23_249 0 n46 ns249 0 0.000479382777746
Gc23_250 0 n46 ns250 0 -0.0119887494221
Gc23_251 0 n46 ns251 0 -0.00752864913694
Gc23_252 0 n46 ns252 0 -0.0033084513731
Gc23_253 0 n46 ns253 0 -0.00149216015486
Gc23_254 0 n46 ns254 0 -0.000129721440986
Gc23_255 0 n46 ns255 0 0.00258196341135
Gc23_256 0 n46 ns256 0 0.00784284432469
Gc23_257 0 n46 ns257 0 -0.00613955205055
Gc23_258 0 n46 ns258 0 0.0016972163403
Gc23_259 0 n46 ns259 0 0.00216255129603
Gc23_260 0 n46 ns260 0 0.0034248606607
Gc23_261 0 n46 ns261 0 3.10305858424e-05
Gc23_262 0 n46 ns262 0 -0.112785994879
Gc23_263 0 n46 ns263 0 0.0739893998248
Gc23_264 0 n46 ns264 0 -0.00891191442589
Gc23_265 0 n46 ns265 0 -1.30381331231e-05
Gc23_266 0 n46 ns266 0 2.43299256858e-05
Gc23_267 0 n46 ns267 0 -0.000503298297989
Gc23_268 0 n46 ns268 0 0.000472458172307
Gc23_269 0 n46 ns269 0 0.00505172338279
Gc23_270 0 n46 ns270 0 -0.00128364862894
Gc23_271 0 n46 ns271 0 -0.000563326313829
Gc23_272 0 n46 ns272 0 0.00186786510254
Gc23_273 0 n46 ns273 0 0.000517522196613
Gc23_274 0 n46 ns274 0 -0.000159582560629
Gc23_275 0 n46 ns275 0 -0.000178770742606
Gc23_276 0 n46 ns276 0 0.00125502552935
Gc23_277 0 n46 ns277 0 -0.00135826456828
Gc23_278 0 n46 ns278 0 -8.61207884453e-05
Gc23_279 0 n46 ns279 0 0.000416298348189
Gc23_280 0 n46 ns280 0 -0.000327863219258
Gc23_281 0 n46 ns281 0 0.00035251969726
Gc23_282 0 n46 ns282 0 0.000528088065492
Gc23_283 0 n46 ns283 0 -0.00304202218197
Gc23_284 0 n46 ns284 0 -0.00132149550672
Gc23_285 0 n46 ns285 0 -0.000280639698994
Gc23_286 0 n46 ns286 0 0.000227511874456
Gc23_287 0 n46 ns287 0 0.000511445177799
Gc23_288 0 n46 ns288 0 0.000950642706272
Gc23_289 0 n46 ns289 0 -0.00461467892623
Gc23_290 0 n46 ns290 0 -0.00194566081705
Gc23_291 0 n46 ns291 0 -0.00110730192862
Gc23_292 0 n46 ns292 0 -0.000420951456001
Gc23_293 0 n46 ns293 0 0.00201574777475
Gc23_294 0 n46 ns294 0 -0.0110098126394
Gc23_295 0 n46 ns295 0 -0.00582399535567
Gc23_296 0 n46 ns296 0 -0.00152385408059
Gc23_297 0 n46 ns297 0 0.00270620598726
Gc23_298 0 n46 ns298 0 0.00309320154784
Gc23_299 0 n46 ns299 0 0.000478703727768
Gc23_300 0 n46 ns300 0 -0.068106015156
Gc23_301 0 n46 ns301 0 0.0651092507997
Gc23_302 0 n46 ns302 0 -0.00643534308142
Gc23_303 0 n46 ns303 0 -1.31752373965e-05
Gc23_304 0 n46 ns304 0 3.16441365015e-05
Gc23_305 0 n46 ns305 0 0.00064654931621
Gc23_306 0 n46 ns306 0 -0.000597826425603
Gc23_307 0 n46 ns307 0 0.00929897470776
Gc23_308 0 n46 ns308 0 0.000323204545598
Gc23_309 0 n46 ns309 0 0.000221930795978
Gc23_310 0 n46 ns310 0 4.96940925202e-05
Gc23_311 0 n46 ns311 0 -0.000184638427448
Gc23_312 0 n46 ns312 0 -0.000114805707636
Gc23_313 0 n46 ns313 0 3.42418774944e-05
Gc23_314 0 n46 ns314 0 -0.000594067640763
Gc23_315 0 n46 ns315 0 -0.00373383698821
Gc23_316 0 n46 ns316 0 0.000605057645585
Gc23_317 0 n46 ns317 0 0.00117574043875
Gc23_318 0 n46 ns318 0 -1.8173981904e-05
Gc23_319 0 n46 ns319 0 0.000219808586038
Gc23_320 0 n46 ns320 0 -0.00119436727894
Gc23_321 0 n46 ns321 0 0.000563342245735
Gc23_322 0 n46 ns322 0 -6.39898714285e-05
Gc23_323 0 n46 ns323 0 -0.000769063837028
Gc23_324 0 n46 ns324 0 0.000148854783779
Gc23_325 0 n46 ns325 0 0.000144809571341
Gc23_326 0 n46 ns326 0 -0.00264606139372
Gc23_327 0 n46 ns327 0 -0.004101266678
Gc23_328 0 n46 ns328 0 -0.000316067264266
Gc23_329 0 n46 ns329 0 0.000699971012349
Gc23_330 0 n46 ns330 0 -0.000121751187183
Gc23_331 0 n46 ns331 0 0.000695924571967
Gc23_332 0 n46 ns332 0 -0.00651779361776
Gc23_333 0 n46 ns333 0 -0.00454391590332
Gc23_334 0 n46 ns334 0 -0.00231271545524
Gc23_335 0 n46 ns335 0 0.0027526332489
Gc23_336 0 n46 ns336 0 0.00214008176594
Gc23_337 0 n46 ns337 0 0.000124398887845
Gc23_338 0 n46 ns338 0 -0.0655223215445
Gc23_339 0 n46 ns339 0 0.0577433412487
Gc23_340 0 n46 ns340 0 -0.00292329196402
Gc23_341 0 n46 ns341 0 -7.49792073677e-06
Gc23_342 0 n46 ns342 0 2.01473689196e-05
Gc23_343 0 n46 ns343 0 0.000525834883577
Gc23_344 0 n46 ns344 0 -0.00061039045678
Gc23_345 0 n46 ns345 0 0.00272614148495
Gc23_346 0 n46 ns346 0 -0.000167101098868
Gc23_347 0 n46 ns347 0 0.000338768498225
Gc23_348 0 n46 ns348 0 0.000186706338607
Gc23_349 0 n46 ns349 0 -2.50682541368e-06
Gc23_350 0 n46 ns350 0 -1.27357394298e-05
Gc23_351 0 n46 ns351 0 -4.0430555185e-05
Gc23_352 0 n46 ns352 0 0.00070950288641
Gc23_353 0 n46 ns353 0 -0.000965544347015
Gc23_354 0 n46 ns354 0 -0.000495008113152
Gc23_355 0 n46 ns355 0 0.000316213892391
Gc23_356 0 n46 ns356 0 0.000191987760918
Gc23_357 0 n46 ns357 0 0.000151923014872
Gc23_358 0 n46 ns358 0 -0.000452214143778
Gc23_359 0 n46 ns359 0 -0.00097015185805
Gc23_360 0 n46 ns360 0 -4.11827789006e-05
Gc23_361 0 n46 ns361 0 0.000668085588789
Gc23_362 0 n46 ns362 0 0.000111192205135
Gc23_363 0 n46 ns363 0 -0.000103603840372
Gc23_364 0 n46 ns364 0 -0.000181188894863
Gc23_365 0 n46 ns365 0 -0.00134628525655
Gc23_366 0 n46 ns366 0 -0.00136765401045
Gc23_367 0 n46 ns367 0 -0.000338748526271
Gc23_368 0 n46 ns368 0 0.000711643383944
Gc23_369 0 n46 ns369 0 0.000695115455266
Gc23_370 0 n46 ns370 0 -0.00356136785423
Gc23_371 0 n46 ns371 0 -0.00071376966134
Gc23_372 0 n46 ns372 0 0.000687736884904
Gc23_373 0 n46 ns373 0 0.00146060171163
Gc23_374 0 n46 ns374 0 0.000454546672759
Gc23_375 0 n46 ns375 0 -0.000547752871838
Gc23_376 0 n46 ns376 0 -0.00769256048704
Gc23_377 0 n46 ns377 0 0.00594613481527
Gc23_378 0 n46 ns378 0 -0.000207517562765
Gc23_379 0 n46 ns379 0 5.55051488019e-06
Gc23_380 0 n46 ns380 0 -3.18044370078e-05
Gc23_381 0 n46 ns381 0 0.000521920078444
Gc23_382 0 n46 ns382 0 -0.000609159224427
Gc23_383 0 n46 ns383 0 0.00423521565866
Gc23_384 0 n46 ns384 0 -0.00033214969657
Gc23_385 0 n46 ns385 0 0.000451371850801
Gc23_386 0 n46 ns386 0 0.000428639950786
Gc23_387 0 n46 ns387 0 7.07347872038e-05
Gc23_388 0 n46 ns388 0 2.99488869784e-05
Gc23_389 0 n46 ns389 0 -2.95606794868e-05
Gc23_390 0 n46 ns390 0 -8.53869826189e-05
Gc23_391 0 n46 ns391 0 -0.000754663857372
Gc23_392 0 n46 ns392 0 1.38505747455e-05
Gc23_393 0 n46 ns393 0 -9.31302484771e-05
Gc23_394 0 n46 ns394 0 0.000119074283214
Gc23_395 0 n46 ns395 0 0.000194628585293
Gc23_396 0 n46 ns396 0 0.000954108569158
Gc23_397 0 n46 ns397 0 -0.000982495776829
Gc23_398 0 n46 ns398 0 -0.000876435843625
Gc23_399 0 n46 ns399 0 0.000191151181825
Gc23_400 0 n46 ns400 0 8.32909217106e-05
Gc23_401 0 n46 ns401 0 6.82780960402e-06
Gc23_402 0 n46 ns402 0 -0.000584765172098
Gc23_403 0 n46 ns403 0 -0.00190901388923
Gc23_404 0 n46 ns404 0 -0.0011827044667
Gc23_405 0 n46 ns405 0 -0.000992704735786
Gc23_406 0 n46 ns406 0 0.000436052563262
Gc23_407 0 n46 ns407 0 0.00122361925996
Gc23_408 0 n46 ns408 0 -0.0051875157661
Gc23_409 0 n46 ns409 0 -0.00278503062706
Gc23_410 0 n46 ns410 0 0.000228554084197
Gc23_411 0 n46 ns411 0 0.00274630592638
Gc23_412 0 n46 ns412 0 0.00101861629933
Gc23_413 0 n46 ns413 0 -0.000687378337231
Gc23_414 0 n46 ns414 0 -0.0213659144786
Gc23_415 0 n46 ns415 0 0.0176810117954
Gc23_416 0 n46 ns416 0 -0.000682951631638
Gc23_417 0 n46 ns417 0 -1.02338778927e-06
Gc23_418 0 n46 ns418 0 -3.29494587877e-05
Gc23_419 0 n46 ns419 0 0.000717755237526
Gc23_420 0 n46 ns420 0 -0.0016898575863
Gc23_421 0 n46 ns421 0 0.00918055628454
Gc23_422 0 n46 ns422 0 0.00022472992949
Gc23_423 0 n46 ns423 0 0.000266788418863
Gc23_424 0 n46 ns424 0 0.000151069006258
Gc23_425 0 n46 ns425 0 0.000151034296519
Gc23_426 0 n46 ns426 0 -1.12795285795e-05
Gc23_427 0 n46 ns427 0 5.57866699849e-06
Gc23_428 0 n46 ns428 0 -0.000474280579979
Gc23_429 0 n46 ns429 0 -0.00336384829289
Gc23_430 0 n46 ns430 0 0.000251598070381
Gc23_431 0 n46 ns431 0 0.000822507429661
Gc23_432 0 n46 ns432 0 0.000192633593065
Gc23_433 0 n46 ns433 0 0.000380922455735
Gc23_434 0 n46 ns434 0 -0.000188790563398
Gc23_435 0 n46 ns435 0 -7.64572101865e-05
Gc23_436 0 n46 ns436 0 -0.000519454134445
Gc23_437 0 n46 ns437 0 -0.000232443377254
Gc23_438 0 n46 ns438 0 0.000184072083669
Gc23_439 0 n46 ns439 0 -1.22732944512e-05
Gc23_440 0 n46 ns440 0 -0.00204999765189
Gc23_441 0 n46 ns441 0 -0.00370916188276
Gc23_442 0 n46 ns442 0 -0.00106156810641
Gc23_443 0 n46 ns443 0 -0.000383492333627
Gc23_444 0 n46 ns444 0 0.000318701423415
Gc23_445 0 n46 ns445 0 0.00134222173704
Gc23_446 0 n46 ns446 0 -0.00742663602153
Gc23_447 0 n46 ns447 0 -0.00478773432974
Gc23_448 0 n46 ns448 0 -0.00115855182911
Gc23_449 0 n46 ns449 0 0.00373472373792
Gc23_450 0 n46 ns450 0 0.00192781799851
Gc23_451 0 n46 ns451 0 -0.000461872215072
Gc23_452 0 n46 ns452 0 -0.0532477475213
Gc23_453 0 n46 ns453 0 0.0457473116793
Gc23_454 0 n46 ns454 0 -0.0019939627799
Gc23_455 0 n46 ns455 0 -8.46251664415e-06
Gc23_456 0 n46 ns456 0 -2.36634766604e-05
Gc23_457 0 n46 ns457 0 0.000206136003455
Gc23_458 0 n46 ns458 0 -0.00107184753124
Gc23_459 0 n46 ns459 0 0.00985646569689
Gc23_460 0 n46 ns460 0 -0.000251283948399
Gc23_461 0 n46 ns461 0 0.000176100498602
Gc23_462 0 n46 ns462 0 0.000486100517272
Gc23_463 0 n46 ns463 0 -0.000511964749878
Gc23_464 0 n46 ns464 0 -8.39815591768e-05
Gc23_465 0 n46 ns465 0 3.38352764949e-05
Gc23_466 0 n46 ns466 0 0.00201961530475
Gc23_467 0 n46 ns467 0 -0.00276994579318
Gc23_468 0 n46 ns468 0 -0.000632350789761
Gc23_469 0 n46 ns469 0 0.000848617065656
Gc23_470 0 n46 ns470 0 -4.76817829903e-05
Gc23_471 0 n46 ns471 0 0.000523051001519
Gc23_472 0 n46 ns472 0 -0.00135088143693
Gc23_473 0 n46 ns473 0 -0.00244553842378
Gc23_474 0 n46 ns474 0 -0.000628698967347
Gc23_475 0 n46 ns475 0 0.000440191324907
Gc23_476 0 n46 ns476 0 0.000366368938135
Gc23_477 0 n46 ns477 0 0.000261540098861
Gc23_478 0 n46 ns478 0 -0.000251534618995
Gc23_479 0 n46 ns479 0 -0.00646243740039
Gc23_480 0 n46 ns480 0 -0.00291597764981
Gc23_481 0 n46 ns481 0 -0.000479807348075
Gc23_482 0 n46 ns482 0 0.00049939281273
Gc23_483 0 n46 ns483 0 0.00210712979555
Gc23_484 0 n46 ns484 0 -0.0109178659793
Gc23_485 0 n46 ns485 0 -0.00562699985744
Gc23_486 0 n46 ns486 0 -0.00184763761491
Gc23_487 0 n46 ns487 0 0.00293720518041
Gc23_488 0 n46 ns488 0 0.00271224911463
Gc23_489 0 n46 ns489 0 0.000163585525491
Gc23_490 0 n46 ns490 0 -0.0913994923345
Gc23_491 0 n46 ns491 0 0.083161334597
Gc23_492 0 n46 ns492 0 -0.00526380461272
Gc23_493 0 n46 ns493 0 -1.01346748931e-05
Gc23_494 0 n46 ns494 0 -3.68129962307e-07
Gc23_495 0 n46 ns495 0 -0.00538123728935
Gc23_496 0 n46 ns496 0 -0.00493149561526
Gc23_497 0 n46 ns497 0 0.00901834109665
Gc23_498 0 n46 ns498 0 0.00255313624191
Gc23_499 0 n46 ns499 0 -0.00209650862076
Gc23_500 0 n46 ns500 0 0.000711299491472
Gc23_501 0 n46 ns501 0 0.00280423123437
Gc23_502 0 n46 ns502 0 -7.37267521424e-06
Gc23_503 0 n46 ns503 0 -0.000312963736227
Gc23_504 0 n46 ns504 0 -0.00100599333469
Gc23_505 0 n46 ns505 0 -0.00149872596576
Gc23_506 0 n46 ns506 0 -0.000872900694246
Gc23_507 0 n46 ns507 0 0.00049947726222
Gc23_508 0 n46 ns508 0 -0.000152925042701
Gc23_509 0 n46 ns509 0 0.000584110418657
Gc23_510 0 n46 ns510 0 0.00276867262144
Gc23_511 0 n46 ns511 0 -0.00259870051736
Gc23_512 0 n46 ns512 0 -0.00089654097934
Gc23_513 0 n46 ns513 0 -0.000581815111441
Gc23_514 0 n46 ns514 0 0.000205025865861
Gc23_515 0 n46 ns515 0 0.000195688859342
Gc23_516 0 n46 ns516 0 0.0023901106206
Gc23_517 0 n46 ns517 0 0.00132434324448
Gc23_518 0 n46 ns518 0 -0.00117810120205
Gc23_519 0 n46 ns519 0 -0.00268747641046
Gc23_520 0 n46 ns520 0 -0.0011534485153
Gc23_521 0 n46 ns521 0 0.00211146792034
Gc23_522 0 n46 ns522 0 -0.0147527642966
Gc23_523 0 n46 ns523 0 -0.00568291677691
Gc23_524 0 n46 ns524 0 0.00203321245666
Gc23_525 0 n46 ns525 0 0.00391960147924
Gc23_526 0 n46 ns526 0 0.00372630966964
Gc23_527 0 n46 ns527 0 0.00016561349291
Gc23_528 0 n46 ns528 0 0.00889465107398
Gc23_529 0 n46 ns529 0 -0.00112722925392
Gc23_530 0 n46 ns530 0 -0.00787364627726
Gc23_531 0 n46 ns531 0 -1.3375471705e-05
Gc23_532 0 n46 ns532 0 1.59930586399e-05
Gc23_533 0 n46 ns533 0 -0.00261871040824
Gc23_534 0 n46 ns534 0 -0.00249522522223
Gc23_535 0 n46 ns535 0 0.00682975845372
Gc23_536 0 n46 ns536 0 0.000990811183368
Gc23_537 0 n46 ns537 0 -0.00182531498036
Gc23_538 0 n46 ns538 0 0.000732112513583
Gc23_539 0 n46 ns539 0 0.0019238276327
Gc23_540 0 n46 ns540 0 3.2047528928e-05
Gc23_541 0 n46 ns541 0 -0.000240520006933
Gc23_542 0 n46 ns542 0 0.000278271076754
Gc23_543 0 n46 ns543 0 -0.000239306835895
Gc23_544 0 n46 ns544 0 -0.000632670405584
Gc23_545 0 n46 ns545 0 -3.84872840955e-05
Gc23_546 0 n46 ns546 0 -0.000404988779001
Gc23_547 0 n46 ns547 0 0.000447594837946
Gc23_548 0 n46 ns548 0 0.00210508864212
Gc23_549 0 n46 ns549 0 -0.00290828787083
Gc23_550 0 n46 ns550 0 -0.00116301229491
Gc23_551 0 n46 ns551 0 -0.000442001843511
Gc23_552 0 n46 ns552 0 0.000246991408446
Gc23_553 0 n46 ns553 0 0.000408679617181
Gc23_554 0 n46 ns554 0 0.0019889256495
Gc23_555 0 n46 ns555 0 -0.00163554782164
Gc23_556 0 n46 ns556 0 -0.00186383393553
Gc23_557 0 n46 ns557 0 -0.00200341666563
Gc23_558 0 n46 ns558 0 -0.000787754948592
Gc23_559 0 n46 ns559 0 0.00226459513931
Gc23_560 0 n46 ns560 0 -0.011113664075
Gc23_561 0 n46 ns561 0 -0.0051933794285
Gc23_562 0 n46 ns562 0 -0.00012058318099
Gc23_563 0 n46 ns563 0 0.00238299255219
Gc23_564 0 n46 ns564 0 0.00319956464447
Gc23_565 0 n46 ns565 0 0.000343657416783
Gc23_566 0 n46 ns566 0 -0.0368942695464
Gc23_567 0 n46 ns567 0 0.0387502375205
Gc23_568 0 n46 ns568 0 -0.00710152213041
Gc23_569 0 n46 ns569 0 -1.32560051999e-05
Gc23_570 0 n46 ns570 0 2.94669588689e-05
Gc23_571 0 n46 ns571 0 -7.57368749464e-05
Gc23_572 0 n46 ns572 0 -0.000820842199217
Gc23_573 0 n46 ns573 0 0.00943577067009
Gc23_574 0 n46 ns574 0 0.000111235226468
Gc23_575 0 n46 ns575 0 0.000173333479551
Gc23_576 0 n46 ns576 0 0.000397986908025
Gc23_577 0 n46 ns577 0 -0.000368588183384
Gc23_578 0 n46 ns578 0 -0.000139520889676
Gc23_579 0 n46 ns579 0 2.51001343346e-05
Gc23_580 0 n46 ns580 0 0.000119025631477
Gc23_581 0 n46 ns581 0 -0.00319618338044
Gc23_582 0 n46 ns582 0 0.000393586346118
Gc23_583 0 n46 ns583 0 0.000985773888596
Gc23_584 0 n46 ns584 0 -0.000154085087839
Gc23_585 0 n46 ns585 0 0.000293070701366
Gc23_586 0 n46 ns586 0 -0.00105119091361
Gc23_587 0 n46 ns587 0 -0.000291344908008
Gc23_588 0 n46 ns588 0 -0.000316302981896
Gc23_589 0 n46 ns589 0 -0.00068404923815
Gc23_590 0 n46 ns590 0 0.000208317832178
Gc23_591 0 n46 ns591 0 0.000245347780511
Gc23_592 0 n46 ns592 0 -0.00175955792877
Gc23_593 0 n46 ns593 0 -0.00495270121736
Gc23_594 0 n46 ns594 0 -0.000897700878664
Gc23_595 0 n46 ns595 0 0.000300214446459
Gc23_596 0 n46 ns596 0 -0.000181735916464
Gc23_597 0 n46 ns597 0 0.00117238758853
Gc23_598 0 n46 ns598 0 -0.00775143291266
Gc23_599 0 n46 ns599 0 -0.00535954272273
Gc23_600 0 n46 ns600 0 -0.00259096323353
Gc23_601 0 n46 ns601 0 0.00280294014969
Gc23_602 0 n46 ns602 0 0.00252615755668
Gc23_603 0 n46 ns603 0 0.000259365671845
Gc23_604 0 n46 ns604 0 -0.0779186295414
Gc23_605 0 n46 ns605 0 0.0700542176142
Gc23_606 0 n46 ns606 0 -0.00407998059868
Gc23_607 0 n46 ns607 0 -1.02942442645e-05
Gc23_608 0 n46 ns608 0 2.32907404166e-05
Gc23_609 0 n46 ns609 0 0.000164330556951
Gc23_610 0 n46 ns610 0 -0.000731052944328
Gc23_611 0 n46 ns611 0 0.000367728464874
Gc23_612 0 n46 ns612 0 9.23030312668e-05
Gc23_613 0 n46 ns613 0 -0.000113269746225
Gc23_614 0 n46 ns614 0 9.05835233435e-05
Gc23_615 0 n46 ns615 0 2.74232545301e-06
Gc23_616 0 n46 ns616 0 1.40476699462e-05
Gc23_617 0 n46 ns617 0 -5.54154681219e-05
Gc23_618 0 n46 ns618 0 -0.000919908108403
Gc23_619 0 n46 ns619 0 0.000473287144961
Gc23_620 0 n46 ns620 0 0.000394953981061
Gc23_621 0 n46 ns621 0 -0.000437852256889
Gc23_622 0 n46 ns622 0 -0.000143783796341
Gc23_623 0 n46 ns623 0 -3.91409798075e-05
Gc23_624 0 n46 ns624 0 -0.000927472167862
Gc23_625 0 n46 ns625 0 0.000457922463598
Gc23_626 0 n46 ns626 0 0.000592795879269
Gc23_627 0 n46 ns627 0 0.000325157673722
Gc23_628 0 n46 ns628 0 6.57856291971e-05
Gc23_629 0 n46 ns629 0 -0.000157011987337
Gc23_630 0 n46 ns630 0 0.000360361644018
Gc23_631 0 n46 ns631 0 0.00116590457991
Gc23_632 0 n46 ns632 0 0.000805100024293
Gc23_633 0 n46 ns633 0 -0.00024181416695
Gc23_634 0 n46 ns634 0 -0.000538183123815
Gc23_635 0 n46 ns635 0 -0.000142238643179
Gc23_636 0 n46 ns636 0 0.000477962613048
Gc23_637 0 n46 ns637 0 0.000711475321758
Gc23_638 0 n46 ns638 0 0.000299469348098
Gc23_639 0 n46 ns639 0 8.55760575916e-05
Gc23_640 0 n46 ns640 0 6.96619377781e-08
Gc23_641 0 n46 ns641 0 -0.000262585760472
Gc23_642 0 n46 ns642 0 0.00957401859614
Gc23_643 0 n46 ns643 0 -0.00838823308643
Gc23_644 0 n46 ns644 0 0.000334680652829
Gc23_645 0 n46 ns645 0 -7.50907730556e-06
Gc23_646 0 n46 ns646 0 -2.71749440539e-05
Gc23_647 0 n46 ns647 0 0.000348809909859
Gc23_648 0 n46 ns648 0 -0.000998136059321
Gc23_649 0 n46 ns649 0 0.000925894392378
Gc23_650 0 n46 ns650 0 9.19072738987e-05
Gc23_651 0 n46 ns651 0 -8.83817869806e-05
Gc23_652 0 n46 ns652 0 8.49813858581e-05
Gc23_653 0 n46 ns653 0 -5.14785727296e-05
Gc23_654 0 n46 ns654 0 1.06630082616e-05
Gc23_655 0 n46 ns655 0 -2.07764703035e-05
Gc23_656 0 n46 ns656 0 -0.000972320473688
Gc23_657 0 n46 ns657 0 0.000399817460861
Gc23_658 0 n46 ns658 0 0.000484090536343
Gc23_659 0 n46 ns659 0 -0.000415030332522
Gc23_660 0 n46 ns660 0 -0.000172232217875
Gc23_661 0 n46 ns661 0 -6.43897301478e-05
Gc23_662 0 n46 ns662 0 -0.00111124313778
Gc23_663 0 n46 ns663 0 0.00020343702895
Gc23_664 0 n46 ns664 0 0.000569220776733
Gc23_665 0 n46 ns665 0 0.000535810001513
Gc23_666 0 n46 ns666 0 0.000109457551849
Gc23_667 0 n46 ns667 0 -0.000168281576683
Gc23_668 0 n46 ns668 0 0.000134840664929
Gc23_669 0 n46 ns669 0 0.00128158229145
Gc23_670 0 n46 ns670 0 0.00097240500665
Gc23_671 0 n46 ns671 0 -0.000125280011311
Gc23_672 0 n46 ns672 0 -0.000614894366552
Gc23_673 0 n46 ns673 0 -0.000254733783027
Gc23_674 0 n46 ns674 0 0.000119058404714
Gc23_675 0 n46 ns675 0 0.000737001883729
Gc23_676 0 n46 ns676 0 0.00040867007081
Gc23_677 0 n46 ns677 0 0.000274933899167
Gc23_678 0 n46 ns678 0 5.40698383066e-05
Gc23_679 0 n46 ns679 0 -0.000352148873333
Gc23_680 0 n46 ns680 0 0.0100698624952
Gc23_681 0 n46 ns681 0 -0.009031013418
Gc23_682 0 n46 ns682 0 0.000389281522536
Gc23_683 0 n46 ns683 0 -3.94056731854e-06
Gc23_684 0 n46 ns684 0 -3.0721950298e-05
Gc23_685 0 n46 ns685 0 -0.000180290347401
Gc23_686 0 n46 ns686 0 5.5298633936e-05
Gc23_687 0 n46 ns687 0 -0.000751903708958
Gc23_688 0 n46 ns688 0 -0.000159824214085
Gc23_689 0 n46 ns689 0 7.72009076839e-05
Gc23_690 0 n46 ns690 0 -8.0401892519e-05
Gc23_691 0 n46 ns691 0 0.000120608637847
Gc23_692 0 n46 ns692 0 3.35285084575e-06
Gc23_693 0 n46 ns693 0 3.40607544974e-05
Gc23_694 0 n46 ns694 0 0.00038921833336
Gc23_695 0 n46 ns695 0 9.43516343001e-05
Gc23_696 0 n46 ns696 0 0.000242327436302
Gc23_697 0 n46 ns697 0 0.000144974200525
Gc23_698 0 n46 ns698 0 -0.000135416611264
Gc23_699 0 n46 ns699 0 -0.000134758562562
Gc23_700 0 n46 ns700 0 -7.07416150284e-05
Gc23_701 0 n46 ns701 0 -0.000728558662247
Gc23_702 0 n46 ns702 0 -0.000176375447155
Gc23_703 0 n46 ns703 0 0.000658775297889
Gc23_704 0 n46 ns704 0 0.000171500674318
Gc23_705 0 n46 ns705 0 -9.955478967e-05
Gc23_706 0 n46 ns706 0 -0.000150564471917
Gc23_707 0 n46 ns707 0 0.000475044621226
Gc23_708 0 n46 ns708 0 0.000897545891557
Gc23_709 0 n46 ns709 0 0.00053970372107
Gc23_710 0 n46 ns710 0 -0.000491452329633
Gc23_711 0 n46 ns711 0 -0.000663692163899
Gc23_712 0 n46 ns712 0 -0.000419974022288
Gc23_713 0 n46 ns713 0 0.000322948244413
Gc23_714 0 n46 ns714 0 0.000481036759653
Gc23_715 0 n46 ns715 0 0.000892451729846
Gc23_716 0 n46 ns716 0 0.000293134915396
Gc23_717 0 n46 ns717 0 -0.000595099453561
Gc23_718 0 n46 ns718 0 0.0147925427717
Gc23_719 0 n46 ns719 0 -0.0135145535255
Gc23_720 0 n46 ns720 0 0.000641515853213
Gc23_721 0 n46 ns721 0 -3.97555109897e-06
Gc23_722 0 n46 ns722 0 -3.29962334908e-05
Gc23_723 0 n46 ns723 0 -0.000959470546241
Gc23_724 0 n46 ns724 0 0.00227181154583
Gc23_725 0 n46 ns725 0 -0.00578341198582
Gc23_726 0 n46 ns726 0 -0.000431313231337
Gc23_727 0 n46 ns727 0 -0.000222524579437
Gc23_728 0 n46 ns728 0 -0.0003613587505
Gc23_729 0 n46 ns729 0 -6.4361694342e-05
Gc23_730 0 n46 ns730 0 -3.12497801852e-06
Gc23_731 0 n46 ns731 0 2.54445983678e-05
Gc23_732 0 n46 ns732 0 0.000773936737775
Gc23_733 0 n46 ns733 0 0.00219437565432
Gc23_734 0 n46 ns734 0 -0.000355122404619
Gc23_735 0 n46 ns735 0 -0.000132063122671
Gc23_736 0 n46 ns736 0 -0.000127431186939
Gc23_737 0 n46 ns737 0 -0.000234157575766
Gc23_738 0 n46 ns738 0 0.0013101097941
Gc23_739 0 n46 ns739 0 0.00116175457406
Gc23_740 0 n46 ns740 0 -0.000279286331749
Gc23_741 0 n46 ns741 0 -0.000282504380488
Gc23_742 0 n46 ns742 0 0.000188263733298
Gc23_743 0 n46 ns743 0 -0.000146564263055
Gc23_744 0 n46 ns744 0 0.00221405684076
Gc23_745 0 n46 ns745 0 0.00067769477013
Gc23_746 0 n46 ns746 0 0.000363646946878
Gc23_747 0 n46 ns747 0 0.000493079652079
Gc23_748 0 n46 ns748 0 -0.000244042201027
Gc23_749 0 n46 ns749 0 -0.000883475034266
Gc23_750 0 n46 ns750 0 0.00233908947708
Gc23_751 0 n46 ns751 0 -6.42648987926e-05
Gc23_752 0 n46 ns752 0 -0.000411684487803
Gc23_753 0 n46 ns753 0 0.00107450785799
Gc23_754 0 n46 ns754 0 0.000644395866495
Gc23_755 0 n46 ns755 0 -0.000670670446828
Gc23_756 0 n46 ns756 0 0.0351669282316
Gc23_757 0 n46 ns757 0 -0.0311622448622
Gc23_758 0 n46 ns758 0 0.00140539958626
Gc23_759 0 n46 ns759 0 -7.08053911822e-06
Gc23_760 0 n46 ns760 0 -2.50277568055e-05
Gc23_761 0 n46 ns761 0 -0.0013438834835
Gc23_762 0 n46 ns762 0 0.000769806098357
Gc23_763 0 n46 ns763 0 -0.00186082617507
Gc23_764 0 n46 ns764 0 0.000411824842924
Gc23_765 0 n46 ns765 0 -0.000477897606548
Gc23_766 0 n46 ns766 0 0.000438951382067
Gc23_767 0 n46 ns767 0 -0.000212800019464
Gc23_768 0 n46 ns768 0 -5.99344082671e-05
Gc23_769 0 n46 ns769 0 -1.25835521019e-06
Gc23_770 0 n46 ns770 0 -0.00199702432823
Gc23_771 0 n46 ns771 0 0.00066972712966
Gc23_772 0 n46 ns772 0 0.000376005351692
Gc23_773 0 n46 ns773 0 -0.000486379124143
Gc23_774 0 n46 ns774 0 5.84640474073e-05
Gc23_775 0 n46 ns775 0 -0.000423840632384
Gc23_776 0 n46 ns776 0 -0.00163840835561
Gc23_777 0 n46 ns777 0 0.00102190964902
Gc23_778 0 n46 ns778 0 0.000172566798143
Gc23_779 0 n46 ns779 0 0.000102855422624
Gc23_780 0 n46 ns780 0 0.000422761014842
Gc23_781 0 n46 ns781 0 -1.35870784662e-05
Gc23_782 0 n46 ns782 0 0.000373023402389
Gc23_783 0 n46 ns783 0 0.00372009990203
Gc23_784 0 n46 ns784 0 0.000736536628936
Gc23_785 0 n46 ns785 0 0.000391879088946
Gc23_786 0 n46 ns786 0 2.28241759774e-05
Gc23_787 0 n46 ns787 0 -0.00126784714629
Gc23_788 0 n46 ns788 0 0.00276860221646
Gc23_789 0 n46 ns789 0 0.0017618244976
Gc23_790 0 n46 ns790 0 -0.00161093887184
Gc23_791 0 n46 ns791 0 0.000689975455852
Gc23_792 0 n46 ns792 0 0.00136222390213
Gc23_793 0 n46 ns793 0 -0.000432001393766
Gc23_794 0 n46 ns794 0 0.0482024990588
Gc23_795 0 n46 ns795 0 -0.0452072137946
Gc23_796 0 n46 ns796 0 0.00276015206655
Gc23_797 0 n46 ns797 0 -1.97322426903e-06
Gc23_798 0 n46 ns798 0 -9.35832149603e-06
Gc23_799 0 n46 ns799 0 -0.00192923623818
Gc23_800 0 n46 ns800 0 -0.00228666804004
Gc23_801 0 n46 ns801 0 0.00514070998198
Gc23_802 0 n46 ns802 0 0.000416019179356
Gc23_803 0 n46 ns803 0 -0.000424436202551
Gc23_804 0 n46 ns804 0 0.000602592467266
Gc23_805 0 n46 ns805 0 0.000436781202731
Gc23_806 0 n46 ns806 0 -0.000151666394254
Gc23_807 0 n46 ns807 0 -8.93597688514e-05
Gc23_808 0 n46 ns808 0 -0.00173014934494
Gc23_809 0 n46 ns809 0 -0.000346632708997
Gc23_810 0 n46 ns810 0 0.00128568655572
Gc23_811 0 n46 ns811 0 1.84145224598e-05
Gc23_812 0 n46 ns812 0 0.000341180392688
Gc23_813 0 n46 ns813 0 -0.000569948424054
Gc23_814 0 n46 ns814 0 -0.000102708788399
Gc23_815 0 n46 ns815 0 -0.00221878602259
Gc23_816 0 n46 ns816 0 -0.000456029103381
Gc23_817 0 n46 ns817 0 0.000264215427085
Gc23_818 0 n46 ns818 0 0.000429517678758
Gc23_819 0 n46 ns819 0 0.000244305153757
Gc23_820 0 n46 ns820 0 -0.00418766047487
Gc23_821 0 n46 ns821 0 -0.000856893077215
Gc23_822 0 n46 ns822 0 0.00087694243715
Gc23_823 0 n46 ns823 0 0.00165522505869
Gc23_824 0 n46 ns824 0 0.000855759380712
Gc23_825 0 n46 ns825 0 -0.00170338215044
Gc23_826 0 n46 ns826 0 -0.00573527214539
Gc23_827 0 n46 ns827 0 -0.00118733924207
Gc23_828 0 n46 ns828 0 -0.00119454302589
Gc23_829 0 n46 ns829 0 0.000889296273396
Gc23_830 0 n46 ns830 0 0.00246424766126
Gc23_831 0 n46 ns831 0 0.000238688145622
Gc23_832 0 n46 ns832 0 0.0189555789449
Gc23_833 0 n46 ns833 0 -0.0269271739123
Gc23_834 0 n46 ns834 0 0.00543790499746
Gc23_835 0 n46 ns835 0 2.69804647353e-06
Gc23_836 0 n46 ns836 0 1.59454380078e-05
Gc23_837 0 n46 ns837 0 -0.00304848441269
Gc23_838 0 n46 ns838 0 0.000241258154188
Gc23_839 0 n46 ns839 0 -0.00144635450071
Gc23_840 0 n46 ns840 0 0.000227656524005
Gc23_841 0 n46 ns841 0 -0.000256131604127
Gc23_842 0 n46 ns842 0 0.000381313412862
Gc23_843 0 n46 ns843 0 -0.000129692969585
Gc23_844 0 n46 ns844 0 -0.000200696213811
Gc23_845 0 n46 ns845 0 -6.51807680791e-05
Gc23_846 0 n46 ns846 0 -0.00372564111241
Gc23_847 0 n46 ns847 0 0.00112553998103
Gc23_848 0 n46 ns848 0 0.00146619130887
Gc23_849 0 n46 ns849 0 0.000208589790486
Gc23_850 0 n46 ns850 0 0.00051476188606
Gc23_851 0 n46 ns851 0 -0.000645161822681
Gc23_852 0 n46 ns852 0 0.000171988339865
Gc23_853 0 n46 ns853 0 0.000576201360572
Gc23_854 0 n46 ns854 0 8.41477018245e-05
Gc23_855 0 n46 ns855 0 0.000499751296428
Gc23_856 0 n46 ns856 0 0.000633761191115
Gc23_857 0 n46 ns857 0 0.000302641919835
Gc23_858 0 n46 ns858 0 -2.91962940272e-05
Gc23_859 0 n46 ns859 0 0.000388017294249
Gc23_860 0 n46 ns860 0 0.00112847799089
Gc23_861 0 n46 ns861 0 0.00327263703011
Gc23_862 0 n46 ns862 0 0.00155699632569
Gc23_863 0 n46 ns863 0 -0.00233196576804
Gc23_864 0 n46 ns864 0 -0.00124467694831
Gc23_865 0 n46 ns865 0 -0.00291518672366
Gc23_866 0 n46 ns866 0 0.00208105027195
Gc23_867 0 n46 ns867 0 0.00201572262119
Gc23_868 0 n46 ns868 0 0.0032974000649
Gc23_869 0 n46 ns869 0 3.8009504968e-05
Gc23_870 0 n46 ns870 0 -0.0268626524431
Gc23_871 0 n46 ns871 0 0.0258871735607
Gc23_872 0 n46 ns872 0 0.00688572444646
Gc23_873 0 n46 ns873 0 1.11643210791e-05
Gc23_874 0 n46 ns874 0 3.12280752564e-05
Gc23_875 0 n46 ns875 0 -0.00223178689572
Gc23_876 0 n46 ns876 0 -0.00118564423867
Gc23_877 0 n46 ns877 0 0.00288122086617
Gc23_878 0 n46 ns878 0 0.000357948305904
Gc23_879 0 n46 ns879 0 -0.000570985341493
Gc23_880 0 n46 ns880 0 0.00034344726034
Gc23_881 0 n46 ns881 0 0.000374425087572
Gc23_882 0 n46 ns882 0 -0.000178226914087
Gc23_883 0 n46 ns883 0 -5.76585102624e-05
Gc23_884 0 n46 ns884 0 -0.000667461108318
Gc23_885 0 n46 ns885 0 0.000194331353775
Gc23_886 0 n46 ns886 0 0.000518153709891
Gc23_887 0 n46 ns887 0 0.000123697046771
Gc23_888 0 n46 ns888 0 0.000492617283498
Gc23_889 0 n46 ns889 0 -0.000437118037815
Gc23_890 0 n46 ns890 0 0.00117225107025
Gc23_891 0 n46 ns891 0 -0.00168047683557
Gc23_892 0 n46 ns892 0 -0.000792581218211
Gc23_893 0 n46 ns893 0 -0.000536627087213
Gc23_894 0 n46 ns894 0 0.000287769550147
Gc23_895 0 n46 ns895 0 0.000356161155774
Gc23_896 0 n46 ns896 0 -0.00355019891515
Gc23_897 0 n46 ns897 0 -0.00187264057105
Gc23_898 0 n46 ns898 0 -4.4078980724e-05
Gc23_899 0 n46 ns899 0 0.00157052288703
Gc23_900 0 n46 ns900 0 0.00135828237829
Gc23_901 0 n46 ns901 0 -0.00141666762057
Gc23_902 0 n46 ns902 0 -0.00530333645846
Gc23_903 0 n46 ns903 0 -0.0014578227819
Gc23_904 0 n46 ns904 0 -0.00149181110143
Gc23_905 0 n46 ns905 0 0.000732615491198
Gc23_906 0 n46 ns906 0 0.00249751914513
Gc23_907 0 n46 ns907 0 0.000378396584932
Gc23_908 0 n46 ns908 0 0.0208338008683
Gc23_909 0 n46 ns909 0 -0.0284792295989
Gc23_910 0 n46 ns910 0 0.00551408935182
Gc23_911 0 n46 ns911 0 2.1848641132e-06
Gc23_912 0 n46 ns912 0 3.4262635983e-05
Gc23_913 0 n46 ns913 0 -0.00118517003841
Gc23_914 0 n46 ns914 0 0.000770104545357
Gc23_915 0 n46 ns915 0 -0.000988367566508
Gc23_916 0 n46 ns916 0 0.000741440041665
Gc23_917 0 n46 ns917 0 -0.000675709954565
Gc23_918 0 n46 ns918 0 0.000513565430112
Gc23_919 0 n46 ns919 0 -0.000369318013067
Gc23_920 0 n46 ns920 0 -5.6262767007e-05
Gc23_921 0 n46 ns921 0 -1.39794375028e-05
Gc23_922 0 n46 ns922 0 -0.00276726515531
Gc23_923 0 n46 ns923 0 0.000370934999094
Gc23_924 0 n46 ns924 0 0.00011915039248
Gc23_925 0 n46 ns925 0 -0.00065965685371
Gc23_926 0 n46 ns926 0 0.000252405729786
Gc23_927 0 n46 ns927 0 -0.000246135268964
Gc23_928 0 n46 ns928 0 -0.00208408813697
Gc23_929 0 n46 ns929 0 0.00202673621297
Gc23_930 0 n46 ns930 0 0.000517004055607
Gc23_931 0 n46 ns931 0 -0.00052612363069
Gc23_932 0 n46 ns932 0 0.000289772964968
Gc23_933 0 n46 ns933 0 8.94725116669e-05
Gc23_934 0 n46 ns934 0 0.000659479761883
Gc23_935 0 n46 ns935 0 0.00386815027538
Gc23_936 0 n46 ns936 0 -0.000100212542589
Gc23_937 0 n46 ns937 0 -0.000235720947119
Gc23_938 0 n46 ns938 0 0.000488026514577
Gc23_939 0 n46 ns939 0 -0.0006755138243
Gc23_940 0 n46 ns940 0 0.00316375670886
Gc23_941 0 n46 ns941 0 0.00187391852167
Gc23_942 0 n46 ns942 0 -0.00212969378862
Gc23_943 0 n46 ns943 0 4.80397208073e-05
Gc23_944 0 n46 ns944 0 0.00131786069581
Gc23_945 0 n46 ns945 0 -3.5775891227e-05
Gc23_946 0 n46 ns946 0 0.0411634111239
Gc23_947 0 n46 ns947 0 -0.039056917938
Gc23_948 0 n46 ns948 0 0.00260658264852
Gc23_949 0 n46 ns949 0 -2.44034294952e-06
Gc23_950 0 n46 ns950 0 2.27692678043e-05
Gc23_951 0 n46 ns951 0 0.000110605874615
Gc23_952 0 n46 ns952 0 -0.000265596604674
Gc23_953 0 n46 ns953 0 -5.14864980142e-05
Gc23_954 0 n46 ns954 0 -7.69432100629e-05
Gc23_955 0 n46 ns955 0 5.75330902717e-05
Gc23_956 0 n46 ns956 0 -1.83927239308e-05
Gc23_957 0 n46 ns957 0 3.29594433498e-05
Gc23_958 0 n46 ns958 0 9.28240449582e-06
Gc23_959 0 n46 ns959 0 3.04335517821e-05
Gc23_960 0 n46 ns960 0 1.38479585627e-05
Gc23_961 0 n46 ns961 0 0.000353729448388
Gc23_962 0 n46 ns962 0 0.000333477896459
Gc23_963 0 n46 ns963 0 -0.000204280460175
Gc23_964 0 n46 ns964 0 -0.000211738805416
Gc23_965 0 n46 ns965 0 -8.96775179423e-05
Gc23_966 0 n46 ns966 0 -0.00047173079401
Gc23_967 0 n46 ns967 0 -0.000476987109529
Gc23_968 0 n46 ns968 0 0.000138162465853
Gc23_969 0 n46 ns969 0 0.000622481016272
Gc23_970 0 n46 ns970 0 0.000127168869734
Gc23_971 0 n46 ns971 0 -0.000139220443729
Gc23_972 0 n46 ns972 0 -0.00020647396325
Gc23_973 0 n46 ns973 0 0.000670087119857
Gc23_974 0 n46 ns974 0 0.000963822426058
Gc23_975 0 n46 ns975 0 0.000336873733197
Gc23_976 0 n46 ns976 0 -0.000547220565932
Gc23_977 0 n46 ns977 0 -0.000522604542877
Gc23_978 0 n46 ns978 0 -0.000519172444275
Gc23_979 0 n46 ns979 0 0.00047772367816
Gc23_980 0 n46 ns980 0 0.000542127356887
Gc23_981 0 n46 ns981 0 0.000783642767839
Gc23_982 0 n46 ns982 0 0.000247153544627
Gc23_983 0 n46 ns983 0 -0.000547557884581
Gc23_984 0 n46 ns984 0 0.0135641615456
Gc23_985 0 n46 ns985 0 -0.0124209416967
Gc23_986 0 n46 ns986 0 0.000580641380775
Gc23_987 0 n46 ns987 0 -3.61235210609e-06
Gc23_988 0 n46 ns988 0 -3.26746625589e-05
Gc23_989 0 n46 ns989 0 -0.000697957276099
Gc23_990 0 n46 ns990 0 0.00163917290347
Gc23_991 0 n46 ns991 0 -0.00450244198463
Gc23_992 0 n46 ns992 0 -0.000327706244337
Gc23_993 0 n46 ns993 0 -0.000133877602254
Gc23_994 0 n46 ns994 0 -0.000345387705063
Gc23_995 0 n46 ns995 0 4.97243170664e-05
Gc23_996 0 n46 ns996 0 -1.10650342525e-05
Gc23_997 0 n46 ns997 0 3.17736696368e-05
Gc23_998 0 n46 ns998 0 0.000822568854727
Gc23_999 0 n46 ns999 0 0.00151996083844
Gc23_1000 0 n46 ns1000 0 -0.000124576303529
Gc23_1001 0 n46 ns1001 0 2.47353047656e-05
Gc23_1002 0 n46 ns1002 0 -0.000137746417603
Gc23_1003 0 n46 ns1003 0 -0.000201620451155
Gc23_1004 0 n46 ns1004 0 0.00107660656526
Gc23_1005 0 n46 ns1005 0 0.000333556340733
Gc23_1006 0 n46 ns1006 0 -0.000319010210415
Gc23_1007 0 n46 ns1007 0 6.70288399886e-05
Gc23_1008 0 n46 ns1008 0 0.000166951190236
Gc23_1009 0 n46 ns1009 0 -0.00012958303881
Gc23_1010 0 n46 ns1010 0 0.00132799905689
Gc23_1011 0 n46 ns1011 0 0.000331344549136
Gc23_1012 0 n46 ns1012 0 0.000557327721653
Gc23_1013 0 n46 ns1013 0 0.000595873006403
Gc23_1014 0 n46 ns1014 0 -0.000336753326207
Gc23_1015 0 n46 ns1015 0 -0.000814350323875
Gc23_1016 0 n46 ns1016 0 0.00127666832721
Gc23_1017 0 n46 ns1017 0 0.000181180094462
Gc23_1018 0 n46 ns1018 0 7.59375481572e-05
Gc23_1019 0 n46 ns1019 0 0.000983317252964
Gc23_1020 0 n46 ns1020 0 0.000453536058438
Gc23_1021 0 n46 ns1021 0 -0.000686225456185
Gc23_1022 0 n46 ns1022 0 0.028685432588
Gc23_1023 0 n46 ns1023 0 -0.0254281798631
Gc23_1024 0 n46 ns1024 0 0.00111177548356
Gc23_1025 0 n46 ns1025 0 -6.81273004275e-06
Gc23_1026 0 n46 ns1026 0 -3.07855405813e-05
Gc23_1027 0 n46 ns1027 0 -0.00115038115267
Gc23_1028 0 n46 ns1028 0 0.00217549929374
Gc23_1029 0 n46 ns1029 0 -0.00468367440931
Gc23_1030 0 n46 ns1030 0 -3.26446010926e-05
Gc23_1031 0 n46 ns1031 0 -0.000274755238035
Gc23_1032 0 n46 ns1032 0 0.000104168061095
Gc23_1033 0 n46 ns1033 0 -0.000359401769576
Gc23_1034 0 n46 ns1034 0 -2.03107876596e-05
Gc23_1035 0 n46 ns1035 0 2.05835245918e-05
Gc23_1036 0 n46 ns1036 0 -0.00101926754155
Gc23_1037 0 n46 ns1037 0 0.00153930847459
Gc23_1038 0 n46 ns1038 0 -6.4487304342e-05
Gc23_1039 0 n46 ns1039 0 -0.000373887922353
Gc23_1040 0 n46 ns1040 0 -3.61037253775e-05
Gc23_1041 0 n46 ns1041 0 -0.000318823093828
Gc23_1042 0 n46 ns1042 0 -0.000466297673621
Gc23_1043 0 n46 ns1043 0 0.00176388265795
Gc23_1044 0 n46 ns1044 0 0.000130824118359
Gc23_1045 0 n46 ns1045 0 -0.000170300088493
Gc23_1046 0 n46 ns1046 0 0.000323795932707
Gc23_1047 0 n46 ns1047 0 -0.000100577481556
Gc23_1048 0 n46 ns1048 0 0.00200797977373
Gc23_1049 0 n46 ns1049 0 0.00286393224164
Gc23_1050 0 n46 ns1050 0 0.000504297387904
Gc23_1051 0 n46 ns1051 0 0.000253268806574
Gc23_1052 0 n46 ns1052 0 -0.000124180071483
Gc23_1053 0 n46 ns1053 0 -0.00105394974388
Gc23_1054 0 n46 ns1054 0 0.00363212996494
Gc23_1055 0 n46 ns1055 0 0.000811777070163
Gc23_1056 0 n46 ns1056 0 -0.00133962627418
Gc23_1057 0 n46 ns1057 0 0.000875915860578
Gc23_1058 0 n46 ns1058 0 0.00104942177253
Gc23_1059 0 n46 ns1059 0 -0.000531415173097
Gc23_1060 0 n46 ns1060 0 0.0451834633571
Gc23_1061 0 n46 ns1061 0 -0.0409148771133
Gc23_1062 0 n46 ns1062 0 0.00209670492379
Gc23_1063 0 n46 ns1063 0 -5.30482119331e-06
Gc23_1064 0 n46 ns1064 0 -1.99335914185e-05
Gc23_1065 0 n46 ns1065 0 -0.00190368621105
Gc23_1066 0 n46 ns1066 0 -0.000538461236188
Gc23_1067 0 n46 ns1067 0 0.0022492441907
Gc23_1068 0 n46 ns1068 0 0.000633279800094
Gc23_1069 0 n46 ns1069 0 -0.000290536723976
Gc23_1070 0 n46 ns1070 0 0.000725983449814
Gc23_1071 0 n46 ns1071 0 0.000381331917952
Gc23_1072 0 n46 ns1072 0 -0.000151109431762
Gc23_1073 0 n46 ns1073 0 -6.72430281122e-05
Gc23_1074 0 n46 ns1074 0 -0.00137681778527
Gc23_1075 0 n46 ns1075 0 -0.00061984746627
Gc23_1076 0 n46 ns1076 0 0.000994944105806
Gc23_1077 0 n46 ns1077 0 -0.000256362388146
Gc23_1078 0 n46 ns1078 0 0.000196435606419
Gc23_1079 0 n46 ns1079 0 -0.000533200480474
Gc23_1080 0 n46 ns1080 0 -0.00115916013124
Gc23_1081 0 n46 ns1081 0 -0.00194943952241
Gc23_1082 0 n46 ns1082 0 -0.000424433478539
Gc23_1083 0 n46 ns1083 0 0.000311551983314
Gc23_1084 0 n46 ns1084 0 0.000396061570243
Gc23_1085 0 n46 ns1085 0 0.000181706059096
Gc23_1086 0 n46 ns1086 0 -0.0037726448467
Gc23_1087 0 n46 ns1087 0 0.00146874782776
Gc23_1088 0 n46 ns1088 0 0.000831478219641
Gc23_1089 0 n46 ns1089 0 0.00113133536236
Gc23_1090 0 n46 ns1090 0 0.00055137698676
Gc23_1091 0 n46 ns1091 0 -0.0015120282658
Gc23_1092 0 n46 ns1092 0 -0.00217336153046
Gc23_1093 0 n46 ns1093 0 0.001611457003
Gc23_1094 0 n46 ns1094 0 -0.00169309422892
Gc23_1095 0 n46 ns1095 0 0.000441714289668
Gc23_1096 0 n46 ns1096 0 0.00200394125213
Gc23_1097 0 n46 ns1097 0 2.09032469825e-05
Gc23_1098 0 n46 ns1098 0 0.0414855397082
Gc23_1099 0 n46 ns1099 0 -0.0444732476316
Gc23_1100 0 n46 ns1100 0 0.00449401888701
Gc23_1101 0 n46 ns1101 0 3.0606848436e-06
Gc23_1102 0 n46 ns1102 0 4.60981198756e-06
Gc23_1103 0 n46 ns1103 0 -0.00480739809462
Gc23_1104 0 n46 ns1104 0 -0.000758038661599
Gc23_1105 0 n46 ns1105 0 -0.00365425953979
Gc23_1106 0 n46 ns1106 0 0.000165203192798
Gc23_1107 0 n46 ns1107 0 -0.00102281669498
Gc23_1108 0 n46 ns1108 0 -4.56359509419e-05
Gc23_1109 0 n46 ns1109 0 0.000298960308031
Gc23_1110 0 n46 ns1110 0 -8.7957390062e-05
Gc23_1111 0 n46 ns1111 0 -1.40822308075e-05
Gc23_1112 0 n46 ns1112 0 -0.00234198232738
Gc23_1113 0 n46 ns1113 0 0.00202017055843
Gc23_1114 0 n46 ns1114 0 0.00104440175392
Gc23_1115 0 n46 ns1115 0 -0.000195491470934
Gc23_1116 0 n46 ns1116 0 0.000313543498163
Gc23_1117 0 n46 ns1117 0 -0.000566014989562
Gc23_1118 0 n46 ns1118 0 -2.39342760547e-05
Gc23_1119 0 n46 ns1119 0 0.000960971176296
Gc23_1120 0 n46 ns1120 0 0.000305500249973
Gc23_1121 0 n46 ns1121 0 0.000345320521842
Gc23_1122 0 n46 ns1122 0 0.000587641158719
Gc23_1123 0 n46 ns1123 0 0.000194934296867
Gc23_1124 0 n46 ns1124 0 0.000912392836827
Gc23_1125 0 n46 ns1125 0 0.00154702324594
Gc23_1126 0 n46 ns1126 0 0.00121424377101
Gc23_1127 0 n46 ns1127 0 0.00288923675636
Gc23_1128 0 n46 ns1128 0 0.00134276005295
Gc23_1129 0 n46 ns1129 0 -0.00221200045531
Gc23_1130 0 n46 ns1130 0 0.00188938318324
Gc23_1131 0 n46 ns1131 0 -0.00153357716363
Gc23_1132 0 n46 ns1132 0 0.00186996576235
Gc23_1133 0 n46 ns1133 0 0.0014403181571
Gc23_1134 0 n46 ns1134 0 0.00305695487744
Gc23_1135 0 n46 ns1135 0 2.4816040569e-05
Gc23_1136 0 n46 ns1136 0 -0.016226701914
Gc23_1137 0 n46 ns1137 0 0.0186420390057
Gc23_1138 0 n46 ns1138 0 0.00690907559149
Gc23_1139 0 n46 ns1139 0 9.71355784405e-08
Gc23_1140 0 n46 ns1140 0 1.78300982487e-05
Gc23_1141 0 n46 ns1141 0 -0.00501440496904
Gc23_1142 0 n46 ns1142 0 -0.000764356280168
Gc23_1143 0 n46 ns1143 0 -0.00405457341198
Gc23_1144 0 n46 ns1144 0 0.00035626516312
Gc23_1145 0 n46 ns1145 0 -0.00139548225718
Gc23_1146 0 n46 ns1146 0 -0.000330366306472
Gc23_1147 0 n46 ns1147 0 0.000805002971375
Gc23_1148 0 n46 ns1148 0 -0.00012817668647
Gc23_1149 0 n46 ns1149 0 -1.94029582445e-05
Gc23_1150 0 n46 ns1150 0 -4.12323754622e-05
Gc23_1151 0 n46 ns1151 0 0.00198908307437
Gc23_1152 0 n46 ns1152 0 0.000521973288565
Gc23_1153 0 n46 ns1153 0 -0.000171304901505
Gc23_1154 0 n46 ns1154 0 0.000358877044985
Gc23_1155 0 n46 ns1155 0 -0.000504565393581
Gc23_1156 0 n46 ns1156 0 0.00128562188842
Gc23_1157 0 n46 ns1157 0 -0.000950524042919
Gc23_1158 0 n46 ns1158 0 -0.000439113760351
Gc23_1159 0 n46 ns1159 0 -0.00028886990524
Gc23_1160 0 n46 ns1160 0 0.000400139690521
Gc23_1161 0 n46 ns1161 0 0.000292681985917
Gc23_1162 0 n46 ns1162 0 -0.00169233470604
Gc23_1163 0 n46 ns1163 0 0.00010700381002
Gc23_1164 0 n46 ns1164 0 0.000874615307619
Gc23_1165 0 n46 ns1165 0 0.00221476587694
Gc23_1166 0 n46 ns1166 0 0.00129294968829
Gc23_1167 0 n46 ns1167 0 -0.00195162616572
Gc23_1168 0 n46 ns1168 0 0.000282598191172
Gc23_1169 0 n46 ns1169 0 0.000803134440048
Gc23_1170 0 n46 ns1170 0 0.000122095671377
Gc23_1171 0 n46 ns1171 0 5.27315849812e-05
Gc23_1172 0 n46 ns1172 0 0.00254999418598
Gc23_1173 0 n46 ns1173 0 0.000143443413374
Gc23_1174 0 n46 ns1174 0 0.0250158398573
Gc23_1175 0 n46 ns1175 0 -0.0244753106229
Gc23_1176 0 n46 ns1176 0 0.00661977797321
Gc23_1177 0 n46 ns1177 0 -3.44435548525e-06
Gc23_1178 0 n46 ns1178 0 2.84949216648e-05
Gc23_1179 0 n46 ns1179 0 -0.00156499994082
Gc23_1180 0 n46 ns1180 0 0.000919551392541
Gc23_1181 0 n46 ns1181 0 -0.00146395009767
Gc23_1182 0 n46 ns1182 0 0.000689418592159
Gc23_1183 0 n46 ns1183 0 -0.000751143867499
Gc23_1184 0 n46 ns1184 0 0.000549389567509
Gc23_1185 0 n46 ns1185 0 -0.000124836008334
Gc23_1186 0 n46 ns1186 0 -0.000121359296217
Gc23_1187 0 n46 ns1187 0 -2.03627607036e-05
Gc23_1188 0 n46 ns1188 0 -0.00240447800797
Gc23_1189 0 n46 ns1189 0 0.000406320028394
Gc23_1190 0 n46 ns1190 0 0.0003344315969
Gc23_1191 0 n46 ns1191 0 -0.000584943234054
Gc23_1192 0 n46 ns1192 0 0.000337900573317
Gc23_1193 0 n46 ns1193 0 -0.000368837171986
Gc23_1194 0 n46 ns1194 0 -0.00163819679485
Gc23_1195 0 n46 ns1195 0 0.00102693806624
Gc23_1196 0 n46 ns1196 0 0.000245581086234
Gc23_1197 0 n46 ns1197 0 -0.000537267399301
Gc23_1198 0 n46 ns1198 0 0.00033838550255
Gc23_1199 0 n46 ns1199 0 0.000163151946301
Gc23_1200 0 n46 ns1200 0 -0.000557450331493
Gc23_1201 0 n46 ns1201 0 0.00321731959708
Gc23_1202 0 n46 ns1202 0 2.96461283846e-05
Gc23_1203 0 n46 ns1203 0 0.000115921984629
Gc23_1204 0 n46 ns1204 0 0.000694178812434
Gc23_1205 0 n46 ns1205 0 -0.000963347602535
Gc23_1206 0 n46 ns1206 0 0.00207160761167
Gc23_1207 0 n46 ns1207 0 0.00196897194328
Gc23_1208 0 n46 ns1208 0 -0.00230330730344
Gc23_1209 0 n46 ns1209 0 -4.91024144261e-05
Gc23_1210 0 n46 ns1210 0 0.00166808073663
Gc23_1211 0 n46 ns1211 0 6.20827302481e-05
Gc23_1212 0 n46 ns1212 0 0.0471008011611
Gc23_1213 0 n46 ns1213 0 -0.0462488580095
Gc23_1214 0 n46 ns1214 0 0.00365037056779
Gc23_1215 0 n46 ns1215 0 -4.66082076488e-07
Gc23_1216 0 n46 ns1216 0 2.82087353519e-05
Gd23_1 0 n46 ni1 0 -8.32356198859e-05
Gd23_2 0 n46 ni2 0 -2.2852904466e-05
Gd23_3 0 n46 ni3 0 0.000252937187119
Gd23_4 0 n46 ni4 0 0.000227535386937
Gd23_5 0 n46 ni5 0 0.000577173671361
Gd23_6 0 n46 ni6 0 -0.000457068294975
Gd23_7 0 n46 ni7 0 -0.00680736897698
Gd23_8 0 n46 ni8 0 -0.00030434219225
Gd23_9 0 n46 ni9 0 0.000556962355805
Gd23_10 0 n46 ni10 0 0.00024490492868
Gd23_11 0 n46 ni11 0 0.000288513211564
Gd23_12 0 n46 ni12 0 0.000240456782882
Gd23_13 0 n46 ni13 0 -0.000177672316653
Gd23_14 0 n46 ni14 0 -0.00313956749142
Gd23_15 0 n46 ni15 0 -0.00156556434766
Gd23_16 0 n46 ni16 0 -5.84742669889e-05
Gd23_17 0 n46 ni17 0 -0.000103726971943
Gd23_18 0 n46 ni18 0 -6.72281788023e-05
Gd23_19 0 n46 ni19 0 -5.82084108077e-05
Gd23_20 0 n46 ni20 0 0.000154272850159
Gd23_21 0 n46 ni21 0 -0.000411907817747
Gd23_22 0 n46 ni22 0 -0.00177973488904
Gd23_23 0 n46 ni23 0 0.000780118143333
Gd23_24 0 n46 ni24 0 -0.00171016007333
Gd23_25 0 n46 ni25 0 -0.000239250854703
Gd23_26 0 n46 ni26 0 4.65727700302e-05
Gd23_27 0 n46 ni27 0 7.42765991013e-05
Gd23_28 0 n46 ni28 0 9.76897435949e-05
Gd23_29 0 n46 ni29 0 -0.00115844474539
Gd23_30 0 n46 ni30 0 -0.0009175097633
Gd23_31 0 n46 ni31 0 -0.0026856468173
Gd23_32 0 n46 ni32 0 -0.000626448406643
Gc24_1 0 n48 ns1 0 -3.72961552144e-05
Gc24_2 0 n48 ns2 0 -0.000100302506423
Gc24_3 0 n48 ns3 0 -0.00105602875432
Gc24_4 0 n48 ns4 0 -0.000181926975949
Gc24_5 0 n48 ns5 0 8.1278445291e-05
Gc24_6 0 n48 ns6 0 4.60605499931e-05
Gc24_7 0 n48 ns7 0 0.000164531330989
Gc24_8 0 n48 ns8 0 3.85439886878e-05
Gc24_9 0 n48 ns9 0 -1.80476084599e-05
Gc24_10 0 n48 ns10 0 -0.000404200745843
Gc24_11 0 n48 ns11 0 -9.91005013548e-05
Gc24_12 0 n48 ns12 0 0.000316878644358
Gc24_13 0 n48 ns13 0 0.000209702896089
Gc24_14 0 n48 ns14 0 5.2546413369e-05
Gc24_15 0 n48 ns15 0 -0.000132631481155
Gc24_16 0 n48 ns16 0 4.79181631156e-05
Gc24_17 0 n48 ns17 0 0.000780047646902
Gc24_18 0 n48 ns18 0 0.000393398442714
Gc24_19 0 n48 ns19 0 -0.000287378517118
Gc24_20 0 n48 ns20 0 -7.45674298691e-05
Gc24_21 0 n48 ns21 0 -0.000114695437647
Gc24_22 0 n48 ns22 0 0.0004039749409
Gc24_23 0 n48 ns23 0 -0.000135339733485
Gc24_24 0 n48 ns24 0 -0.000215302341494
Gc24_25 0 n48 ns25 0 9.19842960556e-05
Gc24_26 0 n48 ns26 0 0.000158399607825
Gc24_27 0 n48 ns27 0 -1.71694762279e-05
Gc24_28 0 n48 ns28 0 0.000517477838163
Gc24_29 0 n48 ns29 0 0.00101317982408
Gc24_30 0 n48 ns30 0 0.00032875558425
Gc24_31 0 n48 ns31 0 -0.000188424507664
Gc24_32 0 n48 ns32 0 -9.00225463925e-05
Gc24_33 0 n48 ns33 0 -0.000190837078071
Gc24_34 0 n48 ns34 0 0.0101784761841
Gc24_35 0 n48 ns35 0 -0.00859314705184
Gc24_36 0 n48 ns36 0 0.00022721185832
Gc24_37 0 n48 ns37 0 5.52056210601e-06
Gc24_38 0 n48 ns38 0 -2.74750965823e-05
Gc24_39 0 n48 ns39 0 0.000148020689557
Gc24_40 0 n48 ns40 0 -0.000241504381078
Gc24_41 0 n48 ns41 0 -0.000607046354904
Gc24_42 0 n48 ns42 0 -0.000237174548553
Gc24_43 0 n48 ns43 0 0.000156585944758
Gc24_44 0 n48 ns44 0 8.15327468981e-05
Gc24_45 0 n48 ns45 0 0.000152450481349
Gc24_46 0 n48 ns46 0 2.94096237991e-05
Gc24_47 0 n48 ns47 0 -1.0489482657e-05
Gc24_48 0 n48 ns48 0 -0.00036823326049
Gc24_49 0 n48 ns49 0 -0.000366674350685
Gc24_50 0 n48 ns50 0 0.000285844101846
Gc24_51 0 n48 ns51 0 0.000352502799115
Gc24_52 0 n48 ns52 0 9.90478031519e-05
Gc24_53 0 n48 ns53 0 -0.000130689560954
Gc24_54 0 n48 ns54 0 -9.5343814806e-05
Gc24_55 0 n48 ns55 0 0.000772756779363
Gc24_56 0 n48 ns56 0 0.000479014403022
Gc24_57 0 n48 ns57 0 -0.00023571927911
Gc24_58 0 n48 ns58 0 -7.26478314491e-05
Gc24_59 0 n48 ns59 0 -0.000144422071863
Gc24_60 0 n48 ns60 0 0.000346906578376
Gc24_61 0 n48 ns61 0 -0.000340604357103
Gc24_62 0 n48 ns62 0 -0.000397534706327
Gc24_63 0 n48 ns63 0 0.000148649248317
Gc24_64 0 n48 ns64 0 0.000277835176199
Gc24_65 0 n48 ns65 0 1.10176245324e-05
Gc24_66 0 n48 ns66 0 0.000134867794911
Gc24_67 0 n48 ns67 0 0.000949156851934
Gc24_68 0 n48 ns68 0 0.000399968064306
Gc24_69 0 n48 ns69 0 -6.41527578e-05
Gc24_70 0 n48 ns70 0 -5.88844023516e-05
Gc24_71 0 n48 ns71 0 -0.000234470813321
Gc24_72 0 n48 ns72 0 0.00859292908296
Gc24_73 0 n48 ns73 0 -0.00728480100656
Gc24_74 0 n48 ns74 0 0.000183151939543
Gc24_75 0 n48 ns75 0 4.92467255e-06
Gc24_76 0 n48 ns76 0 -2.96254762177e-05
Gc24_77 0 n48 ns77 0 0.000520718804714
Gc24_78 0 n48 ns78 0 -0.00105373295759
Gc24_79 0 n48 ns79 0 0.00192904145846
Gc24_80 0 n48 ns80 0 -0.000113358166301
Gc24_81 0 n48 ns81 0 0.000142817444488
Gc24_82 0 n48 ns82 0 2.83871832876e-05
Gc24_83 0 n48 ns83 0 3.53996032442e-05
Gc24_84 0 n48 ns84 0 -5.59422677418e-06
Gc24_85 0 n48 ns85 0 -2.87608857296e-07
Gc24_86 0 n48 ns86 0 0.000286248324194
Gc24_87 0 n48 ns87 0 -0.000898568742317
Gc24_88 0 n48 ns88 0 -0.000253654905325
Gc24_89 0 n48 ns89 0 0.000509015038916
Gc24_90 0 n48 ns90 0 0.000200650181338
Gc24_91 0 n48 ns91 0 3.51937625799e-05
Gc24_92 0 n48 ns92 0 -0.000650060431654
Gc24_93 0 n48 ns93 0 -5.59626968792e-05
Gc24_94 0 n48 ns94 0 0.000417891599632
Gc24_95 0 n48 ns95 0 0.000325892315887
Gc24_96 0 n48 ns96 0 3.20081052229e-05
Gc24_97 0 n48 ns97 0 -0.000166977517585
Gc24_98 0 n48 ns98 0 -2.55547687301e-05
Gc24_99 0 n48 ns99 0 -0.000931486470099
Gc24_100 0 n48 ns100 0 -0.00103989535394
Gc24_101 0 n48 ns101 0 7.52709416681e-05
Gc24_102 0 n48 ns102 0 0.000635079351387
Gc24_103 0 n48 ns103 0 0.000295938308043
Gc24_104 0 n48 ns104 0 -0.00198082751605
Gc24_105 0 n48 ns105 0 0.00035986101733
Gc24_106 0 n48 ns106 0 0.000694235076052
Gc24_107 0 n48 ns107 0 0.000677697261741
Gc24_108 0 n48 ns108 0 0.00016015886381
Gc24_109 0 n48 ns109 0 -0.000432081144863
Gc24_110 0 n48 ns110 0 -0.000317608058299
Gc24_111 0 n48 ns111 0 -3.98183663189e-05
Gc24_112 0 n48 ns112 0 -4.1090312342e-05
Gc24_113 0 n48 ns113 0 7.30885157029e-06
Gc24_114 0 n48 ns114 0 -3.4532697244e-05
Gc24_115 0 n48 ns115 0 0.000411521978312
Gc24_116 0 n48 ns116 0 -0.000536874296995
Gc24_117 0 n48 ns117 0 0.00317177983424
Gc24_118 0 n48 ns118 0 -0.000162874695438
Gc24_119 0 n48 ns119 0 0.000334558690508
Gc24_120 0 n48 ns120 0 0.000229793157755
Gc24_121 0 n48 ns121 0 9.8236292444e-06
Gc24_122 0 n48 ns122 0 9.40405094814e-06
Gc24_123 0 n48 ns123 0 -4.47718515202e-05
Gc24_124 0 n48 ns124 0 0.000688110502792
Gc24_125 0 n48 ns125 0 -0.000910383268295
Gc24_126 0 n48 ns126 0 -0.000520661854765
Gc24_127 0 n48 ns127 0 0.000146189131285
Gc24_128 0 n48 ns128 0 0.000189670857637
Gc24_129 0 n48 ns129 0 0.000226098811958
Gc24_130 0 n48 ns130 0 -0.000166795025504
Gc24_131 0 n48 ns131 0 -0.00130505898605
Gc24_132 0 n48 ns132 0 -0.000371231518022
Gc24_133 0 n48 ns133 0 0.000764022174723
Gc24_134 0 n48 ns134 0 0.000158603053719
Gc24_135 0 n48 ns135 0 -6.00814301538e-05
Gc24_136 0 n48 ns136 0 -0.000199914002591
Gc24_137 0 n48 ns137 0 -0.00139764794184
Gc24_138 0 n48 ns138 0 -0.00139114246609
Gc24_139 0 n48 ns139 0 -0.000703047184057
Gc24_140 0 n48 ns140 0 0.000641756026733
Gc24_141 0 n48 ns141 0 0.000960688962579
Gc24_142 0 n48 ns142 0 -0.00416994140805
Gc24_143 0 n48 ns143 0 -0.00139680441515
Gc24_144 0 n48 ns144 0 0.000593776571125
Gc24_145 0 n48 ns145 0 0.00188378184329
Gc24_146 0 n48 ns146 0 0.000616259654861
Gc24_147 0 n48 ns147 0 -0.000603548580324
Gc24_148 0 n48 ns148 0 -0.0120814038207
Gc24_149 0 n48 ns149 0 0.00966803459709
Gc24_150 0 n48 ns150 0 -0.000346782202038
Gc24_151 0 n48 ns151 0 2.60351478301e-06
Gc24_152 0 n48 ns152 0 -2.65634036871e-05
Gc24_153 0 n48 ns153 0 0.000265223315702
Gc24_154 0 n48 ns154 0 -0.000970319366542
Gc24_155 0 n48 ns155 0 0.0067180460084
Gc24_156 0 n48 ns156 0 0.000146651165222
Gc24_157 0 n48 ns157 0 0.000289051398448
Gc24_158 0 n48 ns158 0 0.000325714401983
Gc24_159 0 n48 ns159 0 6.99277375833e-05
Gc24_160 0 n48 ns160 0 7.2625840071e-07
Gc24_161 0 n48 ns161 0 3.82607778559e-06
Gc24_162 0 n48 ns162 0 -0.000297911997857
Gc24_163 0 n48 ns163 0 -0.00208568539168
Gc24_164 0 n48 ns164 0 -1.49354019739e-05
Gc24_165 0 n48 ns165 0 0.000261543058497
Gc24_166 0 n48 ns166 0 0.000214495826979
Gc24_167 0 n48 ns167 0 0.000371390010198
Gc24_168 0 n48 ns168 0 0.000627258262765
Gc24_169 0 n48 ns169 0 -0.0011267880951
Gc24_170 0 n48 ns170 0 -0.00106992979175
Gc24_171 0 n48 ns171 0 0.000245571122671
Gc24_172 0 n48 ns172 0 0.000173939922732
Gc24_173 0 n48 ns173 0 4.78006581508e-05
Gc24_174 0 n48 ns174 0 -0.00122810021516
Gc24_175 0 n48 ns175 0 -0.00250548495057
Gc24_176 0 n48 ns176 0 -0.00117162254752
Gc24_177 0 n48 ns177 0 -0.00117571634
Gc24_178 0 n48 ns178 0 0.000333889944478
Gc24_179 0 n48 ns179 0 0.00152133579536
Gc24_180 0 n48 ns180 0 -0.00694346152915
Gc24_181 0 n48 ns181 0 -0.00438193208717
Gc24_182 0 n48 ns182 0 -0.000237555491611
Gc24_183 0 n48 ns183 0 0.00359065418138
Gc24_184 0 n48 ns184 0 0.00145880358886
Gc24_185 0 n48 ns185 0 -0.000644279427743
Gc24_186 0 n48 ns186 0 -0.0382859593169
Gc24_187 0 n48 ns187 0 0.0321375276573
Gc24_188 0 n48 ns188 0 -0.00123260441374
Gc24_189 0 n48 ns189 0 -4.95375378726e-06
Gc24_190 0 n48 ns190 0 -7.6022145093e-06
Gc24_191 0 n48 ns191 0 0.000708364996204
Gc24_192 0 n48 ns192 0 -0.0010120307052
Gc24_193 0 n48 ns193 0 0.0116025599227
Gc24_194 0 n48 ns194 0 0.000324675766257
Gc24_195 0 n48 ns195 0 0.000582488457892
Gc24_196 0 n48 ns196 0 0.000419411897618
Gc24_197 0 n48 ns197 0 -0.000311490106801
Gc24_198 0 n48 ns198 0 -0.000121707193964
Gc24_199 0 n48 ns199 0 -3.35064775301e-05
Gc24_200 0 n48 ns200 0 3.06712101858e-05
Gc24_201 0 n48 ns201 0 -0.00372322015848
Gc24_202 0 n48 ns202 0 8.48172352235e-05
Gc24_203 0 n48 ns203 0 0.000612682356108
Gc24_204 0 n48 ns204 0 2.48921785819e-06
Gc24_205 0 n48 ns205 0 0.000517565013911
Gc24_206 0 n48 ns206 0 -0.000925733012308
Gc24_207 0 n48 ns207 0 -0.0013842536915
Gc24_208 0 n48 ns208 0 -0.000947863833874
Gc24_209 0 n48 ns209 0 0.000186079549681
Gc24_210 0 n48 ns210 0 0.000358560352942
Gc24_211 0 n48 ns211 0 0.000221384515933
Gc24_212 0 n48 ns212 0 -0.00263996945637
Gc24_213 0 n48 ns213 0 -0.00468117678118
Gc24_214 0 n48 ns214 0 -0.00128422967678
Gc24_215 0 n48 ns215 0 -0.000300496939036
Gc24_216 0 n48 ns216 0 0.000223451882957
Gc24_217 0 n48 ns217 0 0.00159125723422
Gc24_218 0 n48 ns218 0 -0.00973188898395
Gc24_219 0 n48 ns219 0 -0.00622578899969
Gc24_220 0 n48 ns220 0 -0.00177453290648
Gc24_221 0 n48 ns221 0 0.00421513186108
Gc24_222 0 n48 ns222 0 0.00245934614309
Gc24_223 0 n48 ns223 0 -0.00025088719699
Gc24_224 0 n48 ns224 0 -0.0779811187454
Gc24_225 0 n48 ns225 0 0.0677345586996
Gc24_226 0 n48 ns226 0 -0.00313203799147
Gc24_227 0 n48 ns227 0 -1.03181803639e-05
Gc24_228 0 n48 ns228 0 1.18901553425e-05
Gc24_229 0 n48 ns229 0 -0.000499778835804
Gc24_230 0 n48 ns230 0 0.00049771185715
Gc24_231 0 n48 ns231 0 0.00502297614519
Gc24_232 0 n48 ns232 0 -0.00129833988109
Gc24_233 0 n48 ns233 0 -0.000554005193329
Gc24_234 0 n48 ns234 0 0.00187471137382
Gc24_235 0 n48 ns235 0 0.000525891225802
Gc24_236 0 n48 ns236 0 -0.000158686726471
Gc24_237 0 n48 ns237 0 -0.000180747320811
Gc24_238 0 n48 ns238 0 0.00127117601684
Gc24_239 0 n48 ns239 0 -0.00137489119945
Gc24_240 0 n48 ns240 0 -8.76166769599e-05
Gc24_241 0 n48 ns241 0 0.00042312146768
Gc24_242 0 n48 ns242 0 -0.000326733002117
Gc24_243 0 n48 ns243 0 0.000353247600989
Gc24_244 0 n48 ns244 0 0.000533240920173
Gc24_245 0 n48 ns245 0 -0.00304877524817
Gc24_246 0 n48 ns246 0 -0.00132442433598
Gc24_247 0 n48 ns247 0 -0.000281427036276
Gc24_248 0 n48 ns248 0 0.000226986747827
Gc24_249 0 n48 ns249 0 0.00051220155695
Gc24_250 0 n48 ns250 0 0.000953071220856
Gc24_251 0 n48 ns251 0 -0.0046237474418
Gc24_252 0 n48 ns252 0 -0.00194882872937
Gc24_253 0 n48 ns253 0 -0.00110808856749
Gc24_254 0 n48 ns254 0 -0.000420333373796
Gc24_255 0 n48 ns255 0 0.00201736347438
Gc24_256 0 n48 ns256 0 -0.0110129887054
Gc24_257 0 n48 ns257 0 -0.0058360804686
Gc24_258 0 n48 ns258 0 -0.00152658043742
Gc24_259 0 n48 ns259 0 0.00270968633616
Gc24_260 0 n48 ns260 0 0.00309459602603
Gc24_261 0 n48 ns261 0 0.000479317681808
Gc24_262 0 n48 ns262 0 -0.0681394166173
Gc24_263 0 n48 ns263 0 0.0651371439503
Gc24_264 0 n48 ns264 0 -0.0064357261294
Gc24_265 0 n48 ns265 0 -1.31736919002e-05
Gc24_266 0 n48 ns266 0 3.19204745426e-05
Gc24_267 0 n48 ns267 0 -0.0172175585815
Gc24_268 0 n48 ns268 0 -0.00101838405894
Gc24_269 0 n48 ns269 0 0.0192606552089
Gc24_270 0 n48 ns270 0 0.00643253709139
Gc24_271 0 n48 ns271 0 0.00994506060902
Gc24_272 0 n48 ns272 0 0.00121160065076
Gc24_273 0 n48 ns273 0 -0.00331087699423
Gc24_274 0 n48 ns274 0 -0.000531509804013
Gc24_275 0 n48 ns275 0 7.58769303352e-05
Gc24_276 0 n48 ns276 0 -0.00185824039455
Gc24_277 0 n48 ns277 0 -0.0140545575752
Gc24_278 0 n48 ns278 0 0.0015620503443
Gc24_279 0 n48 ns279 0 0.00213185041545
Gc24_280 0 n48 ns280 0 8.57389902702e-05
Gc24_281 0 n48 ns281 0 0.000142336872152
Gc24_282 0 n48 ns282 0 0.000261381688424
Gc24_283 0 n48 ns283 0 0.00185206673037
Gc24_284 0 n48 ns284 0 0.000465210450539
Gc24_285 0 n48 ns285 0 -0.000358925623544
Gc24_286 0 n48 ns286 0 0.000337643036072
Gc24_287 0 n48 ns287 0 0.000398427098726
Gc24_288 0 n48 ns288 0 -0.0118862973938
Gc24_289 0 n48 ns289 0 -0.00709710004426
Gc24_290 0 n48 ns290 0 -0.00240847620264
Gc24_291 0 n48 ns291 0 -0.000517517174566
Gc24_292 0 n48 ns292 0 -0.000465814553522
Gc24_293 0 n48 ns293 0 0.00170225015413
Gc24_294 0 n48 ns294 0 0.0110997822818
Gc24_295 0 n48 ns295 0 -0.00502822561194
Gc24_296 0 n48 ns296 0 0.000904082640436
Gc24_297 0 n48 ns297 0 0.000796519230546
Gc24_298 0 n48 ns298 0 0.00317216552679
Gc24_299 0 n48 ns299 0 0.000496087326411
Gc24_300 0 n48 ns300 0 -0.10504892732
Gc24_301 0 n48 ns301 0 0.0682637491431
Gc24_302 0 n48 ns302 0 -0.00887943609453
Gc24_303 0 n48 ns303 0 -1.35948299919e-05
Gc24_304 0 n48 ns304 0 2.63095643954e-05
Gc24_305 0 n48 ns305 0 -0.000536676021866
Gc24_306 0 n48 ns306 0 0.000590868621116
Gc24_307 0 n48 ns307 0 0.00185836850981
Gc24_308 0 n48 ns308 0 -0.00117974959767
Gc24_309 0 n48 ns309 0 -0.00083127958045
Gc24_310 0 n48 ns310 0 0.00159061050018
Gc24_311 0 n48 ns311 0 0.00021057975314
Gc24_312 0 n48 ns312 0 -0.000187243918684
Gc24_313 0 n48 ns313 0 -0.000189541430346
Gc24_314 0 n48 ns314 0 0.00241940850346
Gc24_315 0 n48 ns315 0 -0.000421915838602
Gc24_316 0 n48 ns316 0 -0.000890421796104
Gc24_317 0 n48 ns317 0 0.000637137880779
Gc24_318 0 n48 ns318 0 -0.000275424807962
Gc24_319 0 n48 ns319 0 0.000169000042
Gc24_320 0 n48 ns320 0 -0.00122308842741
Gc24_321 0 n48 ns321 0 -0.00317766353037
Gc24_322 0 n48 ns322 0 -6.93319690471e-05
Gc24_323 0 n48 ns323 0 0.000295858351056
Gc24_324 0 n48 ns324 0 0.000176307489929
Gc24_325 0 n48 ns325 0 0.000384943185471
Gc24_326 0 n48 ns326 0 0.00195039523063
Gc24_327 0 n48 ns327 0 -0.00389199955081
Gc24_328 0 n48 ns328 0 -0.0022234827853
Gc24_329 0 n48 ns329 0 4.90678548051e-05
Gc24_330 0 n48 ns330 0 -9.69867032568e-05
Gc24_331 0 n48 ns331 0 0.00109815075763
Gc24_332 0 n48 ns332 0 -0.00841771017704
Gc24_333 0 n48 ns333 0 -0.00224237560936
Gc24_334 0 n48 ns334 0 -0.000861524315594
Gc24_335 0 n48 ns335 0 0.000326387724961
Gc24_336 0 n48 ns336 0 0.00230386993403
Gc24_337 0 n48 ns337 0 0.000772165962684
Gc24_338 0 n48 ns338 0 -0.0443567433847
Gc24_339 0 n48 ns339 0 0.0452834719816
Gc24_340 0 n48 ns340 0 -0.00596294792451
Gc24_341 0 n48 ns341 0 -5.67319623687e-06
Gc24_342 0 n48 ns342 0 2.86171267122e-05
Gc24_343 0 n48 ns343 0 0.000424559171334
Gc24_344 0 n48 ns344 0 -0.000785021407743
Gc24_345 0 n48 ns345 0 0.000890001737821
Gc24_346 0 n48 ns346 0 -0.000217983805039
Gc24_347 0 n48 ns347 0 0.000154399795454
Gc24_348 0 n48 ns348 0 4.7331433499e-05
Gc24_349 0 n48 ns349 0 0.000105174933219
Gc24_350 0 n48 ns350 0 1.04295731305e-05
Gc24_351 0 n48 ns351 0 3.65541494583e-06
Gc24_352 0 n48 ns352 0 3.23383933259e-05
Gc24_353 0 n48 ns353 0 -0.000755897299424
Gc24_354 0 n48 ns354 0 -1.07969866036e-05
Gc24_355 0 n48 ns355 0 0.000513854690821
Gc24_356 0 n48 ns356 0 0.000166629678725
Gc24_357 0 n48 ns357 0 -4.46221888636e-05
Gc24_358 0 n48 ns358 0 -0.00044316654507
Gc24_359 0 n48 ns359 0 0.00037501340289
Gc24_360 0 n48 ns360 0 0.000494380962464
Gc24_361 0 n48 ns361 0 5.34616326442e-05
Gc24_362 0 n48 ns362 0 -2.183142143e-05
Gc24_363 0 n48 ns363 0 -0.000165118539917
Gc24_364 0 n48 ns364 0 0.000142090100464
Gc24_365 0 n48 ns365 0 -0.000704385139205
Gc24_366 0 n48 ns366 0 -0.000774343543645
Gc24_367 0 n48 ns367 0 0.000152984252013
Gc24_368 0 n48 ns368 0 0.000496837721188
Gc24_369 0 n48 ns369 0 0.000145860939879
Gc24_370 0 n48 ns370 0 -0.00102467061055
Gc24_371 0 n48 ns371 0 0.000624340697254
Gc24_372 0 n48 ns372 0 0.000562021149588
Gc24_373 0 n48 ns373 0 0.000334594196981
Gc24_374 0 n48 ns374 0 5.49452977409e-05
Gc24_375 0 n48 ns375 0 -0.000341228856251
Gc24_376 0 n48 ns376 0 0.00324522309623
Gc24_377 0 n48 ns377 0 -0.00288189959672
Gc24_378 0 n48 ns378 0 3.8613051485e-05
Gc24_379 0 n48 ns379 0 6.51152955043e-06
Gc24_380 0 n48 ns380 0 -3.21527153534e-05
Gc24_381 0 n48 ns381 0 0.000532635959294
Gc24_382 0 n48 ns382 0 -0.00062201808509
Gc24_383 0 n48 ns383 0 0.00273189831193
Gc24_384 0 n48 ns384 0 -0.000168162541371
Gc24_385 0 n48 ns385 0 0.000338422967487
Gc24_386 0 n48 ns386 0 0.000186031098758
Gc24_387 0 n48 ns387 0 -1.71608238967e-06
Gc24_388 0 n48 ns388 0 -1.25143709359e-05
Gc24_389 0 n48 ns389 0 -4.03886065412e-05
Gc24_390 0 n48 ns390 0 0.000712644337426
Gc24_391 0 n48 ns391 0 -0.000965245556966
Gc24_392 0 n48 ns392 0 -0.000496273953622
Gc24_393 0 n48 ns393 0 0.000316589012835
Gc24_394 0 n48 ns394 0 0.000192080397605
Gc24_395 0 n48 ns395 0 0.00015226057588
Gc24_396 0 n48 ns396 0 -0.000451598882168
Gc24_397 0 n48 ns397 0 -0.000969497987956
Gc24_398 0 n48 ns398 0 -4.06844371594e-05
Gc24_399 0 n48 ns399 0 0.000667666112316
Gc24_400 0 n48 ns400 0 0.000111023841131
Gc24_401 0 n48 ns401 0 -0.000103888689056
Gc24_402 0 n48 ns402 0 -0.000181083530695
Gc24_403 0 n48 ns403 0 -0.00134817738909
Gc24_404 0 n48 ns404 0 -0.00136890747742
Gc24_405 0 n48 ns405 0 -0.000338380038557
Gc24_406 0 n48 ns406 0 0.000712391802851
Gc24_407 0 n48 ns407 0 0.00069535396571
Gc24_408 0 n48 ns408 0 -0.00356464418524
Gc24_409 0 n48 ns409 0 -0.000711608209654
Gc24_410 0 n48 ns410 0 0.000689343115482
Gc24_411 0 n48 ns411 0 0.00146147590996
Gc24_412 0 n48 ns412 0 0.000454865625892
Gc24_413 0 n48 ns413 0 -0.00054851090629
Gc24_414 0 n48 ns414 0 -0.00766488509125
Gc24_415 0 n48 ns415 0 0.00591949600598
Gc24_416 0 n48 ns416 0 -0.00020608057333
Gc24_417 0 n48 ns417 0 5.5763569982e-06
Gc24_418 0 n48 ns418 0 -3.17694994873e-05
Gc24_419 0 n48 ns419 0 0.00024694422245
Gc24_420 0 n48 ns420 0 -0.000371833048465
Gc24_421 0 n48 ns421 0 0.00433242951273
Gc24_422 0 n48 ns422 0 -0.000229828560414
Gc24_423 0 n48 ns423 0 0.000438014913748
Gc24_424 0 n48 ns424 0 0.000380634716014
Gc24_425 0 n48 ns425 0 8.11207543898e-05
Gc24_426 0 n48 ns426 0 2.33889481325e-05
Gc24_427 0 n48 ns427 0 -1.75235896776e-05
Gc24_428 0 n48 ns428 0 0.000268152124019
Gc24_429 0 n48 ns429 0 -0.00135140588057
Gc24_430 0 n48 ns430 0 -0.000248569599558
Gc24_431 0 n48 ns431 0 0.000146585331934
Gc24_432 0 n48 ns432 0 0.000212880907688
Gc24_433 0 n48 ns433 0 0.000296380661885
Gc24_434 0 n48 ns434 0 0.00062550146899
Gc24_435 0 n48 ns435 0 -0.00125360335413
Gc24_436 0 n48 ns436 0 -0.000871092582149
Gc24_437 0 n48 ns437 0 0.000428878537174
Gc24_438 0 n48 ns438 0 0.00014540336869
Gc24_439 0 n48 ns439 0 4.34781199819e-06
Gc24_440 0 n48 ns440 0 -0.00047149920269
Gc24_441 0 n48 ns441 0 -0.00193302238054
Gc24_442 0 n48 ns442 0 -0.00125780025498
Gc24_443 0 n48 ns443 0 -0.00120048566831
Gc24_444 0 n48 ns444 0 0.000407841105358
Gc24_445 0 n48 ns445 0 0.00136906592063
Gc24_446 0 n48 ns446 0 -0.00552039430975
Gc24_447 0 n48 ns447 0 -0.00326384591109
Gc24_448 0 n48 ns448 0 0.000140919975483
Gc24_449 0 n48 ns449 0 0.00290435133812
Gc24_450 0 n48 ns450 0 0.00108040326937
Gc24_451 0 n48 ns451 0 -0.000654455416146
Gc24_452 0 n48 ns452 0 -0.0250798451023
Gc24_453 0 n48 ns453 0 0.020871366085
Gc24_454 0 n48 ns454 0 -0.000794749923152
Gc24_455 0 n48 ns455 0 -1.70095988563e-06
Gc24_456 0 n48 ns456 0 -1.77706450936e-05
Gc24_457 0 n48 ns457 0 0.000610020432084
Gc24_458 0 n48 ns458 0 -0.00202877035066
Gc24_459 0 n48 ns459 0 0.0107737836237
Gc24_460 0 n48 ns460 0 0.000567228615801
Gc24_461 0 n48 ns461 0 7.37838026285e-05
Gc24_462 0 n48 ns462 0 6.19292290474e-05
Gc24_463 0 n48 ns463 0 -3.11051626213e-05
Gc24_464 0 n48 ns464 0 -4.78654190844e-05
Gc24_465 0 n48 ns465 0 1.03285901037e-05
Gc24_466 0 n48 ns466 0 -0.000277250581719
Gc24_467 0 n48 ns467 0 -0.00308941462311
Gc24_468 0 n48 ns468 0 -1.85957426864e-05
Gc24_469 0 n48 ns469 0 0.000501459945819
Gc24_470 0 n48 ns470 0 0.000119654815527
Gc24_471 0 n48 ns471 0 0.000505160683441
Gc24_472 0 n48 ns472 0 -0.000302197884856
Gc24_473 0 n48 ns473 0 -0.000824395899581
Gc24_474 0 n48 ns474 0 -0.000883097915581
Gc24_475 0 n48 ns475 0 9.33899012915e-05
Gc24_476 0 n48 ns476 0 0.000272549163479
Gc24_477 0 n48 ns477 0 9.41672911629e-05
Gc24_478 0 n48 ns478 0 -0.00235942701543
Gc24_479 0 n48 ns479 0 -0.0036028308603
Gc24_480 0 n48 ns480 0 -0.000979957950941
Gc24_481 0 n48 ns481 0 -0.000598265497188
Gc24_482 0 n48 ns482 0 0.000206009988535
Gc24_483 0 n48 ns483 0 0.00147409521157
Gc24_484 0 n48 ns484 0 -0.0083959905111
Gc24_485 0 n48 ns485 0 -0.00566970596607
Gc24_486 0 n48 ns486 0 -0.001298964662
Gc24_487 0 n48 ns487 0 0.00414658330183
Gc24_488 0 n48 ns488 0 0.00209018137867
Gc24_489 0 n48 ns489 0 -0.000417888036648
Gc24_490 0 n48 ns490 0 -0.0622287216663
Gc24_491 0 n48 ns491 0 0.0533151737589
Gc24_492 0 n48 ns492 0 -0.00224511213895
Gc24_493 0 n48 ns493 0 -8.816156433e-06
Gc24_494 0 n48 ns494 0 4.1792771342e-07
Gc24_495 0 n48 ns495 0 7.33511282509e-05
Gc24_496 0 n48 ns496 0 -0.000571812192357
Gc24_497 0 n48 ns497 0 0.00925539983295
Gc24_498 0 n48 ns498 0 -0.000220119900672
Gc24_499 0 n48 ns499 0 6.46388150164e-05
Gc24_500 0 n48 ns500 0 0.000559736782789
Gc24_501 0 n48 ns501 0 -0.000577015125761
Gc24_502 0 n48 ns502 0 -8.17317887147e-05
Gc24_503 0 n48 ns503 0 6.14723810227e-06
Gc24_504 0 n48 ns504 0 0.00138059053438
Gc24_505 0 n48 ns505 0 -0.00143328700884
Gc24_506 0 n48 ns506 0 -0.000181344399885
Gc24_507 0 n48 ns507 0 8.85293848608e-05
Gc24_508 0 n48 ns508 0 -0.000317884306859
Gc24_509 0 n48 ns509 0 0.000424078045683
Gc24_510 0 n48 ns510 0 -0.000508832226427
Gc24_511 0 n48 ns511 0 -0.00251595619
Gc24_512 0 n48 ns512 0 -0.00117564825826
Gc24_513 0 n48 ns513 0 0.000129506993945
Gc24_514 0 n48 ns514 0 0.000332558898111
Gc24_515 0 n48 ns515 0 0.000437458022621
Gc24_516 0 n48 ns516 0 -0.00041500272942
Gc24_517 0 n48 ns517 0 -0.00577086743116
Gc24_518 0 n48 ns518 0 -0.00215179142685
Gc24_519 0 n48 ns519 0 -0.000642700125993
Gc24_520 0 n48 ns520 0 2.66515154847e-05
Gc24_521 0 n48 ns521 0 0.00198642210162
Gc24_522 0 n48 ns522 0 -0.0100872522878
Gc24_523 0 n48 ns523 0 -0.00596069072791
Gc24_524 0 n48 ns524 0 -0.00225943423293
Gc24_525 0 n48 ns525 0 0.00285750821415
Gc24_526 0 n48 ns526 0 0.00276730747939
Gc24_527 0 n48 ns527 0 0.000304473739759
Gc24_528 0 n48 ns528 0 -0.0913272537893
Gc24_529 0 n48 ns529 0 0.0832662149097
Gc24_530 0 n48 ns530 0 -0.0052884975161
Gc24_531 0 n48 ns531 0 -1.25996874467e-05
Gc24_532 0 n48 ns532 0 2.09704646404e-05
Gc24_533 0 n48 ns533 0 -0.00558541100895
Gc24_534 0 n48 ns534 0 -0.00414710329416
Gc24_535 0 n48 ns535 0 0.00646253372069
Gc24_536 0 n48 ns536 0 0.00237585300259
Gc24_537 0 n48 ns537 0 -0.00222086925463
Gc24_538 0 n48 ns538 0 0.000657303007079
Gc24_539 0 n48 ns539 0 0.00296799547894
Gc24_540 0 n48 ns540 0 9.71651580389e-06
Gc24_541 0 n48 ns541 0 -0.000277236159656
Gc24_542 0 n48 ns542 0 -0.00205375452071
Gc24_543 0 n48 ns543 0 -0.00117150082735
Gc24_544 0 n48 ns544 0 -3.40655616581e-05
Gc24_545 0 n48 ns545 0 0.00067915876454
Gc24_546 0 n48 ns546 0 -0.000254285689594
Gc24_547 0 n48 ns547 0 0.000282614872888
Gc24_548 0 n48 ns548 0 0.00327063467825
Gc24_549 0 n48 ns549 0 -0.000926837051904
Gc24_550 0 n48 ns550 0 -0.000519790595179
Gc24_551 0 n48 ns551 0 -0.00162438955939
Gc24_552 0 n48 ns552 0 -2.71207844489e-06
Gc24_553 0 n48 ns553 0 0.000200982291062
Gc24_554 0 n48 ns554 0 0.00244727836668
Gc24_555 0 n48 ns555 0 0.00201058286159
Gc24_556 0 n48 ns556 0 -6.32182735624e-05
Gc24_557 0 n48 ns557 0 -0.00212366398933
Gc24_558 0 n48 ns558 0 -0.00167598270581
Gc24_559 0 n48 ns559 0 0.00143749065902
Gc24_560 0 n48 ns560 0 -0.0116577621092
Gc24_561 0 n48 ns561 0 -0.00485498413291
Gc24_562 0 n48 ns562 0 0.00128632485841
Gc24_563 0 n48 ns563 0 0.00285521402862
Gc24_564 0 n48 ns564 0 0.00354388638224
Gc24_565 0 n48 ns565 0 0.000519433094515
Gc24_566 0 n48 ns566 0 0.017466805007
Gc24_567 0 n48 ns567 0 -0.00768134288651
Gc24_568 0 n48 ns568 0 -0.00777237568501
Gc24_569 0 n48 ns569 0 -1.48148600697e-05
Gc24_570 0 n48 ns570 0 2.63376590266e-05
Gc24_571 0 n48 ns571 0 -0.0025340681875
Gc24_572 0 n48 ns572 0 -0.00229598408036
Gc24_573 0 n48 ns573 0 0.00509946463893
Gc24_574 0 n48 ns574 0 0.00115007880007
Gc24_575 0 n48 ns575 0 -0.00191659387905
Gc24_576 0 n48 ns576 0 0.000430541611099
Gc24_577 0 n48 ns577 0 0.00175747654104
Gc24_578 0 n48 ns578 0 -1.22261292518e-05
Gc24_579 0 n48 ns579 0 -0.000229871365696
Gc24_580 0 n48 ns580 0 0.000727625343485
Gc24_581 0 n48 ns581 0 -0.000486514743256
Gc24_582 0 n48 ns582 0 -0.000895637380338
Gc24_583 0 n48 ns583 0 0.000605626114145
Gc24_584 0 n48 ns584 0 -0.000330829488529
Gc24_585 0 n48 ns585 0 0.000223116971606
Gc24_586 0 n48 ns586 0 0.000457347777552
Gc24_587 0 n48 ns587 0 -0.00218185575804
Gc24_588 0 n48 ns588 0 0.000125273996721
Gc24_589 0 n48 ns589 0 -0.000396672591014
Gc24_590 0 n48 ns590 0 0.00014857122619
Gc24_591 0 n48 ns591 0 0.000290560125829
Gc24_592 0 n48 ns592 0 0.00223856261978
Gc24_593 0 n48 ns593 0 -0.00143039517539
Gc24_594 0 n48 ns594 0 -0.00176757376341
Gc24_595 0 n48 ns595 0 -0.000604075434753
Gc24_596 0 n48 ns596 0 -0.000622685558023
Gc24_597 0 n48 ns597 0 0.00125422349231
Gc24_598 0 n48 ns598 0 -0.00864751221345
Gc24_599 0 n48 ns599 0 -0.00272580974867
Gc24_600 0 n48 ns600 0 -0.000227002068413
Gc24_601 0 n48 ns601 0 0.000419767945128
Gc24_602 0 n48 ns602 0 0.00268715189555
Gc24_603 0 n48 ns603 0 0.000793160371257
Gc24_604 0 n48 ns604 0 -0.0266131266215
Gc24_605 0 n48 ns605 0 0.0307928682594
Gc24_606 0 n48 ns606 0 -0.00704886028085
Gc24_607 0 n48 ns607 0 -8.40542157247e-06
Gc24_608 0 n48 ns608 0 2.68032644622e-05
Gc24_609 0 n48 ns609 0 -0.000135613749073
Gc24_610 0 n48 ns610 0 0.000335605520987
Gc24_611 0 n48 ns611 0 -0.00264189435063
Gc24_612 0 n48 ns612 0 -0.000207551131068
Gc24_613 0 n48 ns613 0 -0.000127185112724
Gc24_614 0 n48 ns614 0 -0.000137031269396
Gc24_615 0 n48 ns615 0 2.10756562794e-05
Gc24_616 0 n48 ns616 0 -7.92571469384e-06
Gc24_617 0 n48 ns617 0 1.04948460482e-05
Gc24_618 0 n48 ns618 0 0.000679546309861
Gc24_619 0 n48 ns619 0 0.00103883002751
Gc24_620 0 n48 ns620 0 -0.000377764832575
Gc24_621 0 n48 ns621 0 -0.000344767202946
Gc24_622 0 n48 ns622 0 -8.3384623687e-05
Gc24_623 0 n48 ns623 0 0.000102377905142
Gc24_624 0 n48 ns624 0 0.000221171654106
Gc24_625 0 n48 ns625 0 0.000815259208814
Gc24_626 0 n48 ns626 0 0.000367039321392
Gc24_627 0 n48 ns627 0 -0.000306275093146
Gc24_628 0 n48 ns628 0 -6.43484833046e-05
Gc24_629 0 n48 ns629 0 -0.000102492524607
Gc24_630 0 n48 ns630 0 0.00118515909024
Gc24_631 0 n48 ns631 0 0.000480035850891
Gc24_632 0 n48 ns632 0 0.000295066847546
Gc24_633 0 n48 ns633 0 -0.000551962451577
Gc24_634 0 n48 ns634 0 -0.00034825382409
Gc24_635 0 n48 ns635 0 0.000165461033179
Gc24_636 0 n48 ns636 0 0.00137732500658
Gc24_637 0 n48 ns637 0 0.000659108013081
Gc24_638 0 n48 ns638 0 0.000172022373377
Gc24_639 0 n48 ns639 0 -0.000261970075349
Gc24_640 0 n48 ns640 0 -0.000115547148879
Gc24_641 0 n48 ns641 0 -0.000151480368966
Gc24_642 0 n48 ns642 0 0.0142342904939
Gc24_643 0 n48 ns643 0 -0.0120297109193
Gc24_644 0 n48 ns644 0 0.000415942781698
Gc24_645 0 n48 ns645 0 -7.44147714217e-06
Gc24_646 0 n48 ns646 0 -2.50410302581e-05
Gc24_647 0 n48 ns647 0 -4.08135916611e-05
Gc24_648 0 n48 ns648 0 0.000221819730109
Gc24_649 0 n48 ns649 0 -0.00296848368557
Gc24_650 0 n48 ns650 0 -0.0002493488042
Gc24_651 0 n48 ns651 0 -0.000178405809808
Gc24_652 0 n48 ns652 0 -0.000161405838047
Gc24_653 0 n48 ns653 0 2.14272066452e-05
Gc24_654 0 n48 ns654 0 6.37787850379e-07
Gc24_655 0 n48 ns655 0 1.26079105219e-05
Gc24_656 0 n48 ns656 0 0.000649953812933
Gc24_657 0 n48 ns657 0 0.00129181489073
Gc24_658 0 n48 ns658 0 -0.000371164492799
Gc24_659 0 n48 ns659 0 -0.000471723716365
Gc24_660 0 n48 ns660 0 -0.000124853647895
Gc24_661 0 n48 ns661 0 0.00011250571095
Gc24_662 0 n48 ns662 0 6.99979065341e-05
Gc24_663 0 n48 ns663 0 0.00100949565673
Gc24_664 0 n48 ns664 0 0.000530520693281
Gc24_665 0 n48 ns665 0 -0.000275801288012
Gc24_666 0 n48 ns666 0 -5.55604679827e-05
Gc24_667 0 n48 ns667 0 -0.000147379607585
Gc24_668 0 n48 ns668 0 0.00144491847972
Gc24_669 0 n48 ns669 0 0.000779727655609
Gc24_670 0 n48 ns670 0 0.00048243486177
Gc24_671 0 n48 ns671 0 -0.000678559467845
Gc24_672 0 n48 ns672 0 -0.000493489005359
Gc24_673 0 n48 ns673 0 0.000162394927811
Gc24_674 0 n48 ns674 0 0.00176764630992
Gc24_675 0 n48 ns675 0 0.00081928939406
Gc24_676 0 n48 ns676 0 0.000191185544515
Gc24_677 0 n48 ns677 0 -0.000324099943814
Gc24_678 0 n48 ns678 0 -0.000145084910154
Gc24_679 0 n48 ns679 0 -0.000184778831315
Gc24_680 0 n48 ns680 0 0.0172908972841
Gc24_681 0 n48 ns681 0 -0.0145965066565
Gc24_682 0 n48 ns682 0 0.00049539671211
Gc24_683 0 n48 ns683 0 -5.1936665466e-06
Gc24_684 0 n48 ns684 0 -2.80877534926e-05
Gc24_685 0 n48 ns685 0 0.000188376871419
Gc24_686 0 n48 ns686 0 -0.000428873755562
Gc24_687 0 n48 ns687 0 -0.00141031826774
Gc24_688 0 n48 ns688 0 -0.000111010270239
Gc24_689 0 n48 ns689 0 -0.000129361882968
Gc24_690 0 n48 ns690 0 -5.71149135305e-05
Gc24_691 0 n48 ns691 0 5.0212240554e-05
Gc24_692 0 n48 ns692 0 2.93452289784e-05
Gc24_693 0 n48 ns693 0 9.413949336e-06
Gc24_694 0 n48 ns694 0 -0.000111709846272
Gc24_695 0 n48 ns695 0 0.000671677792117
Gc24_696 0 n48 ns696 0 0.000135369413093
Gc24_697 0 n48 ns697 0 -0.000383780527379
Gc24_698 0 n48 ns698 0 -0.000170337730815
Gc24_699 0 n48 ns699 0 1.46598932391e-05
Gc24_700 0 n48 ns700 0 -0.000784493619251
Gc24_701 0 n48 ns701 0 0.000451135333553
Gc24_702 0 n48 ns702 0 0.000611408623971
Gc24_703 0 n48 ns703 0 0.000348171493086
Gc24_704 0 n48 ns704 0 7.41301845125e-05
Gc24_705 0 n48 ns705 0 -0.000187138194389
Gc24_706 0 n48 ns706 0 0.000787774524737
Gc24_707 0 n48 ns707 0 0.00139885126023
Gc24_708 0 n48 ns708 0 0.00102543368782
Gc24_709 0 n48 ns709 0 -0.000397975142091
Gc24_710 0 n48 ns710 0 -0.00072792204513
Gc24_711 0 n48 ns711 0 -0.000149253259682
Gc24_712 0 n48 ns712 0 0.00120210632541
Gc24_713 0 n48 ns713 0 0.00111630058116
Gc24_714 0 n48 ns714 0 0.000417699558349
Gc24_715 0 n48 ns715 0 -5.4411966574e-05
Gc24_716 0 n48 ns716 0 -7.20802565774e-05
Gc24_717 0 n48 ns717 0 -0.000358535604748
Gc24_718 0 n48 ns718 0 0.0176186453413
Gc24_719 0 n48 ns719 0 -0.0151864142484
Gc24_720 0 n48 ns720 0 0.00055429263662
Gc24_721 0 n48 ns721 0 -3.74339477056e-06
Gc24_722 0 n48 ns722 0 -3.35379282254e-05
Gc24_723 0 n48 ns723 0 -1.18731665419e-05
Gc24_724 0 n48 ns724 0 -0.00038988104938
Gc24_725 0 n48 ns725 0 0.00103731547441
Gc24_726 0 n48 ns726 0 -4.56610315606e-05
Gc24_727 0 n48 ns727 0 0.000156523908002
Gc24_728 0 n48 ns728 0 6.64945593481e-05
Gc24_729 0 n48 ns729 0 4.88033992994e-05
Gc24_730 0 n48 ns730 0 -1.57723067954e-05
Gc24_731 0 n48 ns731 0 5.65399082584e-06
Gc24_732 0 n48 ns732 0 -0.000250518399085
Gc24_733 0 n48 ns733 0 -0.000150309194119
Gc24_734 0 n48 ns734 0 0.000510203379869
Gc24_735 0 n48 ns735 0 0.000130752134293
Gc24_736 0 n48 ns736 0 -0.00013398842694
Gc24_737 0 n48 ns737 0 -0.00019353594264
Gc24_738 0 n48 ns738 0 -0.000304774785577
Gc24_739 0 n48 ns739 0 -0.00091000001102
Gc24_740 0 n48 ns740 0 -0.000207464257219
Gc24_741 0 n48 ns741 0 0.000790400216695
Gc24_742 0 n48 ns742 0 0.000195144903379
Gc24_743 0 n48 ns743 0 -8.61326689795e-05
Gc24_744 0 n48 ns744 0 -0.000625698015455
Gc24_745 0 n48 ns745 0 0.00035943302329
Gc24_746 0 n48 ns746 0 0.000846394983553
Gc24_747 0 n48 ns747 0 0.000730416415942
Gc24_748 0 n48 ns748 0 -0.000406507405999
Gc24_749 0 n48 ns749 0 -0.000731207268123
Gc24_750 0 n48 ns750 0 -0.00127994536959
Gc24_751 0 n48 ns751 0 -3.507101487e-05
Gc24_752 0 n48 ns752 0 0.00046348549052
Gc24_753 0 n48 ns753 0 0.00117230011765
Gc24_754 0 n48 ns754 0 0.000399300808988
Gc24_755 0 n48 ns755 0 -0.000588667896798
Gc24_756 0 n48 ns756 0 0.00877749723398
Gc24_757 0 n48 ns757 0 -0.00860814348151
Gc24_758 0 n48 ns758 0 0.000509905260003
Gc24_759 0 n48 ns759 0 -3.37425819775e-06
Gc24_760 0 n48 ns760 0 -2.60843379283e-05
Gc24_761 0 n48 ns761 0 -0.000605781557276
Gc24_762 0 n48 ns762 0 0.00144998817137
Gc24_763 0 n48 ns763 0 -0.00215597516005
Gc24_764 0 n48 ns764 0 -0.000159223851857
Gc24_765 0 n48 ns765 0 -0.000179616181009
Gc24_766 0 n48 ns766 0 -0.000162364301582
Gc24_767 0 n48 ns767 0 -0.000124208828803
Gc24_768 0 n48 ns768 0 -8.88076128467e-06
Gc24_769 0 n48 ns769 0 -1.73348842164e-05
Gc24_770 0 n48 ns770 0 -0.000509775776061
Gc24_771 0 n48 ns771 0 0.00139042872537
Gc24_772 0 n48 ns772 0 0.000225030109459
Gc24_773 0 n48 ns773 0 2.81078913237e-05
Gc24_774 0 n48 ns774 0 -8.4126190283e-05
Gc24_775 0 n48 ns775 0 -0.000376685334863
Gc24_776 0 n48 ns776 0 0.000740929959651
Gc24_777 0 n48 ns777 0 0.000529245580391
Gc24_778 0 n48 ns778 0 -0.000456558731129
Gc24_779 0 n48 ns779 0 0.000120172905452
Gc24_780 0 n48 ns780 0 0.00027131190615
Gc24_781 0 n48 ns781 0 -8.57152657869e-05
Gc24_782 0 n48 ns782 0 0.000950429643565
Gc24_783 0 n48 ns783 0 0.00055200118779
Gc24_784 0 n48 ns784 0 0.000300937809377
Gc24_785 0 n48 ns785 0 0.00103250678446
Gc24_786 0 n48 ns786 0 -3.31546498403e-05
Gc24_787 0 n48 ns787 0 -0.00110927782426
Gc24_788 0 n48 ns788 0 0.000632443258058
Gc24_789 0 n48 ns789 0 -0.000427089342174
Gc24_790 0 n48 ns790 0 -0.000387039695368
Gc24_791 0 n48 ns791 0 0.00152269097514
Gc24_792 0 n48 ns792 0 0.000822766925046
Gc24_793 0 n48 ns793 0 -0.000666904581144
Gc24_794 0 n48 ns794 0 0.0237573634014
Gc24_795 0 n48 ns795 0 -0.0218926969552
Gc24_796 0 n48 ns796 0 0.0011591101578
Gc24_797 0 n48 ns797 0 -6.2650544049e-06
Gc24_798 0 n48 ns798 0 -7.1827592454e-06
Gc24_799 0 n48 ns799 0 -0.00122811630308
Gc24_800 0 n48 ns800 0 0.000733658072284
Gc24_801 0 n48 ns801 0 -0.000203530813265
Gc24_802 0 n48 ns802 0 0.000557635596393
Gc24_803 0 n48 ns803 0 -0.000584840966004
Gc24_804 0 n48 ns804 0 0.00032897826408
Gc24_805 0 n48 ns805 0 -0.000158474788488
Gc24_806 0 n48 ns806 0 -4.03936878728e-05
Gc24_807 0 n48 ns807 0 3.34283945537e-05
Gc24_808 0 n48 ns808 0 -0.00201228155825
Gc24_809 0 n48 ns809 0 -0.000227458643703
Gc24_810 0 n48 ns810 0 0.000417259689994
Gc24_811 0 n48 ns811 0 2.99969083945e-05
Gc24_812 0 n48 ns812 0 0.000203399760179
Gc24_813 0 n48 ns813 0 -0.000486622265023
Gc24_814 0 n48 ns814 0 -0.00149996287467
Gc24_815 0 n48 ns815 0 0.000137118339879
Gc24_816 0 n48 ns816 0 -0.000378736613615
Gc24_817 0 n48 ns817 0 0.000297159489566
Gc24_818 0 n48 ns818 0 0.000471473846621
Gc24_819 0 n48 ns819 0 0.000135172320325
Gc24_820 0 n48 ns820 0 -0.000823671782012
Gc24_821 0 n48 ns821 0 0.00317351374849
Gc24_822 0 n48 ns822 0 0.00039900566022
Gc24_823 0 n48 ns823 0 0.0010181249459
Gc24_824 0 n48 ns824 0 0.000414020927372
Gc24_825 0 n48 ns825 0 -0.00146511171497
Gc24_826 0 n48 ns826 0 0.00147668697011
Gc24_827 0 n48 ns827 0 0.0017159942082
Gc24_828 0 n48 ns828 0 -0.00156469557361
Gc24_829 0 n48 ns829 0 0.000917322294468
Gc24_830 0 n48 ns830 0 0.00147565364302
Gc24_831 0 n48 ns831 0 -0.000423228794167
Gc24_832 0 n48 ns832 0 0.0410287537295
Gc24_833 0 n48 ns833 0 -0.0394509665209
Gc24_834 0 n48 ns834 0 0.00262434255486
Gc24_835 0 n48 ns835 0 -1.6640180728e-06
Gc24_836 0 n48 ns836 0 1.30570787128e-05
Gc24_837 0 n48 ns837 0 -0.00223178745589
Gc24_838 0 n48 ns838 0 -0.00118564346184
Gc24_839 0 n48 ns839 0 0.00288121778788
Gc24_840 0 n48 ns840 0 0.000357948115538
Gc24_841 0 n48 ns841 0 -0.000570985578107
Gc24_842 0 n48 ns842 0 0.000343447076618
Gc24_843 0 n48 ns843 0 0.00037442536572
Gc24_844 0 n48 ns844 0 -0.000178226864015
Gc24_845 0 n48 ns845 0 -5.76585292599e-05
Gc24_846 0 n48 ns846 0 -0.00066746049672
Gc24_847 0 n48 ns847 0 0.000194331727996
Gc24_848 0 n48 ns848 0 0.000518153491924
Gc24_849 0 n48 ns849 0 0.00012369704502
Gc24_850 0 n48 ns850 0 0.000492617274011
Gc24_851 0 n48 ns851 0 -0.000437117993924
Gc24_852 0 n48 ns852 0 0.00117225118329
Gc24_853 0 n48 ns853 0 -0.00168047641112
Gc24_854 0 n48 ns854 0 -0.000792581046683
Gc24_855 0 n48 ns855 0 -0.000536627200152
Gc24_856 0 n48 ns856 0 0.000287769544532
Gc24_857 0 n48 ns857 0 0.000356161110652
Gc24_858 0 n48 ns858 0 -0.00355019813927
Gc24_859 0 n48 ns859 0 -0.00187263990118
Gc24_860 0 n48 ns860 0 -4.40786875987e-05
Gc24_861 0 n48 ns861 0 0.0015705226123
Gc24_862 0 n48 ns862 0 0.00135828216228
Gc24_863 0 n48 ns863 0 -0.00141666760812
Gc24_864 0 n48 ns864 0 -0.00530333447009
Gc24_865 0 n48 ns865 0 -0.00145782152104
Gc24_866 0 n48 ns866 0 -0.00149181102224
Gc24_867 0 n48 ns867 0 0.000732614783248
Gc24_868 0 n48 ns868 0 0.00249751890069
Gc24_869 0 n48 ns869 0 0.000378396555004
Gc24_870 0 n48 ns870 0 0.0208338162973
Gc24_871 0 n48 ns871 0 -0.028479242518
Gc24_872 0 n48 ns872 0 0.0055140897835
Gc24_873 0 n48 ns873 0 2.18485906772e-06
Gc24_874 0 n48 ns874 0 3.4262640116e-05
Gc24_875 0 n48 ns875 0 -0.00291581219768
Gc24_876 0 n48 ns876 0 -0.000190231328947
Gc24_877 0 n48 ns877 0 -0.00198542728121
Gc24_878 0 n48 ns878 0 0.000483372681824
Gc24_879 0 n48 ns879 0 -0.00042321800289
Gc24_880 0 n48 ns880 0 0.000457114597357
Gc24_881 0 n48 ns881 0 -0.000354305634124
Gc24_882 0 n48 ns882 0 -0.000204717055207
Gc24_883 0 n48 ns883 0 -9.85993843348e-05
Gc24_884 0 n48 ns884 0 -0.00448902151262
Gc24_885 0 n48 ns885 0 0.00182730340888
Gc24_886 0 n48 ns886 0 0.00117409601045
Gc24_887 0 n48 ns887 0 -0.00049922414668
Gc24_888 0 n48 ns888 0 0.000547158618073
Gc24_889 0 n48 ns889 0 -0.000401535416415
Gc24_890 0 n48 ns890 0 -0.000481403623306
Gc24_891 0 n48 ns891 0 0.0024392340368
Gc24_892 0 n48 ns892 0 0.00100781883376
Gc24_893 0 n48 ns893 0 -0.000272366976885
Gc24_894 0 n48 ns894 0 0.000450839106657
Gc24_895 0 n48 ns895 0 0.000255367415401
Gc24_896 0 n48 ns896 0 0.00133631786275
Gc24_897 0 n48 ns897 0 0.00124829731677
Gc24_898 0 n48 ns898 0 0.000672677116628
Gc24_899 0 n48 ns899 0 0.00206516889264
Gc24_900 0 n48 ns900 0 0.00164598334209
Gc24_901 0 n48 ns901 0 -0.00156131761257
Gc24_902 0 n48 ns902 0 0.00068468646739
Gc24_903 0 n48 ns903 0 -0.00235263473665
Gc24_904 0 n48 ns904 0 0.00147757278928
Gc24_905 0 n48 ns905 0 0.00103882498258
Gc24_906 0 n48 ns906 0 0.00315000833613
Gc24_907 0 n48 ns907 0 0.00044244613977
Gc24_908 0 n48 ns908 0 -0.0234755236133
Gc24_909 0 n48 ns909 0 0.0233683810999
Gc24_910 0 n48 ns910 0 0.00698630333065
Gc24_911 0 n48 ns911 0 1.13742119241e-05
Gc24_912 0 n48 ns912 0 3.59279956226e-05
Gc24_913 0 n48 ns913 0 -0.00188381013204
Gc24_914 0 n48 ns914 0 -0.00308437155876
Gc24_915 0 n48 ns915 0 0.00636227807087
Gc24_916 0 n48 ns916 0 0.000703050296936
Gc24_917 0 n48 ns917 0 -0.000331049325435
Gc24_918 0 n48 ns918 0 0.00063810239964
Gc24_919 0 n48 ns919 0 0.00078438308036
Gc24_920 0 n48 ns920 0 -0.000156430463947
Gc24_921 0 n48 ns921 0 -9.2370449676e-05
Gc24_922 0 n48 ns922 0 -0.000810195628477
Gc24_923 0 n48 ns923 0 -0.0018649318758
Gc24_924 0 n48 ns924 0 0.00114158392087
Gc24_925 0 n48 ns925 0 6.35460315943e-05
Gc24_926 0 n48 ns926 0 0.00041324470109
Gc24_927 0 n48 ns927 0 -0.000177047646049
Gc24_928 0 n48 ns928 0 -0.000709925508096
Gc24_929 0 n48 ns929 0 -0.00327926021211
Gc24_930 0 n48 ns930 0 -0.000104928992516
Gc24_931 0 n48 ns931 0 0.000185036128004
Gc24_932 0 n48 ns932 0 0.000162708682639
Gc24_933 0 n48 ns933 0 0.00036912999481
Gc24_934 0 n48 ns934 0 -0.00569696342996
Gc24_935 0 n48 ns935 0 -0.00141103678759
Gc24_936 0 n48 ns936 0 0.000676772141234
Gc24_937 0 n48 ns937 0 0.000855653773627
Gc24_938 0 n48 ns938 0 0.00101867264704
Gc24_939 0 n48 ns939 0 -0.000848610907485
Gc24_940 0 n48 ns940 0 -0.00654876530651
Gc24_941 0 n48 ns941 0 -0.000274400266399
Gc24_942 0 n48 ns942 0 -0.00100350360433
Gc24_943 0 n48 ns943 0 -0.000590349759701
Gc24_944 0 n48 ns944 0 0.00202991637823
Gc24_945 0 n48 ns945 0 0.000790893516212
Gc24_946 0 n48 ns946 0 0.00438362157247
Gc24_947 0 n48 ns947 0 -0.0141660538123
Gc24_948 0 n48 ns948 0 0.00514117363643
Gc24_949 0 n48 ns949 0 1.5688196074e-06
Gc24_950 0 n48 ns950 0 3.03207811971e-05
Gc24_951 0 n48 ns951 0 2.80934723057e-05
Gc24_952 0 n48 ns952 0 -4.25708010123e-05
Gc24_953 0 n48 ns953 0 -0.00273940714132
Gc24_954 0 n48 ns954 0 -0.000177159527777
Gc24_955 0 n48 ns955 0 -0.00018155448733
Gc24_956 0 n48 ns956 0 -0.000118722842025
Gc24_957 0 n48 ns957 0 6.62972253517e-05
Gc24_958 0 n48 ns958 0 2.58413438372e-05
Gc24_959 0 n48 ns959 0 1.30767324212e-06
Gc24_960 0 n48 ns960 0 0.000249567958017
Gc24_961 0 n48 ns961 0 0.00103102428624
Gc24_962 0 n48 ns962 0 -0.000123622152304
Gc24_963 0 n48 ns963 0 -0.000465711922067
Gc24_964 0 n48 ns964 0 -0.000152464022402
Gc24_965 0 n48 ns965 0 7.63308175303e-05
Gc24_966 0 n48 ns966 0 -0.00045356390922
Gc24_967 0 n48 ns967 0 0.00087523373642
Gc24_968 0 n48 ns968 0 0.000672356889842
Gc24_969 0 n48 ns969 0 3.36499338435e-05
Gc24_970 0 n48 ns970 0 1.17443137628e-05
Gc24_971 0 n48 ns971 0 -0.000187709414549
Gc24_972 0 n48 ns972 0 0.00130186558208
Gc24_973 0 n48 ns973 0 0.00132126970222
Gc24_974 0 n48 ns974 0 0.000866224789395
Gc24_975 0 n48 ns975 0 -0.000627739046292
Gc24_976 0 n48 ns976 0 -0.00069133929745
Gc24_977 0 n48 ns977 0 1.01392630928e-05
Gc24_978 0 n48 ns978 0 0.00195329050769
Gc24_979 0 n48 ns979 0 0.00120412168909
Gc24_980 0 n48 ns980 0 0.000302794019184
Gc24_981 0 n48 ns981 0 -0.000346017621158
Gc24_982 0 n48 ns982 0 -0.00016420791005
Gc24_983 0 n48 ns983 0 -0.000271579578711
Gc24_984 0 n48 ns984 0 0.0200885955636
Gc24_985 0 n48 ns985 0 -0.0170106594399
Gc24_986 0 n48 ns986 0 0.00057360186409
Gc24_987 0 n48 ns987 0 -4.05396550039e-06
Gc24_988 0 n48 ns988 0 -3.13126981546e-05
Gc24_989 0 n48 ns989 0 0.000110146952262
Gc24_990 0 n48 ns990 0 -0.00030089612619
Gc24_991 0 n48 ns991 0 -8.5969816168e-06
Gc24_992 0 n48 ns992 0 -7.18868262424e-05
Gc24_993 0 n48 ns993 0 4.88903050333e-05
Gc24_994 0 n48 ns994 0 -2.05953684064e-05
Gc24_995 0 n48 ns995 0 3.56026366559e-05
Gc24_996 0 n48 ns996 0 9.92355091934e-06
Gc24_997 0 n48 ns997 0 3.04407652046e-05
Gc24_998 0 n48 ns998 0 9.08174754124e-06
Gc24_999 0 n48 ns999 0 0.000340600738271
Gc24_1000 0 n48 ns1000 0 0.000333546987161
Gc24_1001 0 n48 ns1001 0 -0.000198481460524
Gc24_1002 0 n48 ns1002 0 -0.000209476093472
Gc24_1003 0 n48 ns1003 0 -8.92163904816e-05
Gc24_1004 0 n48 ns1004 0 -0.000480402989209
Gc24_1005 0 n48 ns1005 0 -0.000478042236583
Gc24_1006 0 n48 ns1006 0 0.000139753011313
Gc24_1007 0 n48 ns1007 0 0.000626384372192
Gc24_1008 0 n48 ns1008 0 0.000128445755048
Gc24_1009 0 n48 ns1009 0 -0.000139067593811
Gc24_1010 0 n48 ns1010 0 -0.000193407717542
Gc24_1011 0 n48 ns1011 0 0.00067490021912
Gc24_1012 0 n48 ns1012 0 0.000966611847589
Gc24_1013 0 n48 ns1013 0 0.000326710692765
Gc24_1014 0 n48 ns1014 0 -0.000551972769624
Gc24_1015 0 n48 ns1015 0 -0.000518908856496
Gc24_1016 0 n48 ns1016 0 -0.000480501053718
Gc24_1017 0 n48 ns1017 0 0.000404841835086
Gc24_1018 0 n48 ns1018 0 0.000505713875956
Gc24_1019 0 n48 ns1019 0 0.00077066586527
Gc24_1020 0 n48 ns1020 0 0.000240338921316
Gc24_1021 0 n48 ns1021 0 -0.000528465321746
Gc24_1022 0 n48 ns1022 0 0.0127068779525
Gc24_1023 0 n48 ns1023 0 -0.011643474335
Gc24_1024 0 n48 ns1024 0 0.000549051438838
Gc24_1025 0 n48 ns1025 0 -3.45012123619e-06
Gc24_1026 0 n48 ns1026 0 -3.24998040349e-05
Gc24_1027 0 n48 ns1027 0 -0.000416253106789
Gc24_1028 0 n48 ns1028 0 0.000870497436351
Gc24_1029 0 n48 ns1029 0 -0.0012758442953
Gc24_1030 0 n48 ns1030 0 -9.87934916428e-05
Gc24_1031 0 n48 ns1031 0 -3.67594491884e-05
Gc24_1032 0 n48 ns1032 0 -0.00011116718475
Gc24_1033 0 n48 ns1033 0 -2.25653746729e-05
Gc24_1034 0 n48 ns1034 0 -2.84143169254e-05
Gc24_1035 0 n48 ns1035 0 -2.20536090367e-05
Gc24_1036 0 n48 ns1036 0 -0.000339713295619
Gc24_1037 0 n48 ns1037 0 0.000913452044001
Gc24_1038 0 n48 ns1038 0 0.000392267803298
Gc24_1039 0 n48 ns1039 0 7.85421072382e-05
Gc24_1040 0 n48 ns1040 0 -0.00012102553107
Gc24_1041 0 n48 ns1041 0 -0.000318317846722
Gc24_1042 0 n48 ns1042 0 0.000598129446089
Gc24_1043 0 n48 ns1043 0 -0.0001200886148
Gc24_1044 0 n48 ns1044 0 -0.000418134382386
Gc24_1045 0 n48 ns1045 0 0.000373361475804
Gc24_1046 0 n48 ns1046 0 0.000225758664318
Gc24_1047 0 n48 ns1047 0 -9.38568756811e-05
Gc24_1048 0 n48 ns1048 0 0.000346101919077
Gc24_1049 0 n48 ns1049 0 0.000159574767424
Gc24_1050 0 n48 ns1050 0 0.000484850268954
Gc24_1051 0 n48 ns1051 0 0.000998926912986
Gc24_1052 0 n48 ns1052 0 -0.000171850144875
Gc24_1053 0 n48 ns1053 0 -0.000970774054873
Gc24_1054 0 n48 ns1054 0 -0.000270359212392
Gc24_1055 0 n48 ns1055 0 -0.000362299602691
Gc24_1056 0 n48 ns1056 0 5.47118800041e-05
Gc24_1057 0 n48 ns1057 0 0.00145091109884
Gc24_1058 0 n48 ns1058 0 0.000634508460425
Gc24_1059 0 n48 ns1059 0 -0.000673914161211
Gc24_1060 0 n48 ns1060 0 0.0178285286742
Gc24_1061 0 n48 ns1061 0 -0.0165682024006
Gc24_1062 0 n48 ns1062 0 0.000871671464645
Gc24_1063 0 n48 ns1063 0 -6.50490783315e-06
Gc24_1064 0 n48 ns1064 0 -1.81429922398e-05
Gc24_1065 0 n48 ns1065 0 -0.000871210573326
Gc24_1066 0 n48 ns1066 0 0.00173408696918
Gc24_1067 0 n48 ns1067 0 -0.00179663454269
Gc24_1068 0 n48 ns1068 0 0.0001683499323
Gc24_1069 0 n48 ns1069 0 -0.000285247857794
Gc24_1070 0 n48 ns1070 0 0.000164720813359
Gc24_1071 0 n48 ns1071 0 -0.000328742463969
Gc24_1072 0 n48 ns1072 0 -3.3993392608e-06
Gc24_1073 0 n48 ns1073 0 1.59264934867e-05
Gc24_1074 0 n48 ns1074 0 -0.00170727647344
Gc24_1075 0 n48 ns1075 0 0.000467276918116
Gc24_1076 0 n48 ns1076 0 0.000302420772901
Gc24_1077 0 n48 ns1077 0 4.58361763519e-05
Gc24_1078 0 n48 ns1078 0 7.03347239941e-05
Gc24_1079 0 n48 ns1079 0 -0.000432885900975
Gc24_1080 0 n48 ns1080 0 -0.000764482816293
Gc24_1081 0 n48 ns1081 0 0.000852893261648
Gc24_1082 0 n48 ns1082 0 -0.000274348673863
Gc24_1083 0 n48 ns1083 0 0.00020801093761
Gc24_1084 0 n48 ns1084 0 0.000404492236644
Gc24_1085 0 n48 ns1085 0 1.60690315419e-05
Gc24_1086 0 n48 ns1086 0 0.000607067585512
Gc24_1087 0 n48 ns1087 0 0.00253477031246
Gc24_1088 0 n48 ns1088 0 0.000318744946692
Gc24_1089 0 n48 ns1089 0 0.000896433882786
Gc24_1090 0 n48 ns1090 0 0.000189672691125
Gc24_1091 0 n48 ns1091 0 -0.00129451661111
Gc24_1092 0 n48 ns1092 0 0.00197131832038
Gc24_1093 0 n48 ns1093 0 0.000617578155782
Gc24_1094 0 n48 ns1094 0 -0.00128677369314
Gc24_1095 0 n48 ns1095 0 0.00124204699769
Gc24_1096 0 n48 ns1096 0 0.00120553674485
Gc24_1097 0 n48 ns1097 0 -0.000528323002284
Gc24_1098 0 n48 ns1098 0 0.0350374382722
Gc24_1099 0 n48 ns1099 0 -0.0327234035591
Gc24_1100 0 n48 ns1100 0 0.00189126443105
Gc24_1101 0 n48 ns1101 0 -4.60009862732e-06
Gc24_1102 0 n48 ns1102 0 2.05190172357e-06
Gc24_1103 0 n48 ns1103 0 -0.00202832184192
Gc24_1104 0 n48 ns1104 0 0.000127243752156
Gc24_1105 0 n48 ns1105 0 0.0018186644313
Gc24_1106 0 n48 ns1106 0 0.000631601684396
Gc24_1107 0 n48 ns1107 0 -0.000404796016776
Gc24_1108 0 n48 ns1108 0 0.000504673070459
Gc24_1109 0 n48 ns1109 0 0.000371900286535
Gc24_1110 0 n48 ns1110 0 -0.000167171515078
Gc24_1111 0 n48 ns1111 0 -1.62324834027e-05
Gc24_1112 0 n48 ns1112 0 -0.000574647883966
Gc24_1113 0 n48 ns1113 0 -0.000761507545775
Gc24_1114 0 n48 ns1114 0 0.000526564936647
Gc24_1115 0 n48 ns1115 0 0.000121057298245
Gc24_1116 0 n48 ns1116 0 0.000360479055405
Gc24_1117 0 n48 ns1117 0 -0.000494437279931
Gc24_1118 0 n48 ns1118 0 -0.000201683330569
Gc24_1119 0 n48 ns1119 0 -0.00222350410106
Gc24_1120 0 n48 ns1120 0 -0.000994710022821
Gc24_1121 0 n48 ns1121 0 -5.41218052698e-05
Gc24_1122 0 n48 ns1122 0 0.000336425140674
Gc24_1123 0 n48 ns1123 0 0.000333735340521
Gc24_1124 0 n48 ns1124 0 -0.00410131389846
Gc24_1125 0 n48 ns1125 0 0.000438405366881
Gc24_1126 0 n48 ns1126 0 9.03168549958e-05
Gc24_1127 0 n48 ns1127 0 0.00147046425339
Gc24_1128 0 n48 ns1128 0 0.00106953342919
Gc24_1129 0 n48 ns1129 0 -0.00146784959904
Gc24_1130 0 n48 ns1130 0 -0.00277364086244
Gc24_1131 0 n48 ns1131 0 0.00134131130814
Gc24_1132 0 n48 ns1132 0 -0.00181447378824
Gc24_1133 0 n48 ns1133 0 0.00054384017692
Gc24_1134 0 n48 ns1134 0 0.00210077002293
Gc24_1135 0 n48 ns1135 0 8.84189624517e-05
Gc24_1136 0 n48 ns1136 0 0.038311216046
Gc24_1137 0 n48 ns1137 0 -0.0419599173297
Gc24_1138 0 n48 ns1138 0 0.00445708093915
Gc24_1139 0 n48 ns1139 0 3.13290166655e-06
Gc24_1140 0 n48 ns1140 0 2.65527814538e-05
Gc24_1141 0 n48 ns1141 0 -0.00474384586654
Gc24_1142 0 n48 ns1142 0 8.04407363092e-05
Gc24_1143 0 n48 ns1143 0 -0.00648073504495
Gc24_1144 0 n48 ns1144 0 0.000109210235113
Gc24_1145 0 n48 ns1145 0 -0.00126874198599
Gc24_1146 0 n48 ns1146 0 -0.000166789349255
Gc24_1147 0 n48 ns1147 0 0.000114830416506
Gc24_1148 0 n48 ns1148 0 -0.000106884993194
Gc24_1149 0 n48 ns1149 0 -2.98814315266e-05
Gc24_1150 0 n48 ns1150 0 -0.00220958663826
Gc24_1151 0 n48 ns1151 0 0.00329113526298
Gc24_1152 0 n48 ns1152 0 0.00038660942695
Gc24_1153 0 n48 ns1153 0 -0.000689565098425
Gc24_1154 0 n48 ns1154 0 0.000389716004769
Gc24_1155 0 n48 ns1155 0 -0.000362650144757
Gc24_1156 0 n48 ns1156 0 0.000454412776366
Gc24_1157 0 n48 ns1157 0 0.00283636311154
Gc24_1158 0 n48 ns1158 0 0.00079303215143
Gc24_1159 0 n48 ns1159 0 -0.000691751127753
Gc24_1160 0 n48 ns1160 0 0.000402232880071
Gc24_1161 0 n48 ns1161 0 0.000180701895632
Gc24_1162 0 n48 ns1162 0 0.00270989676936
Gc24_1163 0 n48 ns1163 0 0.00162956245106
Gc24_1164 0 n48 ns1164 0 0.000463552974205
Gc24_1165 0 n48 ns1165 0 0.00196062341606
Gc24_1166 0 n48 ns1166 0 0.00159026199829
Gc24_1167 0 n48 ns1167 0 -0.00156722824851
Gc24_1168 0 n48 ns1168 0 0.00395887649862
Gc24_1169 0 n48 ns1169 0 -0.00135280016865
Gc24_1170 0 n48 ns1170 0 0.00127883853574
Gc24_1171 0 n48 ns1171 0 0.000683294989642
Gc24_1172 0 n48 ns1172 0 0.00294569055147
Gc24_1173 0 n48 ns1173 0 0.000323742264928
Gc24_1174 0 n48 ns1174 0 -0.00932858960401
Gc24_1175 0 n48 ns1175 0 0.0131498974284
Gc24_1176 0 n48 ns1176 0 0.00707627082252
Gc24_1177 0 n48 ns1177 0 -1.30079929778e-06
Gc24_1178 0 n48 ns1178 0 3.01958467721e-05
Gc24_1179 0 n48 ns1179 0 -0.00452005673247
Gc24_1180 0 n48 ns1180 0 -0.00244006240646
Gc24_1181 0 n48 ns1181 0 -0.00116036870007
Gc24_1182 0 n48 ns1182 0 0.000834663257953
Gc24_1183 0 n48 ns1183 0 -0.00138829376624
Gc24_1184 0 n48 ns1184 0 -3.11809654782e-05
Gc24_1185 0 n48 ns1185 0 0.00094083991085
Gc24_1186 0 n48 ns1186 0 -9.21392103315e-05
Gc24_1187 0 n48 ns1187 0 -5.68087017587e-05
Gc24_1188 0 n48 ns1188 0 -0.000922309334807
Gc24_1189 0 n48 ns1189 0 0.000633509456322
Gc24_1190 0 n48 ns1190 0 0.000860580370065
Gc24_1191 0 n48 ns1191 0 -0.000568322032293
Gc24_1192 0 n48 ns1192 0 0.000334906043642
Gc24_1193 0 n48 ns1193 0 -0.00023418528598
Gc24_1194 0 n48 ns1194 0 -0.000832696326591
Gc24_1195 0 n48 ns1195 0 -0.00115998626197
Gc24_1196 0 n48 ns1196 0 0.000497638722378
Gc24_1197 0 n48 ns1197 0 -1.88750557374e-05
Gc24_1198 0 n48 ns1198 0 0.000274223534296
Gc24_1199 0 n48 ns1199 0 0.000289843749544
Gc24_1200 0 n48 ns1200 0 -0.00275150045197
Gc24_1201 0 n48 ns1201 0 0.00139063483868
Gc24_1202 0 n48 ns1202 0 0.00124386133805
Gc24_1203 0 n48 ns1203 0 0.00117057070074
Gc24_1204 0 n48 ns1204 0 0.00108175220209
Gc24_1205 0 n48 ns1205 0 -0.00126316334746
Gc24_1206 0 n48 ns1206 0 0.000449979010051
Gc24_1207 0 n48 ns1207 0 0.00214372254208
Gc24_1208 0 n48 ns1208 0 -1.02572255318e-05
Gc24_1209 0 n48 ns1209 0 -0.00130532623433
Gc24_1210 0 n48 ns1210 0 0.00222659769221
Gc24_1211 0 n48 ns1211 0 0.000640606882335
Gc24_1212 0 n48 ns1212 0 0.0171627058102
Gc24_1213 0 n48 ns1213 0 -0.0177825593532
Gc24_1214 0 n48 ns1214 0 0.00649635173299
Gc24_1215 0 n48 ns1215 0 -2.67759450847e-06
Gc24_1216 0 n48 ns1216 0 2.6484373652e-05
Gd24_1 0 n48 ni1 0 -0.000102650251492
Gd24_2 0 n48 ni2 0 -1.3930760467e-05
Gd24_3 0 n48 ni3 0 4.24716412335e-05
Gd24_4 0 n48 ni4 0 0.000209091245808
Gd24_5 0 n48 ni5 0 0.000104163406271
Gd24_6 0 n48 ni6 0 0.000515697618459
Gd24_7 0 n48 ni7 0 -0.000294863798784
Gd24_8 0 n48 ni8 0 -0.00683612794353
Gd24_9 0 n48 ni9 0 -0.000472112713881
Gd24_10 0 n48 ni10 0 3.04354555202e-05
Gd24_11 0 n48 ni11 0 0.000244906099124
Gd24_12 0 n48 ni12 0 0.00020450537164
Gd24_13 0 n48 ni13 0 0.00012451483236
Gd24_14 0 n48 ni14 0 -8.74460276561e-05
Gd24_15 0 n48 ni15 0 -0.00306576761082
Gd24_16 0 n48 ni16 0 -0.00151802377393
Gd24_17 0 n48 ni17 0 -8.04524073759e-05
Gd24_18 0 n48 ni18 0 -8.17674846935e-05
Gd24_19 0 n48 ni19 0 -9.74492144949e-05
Gd24_20 0 n48 ni20 0 -1.80558909172e-06
Gd24_21 0 n48 ni21 0 0.000283549548887
Gd24_22 0 n48 ni22 0 -0.00029374233737
Gd24_23 0 n48 ni23 0 -0.00171016026865
Gd24_24 0 n48 ni24 0 0.000709130277795
Gd24_25 0 n48 ni25 0 -0.00208536387748
Gd24_26 0 n48 ni26 0 -0.000128029232196
Gd24_27 0 n48 ni27 0 3.05583059117e-05
Gd24_28 0 n48 ni28 0 0.000159672422297
Gd24_29 0 n48 ni29 0 0.000253167592122
Gd24_30 0 n48 ni30 0 -0.00103492060919
Gd24_31 0 n48 ni31 0 -0.000733215076189
Gd24_32 0 n48 ni32 0 -0.00287726362723
Gc25_1 0 n50 ns1 0 1.20573974444e-05
Gc25_2 0 n50 ns2 0 -0.000583665137319
Gc25_3 0 n50 ns3 0 -0.000349914779644
Gc25_4 0 n50 ns4 0 7.3625596393e-05
Gc25_5 0 n50 ns5 0 -0.000263980620374
Gc25_6 0 n50 ns6 0 -0.000174276782181
Gc25_7 0 n50 ns7 0 3.93374640548e-06
Gc25_8 0 n50 ns8 0 2.66623099512e-05
Gc25_9 0 n50 ns9 0 6.1412707402e-06
Gc25_10 0 n50 ns10 0 -0.000242720212625
Gc25_11 0 n50 ns11 0 0.0009274326232
Gc25_12 0 n50 ns12 0 0.000132157982723
Gc25_13 0 n50 ns13 0 -0.00031248211874
Gc25_14 0 n50 ns14 0 -0.00010111603365
Gc25_15 0 n50 ns15 0 -7.51427446207e-05
Gc25_16 0 n50 ns16 0 0.000288861204558
Gc25_17 0 n50 ns17 0 0.000476857754466
Gc25_18 0 n50 ns18 0 0.000108054197038
Gc25_19 0 n50 ns19 0 -0.000257787858236
Gc25_20 0 n50 ns20 0 -5.73589296661e-05
Gc25_21 0 n50 ns21 0 -2.82853823785e-05
Gc25_22 0 n50 ns22 0 0.000181539231524
Gc25_23 0 n50 ns23 0 0.000156643188927
Gc25_24 0 n50 ns24 0 6.03493960794e-05
Gc25_25 0 n50 ns25 0 7.51820685595e-05
Gc25_26 0 n50 ns26 0 3.80345865307e-06
Gc25_27 0 n50 ns27 0 -7.9601406087e-05
Gc25_28 0 n50 ns28 0 0.000629692606319
Gc25_29 0 n50 ns29 0 0.000837976603968
Gc25_30 0 n50 ns30 0 0.000180313855058
Gc25_31 0 n50 ns31 0 -0.000241888802047
Gc25_32 0 n50 ns32 0 -9.12017028562e-05
Gc25_33 0 n50 ns33 0 -0.000100667174295
Gc25_34 0 n50 ns34 0 0.00736321203394
Gc25_35 0 n50 ns35 0 -0.00612378064736
Gc25_36 0 n50 ns36 0 0.000136436640466
Gc25_37 0 n50 ns37 0 7.75428342295e-06
Gc25_38 0 n50 ns38 0 -2.45786079503e-05
Gc25_39 0 n50 ns39 0 7.23902128611e-05
Gc25_40 0 n50 ns40 0 -0.000385301170567
Gc25_41 0 n50 ns41 0 -0.000638979584734
Gc25_42 0 n50 ns42 0 -6.00174527631e-05
Gc25_43 0 n50 ns43 0 -0.000110435335927
Gc25_44 0 n50 ns44 0 -6.18728054041e-05
Gc25_45 0 n50 ns45 0 4.68187982805e-05
Gc25_46 0 n50 ns46 0 2.74757199567e-05
Gc25_47 0 n50 ns47 0 -8.60749266639e-06
Gc25_48 0 n50 ns48 0 -0.000397336684213
Gc25_49 0 n50 ns49 0 0.000733608169128
Gc25_50 0 n50 ns50 0 0.000264242611365
Gc25_51 0 n50 ns51 0 -0.000209535853383
Gc25_52 0 n50 ns52 0 -7.53154330736e-05
Gc25_53 0 n50 ns53 0 -0.000118286640436
Gc25_54 0 n50 ns54 0 0.00028899026538
Gc25_55 0 n50 ns55 0 0.00064033202616
Gc25_56 0 n50 ns56 0 0.000197162979061
Gc25_57 0 n50 ns57 0 -0.000324266640412
Gc25_58 0 n50 ns58 0 -7.76402141251e-05
Gc25_59 0 n50 ns59 0 -5.49729794592e-05
Gc25_60 0 n50 ns60 0 0.00021374674663
Gc25_61 0 n50 ns61 0 7.56728647291e-05
Gc25_62 0 n50 ns62 0 -6.72876690565e-06
Gc25_63 0 n50 ns63 0 0.000135370628031
Gc25_64 0 n50 ns64 0 6.02627988024e-05
Gc25_65 0 n50 ns65 0 -9.77085319475e-05
Gc25_66 0 n50 ns66 0 0.000648063888164
Gc25_67 0 n50 ns67 0 0.00105474480199
Gc25_68 0 n50 ns68 0 0.000275263910543
Gc25_69 0 n50 ns69 0 -0.000261455095385
Gc25_70 0 n50 ns70 0 -0.000109087870179
Gc25_71 0 n50 ns71 0 -0.0001442601625
Gc25_72 0 n50 ns72 0 0.00966466450861
Gc25_73 0 n50 ns73 0 -0.00815232860077
Gc25_74 0 n50 ns74 0 0.00021380203493
Gc25_75 0 n50 ns75 0 6.62909606482e-06
Gc25_76 0 n50 ns76 0 -2.60632099082e-05
Gc25_77 0 n50 ns77 0 -4.9002168115e-05
Gc25_78 0 n50 ns78 0 2.48699959517e-05
Gc25_79 0 n50 ns79 0 -0.000885088770106
Gc25_80 0 n50 ns80 0 -0.00022850534981
Gc25_81 0 n50 ns81 0 0.000174101808632
Gc25_82 0 n50 ns82 0 6.00814452271e-05
Gc25_83 0 n50 ns83 0 0.000199156299321
Gc25_84 0 n50 ns84 0 3.652154183e-05
Gc25_85 0 n50 ns85 0 -5.43592956359e-06
Gc25_86 0 n50 ns86 0 -0.000177055060657
Gc25_87 0 n50 ns87 0 -0.00076471161107
Gc25_88 0 n50 ns88 0 0.000176422253107
Gc25_89 0 n50 ns89 0 0.000543480271432
Gc25_90 0 n50 ns90 0 0.000163773199902
Gc25_91 0 n50 ns91 0 -8.97231617207e-05
Gc25_92 0 n50 ns92 0 -0.000244087961845
Gc25_93 0 n50 ns93 0 0.000719088647288
Gc25_94 0 n50 ns94 0 0.00052281967692
Gc25_95 0 n50 ns95 0 -0.000156733678884
Gc25_96 0 n50 ns96 0 -5.27307687331e-05
Gc25_97 0 n50 ns97 0 -0.000158133082282
Gc25_98 0 n50 ns98 0 0.000452610936358
Gc25_99 0 n50 ns99 0 -0.00037954742061
Gc25_100 0 n50 ns100 0 -0.000449938152891
Gc25_101 0 n50 ns101 0 5.9639836764e-05
Gc25_102 0 n50 ns102 0 0.000275195726073
Gc25_103 0 n50 ns103 0 7.61329055177e-05
Gc25_104 0 n50 ns104 0 5.73657032216e-05
Gc25_105 0 n50 ns105 0 0.000824578019671
Gc25_106 0 n50 ns106 0 0.000384479196908
Gc25_107 0 n50 ns107 0 -1.97885589119e-05
Gc25_108 0 n50 ns108 0 -3.92965085139e-05
Gc25_109 0 n50 ns109 0 -0.00023015769523
Gc25_110 0 n50 ns110 0 0.0085142901227
Gc25_111 0 n50 ns111 0 -0.00725862087032
Gc25_112 0 n50 ns112 0 0.000191856693135
Gc25_113 0 n50 ns113 0 6.22041537525e-06
Gc25_114 0 n50 ns114 0 -2.76941405179e-05
Gc25_115 0 n50 ns115 0 0.000123095245719
Gc25_116 0 n50 ns116 0 -0.000925993001341
Gc25_117 0 n50 ns117 0 0.00255062117331
Gc25_118 0 n50 ns118 0 0.00011262165406
Gc25_119 0 n50 ns119 0 9.34480735055e-05
Gc25_120 0 n50 ns120 0 -3.22631262199e-05
Gc25_121 0 n50 ns121 0 -2.14414241666e-05
Gc25_122 0 n50 ns122 0 -2.78702819687e-05
Gc25_123 0 n50 ns123 0 1.24116562378e-05
Gc25_124 0 n50 ns124 0 0.000688987864945
Gc25_125 0 n50 ns125 0 -0.00145746884636
Gc25_126 0 n50 ns126 0 -0.000597696736279
Gc25_127 0 n50 ns127 0 0.000666814873285
Gc25_128 0 n50 ns128 0 0.000278438760241
Gc25_129 0 n50 ns129 0 0.000173782751028
Gc25_130 0 n50 ns130 0 -0.00102636701357
Gc25_131 0 n50 ns131 0 -0.000545636573371
Gc25_132 0 n50 ns132 0 0.000332551079479
Gc25_133 0 n50 ns133 0 0.000658835327923
Gc25_134 0 n50 ns134 0 0.000116418229807
Gc25_135 0 n50 ns135 0 -0.000143817610679
Gc25_136 0 n50 ns136 0 -1.65498234757e-05
Gc25_137 0 n50 ns137 0 -0.000987638273341
Gc25_138 0 n50 ns138 0 -0.00113446132993
Gc25_139 0 n50 ns139 0 -0.000179719633742
Gc25_140 0 n50 ns140 0 0.000600203381885
Gc25_141 0 n50 ns141 0 0.000485174776375
Gc25_142 0 n50 ns142 0 -0.00274060937265
Gc25_143 0 n50 ns143 0 -0.000342415987606
Gc25_144 0 n50 ns144 0 0.000618346647651
Gc25_145 0 n50 ns145 0 0.000991675368685
Gc25_146 0 n50 ns146 0 0.000278892872633
Gc25_147 0 n50 ns147 0 -0.000405869964455
Gc25_148 0 n50 ns148 0 -0.00595119619536
Gc25_149 0 n50 ns149 0 0.00464830156791
Gc25_150 0 n50 ns150 0 -0.000184775573761
Gc25_151 0 n50 ns151 0 8.12993752488e-06
Gc25_152 0 n50 ns152 0 -2.10016407247e-05
Gc25_153 0 n50 ns153 0 0.000128852753366
Gc25_154 0 n50 ns154 0 -0.000581886475048
Gc25_155 0 n50 ns155 0 0.0043477251959
Gc25_156 0 n50 ns156 0 0.000197002891209
Gc25_157 0 n50 ns157 0 0.000174061652735
Gc25_158 0 n50 ns158 0 0.000216860999943
Gc25_159 0 n50 ns159 0 -0.000168856992809
Gc25_160 0 n50 ns160 0 -1.90545018095e-05
Gc25_161 0 n50 ns161 0 -7.1210338716e-05
Gc25_162 0 n50 ns162 0 0.000605335380125
Gc25_163 0 n50 ns163 0 -0.000251422813243
Gc25_164 0 n50 ns164 0 -0.000585437744011
Gc25_165 0 n50 ns165 0 -0.000433689339197
Gc25_166 0 n50 ns166 0 2.90160643925e-05
Gc25_167 0 n50 ns167 0 0.000303612791663
Gc25_168 0 n50 ns168 0 2.56750723878e-05
Gc25_169 0 n50 ns169 0 -0.00209917706388
Gc25_170 0 n50 ns170 0 -0.000916777808439
Gc25_171 0 n50 ns171 0 0.000988862666115
Gc25_172 0 n50 ns172 0 0.000229561773077
Gc25_173 0 n50 ns173 0 9.80268826448e-05
Gc25_174 0 n50 ns174 0 -0.00057619766138
Gc25_175 0 n50 ns175 0 -0.00114212784804
Gc25_176 0 n50 ns176 0 -0.00114196226335
Gc25_177 0 n50 ns177 0 -0.000944612694654
Gc25_178 0 n50 ns178 0 0.000433720716977
Gc25_179 0 n50 ns179 0 0.00106275153591
Gc25_180 0 n50 ns180 0 -0.00494256035447
Gc25_181 0 n50 ns181 0 -0.00218135742879
Gc25_182 0 n50 ns182 0 0.000432226967557
Gc25_183 0 n50 ns183 0 0.00223932140837
Gc25_184 0 n50 ns184 0 0.000773085367269
Gc25_185 0 n50 ns185 0 -0.000549415775844
Gc25_186 0 n50 ns186 0 -0.0190544490473
Gc25_187 0 n50 ns187 0 0.015474600617
Gc25_188 0 n50 ns188 0 -0.000532565042059
Gc25_189 0 n50 ns189 0 3.6006849984e-06
Gc25_190 0 n50 ns190 0 -5.88721168991e-06
Gc25_191 0 n50 ns191 0 -5.83175776068e-06
Gc25_192 0 n50 ns192 0 3.34851175026e-05
Gc25_193 0 n50 ns193 0 0.0051005686532
Gc25_194 0 n50 ns194 0 9.59362512887e-05
Gc25_195 0 n50 ns195 0 0.000157714281657
Gc25_196 0 n50 ns196 0 0.000366697408275
Gc25_197 0 n50 ns197 0 0.000130905301085
Gc25_198 0 n50 ns198 0 3.72234370203e-05
Gc25_199 0 n50 ns199 0 -6.36908032032e-06
Gc25_200 0 n50 ns200 0 -0.00138172884591
Gc25_201 0 n50 ns201 0 -0.000903780876788
Gc25_202 0 n50 ns202 0 0.000793968707867
Gc25_203 0 n50 ns203 0 -0.000300362925412
Gc25_204 0 n50 ns204 0 -3.98665157122e-05
Gc25_205 0 n50 ns205 0 0.000158180936845
Gc25_206 0 n50 ns206 0 0.00169842259324
Gc25_207 0 n50 ns207 0 -0.000594191390351
Gc25_208 0 n50 ns208 0 -0.00149076779836
Gc25_209 0 n50 ns209 0 -0.000442334325167
Gc25_210 0 n50 ns210 0 5.86268228676e-05
Gc25_211 0 n50 ns211 0 0.000205204478052
Gc25_212 0 n50 ns212 0 -0.00142254643151
Gc25_213 0 n50 ns213 0 -0.00176379155862
Gc25_214 0 n50 ns214 0 -0.000208301242137
Gc25_215 0 n50 ns215 0 -0.00114388500043
Gc25_216 0 n50 ns216 0 -0.000199398505127
Gc25_217 0 n50 ns217 0 0.00123566031762
Gc25_218 0 n50 ns218 0 -0.00541052662825
Gc25_219 0 n50 ns219 0 -0.00417571927947
Gc25_220 0 n50 ns220 0 -0.00066514991163
Gc25_221 0 n50 ns221 0 0.00317993163318
Gc25_222 0 n50 ns222 0 0.00142356794809
Gc25_223 0 n50 ns223 0 -0.000467137586003
Gc25_224 0 n50 ns224 0 -0.0331170661562
Gc25_225 0 n50 ns225 0 0.0279564048888
Gc25_226 0 n50 ns226 0 -0.0011317703209
Gc25_227 0 n50 ns227 0 -4.56143970932e-06
Gc25_228 0 n50 ns228 0 1.22367448629e-05
Gc25_229 0 n50 ns229 0 0.00064197698585
Gc25_230 0 n50 ns230 0 -0.000594754848716
Gc25_231 0 n50 ns231 0 0.00929949232991
Gc25_232 0 n50 ns232 0 0.000329920994034
Gc25_233 0 n50 ns233 0 0.000224405909168
Gc25_234 0 n50 ns234 0 5.49321711426e-05
Gc25_235 0 n50 ns235 0 -0.000186310367882
Gc25_236 0 n50 ns236 0 -0.000116243388132
Gc25_237 0 n50 ns237 0 3.30276991827e-05
Gc25_238 0 n50 ns238 0 -0.000609044951147
Gc25_239 0 n50 ns239 0 -0.0037431950815
Gc25_240 0 n50 ns240 0 0.000610484849881
Gc25_241 0 n50 ns241 0 0.00117637563905
Gc25_242 0 n50 ns242 0 -1.74055614531e-05
Gc25_243 0 n50 ns243 0 0.000218779529575
Gc25_244 0 n50 ns244 0 -0.00119914380189
Gc25_245 0 n50 ns245 0 0.000560955511546
Gc25_246 0 n50 ns246 0 -6.40142672853e-05
Gc25_247 0 n50 ns247 0 -0.000767418901556
Gc25_248 0 n50 ns248 0 0.000148977388493
Gc25_249 0 n50 ns249 0 0.000145152029281
Gc25_250 0 n50 ns250 0 -0.00265271458227
Gc25_251 0 n50 ns251 0 -0.00410131426455
Gc25_252 0 n50 ns252 0 -0.000316520207237
Gc25_253 0 n50 ns253 0 0.000702328014522
Gc25_254 0 n50 ns254 0 -0.000120632172828
Gc25_255 0 n50 ns255 0 0.000695194573478
Gc25_256 0 n50 ns256 0 -0.00652408508854
Gc25_257 0 n50 ns257 0 -0.00453726965306
Gc25_258 0 n50 ns258 0 -0.00230936964347
Gc25_259 0 n50 ns259 0 0.00275210188827
Gc25_260 0 n50 ns260 0 0.0021396898443
Gc25_261 0 n50 ns261 0 0.00012340844008
Gc25_262 0 n50 ns262 0 -0.0655172018877
Gc25_263 0 n50 ns263 0 0.0577381662631
Gc25_264 0 n50 ns264 0 -0.00292335808924
Gc25_265 0 n50 ns265 0 -7.47668861037e-06
Gc25_266 0 n50 ns266 0 2.0118681909e-05
Gc25_267 0 n50 ns267 0 -0.000521688977648
Gc25_268 0 n50 ns268 0 0.000577664502818
Gc25_269 0 n50 ns269 0 0.0018372353141
Gc25_270 0 n50 ns270 0 -0.00118751120581
Gc25_271 0 n50 ns271 0 -0.000848178621622
Gc25_272 0 n50 ns272 0 0.00157530022318
Gc25_273 0 n50 ns273 0 0.000211730641807
Gc25_274 0 n50 ns274 0 -0.00018483981848
Gc25_275 0 n50 ns275 0 -0.000186594742502
Gc25_276 0 n50 ns276 0 0.00243538831347
Gc25_277 0 n50 ns277 0 -0.000381709916789
Gc25_278 0 n50 ns278 0 -0.000898748811525
Gc25_279 0 n50 ns279 0 0.000628351709565
Gc25_280 0 n50 ns280 0 -0.00027836799448
Gc25_281 0 n50 ns281 0 0.000170080448188
Gc25_282 0 n50 ns282 0 -0.00121620829845
Gc25_283 0 n50 ns283 0 -0.00316117992287
Gc25_284 0 n50 ns284 0 -6.46313695017e-05
Gc25_285 0 n50 ns285 0 0.000291000591928
Gc25_286 0 n50 ns286 0 0.000175971500227
Gc25_287 0 n50 ns287 0 0.000383201324008
Gc25_288 0 n50 ns288 0 0.0019689464105
Gc25_289 0 n50 ns289 0 -0.00387613524984
Gc25_290 0 n50 ns290 0 -0.00221786350273
Gc25_291 0 n50 ns291 0 4.32607960819e-05
Gc25_292 0 n50 ns292 0 -0.000101000757542
Gc25_293 0 n50 ns293 0 0.00109804164303
Gc25_294 0 n50 ns294 0 -0.00838357227559
Gc25_295 0 n50 ns295 0 -0.00222247582922
Gc25_296 0 n50 ns296 0 -0.000860626439983
Gc25_297 0 n50 ns297 0 0.000315508249957
Gc25_298 0 n50 ns298 0 0.00230014599565
Gc25_299 0 n50 ns299 0 0.00077182640195
Gc25_300 0 n50 ns300 0 -0.0441195456756
Gc25_301 0 n50 ns301 0 0.0450879267568
Gc25_302 0 n50 ns302 0 -0.00595813353647
Gc25_303 0 n50 ns303 0 -5.61223133975e-06
Gc25_304 0 n50 ns304 0 2.85136953369e-05
Gc25_305 0 n50 ns305 0 -0.0178446633936
Gc25_306 0 n50 ns306 0 -0.00329549468907
Gc25_307 0 n50 ns307 0 0.0152023684305
Gc25_308 0 n50 ns308 0 0.00884395950227
Gc25_309 0 n50 ns309 0 0.00852528536534
Gc25_310 0 n50 ns310 0 -0.000496461203875
Gc25_311 0 n50 ns311 0 -0.003165013602
Gc25_312 0 n50 ns312 0 -0.000267555397099
Gc25_313 0 n50 ns313 0 0.000229107034758
Gc25_314 0 n50 ns314 0 -0.00376916647894
Gc25_315 0 n50 ns315 0 -0.00898574399787
Gc25_316 0 n50 ns316 0 0.00115167695294
Gc25_317 0 n50 ns317 0 0.000323257773255
Gc25_318 0 n50 ns318 0 4.5111105243e-05
Gc25_319 0 n50 ns319 0 -0.000158005642139
Gc25_320 0 n50 ns320 0 0.00186797412979
Gc25_321 0 n50 ns321 0 0.00189030804933
Gc25_322 0 n50 ns322 0 0.000721490136435
Gc25_323 0 n50 ns323 0 0.000241397063761
Gc25_324 0 n50 ns324 0 0.000219198935974
Gc25_325 0 n50 ns325 0 0.000207907943147
Gc25_326 0 n50 ns326 0 -0.00975976631923
Gc25_327 0 n50 ns327 0 -0.00163912259701
Gc25_328 0 n50 ns328 0 -0.00203936454879
Gc25_329 0 n50 ns329 0 -0.00127135794212
Gc25_330 0 n50 ns330 0 -0.000504483443398
Gc25_331 0 n50 ns331 0 0.00115375010392
Gc25_332 0 n50 ns332 0 0.0164851976912
Gc25_333 0 n50 ns333 0 -0.000491114323999
Gc25_334 0 n50 ns334 0 0.00344374802578
Gc25_335 0 n50 ns335 0 -0.00178886781596
Gc25_336 0 n50 ns336 0 0.00154564630892
Gc25_337 0 n50 ns337 0 0.000133239342256
Gc25_338 0 n50 ns338 0 -0.0361833267112
Gc25_339 0 n50 ns339 0 0.0066676427017
Gc25_340 0 n50 ns340 0 -0.00617160952187
Gc25_341 0 n50 ns341 0 -5.19746885917e-06
Gc25_342 0 n50 ns342 0 1.6316615236e-05
Gc25_343 0 n50 ns343 0 -2.61220582026e-05
Gc25_344 0 n50 ns344 0 -0.000112583094342
Gc25_345 0 n50 ns345 0 -0.00105509306153
Gc25_346 0 n50 ns346 0 -0.000181663068026
Gc25_347 0 n50 ns347 0 7.48974135607e-05
Gc25_348 0 n50 ns348 0 4.01292785356e-05
Gc25_349 0 n50 ns349 0 0.000161749724321
Gc25_350 0 n50 ns350 0 3.87795164871e-05
Gc25_351 0 n50 ns351 0 -1.64526252784e-05
Gc25_352 0 n50 ns352 0 -0.000401084828343
Gc25_353 0 n50 ns353 0 -8.14481420792e-05
Gc25_354 0 n50 ns354 0 0.000313144697735
Gc25_355 0 n50 ns355 0 0.000204699379167
Gc25_356 0 n50 ns356 0 5.12416520455e-05
Gc25_357 0 n50 ns357 0 -0.000132171139962
Gc25_358 0 n50 ns358 0 4.70186513028e-05
Gc25_359 0 n50 ns359 0 0.000786217335396
Gc25_360 0 n50 ns360 0 0.000396351766191
Gc25_361 0 n50 ns361 0 -0.000287517205967
Gc25_362 0 n50 ns362 0 -7.41344754366e-05
Gc25_363 0 n50 ns363 0 -0.00011559676116
Gc25_364 0 n50 ns364 0 0.00040967796752
Gc25_365 0 n50 ns365 0 -0.000129028839955
Gc25_366 0 n50 ns366 0 -0.000213361333923
Gc25_367 0 n50 ns367 0 9.11699419118e-05
Gc25_368 0 n50 ns368 0 0.000157363591607
Gc25_369 0 n50 ns369 0 -1.78028379991e-05
Gc25_370 0 n50 ns370 0 0.000530455084461
Gc25_371 0 n50 ns371 0 0.00102012745725
Gc25_372 0 n50 ns372 0 0.00032699123903
Gc25_373 0 n50 ns373 0 -0.000192944247491
Gc25_374 0 n50 ns374 0 -9.10784364441e-05
Gc25_375 0 n50 ns375 0 -0.000189818912201
Gc25_376 0 n50 ns376 0 0.0102682735569
Gc25_377 0 n50 ns377 0 -0.00867343293628
Gc25_378 0 n50 ns378 0 0.000231458725464
Gc25_379 0 n50 ns379 0 5.52569139251e-06
Gc25_380 0 n50 ns380 0 -2.70211951976e-05
Gc25_381 0 n50 ns381 0 5.55779989819e-05
Gc25_382 0 n50 ns382 0 -0.000434070591378
Gc25_383 0 n50 ns383 0 0.000851545594413
Gc25_384 0 n50 ns384 0 -0.000123371331089
Gc25_385 0 n50 ns385 0 0.000171376183917
Gc25_386 0 n50 ns386 0 1.02052892917e-05
Gc25_387 0 n50 ns387 0 0.000126458591277
Gc25_388 0 n50 ns388 0 4.85122238918e-06
Gc25_389 0 n50 ns389 0 1.53990971788e-05
Gc25_390 0 n50 ns390 0 0.000428240120526
Gc25_391 0 n50 ns391 0 -0.00144863394746
Gc25_392 0 n50 ns392 0 -0.000281934994873
Gc25_393 0 n50 ns393 0 0.000798405774306
Gc25_394 0 n50 ns394 0 0.000272109629374
Gc25_395 0 n50 ns395 0 5.99269181733e-05
Gc25_396 0 n50 ns396 0 -0.000769760518252
Gc25_397 0 n50 ns397 0 9.77949179265e-05
Gc25_398 0 n50 ns398 0 0.000505342913016
Gc25_399 0 n50 ns399 0 0.000286154794748
Gc25_400 0 n50 ns400 0 3.64968856229e-05
Gc25_401 0 n50 ns401 0 -0.00017065022086
Gc25_402 0 n50 ns402 0 0.000257811999791
Gc25_403 0 n50 ns403 0 -0.000775401955828
Gc25_404 0 n50 ns404 0 -0.000872528525343
Gc25_405 0 n50 ns405 0 -4.87805427181e-05
Gc25_406 0 n50 ns406 0 0.000480994985075
Gc25_407 0 n50 ns407 0 0.000295227503332
Gc25_408 0 n50 ns408 0 -0.00140797206044
Gc25_409 0 n50 ns409 0 0.000159696599907
Gc25_410 0 n50 ns410 0 0.000492558607893
Gc25_411 0 n50 ns411 0 0.000507704705963
Gc25_412 0 n50 ns412 0 0.000125052640117
Gc25_413 0 n50 ns413 0 -0.000314968506612
Gc25_414 0 n50 ns414 0 0.000278104454719
Gc25_415 0 n50 ns415 0 -0.00040112649067
Gc25_416 0 n50 ns416 0 -3.74808879444e-05
Gc25_417 0 n50 ns417 0 7.49200751891e-06
Gc25_418 0 n50 ns418 0 -2.50789140436e-05
Gc25_419 0 n50 ns419 0 0.000216216386261
Gc25_420 0 n50 ns420 0 -0.000747297934209
Gc25_421 0 n50 ns421 0 0.0038325076423
Gc25_422 0 n50 ns422 0 0.00020395663732
Gc25_423 0 n50 ns423 0 0.000165947175927
Gc25_424 0 n50 ns424 0 0.000124305680327
Gc25_425 0 n50 ns425 0 -0.000187468479837
Gc25_426 0 n50 ns426 0 -5.40363278782e-05
Gc25_427 0 n50 ns427 0 -4.33060353158e-05
Gc25_428 0 n50 ns428 0 0.000825688329636
Gc25_429 0 n50 ns429 0 -0.000798620739337
Gc25_430 0 n50 ns430 0 -0.000760714690328
Gc25_431 0 n50 ns431 0 3.27986773127e-05
Gc25_432 0 n50 ns432 0 0.000144188114364
Gc25_433 0 n50 ns433 0 0.000280093995533
Gc25_434 0 n50 ns434 0 -0.000697548980548
Gc25_435 0 n50 ns435 0 -0.00168294119742
Gc25_436 0 n50 ns436 0 -0.000356930007526
Gc25_437 0 n50 ns437 0 0.00105273349544
Gc25_438 0 n50 ns438 0 0.000219651658833
Gc25_439 0 n50 ns439 0 -3.33924999536e-06
Gc25_440 0 n50 ns440 0 -0.000389999575249
Gc25_441 0 n50 ns441 0 -0.00103951230956
Gc25_442 0 n50 ns442 0 -0.00124253142438
Gc25_443 0 n50 ns443 0 -0.000622414569148
Gc25_444 0 n50 ns444 0 0.000565689507202
Gc25_445 0 n50 ns445 0 0.000844850879832
Gc25_446 0 n50 ns446 0 -0.0043616379912
Gc25_447 0 n50 ns447 0 -0.00113697247231
Gc25_448 0 n50 ns448 0 0.00069972005616
Gc25_449 0 n50 ns449 0 0.00176135703485
Gc25_450 0 n50 ns450 0 0.00057098962718
Gc25_451 0 n50 ns451 0 -0.000561908653583
Gc25_452 0 n50 ns452 0 -0.0120300535254
Gc25_453 0 n50 ns453 0 0.00945442388572
Gc25_454 0 n50 ns454 0 -0.000313134735891
Gc25_455 0 n50 ns455 0 6.47863380563e-06
Gc25_456 0 n50 ns456 0 -1.50498003722e-05
Gc25_457 0 n50 ns457 0 -2.65524989889e-05
Gc25_458 0 n50 ns458 0 0.000217072094086
Gc25_459 0 n50 ns459 0 0.00407566283056
Gc25_460 0 n50 ns460 0 -6.84923462107e-05
Gc25_461 0 n50 ns461 0 0.000296478312273
Gc25_462 0 n50 ns462 0 0.000423390780219
Gc25_463 0 n50 ns463 0 -1.31800859703e-05
Gc25_464 0 n50 ns464 0 3.30261429207e-05
Gc25_465 0 n50 ns465 0 -4.25538094422e-05
Gc25_466 0 n50 ns466 0 -0.000487135691191
Gc25_467 0 n50 ns467 0 -9.74261616042e-05
Gc25_468 0 n50 ns468 0 0.000224593030472
Gc25_469 0 n50 ns469 0 -0.000621148690051
Gc25_470 0 n50 ns470 0 -4.91792440887e-05
Gc25_471 0 n50 ns471 0 0.000204165147749
Gc25_472 0 n50 ns472 0 0.00146174304326
Gc25_473 0 n50 ns473 0 -0.00144420163549
Gc25_474 0 n50 ns474 0 -0.00147982736324
Gc25_475 0 n50 ns475 0 0.000153715128414
Gc25_476 0 n50 ns476 0 0.000114229699045
Gc25_477 0 n50 ns477 0 0.000191305406654
Gc25_478 0 n50 ns478 0 -0.000830618121894
Gc25_479 0 n50 ns479 0 -0.00137049041183
Gc25_480 0 n50 ns480 0 -0.000579722744924
Gc25_481 0 n50 ns481 0 -0.00131551227574
Gc25_482 0 n50 ns482 0 7.03135508171e-07
Gc25_483 0 n50 ns483 0 0.00126604088059
Gc25_484 0 n50 ns484 0 -0.00511476337051
Gc25_485 0 n50 ns485 0 -0.00355697744733
Gc25_486 0 n50 ns486 0 -0.000173915385745
Gc25_487 0 n50 ns487 0 0.00288514730096
Gc25_488 0 n50 ns488 0 0.00115113656774
Gc25_489 0 n50 ns489 0 -0.000533871093525
Gc25_490 0 n50 ns490 0 -0.0256869324984
Gc25_491 0 n50 ns491 0 0.0213966976406
Gc25_492 0 n50 ns492 0 -0.00082012492524
Gc25_493 0 n50 ns493 0 -1.22775240331e-06
Gc25_494 0 n50 ns494 0 3.51800370214e-06
Gc25_495 0 n50 ns495 0 0.000354912763422
Gc25_496 0 n50 ns496 0 -0.00121491292531
Gc25_497 0 n50 ns497 0 0.00840517780752
Gc25_498 0 n50 ns498 0 0.000497408356574
Gc25_499 0 n50 ns499 0 -0.000142665046033
Gc25_500 0 n50 ns500 0 -8.89609431351e-05
Gc25_501 0 n50 ns501 0 0.000177999866487
Gc25_502 0 n50 ns502 0 -1.02488488477e-05
Gc25_503 0 n50 ns503 0 4.67900195233e-05
Gc25_504 0 n50 ns504 0 -0.00135578548896
Gc25_505 0 n50 ns505 0 -0.00286693546471
Gc25_506 0 n50 ns506 0 0.000836461547097
Gc25_507 0 n50 ns507 0 0.000710410167709
Gc25_508 0 n50 ns508 0 2.25849616673e-05
Gc25_509 0 n50 ns509 0 0.000215506242291
Gc25_510 0 n50 ns510 0 0.000228515959444
Gc25_511 0 n50 ns511 0 0.00080218480905
Gc25_512 0 n50 ns512 0 -0.000570793282126
Gc25_513 0 n50 ns513 0 -0.000959430695966
Gc25_514 0 n50 ns514 0 6.53808889738e-05
Gc25_515 0 n50 ns515 0 0.000111199609144
Gc25_516 0 n50 ns516 0 -0.00246761666063
Gc25_517 0 n50 ns517 0 -0.00299117241392
Gc25_518 0 n50 ns518 0 9.33493339731e-05
Gc25_519 0 n50 ns519 0 -1.45672780599e-05
Gc25_520 0 n50 ns520 0 -0.000276910508577
Gc25_521 0 n50 ns521 0 0.00082394873106
Gc25_522 0 n50 ns522 0 -0.00567857442506
Gc25_523 0 n50 ns523 0 -0.00473121954044
Gc25_524 0 n50 ns524 0 -0.00189451326068
Gc25_525 0 n50 ns525 0 0.00313869655927
Gc25_526 0 n50 ns526 0 0.00190743119135
Gc25_527 0 n50 ns527 0 -0.000105485542149
Gc25_528 0 n50 ns528 0 -0.0526478460568
Gc25_529 0 n50 ns529 0 0.0456575111539
Gc25_530 0 n50 ns530 0 -0.00207880476666
Gc25_531 0 n50 ns531 0 -7.41734552242e-06
Gc25_532 0 n50 ns532 0 1.65756173749e-05
Gc25_533 0 n50 ns533 0 0.000210195863581
Gc25_534 0 n50 ns534 0 -0.000302417025386
Gc25_535 0 n50 ns535 0 0.00740605007967
Gc25_536 0 n50 ns536 0 -8.93620312043e-05
Gc25_537 0 n50 ns537 0 -6.14274338435e-05
Gc25_538 0 n50 ns538 0 0.000257461156231
Gc25_539 0 n50 ns539 0 -0.000756406667558
Gc25_540 0 n50 ns540 0 -0.000134107312075
Gc25_541 0 n50 ns541 0 1.54929018708e-05
Gc25_542 0 n50 ns542 0 0.00187208572866
Gc25_543 0 n50 ns543 0 -0.00170373412056
Gc25_544 0 n50 ns544 0 -0.000450603769647
Gc25_545 0 n50 ns545 0 0.000756143624312
Gc25_546 0 n50 ns546 0 -0.000258006366218
Gc25_547 0 n50 ns547 0 0.000210073673871
Gc25_548 0 n50 ns548 0 -0.00223609163021
Gc25_549 0 n50 ns549 0 -0.0017565569189
Gc25_550 0 n50 ns550 0 0.000124449142585
Gc25_551 0 n50 ns551 0 0.000153965159784
Gc25_552 0 n50 ns552 0 0.000248409676395
Gc25_553 0 n50 ns553 0 0.000319486904519
Gc25_554 0 n50 ns554 0 -0.000274342543889
Gc25_555 0 n50 ns555 0 -0.00555870852191
Gc25_556 0 n50 ns556 0 -0.00205059588372
Gc25_557 0 n50 ns557 0 0.000798553071808
Gc25_558 0 n50 ns558 0 0.000214783257541
Gc25_559 0 n50 ns559 0 0.000991265867923
Gc25_560 0 n50 ns560 0 -0.00774591815544
Gc25_561 0 n50 ns561 0 -0.00316033152551
Gc25_562 0 n50 ns562 0 -0.00218416997756
Gc25_563 0 n50 ns563 0 0.000898807509871
Gc25_564 0 n50 ns564 0 0.00222837499407
Gc25_565 0 n50 ns565 0 0.00066777628659
Gc25_566 0 n50 ns566 0 -0.0774721136091
Gc25_567 0 n50 ns567 0 0.0719443418925
Gc25_568 0 n50 ns568 0 -0.00506308912837
Gc25_569 0 n50 ns569 0 -6.792107006e-06
Gc25_570 0 n50 ns570 0 2.32450679701e-05
Gc25_571 0 n50 ns571 0 -0.00527572074106
Gc25_572 0 n50 ns572 0 -0.00348486120518
Gc25_573 0 n50 ns573 0 -0.00251455414027
Gc25_574 0 n50 ns574 0 0.00204001545214
Gc25_575 0 n50 ns575 0 -0.00353437972192
Gc25_576 0 n50 ns576 0 0.000300003811785
Gc25_577 0 n50 ns577 0 0.00329594425674
Gc25_578 0 n50 ns578 0 0.000141760778909
Gc25_579 0 n50 ns579 0 -0.000299431536856
Gc25_580 0 n50 ns580 0 -0.0011161956372
Gc25_581 0 n50 ns581 0 0.00301170035168
Gc25_582 0 n50 ns582 0 -0.000994314450102
Gc25_583 0 n50 ns583 0 -0.000301769769495
Gc25_584 0 n50 ns584 0 -0.000284897809047
Gc25_585 0 n50 ns585 0 6.4091703881e-05
Gc25_586 0 n50 ns586 0 0.00347767140122
Gc25_587 0 n50 ns587 0 -0.00165221165725
Gc25_588 0 n50 ns588 0 2.68842640953e-06
Gc25_589 0 n50 ns589 0 -0.00081305224958
Gc25_590 0 n50 ns590 0 -9.40968490043e-05
Gc25_591 0 n50 ns591 0 8.7452209451e-05
Gc25_592 0 n50 ns592 0 0.00538116850289
Gc25_593 0 n50 ns593 0 0.00565740077425
Gc25_594 0 n50 ns594 0 -2.62313780619e-05
Gc25_595 0 n50 ns595 0 -0.00240992195056
Gc25_596 0 n50 ns596 0 -0.0016607343279
Gc25_597 0 n50 ns597 0 0.000794963255079
Gc25_598 0 n50 ns598 0 -0.00699118207756
Gc25_599 0 n50 ns599 0 0.000757884006724
Gc25_600 0 n50 ns600 0 0.00354627681582
Gc25_601 0 n50 ns601 0 -0.000185044394938
Gc25_602 0 n50 ns602 0 0.00212131972206
Gc25_603 0 n50 ns603 0 0.000407146154597
Gc25_604 0 n50 ns604 0 0.0853962564468
Gc25_605 0 n50 ns605 0 -0.0662591457819
Gc25_606 0 n50 ns606 0 -0.00594882681441
Gc25_607 0 n50 ns607 0 -6.25408415141e-06
Gc25_608 0 n50 ns608 0 2.36908602052e-05
Gc25_609 0 n50 ns609 0 -0.000150393719109
Gc25_610 0 n50 ns610 0 0.000167409586987
Gc25_611 0 n50 ns611 0 -0.000963316899661
Gc25_612 0 n50 ns612 0 -0.000212907913014
Gc25_613 0 n50 ns613 0 0.000161813334071
Gc25_614 0 n50 ns614 0 2.3007691591e-06
Gc25_615 0 n50 ns615 0 8.70611235023e-05
Gc25_616 0 n50 ns616 0 3.67640479271e-06
Gc25_617 0 n50 ns617 0 1.22543296893e-05
Gc25_618 0 n50 ns618 0 0.000822884507833
Gc25_619 0 n50 ns619 0 -0.000102289057421
Gc25_620 0 n50 ns620 0 -0.000294603842593
Gc25_621 0 n50 ns621 0 0.000116220433224
Gc25_622 0 n50 ns622 0 2.22716203531e-05
Gc25_623 0 n50 ns623 0 7.82536970145e-05
Gc25_624 0 n50 ns624 0 0.000384385193739
Gc25_625 0 n50 ns625 0 2.761080789e-05
Gc25_626 0 n50 ns626 0 -6.31041148019e-05
Gc25_627 0 n50 ns627 0 -0.000196335043742
Gc25_628 0 n50 ns628 0 -5.56046313654e-05
Gc25_629 0 n50 ns629 0 8.18470394456e-06
Gc25_630 0 n50 ns630 0 0.000344925601548
Gc25_631 0 n50 ns631 0 -0.000315359779654
Gc25_632 0 n50 ns632 0 -0.000109935459339
Gc25_633 0 n50 ns633 0 -0.000208378269597
Gc25_634 0 n50 ns634 0 -3.10155276829e-05
Gc25_635 0 n50 ns635 0 0.000151094320029
Gc25_636 0 n50 ns636 0 -0.000103724611413
Gc25_637 0 n50 ns637 0 -0.000171705757277
Gc25_638 0 n50 ns638 0 0.000109151308376
Gc25_639 0 n50 ns639 0 0.000139045744269
Gc25_640 0 n50 ns640 0 2.92258679961e-05
Gc25_641 0 n50 ns641 0 -8.72308575898e-05
Gc25_642 0 n50 ns642 0 0.00231501054876
Gc25_643 0 n50 ns643 0 -0.00199086210044
Gc25_644 0 n50 ns644 0 9.12830230549e-05
Gc25_645 0 n50 ns645 0 -7.758286268e-06
Gc25_646 0 n50 ns646 0 -1.90755218572e-05
Gc25_647 0 n50 ns647 0 -0.000153430699584
Gc25_648 0 n50 ns648 0 0.000770813140719
Gc25_649 0 n50 ns649 0 -0.00342303605313
Gc25_650 0 n50 ns650 0 -0.000312731875101
Gc25_651 0 n50 ns651 0 -0.000119942153614
Gc25_652 0 n50 ns652 0 -0.000220940154559
Gc25_653 0 n50 ns653 0 9.58212431839e-05
Gc25_654 0 n50 ns654 0 1.32479788821e-05
Gc25_655 0 n50 ns655 0 4.29993807824e-05
Gc25_656 0 n50 ns656 0 0.00115242203633
Gc25_657 0 n50 ns657 0 0.000787179503839
Gc25_658 0 n50 ns658 0 -0.000523173107652
Gc25_659 0 n50 ns659 0 -0.00012570377074
Gc25_660 0 n50 ns660 0 -3.50380016832e-05
Gc25_661 0 n50 ns661 0 0.000119934246467
Gc25_662 0 n50 ns662 0 0.000426677711156
Gc25_663 0 n50 ns663 0 0.000589763984763
Gc25_664 0 n50 ns664 0 0.000180668969856
Gc25_665 0 n50 ns665 0 -0.000318552093534
Gc25_666 0 n50 ns666 0 -6.19755822357e-05
Gc25_667 0 n50 ns667 0 -5.3116181442e-05
Gc25_668 0 n50 ns668 0 0.00111331860008
Gc25_669 0 n50 ns669 0 0.000371920949801
Gc25_670 0 n50 ns670 0 0.00018978394527
Gc25_671 0 n50 ns671 0 -0.000503964880498
Gc25_672 0 n50 ns672 0 -0.000262716972888
Gc25_673 0 n50 ns673 0 0.000174347847165
Gc25_674 0 n50 ns674 0 0.0015586827782
Gc25_675 0 n50 ns675 0 0.000857834763939
Gc25_676 0 n50 ns676 0 0.000167473479431
Gc25_677 0 n50 ns677 0 -0.000411481225767
Gc25_678 0 n50 ns678 0 -0.00015756519284
Gc25_679 0 n50 ns679 0 -0.000117837070574
Gc25_680 0 n50 ns680 0 0.0157893119229
Gc25_681 0 n50 ns681 0 -0.0133486302607
Gc25_682 0 n50 ns682 0 0.000466894666445
Gc25_683 0 n50 ns683 0 -8.12550793507e-06
Gc25_684 0 n50 ns684 0 -2.24881247954e-05
Gc25_685 0 n50 ns685 0 5.42871680191e-06
Gc25_686 0 n50 ns686 0 -0.000150968832827
Gc25_687 0 n50 ns687 0 -0.00139028767924
Gc25_688 0 n50 ns688 0 -0.000113100614252
Gc25_689 0 n50 ns689 0 -0.000107568647054
Gc25_690 0 n50 ns690 0 -2.57700555364e-05
Gc25_691 0 n50 ns691 0 -3.39683750745e-05
Gc25_692 0 n50 ns692 0 -1.57821137674e-05
Gc25_693 0 n50 ns693 0 -1.99856212337e-05
Gc25_694 0 n50 ns694 0 5.41619920476e-05
Gc25_695 0 n50 ns695 0 0.00106404345135
Gc25_696 0 n50 ns696 0 -0.000118171571895
Gc25_697 0 n50 ns697 0 -0.000495140995161
Gc25_698 0 n50 ns698 0 -0.000127019879067
Gc25_699 0 n50 ns699 0 5.9625289924e-05
Gc25_700 0 n50 ns700 0 -0.000138551464386
Gc25_701 0 n50 ns701 0 0.00085869151366
Gc25_702 0 n50 ns702 0 0.000514293091599
Gc25_703 0 n50 ns703 0 -0.000164753175237
Gc25_704 0 n50 ns704 0 -3.79262484519e-05
Gc25_705 0 n50 ns705 0 -0.000139781450337
Gc25_706 0 n50 ns706 0 0.00103773222615
Gc25_707 0 n50 ns707 0 0.000652446032265
Gc25_708 0 n50 ns708 0 0.000430928795189
Gc25_709 0 n50 ns709 0 -0.00051862306355
Gc25_710 0 n50 ns710 0 -0.0004200906633
Gc25_711 0 n50 ns711 0 0.000109978966179
Gc25_712 0 n50 ns712 0 0.000982880933462
Gc25_713 0 n50 ns713 0 0.000474121361617
Gc25_714 0 n50 ns714 0 0.000183756091734
Gc25_715 0 n50 ns715 0 -6.8355686912e-05
Gc25_716 0 n50 ns716 0 -5.17451837034e-05
Gc25_717 0 n50 ns717 0 -0.000181274075524
Gc25_718 0 n50 ns718 0 0.0116591277393
Gc25_719 0 n50 ns719 0 -0.00995686109179
Gc25_720 0 n50 ns720 0 0.000362193239327
Gc25_721 0 n50 ns721 0 -7.74174228502e-06
Gc25_722 0 n50 ns722 0 -2.69446068722e-05
Gc25_723 0 n50 ns723 0 0.000410591774091
Gc25_724 0 n50 ns724 0 -0.0012770574896
Gc25_725 0 n50 ns725 0 0.00221812163919
Gc25_726 0 n50 ns726 0 0.000187339024058
Gc25_727 0 n50 ns727 0 -0.000136464060748
Gc25_728 0 n50 ns728 0 9.56581111524e-05
Gc25_729 0 n50 ns729 0 1.90548117024e-05
Gc25_730 0 n50 ns730 0 3.51432467122e-05
Gc25_731 0 n50 ns731 0 -3.57088915822e-05
Gc25_732 0 n50 ns732 0 -0.00136652876794
Gc25_733 0 n50 ns733 0 -5.10328236516e-05
Gc25_734 0 n50 ns734 0 0.000713268888656
Gc25_735 0 n50 ns735 0 -0.000252030094238
Gc25_736 0 n50 ns736 0 -0.000140387303705
Gc25_737 0 n50 ns737 0 -0.000128026632393
Gc25_738 0 n50 ns738 0 -0.00134653727773
Gc25_739 0 n50 ns739 0 -0.000147016008893
Gc25_740 0 n50 ns740 0 0.000457515930191
Gc25_741 0 n50 ns741 0 0.000742137804189
Gc25_742 0 n50 ns742 0 0.000154092269106
Gc25_743 0 n50 ns743 0 -0.00013492183482
Gc25_744 0 n50 ns744 0 -0.000439802901953
Gc25_745 0 n50 ns745 0 0.00128919224231
Gc25_746 0 n50 ns746 0 0.000972727027576
Gc25_747 0 n50 ns747 0 0.00013820372645
Gc25_748 0 n50 ns748 0 -0.000522859490976
Gc25_749 0 n50 ns749 0 -0.000378630130262
Gc25_750 0 n50 ns750 0 -0.000420536483026
Gc25_751 0 n50 ns751 0 0.00080562807013
Gc25_752 0 n50 ns752 0 0.00044820135589
Gc25_753 0 n50 ns753 0 0.000356836141156
Gc25_754 0 n50 ns754 0 9.30877458822e-05
Gc25_755 0 n50 ns755 0 -0.000353383029066
Gc25_756 0 n50 ns756 0 0.00657861812852
Gc25_757 0 n50 ns757 0 -0.0061956957573
Gc25_758 0 n50 ns758 0 0.000315725085155
Gc25_759 0 n50 ns759 0 -7.17366300787e-06
Gc25_760 0 n50 ns760 0 -2.33887552357e-05
Gc25_761 0 n50 ns761 0 -0.000134305318718
Gc25_762 0 n50 ns762 0 -0.000296656177041
Gc25_763 0 n50 ns763 0 0.00257886321352
Gc25_764 0 n50 ns764 0 7.86186493195e-05
Gc25_765 0 n50 ns765 0 1.44039637451e-05
Gc25_766 0 n50 ns766 0 -8.60075436379e-05
Gc25_767 0 n50 ns767 0 0.000181911713118
Gc25_768 0 n50 ns768 0 1.88196016084e-05
Gc25_769 0 n50 ns769 0 3.3406106483e-05
Gc25_770 0 n50 ns770 0 -9.84433677866e-05
Gc25_771 0 n50 ns771 0 -0.00103093821908
Gc25_772 0 n50 ns772 0 0.000531140847089
Gc25_773 0 n50 ns773 0 0.000664565023327
Gc25_774 0 n50 ns774 0 -1.5155182467e-06
Gc25_775 0 n50 ns775 0 -0.00025617030131
Gc25_776 0 n50 ns776 0 -9.802142343e-05
Gc25_777 0 n50 ns777 0 -0.00184243563839
Gc25_778 0 n50 ns778 0 -0.000779645823571
Gc25_779 0 n50 ns779 0 0.000986236832201
Gc25_780 0 n50 ns780 0 0.000240958703365
Gc25_781 0 n50 ns781 0 5.82609611743e-05
Gc25_782 0 n50 ns782 0 -0.00180379419801
Gc25_783 0 n50 ns783 0 -0.000219589682407
Gc25_784 0 n50 ns784 0 0.000532097718986
Gc25_785 0 n50 ns785 0 0.00137050029389
Gc25_786 0 n50 ns786 0 -2.89273928055e-05
Gc25_787 0 n50 ns787 0 -0.000945177582789
Gc25_788 0 n50 ns788 0 -0.00245874586728
Gc25_789 0 n50 ns789 0 -0.00014168772489
Gc25_790 0 n50 ns790 0 0.000471036537467
Gc25_791 0 n50 ns791 0 0.00136396168079
Gc25_792 0 n50 ns792 0 0.000503008808649
Gc25_793 0 n50 ns793 0 -0.000558732643905
Gc25_794 0 n50 ns794 0 0.00107870779147
Gc25_795 0 n50 ns795 0 -0.002309335806
Gc25_796 0 n50 ns796 0 0.000348106045544
Gc25_797 0 n50 ns797 0 -7.4824526742e-06
Gc25_798 0 n50 ns798 0 -7.17850244299e-06
Gc25_799 0 n50 ns799 0 -0.001261901888
Gc25_800 0 n50 ns800 0 0.00270590827112
Gc25_801 0 n50 ns801 0 -0.0044175515136
Gc25_802 0 n50 ns802 0 -0.000190984605527
Gc25_803 0 n50 ns803 0 -0.000366360450988
Gc25_804 0 n50 ns804 0 -0.000453060484436
Gc25_805 0 n50 ns805 0 -0.000120784457928
Gc25_806 0 n50 ns806 0 -2.88162129448e-05
Gc25_807 0 n50 ns807 0 2.13849429779e-06
Gc25_808 0 n50 ns808 0 0.000738385857034
Gc25_809 0 n50 ns809 0 0.00194885375112
Gc25_810 0 n50 ns810 0 -0.000589531262007
Gc25_811 0 n50 ns811 0 0.000158323993124
Gc25_812 0 n50 ns812 0 6.29511273122e-05
Gc25_813 0 n50 ns813 0 -0.000247463359807
Gc25_814 0 n50 ns814 0 0.00220340123762
Gc25_815 0 n50 ns815 0 0.00101266987965
Gc25_816 0 n50 ns816 0 -0.000867328109106
Gc25_817 0 n50 ns817 0 -0.000726612561713
Gc25_818 0 n50 ns818 0 0.00012163702634
Gc25_819 0 n50 ns819 0 2.58508068822e-05
Gc25_820 0 n50 ns820 0 0.00164048624539
Gc25_821 0 n50 ns821 0 -0.000694559966336
Gc25_822 0 n50 ns822 0 -0.000666501373329
Gc25_823 0 n50 ns823 0 0.000951714544633
Gc25_824 0 n50 ns824 0 0.000471406874285
Gc25_825 0 n50 ns825 0 -0.000816036881706
Gc25_826 0 n50 ns826 0 0.000905973798192
Gc25_827 0 n50 ns827 0 -0.00108916597552
Gc25_828 0 n50 ns828 0 -0.000725003837964
Gc25_829 0 n50 ns829 0 0.00145038608256
Gc25_830 0 n50 ns830 0 0.000870841682588
Gc25_831 0 n50 ns831 0 -0.000505804889825
Gc25_832 0 n50 ns832 0 0.022507623344
Gc25_833 0 n50 ns833 0 -0.0206371322734
Gc25_834 0 n50 ns834 0 0.00112797565413
Gc25_835 0 n50 ns835 0 -9.7993855581e-06
Gc25_836 0 n50 ns836 0 1.39355363121e-05
Gc25_837 0 n50 ns837 0 -0.00118516938872
Gc25_838 0 n50 ns838 0 0.000770103920767
Gc25_839 0 n50 ns839 0 -0.000988363878954
Gc25_840 0 n50 ns840 0 0.000741440005639
Gc25_841 0 n50 ns841 0 -0.000675709429374
Gc25_842 0 n50 ns842 0 0.000513565774619
Gc25_843 0 n50 ns843 0 -0.000369318116263
Gc25_844 0 n50 ns844 0 -5.62627944892e-05
Gc25_845 0 n50 ns845 0 -1.39794681774e-05
Gc25_846 0 n50 ns846 0 -0.00276726536363
Gc25_847 0 n50 ns847 0 0.000370933923855
Gc25_848 0 n50 ns848 0 0.000119150575213
Gc25_849 0 n50 ns849 0 -0.000659656622017
Gc25_850 0 n50 ns850 0 0.000252405778249
Gc25_851 0 n50 ns851 0 -0.000246135276413
Gc25_852 0 n50 ns852 0 -0.0020840880917
Gc25_853 0 n50 ns853 0 0.00202673541015
Gc25_854 0 n50 ns854 0 0.000517003706431
Gc25_855 0 n50 ns855 0 -0.000526123516006
Gc25_856 0 n50 ns856 0 0.000289772952659
Gc25_857 0 n50 ns857 0 8.94725895273e-05
Gc25_858 0 n50 ns858 0 0.000659478697904
Gc25_859 0 n50 ns859 0 0.00386814896985
Gc25_860 0 n50 ns860 0 -0.000100213072479
Gc25_861 0 n50 ns861 0 -0.0002357205584
Gc25_862 0 n50 ns862 0 0.000488026862202
Gc25_863 0 n50 ns863 0 -0.000675513800716
Gc25_864 0 n50 ns864 0 0.0031637537391
Gc25_865 0 n50 ns865 0 0.00187391629498
Gc25_866 0 n50 ns866 0 -0.00212969400303
Gc25_867 0 n50 ns867 0 4.80408757778e-05
Gc25_868 0 n50 ns868 0 0.0013178611082
Gc25_869 0 n50 ns869 0 -3.57758242576e-05
Gc25_870 0 n50 ns870 0 0.0411633881144
Gc25_871 0 n50 ns871 0 -0.0390568986825
Gc25_872 0 n50 ns872 0 0.00260658201392
Gc25_873 0 n50 ns873 0 -2.44033606434e-06
Gc25_874 0 n50 ns874 0 2.27692733747e-05
Gc25_875 0 n50 ns875 0 -0.00188381008623
Gc25_876 0 n50 ns876 0 -0.00308437178679
Gc25_877 0 n50 ns877 0 0.00636227716033
Gc25_878 0 n50 ns878 0 0.000703050250438
Gc25_879 0 n50 ns879 0 -0.000331049662389
Gc25_880 0 n50 ns880 0 0.000638102109216
Gc25_881 0 n50 ns881 0 0.000784383102061
Gc25_882 0 n50 ns882 0 -0.000156430427632
Gc25_883 0 n50 ns883 0 -9.23704035764e-05
Gc25_884 0 n50 ns884 0 -0.000810195328106
Gc25_885 0 n50 ns885 0 -0.00186493111126
Gc25_886 0 n50 ns886 0 0.00114158373958
Gc25_887 0 n50 ns887 0 6.35458548645e-05
Gc25_888 0 n50 ns888 0 0.00041324464851
Gc25_889 0 n50 ns889 0 -0.000177047625076
Gc25_890 0 n50 ns890 0 -0.000709925454479
Gc25_891 0 n50 ns891 0 -0.00327925986655
Gc25_892 0 n50 ns892 0 -0.00010492885858
Gc25_893 0 n50 ns893 0 0.000185036057725
Gc25_894 0 n50 ns894 0 0.000162708682923
Gc25_895 0 n50 ns895 0 0.00036912995973
Gc25_896 0 n50 ns896 0 -0.00569696304531
Gc25_897 0 n50 ns897 0 -0.00141103631791
Gc25_898 0 n50 ns898 0 0.000676772316777
Gc25_899 0 n50 ns899 0 0.000855653677797
Gc25_900 0 n50 ns900 0 0.00101867254593
Gc25_901 0 n50 ns901 0 -0.000848610938075
Gc25_902 0 n50 ns902 0 -0.00654876418716
Gc25_903 0 n50 ns903 0 -0.000274399352169
Gc25_904 0 n50 ns904 0 -0.00100350352079
Gc25_905 0 n50 ns905 0 -0.000590350222031
Gc25_906 0 n50 ns906 0 0.00202991621709
Gc25_907 0 n50 ns907 0 0.000790893496541
Gc25_908 0 n50 ns908 0 0.00438363001439
Gc25_909 0 n50 ns909 0 -0.0141660608587
Gc25_910 0 n50 ns910 0 0.0051411738531
Gc25_911 0 n50 ns911 0 1.56881784811e-06
Gc25_912 0 n50 ns912 0 3.03207763965e-05
Gc25_913 0 n50 ns913 0 -0.00509753286745
Gc25_914 0 n50 ns914 0 -0.00268642321543
Gc25_915 0 n50 ns915 0 -0.00372984867843
Gc25_916 0 n50 ns916 0 7.42044586121e-05
Gc25_917 0 n50 ns917 0 -0.000580397481737
Gc25_918 0 n50 ns918 0 -9.35231953828e-05
Gc25_919 0 n50 ns919 0 0.000137589275754
Gc25_920 0 n50 ns920 0 -0.000171348208022
Gc25_921 0 n50 ns921 0 -0.000135655484279
Gc25_922 0 n50 ns922 0 -0.00178756544446
Gc25_923 0 n50 ns923 0 0.00167565678619
Gc25_924 0 n50 ns924 0 0.00097375715211
Gc25_925 0 n50 ns925 0 0.000155086446649
Gc25_926 0 n50 ns926 0 0.000273361678365
Gc25_927 0 n50 ns927 0 -0.000147351662115
Gc25_928 0 n50 ns928 0 0.00181500634357
Gc25_929 0 n50 ns929 0 0.000787024905358
Gc25_930 0 n50 ns930 0 0.000520010439632
Gc25_931 0 n50 ns931 0 0.00016652377154
Gc25_932 0 n50 ns932 0 0.000180548085098
Gc25_933 0 n50 ns933 0 0.000178097044474
Gc25_934 0 n50 ns934 0 0.0013825888409
Gc25_935 0 n50 ns935 0 -0.0020122680334
Gc25_936 0 n50 ns936 0 0.00100913120711
Gc25_937 0 n50 ns937 0 0.00250338266055
Gc25_938 0 n50 ns938 0 0.0012860860626
Gc25_939 0 n50 ns939 0 -0.00119305590978
Gc25_940 0 n50 ns940 0 -0.000495507871207
Gc25_941 0 n50 ns941 0 -0.00363241786588
Gc25_942 0 n50 ns942 0 0.0037625336733
Gc25_943 0 n50 ns943 0 0.000799452729977
Gc25_944 0 n50 ns944 0 0.00222363669277
Gc25_945 0 n50 ns945 0 0.000239765730325
Gc25_946 0 n50 ns946 0 -0.0612120434518
Gc25_947 0 n50 ns947 0 0.0618304009279
Gc25_948 0 n50 ns948 0 0.00484513691109
Gc25_949 0 n50 ns949 0 7.06459042916e-06
Gc25_950 0 n50 ns950 0 2.83080299785e-05
Gc25_951 0 n50 ns951 0 -0.000130448416989
Gc25_952 0 n50 ns952 0 0.000326808389385
Gc25_953 0 n50 ns953 0 -0.00263019008799
Gc25_954 0 n50 ns954 0 -0.000206735581569
Gc25_955 0 n50 ns955 0 -0.000126080794411
Gc25_956 0 n50 ns956 0 -0.000136250497932
Gc25_957 0 n50 ns957 0 2.0971133533e-05
Gc25_958 0 n50 ns958 0 -7.84005775214e-06
Gc25_959 0 n50 ns959 0 1.03723219806e-05
Gc25_960 0 n50 ns960 0 0.000676630787324
Gc25_961 0 n50 ns961 0 0.00103531519224
Gc25_962 0 n50 ns962 0 -0.000376008291942
Gc25_963 0 n50 ns963 0 -0.000343974516947
Gc25_964 0 n50 ns964 0 -8.32682732881e-05
Gc25_965 0 n50 ns965 0 0.00010200261195
Gc25_966 0 n50 ns966 0 0.000219540318756
Gc25_967 0 n50 ns967 0 0.000813149931798
Gc25_968 0 n50 ns968 0 0.00036662521442
Gc25_969 0 n50 ns969 0 -0.000304892110088
Gc25_970 0 n50 ns970 0 -6.40284230396e-05
Gc25_971 0 n50 ns971 0 -0.00010244354717
Gc25_972 0 n50 ns972 0 0.00118209975645
Gc25_973 0 n50 ns973 0 0.000479076810988
Gc25_974 0 n50 ns974 0 0.000295057982452
Gc25_975 0 n50 ns975 0 -0.000550209329969
Gc25_976 0 n50 ns976 0 -0.000347784581125
Gc25_977 0 n50 ns977 0 0.00016456021032
Gc25_978 0 n50 ns978 0 0.00137301872919
Gc25_979 0 n50 ns979 0 0.000655464022689
Gc25_980 0 n50 ns980 0 0.000171267401185
Gc25_981 0 n50 ns981 0 -0.000260267806102
Gc25_982 0 n50 ns982 0 -0.000114855174707
Gc25_983 0 n50 ns983 0 -0.000151198849347
Gc25_984 0 n50 ns984 0 0.0141840664891
Gc25_985 0 n50 ns985 0 -0.0119870010143
Gc25_986 0 n50 ns986 0 0.000414521261919
Gc25_987 0 n50 ns987 0 -7.4032681245e-06
Gc25_988 0 n50 ns988 0 -2.49304634477e-05
Gc25_989 0 n50 ns989 0 0.000171739829278
Gc25_990 0 n50 ns990 0 -0.000740696213922
Gc25_991 0 n50 ns991 0 0.000374070841898
Gc25_992 0 n50 ns992 0 9.09260147572e-05
Gc25_993 0 n50 ns993 0 -0.00011103272724
Gc25_994 0 n50 ns994 0 9.11929354174e-05
Gc25_995 0 n50 ns995 0 4.70357814942e-06
Gc25_996 0 n50 ns996 0 1.44728631194e-05
Gc25_997 0 n50 ns997 0 -5.56456950023e-05
Gc25_998 0 n50 ns998 0 -0.000915310230726
Gc25_999 0 n50 ns999 0 0.000466492823717
Gc25_1000 0 n50 ns1000 0 0.000394870830964
Gc25_1001 0 n50 ns1001 0 -0.000434883910134
Gc25_1002 0 n50 ns1002 0 -0.000143357988795
Gc25_1003 0 n50 ns1003 0 -3.91151286167e-05
Gc25_1004 0 n50 ns1004 0 -0.000925512006218
Gc25_1005 0 n50 ns1005 0 0.000453070727094
Gc25_1006 0 n50 ns1006 0 0.000590247317971
Gc25_1007 0 n50 ns1007 0 0.000325730343697
Gc25_1008 0 n50 ns1008 0 6.58056971528e-05
Gc25_1009 0 n50 ns1009 0 -0.000156489634933
Gc25_1010 0 n50 ns1010 0 0.000356431974608
Gc25_1011 0 n50 ns1011 0 0.00116246011312
Gc25_1012 0 n50 ns1012 0 0.000804357941698
Gc25_1013 0 n50 ns1013 0 -0.000239232517507
Gc25_1014 0 n50 ns1014 0 -0.000537088179319
Gc25_1015 0 n50 ns1015 0 -0.000143328825105
Gc25_1016 0 n50 ns1016 0 0.000476359541533
Gc25_1017 0 n50 ns1017 0 0.000705405348114
Gc25_1018 0 n50 ns1018 0 0.00029613967475
Gc25_1019 0 n50 ns1019 0 8.66241527139e-05
Gc25_1020 0 n50 ns1020 0 1.1128594361e-06
Gc25_1021 0 n50 ns1021 0 -0.000261184797293
Gc25_1022 0 n50 ns1022 0 0.00951327061041
Gc25_1023 0 n50 ns1023 0 -0.00833559861668
Gc25_1024 0 n50 ns1024 0 0.000332812724098
Gc25_1025 0 n50 ns1025 0 -7.35925809257e-06
Gc25_1026 0 n50 ns1026 0 -2.68066581006e-05
Gc25_1027 0 n50 ns1027 0 0.000266465010094
Gc25_1028 0 n50 ns1028 0 -0.000368033426194
Gc25_1029 0 n50 ns1029 0 0.00275818131598
Gc25_1030 0 n50 ns1030 0 0.000137545908966
Gc25_1031 0 n50 ns1031 0 0.000172254513265
Gc25_1032 0 n50 ns1032 0 0.000122297078478
Gc25_1033 0 n50 ns1033 0 3.75749652083e-05
Gc25_1034 0 n50 ns1034 0 2.02788452814e-05
Gc25_1035 0 n50 ns1035 0 2.21899718807e-05
Gc25_1036 0 n50 ns1036 0 -0.000803616397927
Gc25_1037 0 n50 ns1037 0 -0.001028688034
Gc25_1038 0 n50 ns1038 0 0.000770274717315
Gc25_1039 0 n50 ns1039 0 0.000299256184819
Gc25_1040 0 n50 ns1040 0 -8.3010994419e-05
Gc25_1041 0 n50 ns1041 0 -0.000209255542895
Gc25_1042 0 n50 ns1042 0 -0.000917162321447
Gc25_1043 0 n50 ns1043 0 -0.00153730252316
Gc25_1044 0 n50 ns1044 0 -0.000297288185818
Gc25_1045 0 n50 ns1045 0 0.00109892561834
Gc25_1046 0 n50 ns1046 0 0.000226353635432
Gc25_1047 0 n50 ns1047 0 -7.16163623445e-06
Gc25_1048 0 n50 ns1048 0 -0.00181018830364
Gc25_1049 0 n50 ns1049 0 0.000454088459592
Gc25_1050 0 n50 ns1050 0 0.000832689733175
Gc25_1051 0 n50 ns1051 0 0.00104827324951
Gc25_1052 0 n50 ns1052 0 -0.000233174270691
Gc25_1053 0 n50 ns1053 0 -0.00080949915717
Gc25_1054 0 n50 ns1054 0 -0.00226340571945
Gc25_1055 0 n50 ns1055 0 0.000627373334085
Gc25_1056 0 n50 ns1056 0 0.000749647125129
Gc25_1057 0 n50 ns1057 0 0.00108745414532
Gc25_1058 0 n50 ns1058 0 0.000363190379855
Gc25_1059 0 n50 ns1059 0 -0.000597673381028
Gc25_1060 0 n50 ns1060 0 0.00447074135695
Gc25_1061 0 n50 ns1061 0 -0.00512036324441
Gc25_1062 0 n50 ns1062 0 0.000401117675523
Gc25_1063 0 n50 ns1063 0 -7.80872240142e-06
Gc25_1064 0 n50 ns1064 0 -1.74014146527e-05
Gc25_1065 0 n50 ns1065 0 -0.000855481642496
Gc25_1066 0 n50 ns1066 0 0.00176924213028
Gc25_1067 0 n50 ns1067 0 -0.00171120611904
Gc25_1068 0 n50 ns1068 0 -9.03762909216e-05
Gc25_1069 0 n50 ns1069 0 -0.00013242885665
Gc25_1070 0 n50 ns1070 0 -0.000324412442223
Gc25_1071 0 n50 ns1071 0 3.83545974451e-05
Gc25_1072 0 n50 ns1072 0 -4.05287359616e-05
Gc25_1073 0 n50 ns1073 0 1.13620116655e-05
Gc25_1074 0 n50 ns1074 0 0.000617951630657
Gc25_1075 0 n50 ns1075 0 0.000655429040636
Gc25_1076 0 n50 ns1076 0 -9.04318568386e-05
Gc25_1077 0 n50 ns1077 0 0.000513814732333
Gc25_1078 0 n50 ns1078 0 4.36527003834e-05
Gc25_1079 0 n50 ns1079 0 -0.000281609070398
Gc25_1080 0 n50 ns1080 0 0.00169890265243
Gc25_1081 0 n50 ns1081 0 -0.00051311019655
Gc25_1082 0 n50 ns1082 0 -0.0010681371774
Gc25_1083 0 n50 ns1083 0 -7.8632312115e-06
Gc25_1084 0 n50 ns1084 0 0.000157937736941
Gc25_1085 0 n50 ns1085 0 6.31002828709e-05
Gc25_1086 0 n50 ns1086 0 -7.26973401038e-06
Gc25_1087 0 n50 ns1087 0 -0.00110774019384
Gc25_1088 0 n50 ns1088 0 -0.000307873829634
Gc25_1089 0 n50 ns1089 0 0.00135936048685
Gc25_1090 0 n50 ns1090 0 0.000360569107312
Gc25_1091 0 n50 ns1091 0 -0.000919125635502
Gc25_1092 0 n50 ns1092 0 -0.00109861520673
Gc25_1093 0 n50 ns1093 0 -0.000992369699635
Gc25_1094 0 n50 ns1094 0 -0.000100774426024
Gc25_1095 0 n50 ns1095 0 0.00164811415611
Gc25_1096 0 n50 ns1096 0 0.000754858277117
Gc25_1097 0 n50 ns1097 0 -0.000584623204263
Gc25_1098 0 n50 ns1098 0 0.0117038838001
Gc25_1099 0 n50 ns1099 0 -0.011466519377
Gc25_1100 0 n50 ns1100 0 0.000746654837221
Gc25_1101 0 n50 ns1101 0 -9.96758215721e-06
Gc25_1102 0 n50 ns1102 0 3.86451722231e-06
Gc25_1103 0 n50 ns1103 0 -0.00117355719893
Gc25_1104 0 n50 ns1104 0 0.00251334993717
Gc25_1105 0 n50 ns1105 0 -0.00398867253962
Gc25_1106 0 n50 ns1106 0 0.000220479153907
Gc25_1107 0 n50 ns1107 0 -0.000501118573872
Gc25_1108 0 n50 ns1108 0 7.80504135542e-05
Gc25_1109 0 n50 ns1109 0 -0.000534818209345
Gc25_1110 0 n50 ns1110 0 -3.3470331713e-05
Gc25_1111 0 n50 ns1111 0 -7.75896958933e-06
Gc25_1112 0 n50 ns1112 0 -0.0015872689167
Gc25_1113 0 n50 ns1113 0 0.00168508335243
Gc25_1114 0 n50 ns1114 0 -0.000363987186183
Gc25_1115 0 n50 ns1115 0 -0.000448767195878
Gc25_1116 0 n50 ns1116 0 0.00014913243003
Gc25_1117 0 n50 ns1117 0 -0.000237125336818
Gc25_1118 0 n50 ns1118 0 -0.000159907861988
Gc25_1119 0 n50 ns1119 0 0.00268110343602
Gc25_1120 0 n50 ns1120 0 0.000134757468031
Gc25_1121 0 n50 ns1121 0 -0.000880931252919
Gc25_1122 0 n50 ns1122 0 0.000209156321936
Gc25_1123 0 n50 ns1123 0 9.90598847117e-06
Gc25_1124 0 n50 ns1124 0 0.00235674710345
Gc25_1125 0 n50 ns1125 0 0.00234729521409
Gc25_1126 0 n50 ns1126 0 -0.000512342310579
Gc25_1127 0 n50 ns1127 0 5.1098080423e-06
Gc25_1128 0 n50 ns1128 0 0.000463679360044
Gc25_1129 0 n50 ns1129 0 -0.000645865226352
Gc25_1130 0 n50 ns1130 0 0.00358712409784
Gc25_1131 0 n50 ns1131 0 0.000271873195336
Gc25_1132 0 n50 ns1132 0 -0.0018920976201
Gc25_1133 0 n50 ns1133 0 0.00066985912727
Gc25_1134 0 n50 ns1134 0 0.00113416923148
Gc25_1135 0 n50 ns1135 0 -0.00021028106468
Gc25_1136 0 n50 ns1136 0 0.036648897969
Gc25_1137 0 n50 ns1137 0 -0.0335884361971
Gc25_1138 0 n50 ns1138 0 0.00190250273711
Gc25_1139 0 n50 ns1139 0 -6.38501686591e-06
Gc25_1140 0 n50 ns1140 0 1.82614494479e-05
Gc25_1141 0 n50 ns1141 0 -0.00160051367466
Gc25_1142 0 n50 ns1142 0 -0.00163244763257
Gc25_1143 0 n50 ns1143 0 0.00475186684965
Gc25_1144 0 n50 ns1144 0 0.00104786048498
Gc25_1145 0 n50 ns1145 0 -0.000413265771446
Gc25_1146 0 n50 ns1146 0 0.000837186438765
Gc25_1147 0 n50 ns1147 0 0.000539914260286
Gc25_1148 0 n50 ns1148 0 -0.000135234608637
Gc25_1149 0 n50 ns1149 0 -4.79821309571e-05
Gc25_1150 0 n50 ns1150 0 -0.00139435558992
Gc25_1151 0 n50 ns1151 0 -0.00206300099452
Gc25_1152 0 n50 ns1152 0 0.000833565560435
Gc25_1153 0 n50 ns1153 0 -0.000309122746
Gc25_1154 0 n50 ns1154 0 0.000344250355083
Gc25_1155 0 n50 ns1155 0 -0.000223981055011
Gc25_1156 0 n50 ns1156 0 -0.00234634910132
Gc25_1157 0 n50 ns1157 0 -0.00235004923189
Gc25_1158 0 n50 ns1158 0 -4.1879928148e-05
Gc25_1159 0 n50 ns1159 0 0.0001724759709
Gc25_1160 0 n50 ns1160 0 0.000221731787118
Gc25_1161 0 n50 ns1161 0 0.000330883938452
Gc25_1162 0 n50 ns1162 0 -0.00504699637868
Gc25_1163 0 n50 ns1163 0 0.00182059887004
Gc25_1164 0 n50 ns1164 0 0.000478749155124
Gc25_1165 0 n50 ns1165 0 0.000411737884156
Gc25_1166 0 n50 ns1166 0 0.000838776491664
Gc25_1167 0 n50 ns1167 0 -0.000815507231594
Gc25_1168 0 n50 ns1168 0 -0.00255662236157
Gc25_1169 0 n50 ns1169 0 0.00266404777666
Gc25_1170 0 n50 ns1170 0 -0.00186823480475
Gc25_1171 0 n50 ns1171 0 -0.000773622170295
Gc25_1172 0 n50 ns1172 0 0.00175924430914
Gc25_1173 0 n50 ns1173 0 0.000532175745166
Gc25_1174 0 n50 ns1174 0 0.0300588352789
Gc25_1175 0 n50 ns1175 0 -0.0347266930901
Gc25_1176 0 n50 ns1176 0 0.00429230224553
Gc25_1177 0 n50 ns1177 0 2.5627221943e-06
Gc25_1178 0 n50 ns1178 0 2.87000706609e-05
Gc25_1179 0 n50 ns1179 0 -0.00575442331428
Gc25_1180 0 n50 ns1180 0 -0.00343033756224
Gc25_1181 0 n50 ns1181 0 -0.00385117063436
Gc25_1182 0 n50 ns1182 0 0.000390783520274
Gc25_1183 0 n50 ns1183 0 -0.00152078964724
Gc25_1184 0 n50 ns1184 0 -0.000784934587098
Gc25_1185 0 n50 ns1185 0 0.000740030916698
Gc25_1186 0 n50 ns1186 0 -2.72514439577e-05
Gc25_1187 0 n50 ns1187 0 -5.98004868633e-05
Gc25_1188 0 n50 ns1188 0 -0.000368974500841
Gc25_1189 0 n50 ns1189 0 0.00268296064738
Gc25_1190 0 n50 ns1190 0 0.000559556082622
Gc25_1191 0 n50 ns1191 0 -0.000284917405815
Gc25_1192 0 n50 ns1192 0 0.000186079680382
Gc25_1193 0 n50 ns1193 0 -9.78786757014e-05
Gc25_1194 0 n50 ns1194 0 0.0015568367516
Gc25_1195 0 n50 ns1195 0 0.000780053101216
Gc25_1196 0 n50 ns1196 0 0.000744859348153
Gc25_1197 0 n50 ns1197 0 -9.87247887618e-05
Gc25_1198 0 n50 ns1198 0 0.000174613781402
Gc25_1199 0 n50 ns1199 0 0.000133219912342
Gc25_1200 0 n50 ns1200 0 0.00126833710238
Gc25_1201 0 n50 ns1201 0 -0.00115163779522
Gc25_1202 0 n50 ns1202 0 0.00112778297479
Gc25_1203 0 n50 ns1203 0 0.00203354140459
Gc25_1204 0 n50 ns1204 0 0.00119844071576
Gc25_1205 0 n50 ns1205 0 -0.00113549893548
Gc25_1206 0 n50 ns1206 0 0.000935795470603
Gc25_1207 0 n50 ns1207 0 -0.00195072475527
Gc25_1208 0 n50 ns1208 0 0.00314148623664
Gc25_1209 0 n50 ns1209 0 -0.000135347954478
Gc25_1210 0 n50 ns1210 0 0.0021758621309
Gc25_1211 0 n50 ns1211 0 0.000420758274842
Gc25_1212 0 n50 ns1212 0 -0.0408957671359
Gc25_1213 0 n50 ns1213 0 0.0422241311399
Gc25_1214 0 n50 ns1214 0 0.0059942763783
Gc25_1215 0 n50 ns1215 0 -4.82885050977e-06
Gc25_1216 0 n50 ns1216 0 2.16806714423e-05
Gd25_1 0 n50 ni1 0 -0.000230971215587
Gd25_2 0 n50 ni2 0 -0.000115100424106
Gd25_3 0 n50 ni3 0 -5.77512264655e-05
Gd25_4 0 n50 ni4 0 -0.000137645688715
Gd25_5 0 n50 ni5 0 7.21663030296e-05
Gd25_6 0 n50 ni6 0 0.000262513410082
Gd25_7 0 n50 ni7 0 0.00055458003509
Gd25_8 0 n50 ni8 0 -0.000469003317312
Gd25_9 0 n50 ni9 0 -0.00755734333505
Gd25_10 0 n50 ni10 0 -9.97046320941e-05
Gd25_11 0 n50 ni11 0 -8.44891429595e-05
Gd25_12 0 n50 ni12 0 4.07628015063e-05
Gd25_13 0 n50 ni13 0 0.000261973240757
Gd25_14 0 n50 ni14 0 0.000194504454818
Gd25_15 0 n50 ni15 0 6.53799278695e-06
Gd25_16 0 n50 ni16 0 -0.00315752400672
Gd25_17 0 n50 ni17 0 -7.85258711621e-05
Gd25_18 0 n50 ni18 0 1.09678347451e-05
Gd25_19 0 n50 ni19 0 -8.51004182656e-05
Gd25_20 0 n50 ni20 0 -4.26818932838e-05
Gd25_21 0 n50 ni21 0 4.73551834415e-05
Gd25_22 0 n50 ni22 0 0.000236254864569
Gd25_23 0 n50 ni23 0 -0.000239250520995
Gd25_24 0 n50 ni24 0 -0.00208536397105
Gd25_25 0 n50 ni25 0 -0.00236534966719
Gd25_26 0 n50 ni26 0 -8.01022604272e-05
Gd25_27 0 n50 ni27 0 -0.000102242196807
Gd25_28 0 n50 ni28 0 0.000250696933885
Gd25_29 0 n50 ni29 0 0.000206939497667
Gd25_30 0 n50 ni30 0 0.000297616039473
Gd25_31 0 n50 ni31 0 -0.00125376995893
Gd25_32 0 n50 ni32 0 -0.00275489029154
Gc26_1 0 n52 ns1 0 -0.000510052340133
Gc26_2 0 n52 ns2 0 0.000610103875154
Gc26_3 0 n52 ns3 0 0.00191981696476
Gc26_4 0 n52 ns4 0 -0.0011914673181
Gc26_5 0 n52 ns5 0 -0.000825370423993
Gc26_6 0 n52 ns6 0 0.00159872705247
Gc26_7 0 n52 ns7 0 0.000206726334293
Gc26_8 0 n52 ns8 0 -0.000189183039842
Gc26_9 0 n52 ns9 0 -0.000189560940753
Gc26_10 0 n52 ns10 0 0.00240856073514
Gc26_11 0 n52 ns11 0 -0.000439048717192
Gc26_12 0 n52 ns12 0 -0.000885240297349
Gc26_13 0 n52 ns13 0 0.000642009338813
Gc26_14 0 n52 ns14 0 -0.000275417076315
Gc26_15 0 n52 ns15 0 0.000168722399421
Gc26_16 0 n52 ns16 0 -0.00123359218272
Gc26_17 0 n52 ns17 0 -0.00317996952162
Gc26_18 0 n52 ns18 0 -7.08923576075e-05
Gc26_19 0 n52 ns19 0 0.000296388519744
Gc26_20 0 n52 ns20 0 0.000177576513083
Gc26_21 0 n52 ns21 0 0.000386270513285
Gc26_22 0 n52 ns22 0 0.00192813733788
Gc26_23 0 n52 ns23 0 -0.00390790915444
Gc26_24 0 n52 ns24 0 -0.0022268731579
Gc26_25 0 n52 ns25 0 5.30193181671e-05
Gc26_26 0 n52 ns26 0 -9.44981394188e-05
Gc26_27 0 n52 ns27 0 0.00110097675826
Gc26_28 0 n52 ns28 0 -0.00847033482708
Gc26_29 0 n52 ns29 0 -0.00226853834364
Gc26_30 0 n52 ns30 0 -0.000863864932398
Gc26_31 0 n52 ns31 0 0.000348004790756
Gc26_32 0 n52 ns32 0 0.00231172501188
Gc26_33 0 n52 ns33 0 0.00077044268434
Gc26_34 0 n52 ns34 0 -0.0446997501031
Gc26_35 0 n52 ns35 0 0.0455628212318
Gc26_36 0 n52 ns36 0 -0.00596936415298
Gc26_37 0 n52 ns37 0 -5.60892835746e-06
Gc26_38 0 n52 ns38 0 2.8957470615e-05
Gc26_39 0 n52 ns39 0 -0.0025279638163
Gc26_40 0 n52 ns40 0 -0.00229868469411
Gc26_41 0 n52 ns41 0 0.00516350192697
Gc26_42 0 n52 ns42 0 0.00115329837828
Gc26_43 0 n52 ns43 0 -0.00190604304511
Gc26_44 0 n52 ns44 0 0.000429072051063
Gc26_45 0 n52 ns45 0 0.00175082544613
Gc26_46 0 n52 ns46 0 -1.23360029967e-05
Gc26_47 0 n52 ns47 0 -0.000228283136671
Gc26_48 0 n52 ns48 0 0.000717178821699
Gc26_49 0 n52 ns49 0 -0.000489235223422
Gc26_50 0 n52 ns50 0 -0.000891476545583
Gc26_51 0 n52 ns51 0 0.00060327526781
Gc26_52 0 n52 ns52 0 -0.00033056355824
Gc26_53 0 n52 ns53 0 0.000222525602899
Gc26_54 0 n52 ns54 0 0.000464035864261
Gc26_55 0 n52 ns55 0 -0.00218403703363
Gc26_56 0 n52 ns56 0 0.000120095642544
Gc26_57 0 n52 ns57 0 -0.000397114000081
Gc26_58 0 n52 ns58 0 0.000147728675109
Gc26_59 0 n52 ns59 0 0.000291165710845
Gc26_60 0 n52 ns60 0 0.00222771478576
Gc26_61 0 n52 ns61 0 -0.00143808476692
Gc26_62 0 n52 ns62 0 -0.00176854826977
Gc26_63 0 n52 ns63 0 -0.000604261512386
Gc26_64 0 n52 ns64 0 -0.000621348704187
Gc26_65 0 n52 ns65 0 0.00125366392899
Gc26_66 0 n52 ns66 0 -0.00868307285586
Gc26_67 0 n52 ns67 0 -0.00277039425598
Gc26_68 0 n52 ns68 0 -0.000234125112472
Gc26_69 0 n52 ns69 0 0.000439535407764
Gc26_70 0 n52 ns70 0 0.00269262935991
Gc26_71 0 n52 ns71 0 0.000797474645745
Gc26_72 0 n52 ns72 0 -0.0269536785776
Gc26_73 0 n52 ns73 0 0.0310779622003
Gc26_74 0 n52 ns74 0 -0.00705822104024
Gc26_75 0 n52 ns75 0 -8.39160026839e-06
Gc26_76 0 n52 ns76 0 2.68036018744e-05
Gc26_77 0 n52 ns77 0 -0.00566538020091
Gc26_78 0 n52 ns78 0 -0.0042784591491
Gc26_79 0 n52 ns79 0 0.00662855609475
Gc26_80 0 n52 ns80 0 0.00244187163019
Gc26_81 0 n52 ns81 0 -0.00223554074575
Gc26_82 0 n52 ns82 0 0.000624225452786
Gc26_83 0 n52 ns83 0 0.00296188474207
Gc26_84 0 n52 ns84 0 1.33943926143e-05
Gc26_85 0 n52 ns85 0 -0.000274812389537
Gc26_86 0 n52 ns86 0 -0.00206380842723
Gc26_87 0 n52 ns87 0 -0.00115713387932
Gc26_88 0 n52 ns88 0 -3.78214822894e-05
Gc26_89 0 n52 ns89 0 0.000670350746188
Gc26_90 0 n52 ns90 0 -0.000256490589491
Gc26_91 0 n52 ns91 0 0.000282888182172
Gc26_92 0 n52 ns92 0 0.0032821752003
Gc26_93 0 n52 ns93 0 -0.000931463201549
Gc26_94 0 n52 ns94 0 -0.000524160673758
Gc26_95 0 n52 ns95 0 -0.00162680454476
Gc26_96 0 n52 ns96 0 -3.74044210532e-06
Gc26_97 0 n52 ns97 0 0.000201900474603
Gc26_98 0 n52 ns98 0 0.00243152092128
Gc26_99 0 n52 ns99 0 0.00201166295331
Gc26_100 0 n52 ns100 0 -6.48264524962e-05
Gc26_101 0 n52 ns101 0 -0.00212120257658
Gc26_102 0 n52 ns102 0 -0.00167446154217
Gc26_103 0 n52 ns103 0 0.00143754280802
Gc26_104 0 n52 ns104 0 -0.0116740909509
Gc26_105 0 n52 ns105 0 -0.00487606702249
Gc26_106 0 n52 ns106 0 0.00128329698093
Gc26_107 0 n52 ns107 0 0.0028614450784
Gc26_108 0 n52 ns108 0 0.00354673879523
Gc26_109 0 n52 ns109 0 0.000520981124115
Gc26_110 0 n52 ns110 0 0.0172371852437
Gc26_111 0 n52 ns111 0 -0.00749555835242
Gc26_112 0 n52 ns112 0 -0.00777840474107
Gc26_113 0 n52 ns113 0 -1.48071978026e-05
Gc26_114 0 n52 ns114 0 2.62645643269e-05
Gc26_115 0 n52 ns115 0 6.83077513069e-05
Gc26_116 0 n52 ns116 0 -0.000586717013997
Gc26_117 0 n52 ns117 0 0.00924125596897
Gc26_118 0 n52 ns118 0 -0.000212776856689
Gc26_119 0 n52 ns119 0 5.83948616026e-05
Gc26_120 0 n52 ns120 0 0.000557017112565
Gc26_121 0 n52 ns121 0 -0.000580460973849
Gc26_122 0 n52 ns122 0 -8.22374266973e-05
Gc26_123 0 n52 ns123 0 6.77366246317e-06
Gc26_124 0 n52 ns124 0 0.0013744947025
Gc26_125 0 n52 ns125 0 -0.00141473056005
Gc26_126 0 n52 ns126 0 -0.00018075495307
Gc26_127 0 n52 ns127 0 8.30642590451e-05
Gc26_128 0 n52 ns128 0 -0.000319084900885
Gc26_129 0 n52 ns129 0 0.000422025753948
Gc26_130 0 n52 ns130 0 -0.000509807552115
Gc26_131 0 n52 ns131 0 -0.00251257223195
Gc26_132 0 n52 ns132 0 -0.00117234097301
Gc26_133 0 n52 ns133 0 0.000129360382055
Gc26_134 0 n52 ns134 0 0.000331867728387
Gc26_135 0 n52 ns135 0 0.000437477661996
Gc26_136 0 n52 ns136 0 -0.000404906056104
Gc26_137 0 n52 ns137 0 -0.00575740244313
Gc26_138 0 n52 ns138 0 -0.00214560170018
Gc26_139 0 n52 ns139 0 -0.000642493944268
Gc26_140 0 n52 ns140 0 2.26260909745e-05
Gc26_141 0 n52 ns141 0 0.00198200693969
Gc26_142 0 n52 ns142 0 -0.0100622697357
Gc26_143 0 n52 ns143 0 -0.00594948372833
Gc26_144 0 n52 ns144 0 -0.0022615887874
Gc26_145 0 n52 ns145 0 0.00284577546953
Gc26_146 0 n52 ns146 0 0.00276467634321
Gc26_147 0 n52 ns147 0 0.000307353792384
Gc26_148 0 n52 ns148 0 -0.091213733729
Gc26_149 0 n52 ns149 0 0.0831775957846
Gc26_150 0 n52 ns150 0 -0.00528765269801
Gc26_151 0 n52 ns151 0 -1.25810350028e-05
Gc26_152 0 n52 ns152 0 2.05606904899e-05
Gc26_153 0 n52 ns153 0 0.00060613139752
Gc26_154 0 n52 ns154 0 -0.00201970680578
Gc26_155 0 n52 ns155 0 0.0107613232527
Gc26_156 0 n52 ns156 0 0.000564988343997
Gc26_157 0 n52 ns157 0 7.73079551041e-05
Gc26_158 0 n52 ns158 0 6.50968058255e-05
Gc26_159 0 n52 ns159 0 -3.01179986614e-05
Gc26_160 0 n52 ns160 0 -4.84542523669e-05
Gc26_161 0 n52 ns161 0 9.47794878386e-06
Gc26_162 0 n52 ns162 0 -0.000277420387107
Gc26_163 0 n52 ns163 0 -0.00309293969695
Gc26_164 0 n52 ns164 0 -1.63028052589e-05
Gc26_165 0 n52 ns165 0 0.000503073877096
Gc26_166 0 n52 ns166 0 0.000119083539254
Gc26_167 0 n52 ns167 0 0.000504040368176
Gc26_168 0 n52 ns168 0 -0.000303461810843
Gc26_169 0 n52 ns169 0 -0.000821586881039
Gc26_170 0 n52 ns170 0 -0.000881453845942
Gc26_171 0 n52 ns171 0 9.11840802196e-05
Gc26_172 0 n52 ns172 0 0.000272187947177
Gc26_173 0 n52 ns173 0 9.45799661205e-05
Gc26_174 0 n52 ns174 0 -0.00235758323892
Gc26_175 0 n52 ns175 0 -0.00360171802874
Gc26_176 0 n52 ns176 0 -0.000975952133349
Gc26_177 0 n52 ns177 0 -0.000596960646614
Gc26_178 0 n52 ns178 0 0.0002033689353
Gc26_179 0 n52 ns179 0 0.00147211967554
Gc26_180 0 n52 ns180 0 -0.00838582446481
Gc26_181 0 n52 ns181 0 -0.00567293570215
Gc26_182 0 n52 ns182 0 -0.00130388050743
Gc26_183 0 n52 ns183 0 0.00414429682163
Gc26_184 0 n52 ns184 0 0.00209047358634
Gc26_185 0 n52 ns185 0 -0.000416004614851
Gc26_186 0 n52 ns186 0 -0.062243369867
Gc26_187 0 n52 ns187 0 0.0533331258363
Gc26_188 0 n52 ns188 0 -0.00224682185036
Gc26_189 0 n52 ns189 0 -8.73872553155e-06
Gc26_190 0 n52 ns190 0 1.29406678595e-07
Gc26_191 0 n52 ns191 0 0.000240945001262
Gc26_192 0 n52 ns192 0 -0.000357933233845
Gc26_193 0 n52 ns193 0 0.00433032508966
Gc26_194 0 n52 ns194 0 -0.000230038414023
Gc26_195 0 n52 ns195 0 0.00043693871667
Gc26_196 0 n52 ns196 0 0.000380134030926
Gc26_197 0 n52 ns197 0 8.00039835809e-05
Gc26_198 0 n52 ns198 0 2.34174317889e-05
Gc26_199 0 n52 ns199 0 -1.70172022046e-05
Gc26_200 0 n52 ns200 0 0.000264892891692
Gc26_201 0 n52 ns201 0 -0.00134777764027
Gc26_202 0 n52 ns202 0 -0.000246889987906
Gc26_203 0 n52 ns203 0 0.00014502315057
Gc26_204 0 n52 ns204 0 0.000212251054095
Gc26_205 0 n52 ns205 0 0.000295932330418
Gc26_206 0 n52 ns206 0 0.000628315903275
Gc26_207 0 n52 ns207 0 -0.00125334332783
Gc26_208 0 n52 ns208 0 -0.000872753175786
Gc26_209 0 n52 ns209 0 0.000427340842796
Gc26_210 0 n52 ns210 0 0.00014508984359
Gc26_211 0 n52 ns211 0 4.78899447361e-06
Gc26_212 0 n52 ns212 0 -0.000476026490977
Gc26_213 0 n52 ns213 0 -0.00193355998358
Gc26_214 0 n52 ns214 0 -0.0012568884609
Gc26_215 0 n52 ns215 0 -0.00119859243204
Gc26_216 0 n52 ns216 0 0.000408068628537
Gc26_217 0 n52 ns217 0 0.00136813218571
Gc26_218 0 n52 ns218 0 -0.00552448410186
Gc26_219 0 n52 ns219 0 -0.00326189034363
Gc26_220 0 n52 ns220 0 0.000142250386916
Gc26_221 0 n52 ns221 0 0.00290656181969
Gc26_222 0 n52 ns222 0 0.0010811864616
Gc26_223 0 n52 ns223 0 -0.000655679385945
Gc26_224 0 n52 ns224 0 -0.025055034796
Gc26_225 0 n52 ns225 0 0.0208461791402
Gc26_226 0 n52 ns226 0 -0.0007930480047
Gc26_227 0 n52 ns227 0 -1.79217677804e-06
Gc26_228 0 n52 ns228 0 -1.81730925585e-05
Gc26_229 0 n52 ns229 0 0.000526913409842
Gc26_230 0 n52 ns230 0 -0.000610962579542
Gc26_231 0 n52 ns231 0 0.00273138336909
Gc26_232 0 n52 ns232 0 -0.000167841346912
Gc26_233 0 n52 ns233 0 0.000339868321533
Gc26_234 0 n52 ns234 0 0.000187363895863
Gc26_235 0 n52 ns235 0 -2.496959004e-06
Gc26_236 0 n52 ns236 0 -1.27961552952e-05
Gc26_237 0 n52 ns237 0 -4.0522384045e-05
Gc26_238 0 n52 ns238 0 0.000710704105313
Gc26_239 0 n52 ns239 0 -0.000966634796041
Gc26_240 0 n52 ns240 0 -0.000495187636937
Gc26_241 0 n52 ns241 0 0.000316275305606
Gc26_242 0 n52 ns242 0 0.000191887290253
Gc26_243 0 n52 ns243 0 0.000152059550942
Gc26_244 0 n52 ns244 0 -0.000451519023838
Gc26_245 0 n52 ns245 0 -0.000971804738736
Gc26_246 0 n52 ns246 0 -4.20479438445e-05
Gc26_247 0 n52 ns247 0 0.000668136486953
Gc26_248 0 n52 ns248 0 0.000111112293374
Gc26_249 0 n52 ns249 0 -0.000103402572019
Gc26_250 0 n52 ns250 0 -0.000182490868768
Gc26_251 0 n52 ns251 0 -0.00134851520313
Gc26_252 0 n52 ns252 0 -0.0013686021918
Gc26_253 0 n52 ns253 0 -0.000338697034265
Gc26_254 0 n52 ns254 0 0.000712066301885
Gc26_255 0 n52 ns255 0 0.000695527152663
Gc26_256 0 n52 ns256 0 -0.00356695900469
Gc26_257 0 n52 ns257 0 -0.000717066136896
Gc26_258 0 n52 ns258 0 0.000687851447477
Gc26_259 0 n52 ns259 0 0.00146260664827
Gc26_260 0 n52 ns260 0 0.000455189759172
Gc26_261 0 n52 ns261 0 -0.000547785922803
Gc26_262 0 n52 ns262 0 -0.00771618888862
Gc26_263 0 n52 ns263 0 0.00596380609558
Gc26_264 0 n52 ns264 0 -0.00020756854373
Gc26_265 0 n52 ns265 0 5.58585526834e-06
Gc26_266 0 n52 ns266 0 -3.19669827409e-05
Gc26_267 0 n52 ns267 0 0.000424808880985
Gc26_268 0 n52 ns268 0 -0.000782871073872
Gc26_269 0 n52 ns269 0 0.000885003680759
Gc26_270 0 n52 ns270 0 -0.000217544161971
Gc26_271 0 n52 ns271 0 0.000155801570794
Gc26_272 0 n52 ns272 0 4.84515653033e-05
Gc26_273 0 n52 ns273 0 0.000104806007114
Gc26_274 0 n52 ns274 0 1.01966870519e-05
Gc26_275 0 n52 ns275 0 3.4584972486e-06
Gc26_276 0 n52 ns276 0 3.10545360208e-05
Gc26_277 0 n52 ns277 0 -0.000756408106665
Gc26_278 0 n52 ns278 0 -9.98871744614e-06
Gc26_279 0 n52 ns279 0 0.000513438212663
Gc26_280 0 n52 ns280 0 0.000166480436278
Gc26_281 0 n52 ns281 0 -4.47689923096e-05
Gc26_282 0 n52 ns282 0 -0.000442814103584
Gc26_283 0 n52 ns283 0 0.00037462087964
Gc26_284 0 n52 ns284 0 0.000494062357071
Gc26_285 0 n52 ns285 0 5.3400832668e-05
Gc26_286 0 n52 ns286 0 -2.18548373921e-05
Gc26_287 0 n52 ns287 0 -0.000165035134359
Gc26_288 0 n52 ns288 0 0.000141608140143
Gc26_289 0 n52 ns289 0 -0.000704460947151
Gc26_290 0 n52 ns290 0 -0.00077432478547
Gc26_291 0 n52 ns291 0 0.000153313066877
Gc26_292 0 n52 ns292 0 0.000496944706602
Gc26_293 0 n52 ns293 0 0.000145705246608
Gc26_294 0 n52 ns294 0 -0.00102484094361
Gc26_295 0 n52 ns295 0 0.00062695880699
Gc26_296 0 n52 ns296 0 0.000563039710993
Gc26_297 0 n52 ns297 0 0.000334434590305
Gc26_298 0 n52 ns298 0 5.49256367599e-05
Gc26_299 0 n52 ns299 0 -0.000341650703019
Gc26_300 0 n52 ns300 0 0.00327833327452
Gc26_301 0 n52 ns301 0 -0.00291171468115
Gc26_302 0 n52 ns302 0 3.98962767406e-05
Gc26_303 0 n52 ns303 0 6.51495270594e-06
Gc26_304 0 n52 ns304 0 -3.21953590761e-05
Gc26_305 0 n52 ns305 0 -3.15235235694e-05
Gc26_306 0 n52 ns306 0 -0.000107780527021
Gc26_307 0 n52 ns307 0 -0.00104011511572
Gc26_308 0 n52 ns308 0 -0.000181055897031
Gc26_309 0 n52 ns309 0 8.05803766694e-05
Gc26_310 0 n52 ns310 0 4.52308163383e-05
Gc26_311 0 n52 ns311 0 0.000163171693071
Gc26_312 0 n52 ns312 0 3.84029678879e-05
Gc26_313 0 n52 ns313 0 -1.75915087074e-05
Gc26_314 0 n52 ns314 0 -0.000403973357008
Gc26_315 0 n52 ns315 0 -9.92816953585e-05
Gc26_316 0 n52 ns316 0 0.000315562950089
Gc26_317 0 n52 ns317 0 0.000209704357775
Gc26_318 0 n52 ns318 0 5.27321938553e-05
Gc26_319 0 n52 ns319 0 -0.000132147815215
Gc26_320 0 n52 ns320 0 4.59541540582e-05
Gc26_321 0 n52 ns321 0 0.000779011919392
Gc26_322 0 n52 ns322 0 0.000393553556006
Gc26_323 0 n52 ns323 0 -0.000286264907752
Gc26_324 0 n52 ns324 0 -7.43059431288e-05
Gc26_325 0 n52 ns325 0 -0.000114726245304
Gc26_326 0 n52 ns326 0 0.000402986142912
Gc26_327 0 n52 ns327 0 -0.00013673190413
Gc26_328 0 n52 ns328 0 -0.000216284619844
Gc26_329 0 n52 ns329 0 9.14383483187e-05
Gc26_330 0 n52 ns330 0 0.000158655664805
Gc26_331 0 n52 ns331 0 -1.63997379673e-05
Gc26_332 0 n52 ns332 0 0.000510402829609
Gc26_333 0 n52 ns333 0 0.00100623875325
Gc26_334 0 n52 ns334 0 0.000327234282223
Gc26_335 0 n52 ns335 0 -0.000185608780599
Gc26_336 0 n52 ns336 0 -8.88706623111e-05
Gc26_337 0 n52 ns337 0 -0.000190148241924
Gc26_338 0 n52 ns338 0 0.0101060703791
Gc26_339 0 n52 ns339 0 -0.0085323530361
Gc26_340 0 n52 ns340 0 0.000225249495174
Gc26_341 0 n52 ns341 0 5.5228520372e-06
Gc26_342 0 n52 ns342 0 -2.71465134323e-05
Gc26_343 0 n52 ns343 0 -0.0171404082169
Gc26_344 0 n52 ns344 0 -0.00089335052316
Gc26_345 0 n52 ns345 0 0.0191621605611
Gc26_346 0 n52 ns346 0 0.0063730185757
Gc26_347 0 n52 ns347 0 0.00996052450948
Gc26_348 0 n52 ns348 0 0.0012494805584
Gc26_349 0 n52 ns349 0 -0.00331134053001
Gc26_350 0 n52 ns350 0 -0.000536682666955
Gc26_351 0 n52 ns351 0 7.31859754978e-05
Gc26_352 0 n52 ns352 0 -0.0018638418611
Gc26_353 0 n52 ns353 0 -0.0140675443365
Gc26_354 0 n52 ns354 0 0.0015713253154
Gc26_355 0 n52 ns355 0 0.00213428860576
Gc26_356 0 n52 ns356 0 8.71629078682e-05
Gc26_357 0 n52 ns357 0 0.000140658467686
Gc26_358 0 n52 ns358 0 0.000250651478568
Gc26_359 0 n52 ns359 0 0.00183882873069
Gc26_360 0 n52 ns360 0 0.000459599921418
Gc26_361 0 n52 ns361 0 -0.000351137601864
Gc26_362 0 n52 ns362 0 0.000338595405356
Gc26_363 0 n52 ns363 0 0.000400234377288
Gc26_364 0 n52 ns364 0 -0.0118884043098
Gc26_365 0 n52 ns365 0 -0.00710922190591
Gc26_366 0 n52 ns366 0 -0.00241056988561
Gc26_367 0 n52 ns367 0 -0.000517120677955
Gc26_368 0 n52 ns368 0 -0.000464145216774
Gc26_369 0 n52 ns369 0 0.00170137282352
Gc26_370 0 n52 ns370 0 0.0110699387745
Gc26_371 0 n52 ns371 0 -0.00504237383565
Gc26_372 0 n52 ns372 0 0.000904439013254
Gc26_373 0 n52 ns373 0 0.000807871916925
Gc26_374 0 n52 ns374 0 0.00317389214244
Gc26_375 0 n52 ns375 0 0.000496483381109
Gc26_376 0 n52 ns376 0 -0.105253247289
Gc26_377 0 n52 ns377 0 0.0684496071665
Gc26_378 0 n52 ns378 0 -0.00888604834357
Gc26_379 0 n52 ns379 0 -1.34935993939e-05
Gc26_380 0 n52 ns380 0 2.6406301154e-05
Gc26_381 0 n52 ns381 0 -0.000520775640555
Gc26_382 0 n52 ns382 0 0.000509645177146
Gc26_383 0 n52 ns383 0 0.00498374053585
Gc26_384 0 n52 ns384 0 -0.00129713698542
Gc26_385 0 n52 ns385 0 -0.000552859192008
Gc26_386 0 n52 ns386 0 0.00187585134474
Gc26_387 0 n52 ns387 0 0.000532275300264
Gc26_388 0 n52 ns388 0 -0.000157998774817
Gc26_389 0 n52 ns389 0 -0.000182334738366
Gc26_390 0 n52 ns390 0 0.00128393319191
Gc26_391 0 n52 ns391 0 -0.00138181168196
Gc26_392 0 n52 ns392 0 -9.01898506273e-05
Gc26_393 0 n52 ns393 0 0.000425717068684
Gc26_394 0 n52 ns394 0 -0.000326795986792
Gc26_395 0 n52 ns395 0 0.000353890742953
Gc26_396 0 n52 ns396 0 0.000537621037292
Gc26_397 0 n52 ns397 0 -0.00305415554964
Gc26_398 0 n52 ns398 0 -0.00132622009952
Gc26_399 0 n52 ns399 0 -0.000281986534516
Gc26_400 0 n52 ns400 0 0.000226505050885
Gc26_401 0 n52 ns401 0 0.000512867773201
Gc26_402 0 n52 ns402 0 0.000959395848804
Gc26_403 0 n52 ns403 0 -0.00462329672093
Gc26_404 0 n52 ns404 0 -0.00194795321537
Gc26_405 0 n52 ns405 0 -0.00110916193012
Gc26_406 0 n52 ns406 0 -0.000421820549527
Gc26_407 0 n52 ns407 0 0.00201708374056
Gc26_408 0 n52 ns408 0 -0.010997533938
Gc26_409 0 n52 ns409 0 -0.00583331719508
Gc26_410 0 n52 ns410 0 -0.00152824557845
Gc26_411 0 n52 ns411 0 0.00270439278006
Gc26_412 0 n52 ns412 0 0.00309370887024
Gc26_413 0 n52 ns413 0 0.000480184467445
Gc26_414 0 n52 ns414 0 -0.068031530352
Gc26_415 0 n52 ns415 0 0.0650481740142
Gc26_416 0 n52 ns416 0 -0.00643340553231
Gc26_417 0 n52 ns417 0 -1.32200959471e-05
Gc26_418 0 n52 ns418 0 3.19164810614e-05
Gc26_419 0 n52 ns419 0 0.000702370440794
Gc26_420 0 n52 ns420 0 -0.00100135987699
Gc26_421 0 n52 ns421 0 0.0115855960632
Gc26_422 0 n52 ns422 0 0.000324356299087
Gc26_423 0 n52 ns423 0 0.000588852460512
Gc26_424 0 n52 ns424 0 0.000424072151091
Gc26_425 0 n52 ns425 0 -0.0003105073633
Gc26_426 0 n52 ns426 0 -0.000122247413427
Gc26_427 0 n52 ns427 0 -3.4699691703e-05
Gc26_428 0 n52 ns428 0 3.14300927248e-05
Gc26_429 0 n52 ns429 0 -0.00373351351019
Gc26_430 0 n52 ns430 0 8.7365681191e-05
Gc26_431 0 n52 ns431 0 0.000616261634332
Gc26_432 0 n52 ns432 0 2.63050103908e-06
Gc26_433 0 n52 ns433 0 0.000516409270085
Gc26_434 0 n52 ns434 0 -0.000927199268481
Gc26_435 0 n52 ns435 0 -0.00138665155104
Gc26_436 0 n52 ns436 0 -0.00094743808055
Gc26_437 0 n52 ns437 0 0.000185279050723
Gc26_438 0 n52 ns438 0 0.000358036338036
Gc26_439 0 n52 ns439 0 0.000222201242289
Gc26_440 0 n52 ns440 0 -0.00263813628856
Gc26_441 0 n52 ns441 0 -0.00468419150882
Gc26_442 0 n52 ns442 0 -0.00128284985104
Gc26_443 0 n52 ns443 0 -0.00029846549039
Gc26_444 0 n52 ns444 0 0.00022193145435
Gc26_445 0 n52 ns445 0 0.00158935635505
Gc26_446 0 n52 ns446 0 -0.00972679988692
Gc26_447 0 n52 ns447 0 -0.00623290637347
Gc26_448 0 n52 ns448 0 -0.00177976257954
Gc26_449 0 n52 ns449 0 0.00421308380338
Gc26_450 0 n52 ns450 0 0.00246007381403
Gc26_451 0 n52 ns451 0 -0.000248177571598
Gc26_452 0 n52 ns452 0 -0.0780303562393
Gc26_453 0 n52 ns453 0 0.0677827549521
Gc26_454 0 n52 ns454 0 -0.00313516998768
Gc26_455 0 n52 ns455 0 -1.02743720185e-05
Gc26_456 0 n52 ns456 0 1.16603059481e-05
Gc26_457 0 n52 ns457 0 0.000260169961545
Gc26_458 0 n52 ns458 0 -0.000956734864621
Gc26_459 0 n52 ns459 0 0.00670425455669
Gc26_460 0 n52 ns460 0 0.000145310910706
Gc26_461 0 n52 ns461 0 0.000287131377372
Gc26_462 0 n52 ns462 0 0.000324904090178
Gc26_463 0 n52 ns463 0 6.97969679503e-05
Gc26_464 0 n52 ns464 0 7.22738709021e-07
Gc26_465 0 n52 ns465 0 4.17034710438e-06
Gc26_466 0 n52 ns466 0 -0.000301182685672
Gc26_467 0 n52 ns467 0 -0.00208032675479
Gc26_468 0 n52 ns468 0 -1.30174485511e-05
Gc26_469 0 n52 ns469 0 0.000260126273183
Gc26_470 0 n52 ns470 0 0.000213698578066
Gc26_471 0 n52 ns471 0 0.000370773882472
Gc26_472 0 n52 ns472 0 0.000628404921107
Gc26_473 0 n52 ns473 0 -0.00112145019007
Gc26_474 0 n52 ns474 0 -0.00106916520074
Gc26_475 0 n52 ns475 0 0.000243288888198
Gc26_476 0 n52 ns476 0 0.000173853404291
Gc26_477 0 n52 ns477 0 4.78205334742e-05
Gc26_478 0 n52 ns478 0 -0.00122513323104
Gc26_479 0 n52 ns479 0 -0.0025004865812
Gc26_480 0 n52 ns480 0 -0.0011676944905
Gc26_481 0 n52 ns481 0 -0.00117758410049
Gc26_482 0 n52 ns482 0 0.000331259367118
Gc26_483 0 n52 ns483 0 0.00152125068232
Gc26_484 0 n52 ns484 0 -0.00693470208042
Gc26_485 0 n52 ns485 0 -0.00437961676026
Gc26_486 0 n52 ns486 0 -0.000238985251241
Gc26_487 0 n52 ns487 0 0.0035895386685
Gc26_488 0 n52 ns488 0 0.00145884731374
Gc26_489 0 n52 ns489 0 -0.000644363101715
Gc26_490 0 n52 ns490 0 -0.0382308388313
Gc26_491 0 n52 ns491 0 0.0320915686234
Gc26_492 0 n52 ns492 0 -0.00123131581053
Gc26_493 0 n52 ns493 0 -4.95122148226e-06
Gc26_494 0 n52 ns494 0 -7.98498466181e-06
Gc26_495 0 n52 ns495 0 0.000407266516383
Gc26_496 0 n52 ns496 0 -0.000520721569898
Gc26_497 0 n52 ns497 0 0.00316103034898
Gc26_498 0 n52 ns498 0 -0.000165696502429
Gc26_499 0 n52 ns499 0 0.000336657840142
Gc26_500 0 n52 ns500 0 0.000230184579741
Gc26_501 0 n52 ns501 0 1.03223813969e-05
Gc26_502 0 n52 ns502 0 9.70000488121e-06
Gc26_503 0 n52 ns503 0 -4.4782172064e-05
Gc26_504 0 n52 ns504 0 0.000693336518078
Gc26_505 0 n52 ns505 0 -0.00091216469779
Gc26_506 0 n52 ns506 0 -0.000522226018282
Gc26_507 0 n52 ns507 0 0.000146865293359
Gc26_508 0 n52 ns508 0 0.000189764065478
Gc26_509 0 n52 ns509 0 0.000226578900876
Gc26_510 0 n52 ns510 0 -0.000165378355735
Gc26_511 0 n52 ns511 0 -0.00130815725081
Gc26_512 0 n52 ns512 0 -0.000372426806458
Gc26_513 0 n52 ns513 0 0.000764663215489
Gc26_514 0 n52 ns514 0 0.000158573917742
Gc26_515 0 n52 ns515 0 -6.00498001298e-05
Gc26_516 0 n52 ns516 0 -0.000201291415117
Gc26_517 0 n52 ns517 0 -0.00140086244723
Gc26_518 0 n52 ns518 0 -0.00139375569991
Gc26_519 0 n52 ns519 0 -0.000702388720762
Gc26_520 0 n52 ns520 0 0.000643572458156
Gc26_521 0 n52 ns521 0 0.000961219003368
Gc26_522 0 n52 ns522 0 -0.00417401623067
Gc26_523 0 n52 ns523 0 -0.00139449182829
Gc26_524 0 n52 ns524 0 0.000596104013298
Gc26_525 0 n52 ns525 0 0.00188483228345
Gc26_526 0 n52 ns526 0 0.000616227939115
Gc26_527 0 n52 ns527 0 -0.000604610777477
Gc26_528 0 n52 ns528 0 -0.012046204824
Gc26_529 0 n52 ns529 0 0.00963423046557
Gc26_530 0 n52 ns530 0 -0.000344733395854
Gc26_531 0 n52 ns531 0 2.60702503685e-06
Gc26_532 0 n52 ns532 0 -2.70500717238e-05
Gc26_533 0 n52 ns533 0 0.000520105683643
Gc26_534 0 n52 ns534 0 -0.00105096526799
Gc26_535 0 n52 ns535 0 0.00193593391344
Gc26_536 0 n52 ns536 0 -0.000112484585136
Gc26_537 0 n52 ns537 0 0.000144041253647
Gc26_538 0 n52 ns538 0 2.93342261563e-05
Gc26_539 0 n52 ns539 0 3.44199699843e-05
Gc26_540 0 n52 ns540 0 -5.83316087072e-06
Gc26_541 0 n52 ns541 0 -3.50007014706e-07
Gc26_542 0 n52 ns542 0 0.00028456290643
Gc26_543 0 n52 ns543 0 -0.000900512615594
Gc26_544 0 n52 ns544 0 -0.000253026586151
Gc26_545 0 n52 ns545 0 0.000508813889516
Gc26_546 0 n52 ns546 0 0.000200561155202
Gc26_547 0 n52 ns547 0 3.51830944455e-05
Gc26_548 0 n52 ns548 0 -0.000650545906988
Gc26_549 0 n52 ns549 0 -5.91078023179e-05
Gc26_550 0 n52 ns550 0 0.000416481920447
Gc26_551 0 n52 ns551 0 0.000326730700179
Gc26_552 0 n52 ns552 0 3.20699840397e-05
Gc26_553 0 n52 ns553 0 -0.000166541283931
Gc26_554 0 n52 ns554 0 -3.01780100378e-05
Gc26_555 0 n52 ns555 0 -0.000932936618446
Gc26_556 0 n52 ns556 0 -0.00104042441213
Gc26_557 0 n52 ns557 0 7.68219893371e-05
Gc26_558 0 n52 ns558 0 0.000635855054699
Gc26_559 0 n52 ns559 0 0.000295540613084
Gc26_560 0 n52 ns560 0 -0.00198704252874
Gc26_561 0 n52 ns561 0 0.000359260355879
Gc26_562 0 n52 ns562 0 0.000694937198275
Gc26_563 0 n52 ns563 0 0.000678975303494
Gc26_564 0 n52 ns564 0 0.000160549020512
Gc26_565 0 n52 ns565 0 -0.000432277488657
Gc26_566 0 n52 ns566 0 -0.000351056215405
Gc26_567 0 n52 ns567 0 -1.26441128325e-05
Gc26_568 0 n52 ns568 0 -4.18075331504e-05
Gc26_569 0 n52 ns569 0 7.34291981737e-06
Gc26_570 0 n52 ns570 0 -3.45703377219e-05
Gc26_571 0 n52 ns571 0 0.00015196692436
Gc26_572 0 n52 ns572 0 -0.000245571887567
Gc26_573 0 n52 ns573 0 -0.000610014174317
Gc26_574 0 n52 ns574 0 -0.000238567534706
Gc26_575 0 n52 ns575 0 0.000157125271429
Gc26_576 0 n52 ns576 0 8.13625500267e-05
Gc26_577 0 n52 ns577 0 0.000153139264442
Gc26_578 0 n52 ns578 0 2.96027341206e-05
Gc26_579 0 n52 ns579 0 -1.04608386732e-05
Gc26_580 0 n52 ns580 0 -0.000366099805878
Gc26_581 0 n52 ns581 0 -0.00036715414805
Gc26_582 0 n52 ns582 0 0.000285310397365
Gc26_583 0 n52 ns583 0 0.000353263529018
Gc26_584 0 n52 ns584 0 9.92069598553e-05
Gc26_585 0 n52 ns585 0 -0.000130590177199
Gc26_586 0 n52 ns586 0 -9.50085311393e-05
Gc26_587 0 n52 ns587 0 0.0007738916582
Gc26_588 0 n52 ns588 0 0.000479588626721
Gc26_589 0 n52 ns589 0 -0.00023611601571
Gc26_590 0 n52 ns590 0 -7.27133661916e-05
Gc26_591 0 n52 ns591 0 -0.000144626902761
Gc26_592 0 n52 ns592 0 0.000348227853148
Gc26_593 0 n52 ns593 0 -0.000340144086491
Gc26_594 0 n52 ns594 0 -0.000397373285425
Gc26_595 0 n52 ns595 0 0.000148679194375
Gc26_596 0 n52 ns596 0 0.000277784256955
Gc26_597 0 n52 ns597 0 1.08364838576e-05
Gc26_598 0 n52 ns598 0 0.000138245240558
Gc26_599 0 n52 ns599 0 0.000951253233936
Gc26_600 0 n52 ns600 0 0.000399956339583
Gc26_601 0 n52 ns601 0 -6.54422010006e-05
Gc26_602 0 n52 ns602 0 -5.92869490431e-05
Gc26_603 0 n52 ns603 0 -0.000234359939532
Gc26_604 0 n52 ns604 0 0.00861988044697
Gc26_605 0 n52 ns605 0 -0.0073077703076
Gc26_606 0 n52 ns606 0 0.000183997478055
Gc26_607 0 n52 ns607 0 4.90168704596e-06
Gc26_608 0 n52 ns608 0 -2.9708518768e-05
Gc26_609 0 n52 ns609 0 -0.00187163234705
Gc26_610 0 n52 ns610 0 -0.00309558780329
Gc26_611 0 n52 ns611 0 0.00642350698796
Gc26_612 0 n52 ns612 0 0.000710638710878
Gc26_613 0 n52 ns613 0 -0.000334629391342
Gc26_614 0 n52 ns614 0 0.000640514444131
Gc26_615 0 n52 ns615 0 0.000775101892169
Gc26_616 0 n52 ns616 0 -0.000157729438598
Gc26_617 0 n52 ns617 0 -9.10644610745e-05
Gc26_618 0 n52 ns618 0 -0.000839695360795
Gc26_619 0 n52 ns619 0 -0.00186275518544
Gc26_620 0 n52 ns620 0 0.00114713507737
Gc26_621 0 n52 ns621 0 5.8123378881e-05
Gc26_622 0 n52 ns622 0 0.000414234622689
Gc26_623 0 n52 ns623 0 -0.000179057542361
Gc26_624 0 n52 ns624 0 -0.000722978264638
Gc26_625 0 n52 ns625 0 -0.00327738417161
Gc26_626 0 n52 ns626 0 -0.000105088598298
Gc26_627 0 n52 ns627 0 0.000185777123666
Gc26_628 0 n52 ns628 0 0.00016401617471
Gc26_629 0 n52 ns629 0 0.000370175592257
Gc26_630 0 n52 ns630 0 -0.00570934580309
Gc26_631 0 n52 ns631 0 -0.00140704656766
Gc26_632 0 n52 ns632 0 0.000671860760367
Gc26_633 0 n52 ns633 0 0.000859446952833
Gc26_634 0 n52 ns634 0 0.00102244472193
Gc26_635 0 n52 ns635 0 -0.000850724186485
Gc26_636 0 n52 ns636 0 -0.00657762794734
Gc26_637 0 n52 ns637 0 -0.000287288216335
Gc26_638 0 n52 ns638 0 -0.00100690752785
Gc26_639 0 n52 ns639 0 -0.00057669126443
Gc26_640 0 n52 ns640 0 0.00203504537491
Gc26_641 0 n52 ns641 0 0.000789724259969
Gc26_642 0 n52 ns642 0 0.00419283378801
Gc26_643 0 n52 ns643 0 -0.0140126346946
Gc26_644 0 n52 ns644 0 0.0051361041373
Gc26_645 0 n52 ns645 0 1.61613402751e-06
Gc26_646 0 n52 ns646 0 3.03518833711e-05
Gc26_647 0 n52 ns647 0 -0.00454056144856
Gc26_648 0 n52 ns648 0 -0.00245192358478
Gc26_649 0 n52 ns649 0 -0.00107606970607
Gc26_650 0 n52 ns650 0 0.000840623012383
Gc26_651 0 n52 ns651 0 -0.00137507611525
Gc26_652 0 n52 ns652 0 -2.60283293896e-05
Gc26_653 0 n52 ns653 0 0.000934483236794
Gc26_654 0 n52 ns654 0 -9.29651920554e-05
Gc26_655 0 n52 ns655 0 -5.71573583567e-05
Gc26_656 0 n52 ns656 0 -0.000923360939324
Gc26_657 0 n52 ns657 0 0.00060903693148
Gc26_658 0 n52 ns658 0 0.000859894024449
Gc26_659 0 n52 ns659 0 -0.000561157864374
Gc26_660 0 n52 ns660 0 0.00033613197785
Gc26_661 0 n52 ns661 0 -0.00023303961905
Gc26_662 0 n52 ns662 0 -0.000823425817161
Gc26_663 0 n52 ns663 0 -0.00117451038395
Gc26_664 0 n52 ns664 0 0.000486785178855
Gc26_665 0 n52 ns665 0 -1.958760014e-05
Gc26_666 0 n52 ns666 0 0.000272163604253
Gc26_667 0 n52 ns667 0 0.000292031486102
Gc26_668 0 n52 ns668 0 -0.00277400305555
Gc26_669 0 n52 ns669 0 0.00135658994822
Gc26_670 0 n52 ns670 0 0.00122733750486
Gc26_671 0 n52 ns671 0 0.00118227776601
Gc26_672 0 n52 ns672 0 0.0010917538307
Gc26_673 0 n52 ns673 0 -0.00126085519493
Gc26_674 0 n52 ns674 0 0.000387927702196
Gc26_675 0 n52 ns675 0 0.00210519855496
Gc26_676 0 n52 ns676 0 -1.09330258362e-05
Gc26_677 0 n52 ns677 0 -0.00128139485929
Gc26_678 0 n52 ns678 0 0.00223369059177
Gc26_679 0 n52 ns679 0 0.000643018333559
Gc26_680 0 n52 ns680 0 0.0167669557868
Gc26_681 0 n52 ns681 0 -0.0174577914407
Gc26_682 0 n52 ns682 0 0.006489232287
Gc26_683 0 n52 ns683 0 -2.5510720138e-06
Gc26_684 0 n52 ns684 0 2.66537714014e-05
Gc26_685 0 n52 ns685 0 -0.00483759062498
Gc26_686 0 n52 ns686 0 -3.01961547265e-05
Gc26_687 0 n52 ns687 0 -0.00637966301273
Gc26_688 0 n52 ns688 0 0.000159949160291
Gc26_689 0 n52 ns689 0 -0.00129927879792
Gc26_690 0 n52 ns690 0 -0.000195536337138
Gc26_691 0 n52 ns691 0 0.000106821438672
Gc26_692 0 n52 ns692 0 -0.000105621212988
Gc26_693 0 n52 ns693 0 -2.52965294662e-05
Gc26_694 0 n52 ns694 0 -0.00220304460893
Gc26_695 0 n52 ns695 0 0.0033263394968
Gc26_696 0 n52 ns696 0 0.000377872527003
Gc26_697 0 n52 ns697 0 -0.000702650236745
Gc26_698 0 n52 ns698 0 0.000385806504253
Gc26_699 0 n52 ns699 0 -0.000361597071781
Gc26_700 0 n52 ns700 0 0.000465548274984
Gc26_701 0 n52 ns701 0 0.00283212668637
Gc26_702 0 n52 ns702 0 0.000788141908143
Gc26_703 0 n52 ns703 0 -0.000696549014037
Gc26_704 0 n52 ns704 0 0.000399911884202
Gc26_705 0 n52 ns705 0 0.000181390281113
Gc26_706 0 n52 ns706 0 0.00269281189612
Gc26_707 0 n52 ns707 0 0.00162732355948
Gc26_708 0 n52 ns708 0 0.000463569668821
Gc26_709 0 n52 ns709 0 0.00197337420769
Gc26_710 0 n52 ns710 0 0.00159429512934
Gc26_711 0 n52 ns711 0 -0.00157280905264
Gc26_712 0 n52 ns712 0 0.00396209725356
Gc26_713 0 n52 ns713 0 -0.00133624177716
Gc26_714 0 n52 ns714 0 0.00128325681201
Gc26_715 0 n52 ns715 0 0.000683452772491
Gc26_716 0 n52 ns716 0 0.00294638428044
Gc26_717 0 n52 ns717 0 0.000322541445411
Gc26_718 0 n52 ns718 0 -0.00937589507648
Gc26_719 0 n52 ns719 0 0.0132083502427
Gc26_720 0 n52 ns720 0 0.00707475170431
Gc26_721 0 n52 ns721 0 -1.31793842547e-06
Gc26_722 0 n52 ns722 0 2.97716729319e-05
Gc26_723 0 n52 ns723 0 -0.00204867108262
Gc26_724 0 n52 ns724 0 0.000157190508292
Gc26_725 0 n52 ns725 0 0.00172278097235
Gc26_726 0 n52 ns726 0 0.000626278570442
Gc26_727 0 n52 ns727 0 -0.00040115017461
Gc26_728 0 n52 ns728 0 0.00050249100447
Gc26_729 0 n52 ns729 0 0.000383872429795
Gc26_730 0 n52 ns730 0 -0.000165039956314
Gc26_731 0 n52 ns731 0 -1.84388153376e-05
Gc26_732 0 n52 ns732 0 -0.000547151000333
Gc26_733 0 n52 ns733 0 -0.00077177933111
Gc26_734 0 n52 ns734 0 0.000520784263911
Gc26_735 0 n52 ns735 0 0.000127218603614
Gc26_736 0 n52 ns736 0 0.000361311737805
Gc26_737 0 n52 ns737 0 -0.000491207734447
Gc26_738 0 n52 ns738 0 -0.000191397288985
Gc26_739 0 n52 ns739 0 -0.00222040544637
Gc26_740 0 n52 ns740 0 -0.000992114173687
Gc26_741 0 n52 ns741 0 -5.90758081358e-05
Gc26_742 0 n52 ns742 0 0.000334491720713
Gc26_743 0 n52 ns743 0 0.000333288187376
Gc26_744 0 n52 ns744 0 -0.00408352564994
Gc26_745 0 n52 ns745 0 0.000438300984617
Gc26_746 0 n52 ns746 0 9.24101526824e-05
Gc26_747 0 n52 ns747 0 0.00146189327405
Gc26_748 0 n52 ns748 0 0.00106695137848
Gc26_749 0 n52 ns749 0 -0.00146341894973
Gc26_750 0 n52 ns750 0 -0.00273115210645
Gc26_751 0 n52 ns751 0 0.00135583460304
Gc26_752 0 n52 ns752 0 -0.00181645944012
Gc26_753 0 n52 ns753 0 0.000527305980876
Gc26_754 0 n52 ns754 0 0.00209620084228
Gc26_755 0 n52 ns755 0 9.08482447435e-05
Gc26_756 0 n52 ns756 0 0.038573824421
Gc26_757 0 n52 ns757 0 -0.0421729891616
Gc26_758 0 n52 ns758 0 0.00446354949622
Gc26_759 0 n52 ns759 0 3.04749765934e-06
Gc26_760 0 n52 ns760 0 2.63861256854e-05
Gc26_761 0 n52 ns761 0 -0.000873012656923
Gc26_762 0 n52 ns762 0 0.00173683542296
Gc26_763 0 n52 ns763 0 -0.00181017749377
Gc26_764 0 n52 ns764 0 0.000170562550015
Gc26_765 0 n52 ns765 0 -0.000287547544652
Gc26_766 0 n52 ns766 0 0.00016365592744
Gc26_767 0 n52 ns767 0 -0.00032833771093
Gc26_768 0 n52 ns768 0 -3.00885772325e-06
Gc26_769 0 n52 ns769 0 1.58302639085e-05
Gc26_770 0 n52 ns770 0 -0.00171067455265
Gc26_771 0 n52 ns771 0 0.000466739959593
Gc26_772 0 n52 ns772 0 0.000301513132253
Gc26_773 0 n52 ns773 0 4.50403173987e-05
Gc26_774 0 n52 ns774 0 7.11406985436e-05
Gc26_775 0 n52 ns775 0 -0.000432109945608
Gc26_776 0 n52 ns776 0 -0.000769633592087
Gc26_777 0 n52 ns777 0 0.000859291666795
Gc26_778 0 n52 ns778 0 -0.000270805089729
Gc26_779 0 n52 ns779 0 0.00020649939795
Gc26_780 0 n52 ns780 0 0.000404371805822
Gc26_781 0 n52 ns781 0 1.61101944039e-05
Gc26_782 0 n52 ns782 0 0.000613087177022
Gc26_783 0 n52 ns783 0 0.00254359099324
Gc26_784 0 n52 ns784 0 0.000318900536706
Gc26_785 0 n52 ns785 0 0.000891810966117
Gc26_786 0 n52 ns786 0 0.000189339222662
Gc26_787 0 n52 ns787 0 -0.00129261708199
Gc26_788 0 n52 ns788 0 0.00198615508759
Gc26_789 0 n52 ns789 0 0.000624569361487
Gc26_790 0 n52 ns790 0 -0.00128953118735
Gc26_791 0 n52 ns791 0 0.00123694891214
Gc26_792 0 n52 ns792 0 0.00120486143264
Gc26_793 0 n52 ns793 0 -0.000527217279004
Gc26_794 0 n52 ns794 0 0.0351134588447
Gc26_795 0 n52 ns795 0 -0.0327863570497
Gc26_796 0 n52 ns796 0 0.00189301562278
Gc26_797 0 n52 ns797 0 -4.56470255907e-06
Gc26_798 0 n52 ns798 0 1.69623984107e-06
Gc26_799 0 n52 ns799 0 -0.000424980134234
Gc26_800 0 n52 ns800 0 0.000886338820273
Gc26_801 0 n52 ns801 0 -0.00129109058467
Gc26_802 0 n52 ns802 0 -9.56907509213e-05
Gc26_803 0 n52 ns803 0 -3.91428507524e-05
Gc26_804 0 n52 ns804 0 -0.000112097186423
Gc26_805 0 n52 ns805 0 -2.46028819501e-05
Gc26_806 0 n52 ns806 0 -2.87798878849e-05
Gc26_807 0 n52 ns807 0 -2.19280861043e-05
Gc26_808 0 n52 ns808 0 -0.000346235883608
Gc26_809 0 n52 ns809 0 0.000917150200931
Gc26_810 0 n52 ns810 0 0.000392652832278
Gc26_811 0 n52 ns811 0 7.74903846428e-05
Gc26_812 0 n52 ns812 0 -0.000120614936408
Gc26_813 0 n52 ns813 0 -0.000318618379946
Gc26_814 0 n52 ns814 0 0.000598131426703
Gc26_815 0 n52 ns815 0 -0.000115791802475
Gc26_816 0 n52 ns816 0 -0.000417454413225
Gc26_817 0 n52 ns817 0 0.00037221396237
Gc26_818 0 n52 ns818 0 0.000225837327427
Gc26_819 0 n52 ns819 0 -9.38896238073e-05
Gc26_820 0 n52 ns820 0 0.000348513101097
Gc26_821 0 n52 ns821 0 0.00016084936553
Gc26_822 0 n52 ns822 0 0.000483774671532
Gc26_823 0 n52 ns823 0 0.000999073919362
Gc26_824 0 n52 ns824 0 -0.000171236539729
Gc26_825 0 n52 ns825 0 -0.000970883205762
Gc26_826 0 n52 ns826 0 -0.000269132724738
Gc26_827 0 n52 ns827 0 -0.00035350275899
Gc26_828 0 n52 ns828 0 5.87034826407e-05
Gc26_829 0 n52 ns829 0 0.0014498881474
Gc26_830 0 n52 ns830 0 0.000633612561826
Gc26_831 0 n52 ns831 0 -0.000675856875479
Gc26_832 0 n52 ns832 0 0.0179177673015
Gc26_833 0 n52 ns833 0 -0.0166466739702
Gc26_834 0 n52 ns834 0 0.000874765426443
Gc26_835 0 n52 ns835 0 -6.63043720967e-06
Gc26_836 0 n52 ns836 0 -1.83472839026e-05
Gc26_837 0 n52 ns837 0 0.000110606330265
Gc26_838 0 n52 ns838 0 -0.000265597260756
Gc26_839 0 n52 ns839 0 -5.14848574945e-05
Gc26_840 0 n52 ns840 0 -7.69431689654e-05
Gc26_841 0 n52 ns841 0 5.75331310731e-05
Gc26_842 0 n52 ns842 0 -1.83927190569e-05
Gc26_843 0 n52 ns843 0 3.2959313115e-05
Gc26_844 0 n52 ns844 0 9.28239646399e-06
Gc26_845 0 n52 ns845 0 3.04335758205e-05
Gc26_846 0 n52 ns846 0 1.3847778569e-05
Gc26_847 0 n52 ns847 0 0.000353729493129
Gc26_848 0 n52 ns848 0 0.00033347795345
Gc26_849 0 n52 ns849 0 -0.000204280515214
Gc26_850 0 n52 ns850 0 -0.000211738823955
Gc26_851 0 n52 ns851 0 -8.96775346807e-05
Gc26_852 0 n52 ns852 0 -0.000471730802332
Gc26_853 0 n52 ns853 0 -0.000476987257328
Gc26_854 0 n52 ns854 0 0.000138162396109
Gc26_855 0 n52 ns855 0 0.000622481045499
Gc26_856 0 n52 ns856 0 0.000127168868457
Gc26_857 0 n52 ns857 0 -0.000139220427344
Gc26_858 0 n52 ns858 0 -0.000206474295084
Gc26_859 0 n52 ns859 0 0.000670086831755
Gc26_860 0 n52 ns860 0 0.000963822298394
Gc26_861 0 n52 ns861 0 0.000336873874211
Gc26_862 0 n52 ns862 0 -0.000547220465298
Gc26_863 0 n52 ns863 0 -0.000522604564722
Gc26_864 0 n52 ns864 0 -0.000519173375161
Gc26_865 0 n52 ns865 0 0.000477723138742
Gc26_866 0 n52 ns866 0 0.000542127346259
Gc26_867 0 n52 ns867 0 0.000783643117264
Gc26_868 0 n52 ns868 0 0.000247153663888
Gc26_869 0 n52 ns869 0 -0.000547557888013
Gc26_870 0 n52 ns870 0 0.0135641552735
Gc26_871 0 n52 ns871 0 -0.0124209365432
Gc26_872 0 n52 ns872 0 0.000580641232287
Gc26_873 0 n52 ns873 0 -3.6123497247e-06
Gc26_874 0 n52 ns874 0 -3.26746670337e-05
Gc26_875 0 n52 ns875 0 2.80930116188e-05
Gc26_876 0 n52 ns876 0 -4.25704511379e-05
Gc26_877 0 n52 ns877 0 -0.00273941235056
Gc26_878 0 n52 ns878 0 -0.000177159852513
Gc26_879 0 n52 ns879 0 -0.000181555356702
Gc26_880 0 n52 ns880 0 -0.000118723562439
Gc26_881 0 n52 ns881 0 6.62975766782e-05
Gc26_882 0 n52 ns882 0 2.58414589308e-05
Gc26_883 0 n52 ns883 0 1.30773197234e-06
Gc26_884 0 n52 ns884 0 0.000249569145606
Gc26_885 0 n52 ns885 0 0.00103102615961
Gc26_886 0 n52 ns886 0 -0.000123622715029
Gc26_887 0 n52 ns887 0 -0.000465712259017
Gc26_888 0 n52 ns888 0 -0.00015246412831
Gc26_889 0 n52 ns889 0 7.6330898014e-05
Gc26_890 0 n52 ns890 0 -0.000453563738578
Gc26_891 0 n52 ns891 0 0.000875234901872
Gc26_892 0 n52 ns892 0 0.000672357356638
Gc26_893 0 n52 ns893 0 3.3649706859e-05
Gc26_894 0 n52 ns894 0 1.17443238947e-05
Gc26_895 0 n52 ns895 0 -0.000187709532599
Gc26_896 0 n52 ns896 0 0.00130186733199
Gc26_897 0 n52 ns897 0 0.00132127153086
Gc26_898 0 n52 ns898 0 0.000866225547733
Gc26_899 0 n52 ns899 0 -0.00062773964021
Gc26_900 0 n52 ns900 0 -0.000691339812122
Gc26_901 0 n52 ns901 0 1.01392355158e-05
Gc26_902 0 n52 ns902 0 0.00195329515155
Gc26_903 0 n52 ns903 0 0.00120412464009
Gc26_904 0 n52 ns904 0 0.000302794131743
Gc26_905 0 n52 ns905 0 -0.00034601931698
Gc26_906 0 n52 ns906 0 -0.000164208490874
Gc26_907 0 n52 ns907 0 -0.000271579604942
Gc26_908 0 n52 ns908 0 0.0200886274016
Gc26_909 0 n52 ns909 0 -0.0170106858021
Gc26_910 0 n52 ns910 0 0.000573602653119
Gc26_911 0 n52 ns911 0 -4.05397435188e-06
Gc26_912 0 n52 ns912 0 -3.13126995241e-05
Gc26_913 0 n52 ns913 0 -0.000130448046021
Gc26_914 0 n52 ns914 0 0.000326807735375
Gc26_915 0 n52 ns915 0 -0.00263018816572
Gc26_916 0 n52 ns916 0 -0.000206735392578
Gc26_917 0 n52 ns917 0 -0.000126080758909
Gc26_918 0 n52 ns918 0 -0.000136250451696
Gc26_919 0 n52 ns919 0 2.09709148539e-05
Gc26_920 0 n52 ns920 0 -7.8400918343e-06
Gc26_921 0 n52 ns921 0 1.03723510445e-05
Gc26_922 0 n52 ns922 0 0.000676630322598
Gc26_923 0 n52 ns923 0 0.00103531517766
Gc26_924 0 n52 ns924 0 -0.000376008162965
Gc26_925 0 n52 ns925 0 -0.000343974585302
Gc26_926 0 n52 ns926 0 -8.32682810227e-05
Gc26_927 0 n52 ns927 0 0.000102002578729
Gc26_928 0 n52 ns928 0 0.000219540208889
Gc26_929 0 n52 ns929 0 0.000813149765891
Gc26_930 0 n52 ns930 0 0.000366625154939
Gc26_931 0 n52 ns931 0 -0.000304892042778
Gc26_932 0 n52 ns932 0 -6.40284162164e-05
Gc26_933 0 n52 ns933 0 -0.000102443528159
Gc26_934 0 n52 ns934 0 0.00118209933535
Gc26_935 0 n52 ns935 0 0.000479076536115
Gc26_936 0 n52 ns936 0 0.000295057851265
Gc26_937 0 n52 ns937 0 -0.000550209186438
Gc26_938 0 n52 ns938 0 -0.00034778447614
Gc26_939 0 n52 ns939 0 0.000164560197433
Gc26_940 0 n52 ns940 0 0.00137301767314
Gc26_941 0 n52 ns941 0 0.000655463440443
Gc26_942 0 n52 ns942 0 0.000171267379523
Gc26_943 0 n52 ns943 0 -0.000260267444124
Gc26_944 0 n52 ns944 0 -0.000114855049466
Gc26_945 0 n52 ns945 0 -0.000151198840846
Gc26_946 0 n52 ns946 0 0.0141840585281
Gc26_947 0 n52 ns947 0 -0.0119869943743
Gc26_948 0 n52 ns948 0 0.000414521042756
Gc26_949 0 n52 ns949 0 -7.40326627338e-06
Gc26_950 0 n52 ns950 0 -2.49304682096e-05
Gc26_951 0 n52 ns951 0 -0.00279381668743
Gc26_952 0 n52 ns952 0 -5.24767297582e-05
Gc26_953 0 n52 ns953 0 -0.00210662523907
Gc26_954 0 n52 ns954 0 0.000425864478504
Gc26_955 0 n52 ns955 0 -0.000399368320857
Gc26_956 0 n52 ns956 0 0.000481765503864
Gc26_957 0 n52 ns957 0 -0.00035080824646
Gc26_958 0 n52 ns958 0 -0.000206788470787
Gc26_959 0 n52 ns959 0 -0.000101005828568
Gc26_960 0 n52 ns960 0 -0.00449773747578
Gc26_961 0 n52 ns961 0 0.00180338338933
Gc26_962 0 n52 ns962 0 0.00117932248776
Gc26_963 0 n52 ns963 0 -0.000485668582938
Gc26_964 0 n52 ns964 0 0.000551789758744
Gc26_965 0 n52 ns965 0 -0.000402133170836
Gc26_966 0 n52 ns966 0 -0.000493248665627
Gc26_967 0 n52 ns967 0 0.00244554969456
Gc26_968 0 n52 ns968 0 0.00101203220841
Gc26_969 0 n52 ns969 0 -0.000265718997685
Gc26_970 0 n52 ns970 0 0.000453350026783
Gc26_971 0 n52 ns971 0 0.000255128828677
Gc26_972 0 n52 ns972 0 0.00134992072115
Gc26_973 0 n52 ns973 0 0.00125759459735
Gc26_974 0 n52 ns974 0 0.000674565990746
Gc26_975 0 n52 ns975 0 0.00205298182134
Gc26_976 0 n52 ns976 0 0.00164087139887
Gc26_977 0 n52 ns977 0 -0.00155501022506
Gc26_978 0 n52 ns978 0 0.000687979156423
Gc26_979 0 n52 ns979 0 -0.00234348731725
Gc26_980 0 n52 ns980 0 0.00147862417542
Gc26_981 0 n52 ns981 0 0.00102929115248
Gc26_982 0 n52 ns982 0 0.00314475355822
Gc26_983 0 n52 ns983 0 0.000443482977585
Gc26_984 0 n52 ns984 0 -0.0232617869935
Gc26_985 0 n52 ns985 0 0.0231574552058
Gc26_986 0 n52 ns986 0 0.00699409403879
Gc26_987 0 n52 ns987 0 1.12417322788e-05
Gc26_988 0 n52 ns988 0 3.63967341168e-05
Gc26_989 0 n52 ns989 0 -0.0022435975274
Gc26_990 0 n52 ns990 0 -0.00120797495552
Gc26_991 0 n52 ns991 0 0.00286644918459
Gc26_992 0 n52 ns992 0 0.000366892453022
Gc26_993 0 n52 ns993 0 -0.00058546763702
Gc26_994 0 n52 ns994 0 0.000331681936906
Gc26_995 0 n52 ns995 0 0.000380087987763
Gc26_996 0 n52 ns996 0 -0.000175983300581
Gc26_997 0 n52 ns997 0 -5.75898279002e-05
Gc26_998 0 n52 ns998 0 -0.000663619314936
Gc26_999 0 n52 ns999 0 0.000206864203031
Gc26_1000 0 n52 ns1000 0 0.000515395923736
Gc26_1001 0 n52 ns1001 0 0.000122170204872
Gc26_1002 0 n52 ns1002 0 0.000492071923236
Gc26_1003 0 n52 ns1003 0 -0.000436629467656
Gc26_1004 0 n52 ns1004 0 0.00117023320653
Gc26_1005 0 n52 ns1005 0 -0.00167138263249
Gc26_1006 0 n52 ns1006 0 -0.000787838218395
Gc26_1007 0 n52 ns1007 0 -0.000536624839311
Gc26_1008 0 n52 ns1008 0 0.000288072310646
Gc26_1009 0 n52 ns1009 0 0.000355402227045
Gc26_1010 0 n52 ns1010 0 -0.00353891934744
Gc26_1011 0 n52 ns1011 0 -0.00185637049384
Gc26_1012 0 n52 ns1012 0 -3.72337744042e-05
Gc26_1013 0 n52 ns1013 0 0.00156731768372
Gc26_1014 0 n52 ns1014 0 0.00135508750228
Gc26_1015 0 n52 ns1015 0 -0.00141745669429
Gc26_1016 0 n52 ns1016 0 -0.00526959987737
Gc26_1017 0 n52 ns1017 0 -0.00143146590638
Gc26_1018 0 n52 ns1018 0 -0.0014889575214
Gc26_1019 0 n52 ns1019 0 0.000718908418445
Gc26_1020 0 n52 ns1020 0 0.00249355814977
Gc26_1021 0 n52 ns1021 0 0.000377783578519
Gc26_1022 0 n52 ns1022 0 0.0210709673941
Gc26_1023 0 n52 ns1023 0 -0.02867433478
Gc26_1024 0 n52 ns1024 0 0.00552010041214
Gc26_1025 0 n52 ns1025 0 2.11900634117e-06
Gc26_1026 0 n52 ns1026 0 3.40629086664e-05
Gc26_1027 0 n52 ns1027 0 -0.00122683384706
Gc26_1028 0 n52 ns1028 0 0.000732045382711
Gc26_1029 0 n52 ns1029 0 -0.000199473741967
Gc26_1030 0 n52 ns1030 0 0.000562371130308
Gc26_1031 0 n52 ns1031 0 -0.000588107741835
Gc26_1032 0 n52 ns1032 0 0.000328228568307
Gc26_1033 0 n52 ns1033 0 -0.000158249527951
Gc26_1034 0 n52 ns1034 0 -4.0335808328e-05
Gc26_1035 0 n52 ns1035 0 3.31294462535e-05
Gc26_1036 0 n52 ns1036 0 -0.00202211135728
Gc26_1037 0 n52 ns1037 0 -0.000229566454961
Gc26_1038 0 n52 ns1038 0 0.000419170281275
Gc26_1039 0 n52 ns1039 0 2.8916420605e-05
Gc26_1040 0 n52 ns1040 0 0.000204347060278
Gc26_1041 0 n52 ns1041 0 -0.000486367443391
Gc26_1042 0 n52 ns1042 0 -0.00150810378732
Gc26_1043 0 n52 ns1043 0 0.000140456402234
Gc26_1044 0 n52 ns1044 0 -0.000375065147066
Gc26_1045 0 n52 ns1045 0 0.000297146308363
Gc26_1046 0 n52 ns1046 0 0.000471386382456
Gc26_1047 0 n52 ns1047 0 0.000135461511165
Gc26_1048 0 n52 ns1048 0 -0.000825521614075
Gc26_1049 0 n52 ns1049 0 0.00318242739275
Gc26_1050 0 n52 ns1050 0 0.000399681186147
Gc26_1051 0 n52 ns1051 0 0.00101485802649
Gc26_1052 0 n52 ns1052 0 0.000414361184407
Gc26_1053 0 n52 ns1053 0 -0.00146338032651
Gc26_1054 0 n52 ns1054 0 0.00148367710452
Gc26_1055 0 n52 ns1055 0 0.00172647992686
Gc26_1056 0 n52 ns1056 0 -0.00156631339764
Gc26_1057 0 n52 ns1057 0 0.000911514422169
Gc26_1058 0 n52 ns1058 0 0.00147519866627
Gc26_1059 0 n52 ns1059 0 -0.000421740326687
Gc26_1060 0 n52 ns1060 0 0.041073098689
Gc26_1061 0 n52 ns1061 0 -0.0394906897773
Gc26_1062 0 n52 ns1062 0 0.00262623770815
Gc26_1063 0 n52 ns1063 0 -1.64064734383e-06
Gc26_1064 0 n52 ns1064 0 1.29177666296e-05
Gc26_1065 0 n52 ns1065 0 -0.000613645257243
Gc26_1066 0 n52 ns1066 0 0.00146006932584
Gc26_1067 0 n52 ns1067 0 -0.00216776184576
Gc26_1068 0 n52 ns1068 0 -0.000156537089102
Gc26_1069 0 n52 ns1069 0 -0.000181902502186
Gc26_1070 0 n52 ns1070 0 -0.000163443181588
Gc26_1071 0 n52 ns1071 0 -0.000125824257919
Gc26_1072 0 n52 ns1072 0 -9.07556657525e-06
Gc26_1073 0 n52 ns1073 0 -1.71796096358e-05
Gc26_1074 0 n52 ns1074 0 -0.000513215388807
Gc26_1075 0 n52 ns1075 0 0.00139467655662
Gc26_1076 0 n52 ns1076 0 0.00022413618455
Gc26_1077 0 n52 ns1077 0 2.66154841653e-05
Gc26_1078 0 n52 ns1078 0 -8.38564606132e-05
Gc26_1079 0 n52 ns1079 0 -0.000376580183599
Gc26_1080 0 n52 ns1080 0 0.000741893139161
Gc26_1081 0 n52 ns1081 0 0.0005339611332
Gc26_1082 0 n52 ns1082 0 -0.000455966268079
Gc26_1083 0 n52 ns1083 0 0.000118042843083
Gc26_1084 0 n52 ns1084 0 0.000271150621871
Gc26_1085 0 n52 ns1085 0 -8.56281352847e-05
Gc26_1086 0 n52 ns1086 0 0.000954017374301
Gc26_1087 0 n52 ns1087 0 0.000553381156978
Gc26_1088 0 n52 ns1088 0 0.000299642137837
Gc26_1089 0 n52 ns1089 0 0.00103200664248
Gc26_1090 0 n52 ns1090 0 -3.24161135951e-05
Gc26_1091 0 n52 ns1091 0 -0.00110909824353
Gc26_1092 0 n52 ns1092 0 0.000639326862645
Gc26_1093 0 n52 ns1093 0 -0.000424522872779
Gc26_1094 0 n52 ns1094 0 -0.000388168165581
Gc26_1095 0 n52 ns1095 0 0.00152097358674
Gc26_1096 0 n52 ns1096 0 0.000822517834668
Gc26_1097 0 n52 ns1097 0 -0.000666866005267
Gc26_1098 0 n52 ns1098 0 0.0237892191204
Gc26_1099 0 n52 ns1099 0 -0.0219178135084
Gc26_1100 0 n52 ns1100 0 0.00115959999979
Gc26_1101 0 n52 ns1101 0 -6.22592784969e-06
Gc26_1102 0 n52 ns1102 0 -7.59043530312e-06
Gc26_1103 0 n52 ns1103 0 -2.29125296102e-05
Gc26_1104 0 n52 ns1104 0 -0.000378405916162
Gc26_1105 0 n52 ns1105 0 0.00102032104889
Gc26_1106 0 n52 ns1106 0 -4.5438161222e-05
Gc26_1107 0 n52 ns1107 0 0.000155699291281
Gc26_1108 0 n52 ns1108 0 6.61743821461e-05
Gc26_1109 0 n52 ns1109 0 4.96974783714e-05
Gc26_1110 0 n52 ns1110 0 -1.57027620762e-05
Gc26_1111 0 n52 ns1111 0 5.63359241054e-06
Gc26_1112 0 n52 ns1112 0 -0.000249188112768
Gc26_1113 0 n52 ns1113 0 -0.000151430433001
Gc26_1114 0 n52 ns1114 0 0.000510192188108
Gc26_1115 0 n52 ns1115 0 0.000131682708093
Gc26_1116 0 n52 ns1116 0 -0.000133880602928
Gc26_1117 0 n52 ns1117 0 -0.000193597218634
Gc26_1118 0 n52 ns1118 0 -0.000305051185031
Gc26_1119 0 n52 ns1119 0 -0.000910794763158
Gc26_1120 0 n52 ns1120 0 -0.000207543766123
Gc26_1121 0 n52 ns1121 0 0.000791382334284
Gc26_1122 0 n52 ns1122 0 0.000195424309892
Gc26_1123 0 n52 ns1123 0 -8.62023422449e-05
Gc26_1124 0 n52 ns1124 0 -0.000624044908238
Gc26_1125 0 n52 ns1125 0 0.000362303851428
Gc26_1126 0 n52 ns1126 0 0.000848482900825
Gc26_1127 0 n52 ns1127 0 0.000730081543934
Gc26_1128 0 n52 ns1128 0 -0.000407816533772
Gc26_1129 0 n52 ns1129 0 -0.000731779796679
Gc26_1130 0 n52 ns1130 0 -0.00127219076397
Gc26_1131 0 n52 ns1131 0 -2.90666754728e-05
Gc26_1132 0 n52 ns1132 0 0.00046488818307
Gc26_1133 0 n52 ns1133 0 0.00116935313581
Gc26_1134 0 n52 ns1134 0 0.000397884131951
Gc26_1135 0 n52 ns1135 0 -0.00058940513017
Gc26_1136 0 n52 ns1136 0 0.00882957336761
Gc26_1137 0 n52 ns1137 0 -0.00864896393738
Gc26_1138 0 n52 ns1138 0 0.000510592294803
Gc26_1139 0 n52 ns1139 0 -3.38277420226e-06
Gc26_1140 0 n52 ns1140 0 -2.64846299063e-05
Gc26_1141 0 n52 ns1141 0 0.000181861740882
Gc26_1142 0 n52 ns1142 0 -0.000421880987482
Gc26_1143 0 n52 ns1143 0 -0.00142990540158
Gc26_1144 0 n52 ns1144 0 -0.000112086656128
Gc26_1145 0 n52 ns1145 0 -0.00012918555167
Gc26_1146 0 n52 ns1146 0 -5.69896223803e-05
Gc26_1147 0 n52 ns1147 0 5.32704326371e-05
Gc26_1148 0 n52 ns1148 0 2.97914144179e-05
Gc26_1149 0 n52 ns1149 0 8.83700979139e-06
Gc26_1150 0 n52 ns1150 0 -0.000107358677472
Gc26_1151 0 n52 ns1151 0 0.000667214558642
Gc26_1152 0 n52 ns1152 0 0.000134843752235
Gc26_1153 0 n52 ns1153 0 -0.000381453281056
Gc26_1154 0 n52 ns1154 0 -0.000169867567455
Gc26_1155 0 n52 ns1155 0 1.48199428996e-05
Gc26_1156 0 n52 ns1156 0 -0.000783280543397
Gc26_1157 0 n52 ns1157 0 0.000450582388624
Gc26_1158 0 n52 ns1158 0 0.00061104257665
Gc26_1159 0 n52 ns1159 0 0.000348062331675
Gc26_1160 0 n52 ns1160 0 7.41881783714e-05
Gc26_1161 0 n52 ns1161 0 -0.000187130104505
Gc26_1162 0 n52 ns1162 0 0.000790808815372
Gc26_1163 0 n52 ns1163 0 0.00139937091802
Gc26_1164 0 n52 ns1164 0 0.00102595207524
Gc26_1165 0 n52 ns1165 0 -0.000398739718671
Gc26_1166 0 n52 ns1166 0 -0.000728447202844
Gc26_1167 0 n52 ns1167 0 -0.000149224792897
Gc26_1168 0 n52 ns1168 0 0.0012093167575
Gc26_1169 0 n52 ns1169 0 0.00111862456526
Gc26_1170 0 n52 ns1170 0 0.000417818282458
Gc26_1171 0 n52 ns1171 0 -5.6284586203e-05
Gc26_1172 0 n52 ns1172 0 -7.28149321406e-05
Gc26_1173 0 n52 ns1173 0 -0.000358727946288
Gc26_1174 0 n52 ns1174 0 0.0176697222609
Gc26_1175 0 n52 ns1175 0 -0.0152275191285
Gc26_1176 0 n52 ns1176 0 0.000555206636607
Gc26_1177 0 n52 ns1177 0 -3.7202733985e-06
Gc26_1178 0 n52 ns1178 0 -3.35875967906e-05
Gc26_1179 0 n52 ns1179 0 -3.46940910492e-05
Gc26_1180 0 n52 ns1180 0 0.000214868767495
Gc26_1181 0 n52 ns1181 0 -0.00295984525873
Gc26_1182 0 n52 ns1182 0 -0.000248727752876
Gc26_1183 0 n52 ns1183 0 -0.000179225143514
Gc26_1184 0 n52 ns1184 0 -0.000162160432171
Gc26_1185 0 n52 ns1185 0 1.97631841625e-05
Gc26_1186 0 n52 ns1186 0 4.66657510809e-07
Gc26_1187 0 n52 ns1187 0 1.30169454741e-05
Gc26_1188 0 n52 ns1188 0 0.000647710267951
Gc26_1189 0 n52 ns1189 0 0.00129529214766
Gc26_1190 0 n52 ns1190 0 -0.000371265618151
Gc26_1191 0 n52 ns1191 0 -0.000472983826394
Gc26_1192 0 n52 ns1192 0 -0.000125023545961
Gc26_1193 0 n52 ns1193 0 0.000112454676671
Gc26_1194 0 n52 ns1194 0 6.86961702153e-05
Gc26_1195 0 n52 ns1195 0 0.00101092957366
Gc26_1196 0 n52 ns1196 0 0.000531336459801
Gc26_1197 0 n52 ns1197 0 -0.000275610760474
Gc26_1198 0 n52 ns1198 0 -5.54660701345e-05
Gc26_1199 0 n52 ns1199 0 -0.000147513722974
Gc26_1200 0 n52 ns1200 0 0.00144484546036
Gc26_1201 0 n52 ns1201 0 0.000781537546605
Gc26_1202 0 n52 ns1202 0 0.000483005865549
Gc26_1203 0 n52 ns1203 0 -0.000678763047661
Gc26_1204 0 n52 ns1204 0 -0.000493771472424
Gc26_1205 0 n52 ns1205 0 0.00016232077325
Gc26_1206 0 n52 ns1206 0 0.001767268831
Gc26_1207 0 n52 ns1207 0 0.000819684026887
Gc26_1208 0 n52 ns1208 0 0.000191122304414
Gc26_1209 0 n52 ns1209 0 -0.00032421475954
Gc26_1210 0 n52 ns1210 0 -0.000145181395215
Gc26_1211 0 n52 ns1211 0 -0.000184629228832
Gc26_1212 0 n52 ns1212 0 0.0172831021174
Gc26_1213 0 n52 ns1213 0 -0.0145906077999
Gc26_1214 0 n52 ns1214 0 0.000495337571848
Gc26_1215 0 n52 ns1215 0 -5.21526214234e-06
Gc26_1216 0 n52 ns1216 0 -2.80085670755e-05
Gd26_1 0 n52 ni1 0 -0.000446886979806
Gd26_2 0 n52 ni2 0 -0.00150850724021
Gd26_3 0 n52 ni3 0 -0.00313844015491
Gd26_4 0 n52 ni4 0 -9.69199313321e-05
Gd26_5 0 n52 ni5 0 0.000125029956125
Gd26_6 0 n52 ni6 0 0.00020573804887
Gd26_7 0 n52 ni7 0 0.000245576129194
Gd26_8 0 n52 ni8 0 3.10343413451e-05
Gd26_9 0 n52 ni9 0 -0.000100587344173
Gd26_10 0 n52 ni10 0 -0.0067649953192
Gd26_11 0 n52 ni11 0 -0.000304419788347
Gd26_12 0 n52 ni12 0 0.000514777239136
Gd26_13 0 n52 ni13 0 0.000105237760214
Gd26_14 0 n52 ni14 0 0.000211536650283
Gd26_15 0 n52 ni15 0 4.35608100134e-05
Gd26_16 0 n52 ni16 0 -1.33824950407e-05
Gd26_17 0 n52 ni17 0 -0.00208133229963
Gd26_18 0 n52 ni18 0 -0.0028876121717
Gd26_19 0 n52 ni19 0 -0.00082213425246
Gd26_20 0 n52 ni20 0 -0.00104083869015
Gd26_21 0 n52 ni21 0 0.000251884585285
Gd26_22 0 n52 ni22 0 0.000158797272541
Gd26_23 0 n52 ni23 0 4.65728810587e-05
Gd26_24 0 n52 ni24 0 -0.000128029610845
Gd26_25 0 n52 ni25 0 -8.01021881679e-05
Gd26_26 0 n52 ni26 0 0.000822406033714
Gd26_27 0 n52 ni27 0 -0.00172287183191
Gd26_28 0 n52 ni28 0 -0.000292828045854
Gd26_29 0 n52 ni29 0 0.000281391988015
Gd26_30 0 n52 ni30 0 -5.85639559579e-06
Gd26_31 0 n52 ni31 0 -0.000100457418205
Gd26_32 0 n52 ni32 0 -8.0006001582e-05
Gc27_1 0 n54 ns1 0 0.000655910697497
Gc27_2 0 n54 ns2 0 -0.00058990285507
Gc27_3 0 n54 ns3 0 0.00933447654778
Gc27_4 0 n54 ns4 0 0.000321396998254
Gc27_5 0 n54 ns5 0 0.000221876525609
Gc27_6 0 n54 ns6 0 5.34621045402e-05
Gc27_7 0 n54 ns7 0 -0.000185151418433
Gc27_8 0 n54 ns8 0 -0.000115440099496
Gc27_9 0 n54 ns9 0 3.40675558426e-05
Gc27_10 0 n54 ns10 0 -0.000610581807395
Gc27_11 0 n54 ns11 0 -0.00374187785541
Gc27_12 0 n54 ns12 0 0.000612744317066
Gc27_13 0 n54 ns13 0 0.00117588296187
Gc27_14 0 n54 ns14 0 -1.83296631314e-05
Gc27_15 0 n54 ns15 0 0.000219487597454
Gc27_16 0 n54 ns16 0 -0.00119397841541
Gc27_17 0 n54 ns17 0 0.000561399729969
Gc27_18 0 n54 ns18 0 -6.9560735972e-05
Gc27_19 0 n54 ns19 0 -0.000769647621037
Gc27_20 0 n54 ns20 0 0.000149665504863
Gc27_21 0 n54 ns21 0 0.000146148909764
Gc27_22 0 n54 ns22 0 -0.00266048688007
Gc27_23 0 n54 ns23 0 -0.00410630802524
Gc27_24 0 n54 ns24 0 -0.000316677558911
Gc27_25 0 n54 ns25 0 0.00069875220666
Gc27_26 0 n54 ns26 0 -0.000121211159887
Gc27_27 0 n54 ns27 0 0.000699398576465
Gc27_28 0 n54 ns28 0 -0.00654969625327
Gc27_29 0 n54 ns29 0 -0.00455563872066
Gc27_30 0 n54 ns30 0 -0.00231119238041
Gc27_31 0 n54 ns31 0 0.00276571188279
Gc27_32 0 n54 ns32 0 0.00214430257046
Gc27_33 0 n54 ns33 0 0.000121938961025
Gc27_34 0 n54 ns34 0 -0.0656767868915
Gc27_35 0 n54 ns35 0 0.0578654728198
Gc27_36 0 n54 ns36 0 -0.00292574482527
Gc27_37 0 n54 ns37 0 -7.37927212195e-06
Gc27_38 0 n54 ns38 0 2.0271032325e-05
Gc27_39 0 n54 ns39 0 -7.3292031383e-05
Gc27_40 0 n54 ns40 0 -0.00082595236125
Gc27_41 0 n54 ns41 0 0.00944643480822
Gc27_42 0 n54 ns42 0 0.000115887325317
Gc27_43 0 n54 ns43 0 0.000170840651607
Gc27_44 0 n54 ns44 0 0.000398286036251
Gc27_45 0 n54 ns45 0 -0.000373819786875
Gc27_46 0 n54 ns46 0 -0.000140230879612
Gc27_47 0 n54 ns47 0 2.56544973066e-05
Gc27_48 0 n54 ns48 0 0.000108449550311
Gc27_49 0 n54 ns49 0 -0.0031830517749
Gc27_50 0 n54 ns50 0 0.000395407461445
Gc27_51 0 n54 ns51 0 0.000979379943123
Gc27_52 0 n54 ns52 0 -0.000154960879463
Gc27_53 0 n54 ns53 0 0.000291898256367
Gc27_54 0 n54 ns54 0 -0.00105250205633
Gc27_55 0 n54 ns55 0 -0.000293979052288
Gc27_56 0 n54 ns56 0 -0.000316829735283
Gc27_57 0 n54 ns57 0 -0.00068166080356
Gc27_58 0 n54 ns58 0 0.000208529867083
Gc27_59 0 n54 ns59 0 0.000245796596607
Gc27_60 0 n54 ns60 0 -0.00175748715346
Gc27_61 0 n54 ns61 0 -0.00494745467092
Gc27_62 0 n54 ns62 0 -0.000896283755681
Gc27_63 0 n54 ns63 0 0.000299041650812
Gc27_64 0 n54 ns64 0 -0.000183205077756
Gc27_65 0 n54 ns65 0 0.00117163919141
Gc27_66 0 n54 ns66 0 -0.00775482672913
Gc27_67 0 n54 ns67 0 -0.00536387782212
Gc27_68 0 n54 ns68 0 -0.00259188354806
Gc27_69 0 n54 ns69 0 0.00280356857093
Gc27_70 0 n54 ns70 0 0.00252697540066
Gc27_71 0 n54 ns71 0 0.000260501369262
Gc27_72 0 n54 ns72 0 -0.07795724481
Gc27_73 0 n54 ns73 0 0.0700879957306
Gc27_74 0 n54 ns74 0 -0.00408183419671
Gc27_75 0 n54 ns75 0 -1.02744899008e-05
Gc27_76 0 n54 ns76 0 2.29864074178e-05
Gc27_77 0 n54 ns77 0 -0.00261820117964
Gc27_78 0 n54 ns78 0 -0.00255652337312
Gc27_79 0 n54 ns79 0 0.00690081079676
Gc27_80 0 n54 ns80 0 0.00100489334125
Gc27_81 0 n54 ns81 0 -0.00184060378989
Gc27_82 0 n54 ns82 0 0.000712563121259
Gc27_83 0 n54 ns83 0 0.00191762514767
Gc27_84 0 n54 ns84 0 3.38760951104e-05
Gc27_85 0 n54 ns85 0 -0.00023732392991
Gc27_86 0 n54 ns86 0 0.000281063384805
Gc27_87 0 n54 ns87 0 -0.00020668498852
Gc27_88 0 n54 ns88 0 -0.000638682401851
Gc27_89 0 n54 ns89 0 -4.82118520349e-05
Gc27_90 0 n54 ns90 0 -0.000408053845298
Gc27_91 0 n54 ns91 0 0.000447822590003
Gc27_92 0 n54 ns92 0 0.00210326325628
Gc27_93 0 n54 ns93 0 -0.00290029182652
Gc27_94 0 n54 ns94 0 -0.00115997260548
Gc27_95 0 n54 ns95 0 -0.000442485532653
Gc27_96 0 n54 ns96 0 0.00024761644317
Gc27_97 0 n54 ns97 0 0.000408461727889
Gc27_98 0 n54 ns98 0 0.00199046906945
Gc27_99 0 n54 ns99 0 -0.00162561588853
Gc27_100 0 n54 ns100 0 -0.00185997578556
Gc27_101 0 n54 ns101 0 -0.00200394804251
Gc27_102 0 n54 ns102 0 -0.00079013748578
Gc27_103 0 n54 ns103 0 0.00226389877996
Gc27_104 0 n54 ns104 0 -0.0111036158821
Gc27_105 0 n54 ns105 0 -0.00518813869073
Gc27_106 0 n54 ns106 0 -0.000124379203287
Gc27_107 0 n54 ns107 0 0.00237949838284
Gc27_108 0 n54 ns108 0 0.00319963206412
Gc27_109 0 n54 ns109 0 0.000344134565532
Gc27_110 0 n54 ns110 0 -0.0369364715308
Gc27_111 0 n54 ns111 0 0.0387835132971
Gc27_112 0 n54 ns112 0 -0.00709999167248
Gc27_113 0 n54 ns113 0 -1.32368260784e-05
Gc27_114 0 n54 ns114 0 2.91922337904e-05
Gc27_115 0 n54 ns115 0 -0.00546414254827
Gc27_116 0 n54 ns116 0 -0.0051290035822
Gc27_117 0 n54 ns117 0 0.00920265237489
Gc27_118 0 n54 ns118 0 0.00261862045215
Gc27_119 0 n54 ns119 0 -0.0021123324577
Gc27_120 0 n54 ns120 0 0.000661482977881
Gc27_121 0 n54 ns121 0 0.00280038612001
Gc27_122 0 n54 ns122 0 -6.78849591772e-07
Gc27_123 0 n54 ns123 0 -0.000308377368904
Gc27_124 0 n54 ns124 0 -0.000992058218517
Gc27_125 0 n54 ns125 0 -0.00146071122876
Gc27_126 0 n54 ns126 0 -0.000884849684221
Gc27_127 0 n54 ns127 0 0.000488097411799
Gc27_128 0 n54 ns128 0 -0.000156755367088
Gc27_129 0 n54 ns129 0 0.000584760029949
Gc27_130 0 n54 ns130 0 0.00278722643547
Gc27_131 0 n54 ns131 0 -0.00258097457717
Gc27_132 0 n54 ns132 0 -0.000892777909427
Gc27_133 0 n54 ns133 0 -0.000591938958361
Gc27_134 0 n54 ns134 0 0.000202090991615
Gc27_135 0 n54 ns135 0 0.000194622128788
Gc27_136 0 n54 ns136 0 0.00239048226695
Gc27_137 0 n54 ns137 0 0.00134793631067
Gc27_138 0 n54 ns138 0 -0.00116515869688
Gc27_139 0 n54 ns139 0 -0.00268364586261
Gc27_140 0 n54 ns140 0 -0.00115804907679
Gc27_141 0 n54 ns141 0 0.00210284508442
Gc27_142 0 n54 ns142 0 -0.0147044220848
Gc27_143 0 n54 ns143 0 -0.0056895574259
Gc27_144 0 n54 ns144 0 0.00202032139122
Gc27_145 0 n54 ns145 0 0.00390671367795
Gc27_146 0 n54 ns146 0 0.00372208385828
Gc27_147 0 n54 ns147 0 0.000173631389232
Gc27_148 0 n54 ns148 0 0.00890812580694
Gc27_149 0 n54 ns149 0 -0.00114389027978
Gc27_150 0 n54 ns150 0 -0.00787290255349
Gc27_151 0 n54 ns151 0 -1.31469228793e-05
Gc27_152 0 n54 ns152 0 1.54262138343e-05
Gc27_153 0 n54 ns153 0 0.000212155446373
Gc27_154 0 n54 ns154 0 -0.00110525695413
Gc27_155 0 n54 ns155 0 0.00990025684277
Gc27_156 0 n54 ns156 0 -0.000243720104747
Gc27_157 0 n54 ns157 0 0.000171414159322
Gc27_158 0 n54 ns158 0 0.000484854290647
Gc27_159 0 n54 ns159 0 -0.000518522090125
Gc27_160 0 n54 ns160 0 -8.47865938501e-05
Gc27_161 0 n54 ns161 0 3.49358373256e-05
Gc27_162 0 n54 ns162 0 0.00200821906008
Gc27_163 0 n54 ns163 0 -0.00275392432692
Gc27_164 0 n54 ns164 0 -0.000629975983222
Gc27_165 0 n54 ns165 0 0.00084260831717
Gc27_166 0 n54 ns166 0 -4.93768163447e-05
Gc27_167 0 n54 ns167 0 0.000520919822298
Gc27_168 0 n54 ns168 0 -0.00135362358552
Gc27_169 0 n54 ns169 0 -0.0024479021822
Gc27_170 0 n54 ns170 0 -0.000628163803881
Gc27_171 0 n54 ns171 0 0.000441520097585
Gc27_172 0 n54 ns172 0 0.000366242545456
Gc27_173 0 n54 ns173 0 0.000262336986971
Gc27_174 0 n54 ns174 0 -0.000254701208026
Gc27_175 0 n54 ns175 0 -0.00645992547031
Gc27_176 0 n54 ns176 0 -0.00291612678674
Gc27_177 0 n54 ns177 0 -0.000476203504188
Gc27_178 0 n54 ns178 0 0.000499778261206
Gc27_179 0 n54 ns179 0 0.00210466320737
Gc27_180 0 n54 ns180 0 -0.0109233714941
Gc27_181 0 n54 ns181 0 -0.00562626949498
Gc27_182 0 n54 ns182 0 -0.00184910440853
Gc27_183 0 n54 ns183 0 0.00293498507443
Gc27_184 0 n54 ns184 0 0.00271259082008
Gc27_185 0 n54 ns185 0 0.000165677974571
Gc27_186 0 n54 ns186 0 -0.0914857730086
Gc27_187 0 n54 ns187 0 0.0832358561593
Gc27_188 0 n54 ns188 0 -0.00526694231153
Gc27_189 0 n54 ns189 0 -1.00310490672e-05
Gc27_190 0 n54 ns190 0 -7.35294224348e-07
Gc27_191 0 n54 ns191 0 0.000716629629647
Gc27_192 0 n54 ns192 0 -0.00170279962313
Gc27_193 0 n54 ns193 0 0.00920529743751
Gc27_194 0 n54 ns194 0 0.000226696940435
Gc27_195 0 n54 ns195 0 0.000262459885872
Gc27_196 0 n54 ns196 0 0.000147555066239
Gc27_197 0 n54 ns197 0 0.00015228672219
Gc27_198 0 n54 ns198 0 -1.07926308058e-05
Gc27_199 0 n54 ns199 0 5.67715426854e-06
Gc27_200 0 n54 ns200 0 -0.000473664612003
Gc27_201 0 n54 ns201 0 -0.00336547230858
Gc27_202 0 n54 ns202 0 0.00025119664046
Gc27_203 0 n54 ns203 0 0.000823784478558
Gc27_204 0 n54 ns204 0 0.000192484909354
Gc27_205 0 n54 ns205 0 0.000381256585277
Gc27_206 0 n54 ns206 0 -0.000191831817829
Gc27_207 0 n54 ns207 0 -7.60010269271e-05
Gc27_208 0 n54 ns208 0 -0.000519101550369
Gc27_209 0 n54 ns209 0 -0.000232147953913
Gc27_210 0 n54 ns210 0 0.000184457685947
Gc27_211 0 n54 ns211 0 -1.22212331664e-05
Gc27_212 0 n54 ns212 0 -0.00205534157843
Gc27_213 0 n54 ns213 0 -0.00371082341071
Gc27_214 0 n54 ns214 0 -0.00106217081582
Gc27_215 0 n54 ns215 0 -0.000381319869327
Gc27_216 0 n54 ns216 0 0.000319772652103
Gc27_217 0 n54 ns217 0 0.00134205823477
Gc27_218 0 n54 ns218 0 -0.00743329371364
Gc27_219 0 n54 ns219 0 -0.00478621079023
Gc27_220 0 n54 ns220 0 -0.00115847500151
Gc27_221 0 n54 ns221 0 0.00373630998755
Gc27_222 0 n54 ns222 0 0.00192873201156
Gc27_223 0 n54 ns223 0 -0.000462314710347
Gc27_224 0 n54 ns224 0 -0.0532849529436
Gc27_225 0 n54 ns225 0 0.0457768003858
Gc27_226 0 n54 ns226 0 -0.00199471511479
Gc27_227 0 n54 ns227 0 -8.40609110437e-06
Gc27_228 0 n54 ns228 0 -2.38614747106e-05
Gc27_229 0 n54 ns229 0 0.000518128793976
Gc27_230 0 n54 ns230 0 -0.000608899671553
Gc27_231 0 n54 ns231 0 0.00423813043918
Gc27_232 0 n54 ns232 0 -0.000331306663571
Gc27_233 0 n54 ns233 0 0.000451673005848
Gc27_234 0 n54 ns234 0 0.000429796482271
Gc27_235 0 n54 ns235 0 7.16815608801e-05
Gc27_236 0 n54 ns236 0 2.98821267244e-05
Gc27_237 0 n54 ns237 0 -3.00404480208e-05
Gc27_238 0 n54 ns238 0 -8.75163971507e-05
Gc27_239 0 n54 ns239 0 -0.000759103720721
Gc27_240 0 n54 ns240 0 1.48123779991e-05
Gc27_241 0 n54 ns241 0 -9.19007535122e-05
Gc27_242 0 n54 ns242 0 0.000119595508796
Gc27_243 0 n54 ns243 0 0.000194565543017
Gc27_244 0 n54 ns244 0 0.000952920621798
Gc27_245 0 n54 ns245 0 -0.000983565328276
Gc27_246 0 n54 ns246 0 -0.000876553147067
Gc27_247 0 n54 ns247 0 0.000191791847378
Gc27_248 0 n54 ns248 0 8.33767316247e-05
Gc27_249 0 n54 ns249 0 6.87814452228e-06
Gc27_250 0 n54 ns250 0 -0.000585896795006
Gc27_251 0 n54 ns251 0 -0.00190962540738
Gc27_252 0 n54 ns252 0 -0.00118329151495
Gc27_253 0 n54 ns253 0 -0.000992577786014
Gc27_254 0 n54 ns254 0 0.000436432434152
Gc27_255 0 n54 ns255 0 0.00122381039282
Gc27_256 0 n54 ns256 0 -0.0051890551622
Gc27_257 0 n54 ns257 0 -0.0027860659138
Gc27_258 0 n54 ns258 0 0.000228594631025
Gc27_259 0 n54 ns259 0 0.00274632664616
Gc27_260 0 n54 ns260 0 0.00101845308845
Gc27_261 0 n54 ns261 0 -0.000687288904437
Gc27_262 0 n54 ns262 0 -0.021394505477
Gc27_263 0 n54 ns263 0 0.0177064706455
Gc27_264 0 n54 ns264 0 -0.000683980169378
Gc27_265 0 n54 ns265 0 -1.02673157716e-06
Gc27_266 0 n54 ns266 0 -3.28754250728e-05
Gc27_267 0 n54 ns267 0 0.000530970561852
Gc27_268 0 n54 ns268 0 -0.000619896465718
Gc27_269 0 n54 ns269 0 0.00272805238415
Gc27_270 0 n54 ns270 0 -0.000167518458531
Gc27_271 0 n54 ns271 0 0.000337585021593
Gc27_272 0 n54 ns272 0 0.000185763624881
Gc27_273 0 n54 ns273 0 -1.87690236127e-06
Gc27_274 0 n54 ns274 0 -1.25199627331e-05
Gc27_275 0 n54 ns275 0 -4.03396394467e-05
Gc27_276 0 n54 ns276 0 0.000710142250677
Gc27_277 0 n54 ns277 0 -0.000964466245981
Gc27_278 0 n54 ns278 0 -0.00049546799346
Gc27_279 0 n54 ns279 0 0.000316535492557
Gc27_280 0 n54 ns280 0 0.000192171051227
Gc27_281 0 n54 ns281 0 0.000151941761566
Gc27_282 0 n54 ns282 0 -0.00045257852126
Gc27_283 0 n54 ns283 0 -0.000968005529878
Gc27_284 0 n54 ns284 0 -3.9897926074e-05
Gc27_285 0 n54 ns285 0 0.000667715440974
Gc27_286 0 n54 ns286 0 0.000111111631867
Gc27_287 0 n54 ns287 0 -0.000104034722761
Gc27_288 0 n54 ns288 0 -0.000180655291845
Gc27_289 0 n54 ns289 0 -0.00134595666706
Gc27_290 0 n54 ns290 0 -0.00136805616372
Gc27_291 0 n54 ns291 0 -0.000338122778577
Gc27_292 0 n54 ns292 0 0.000712133331581
Gc27_293 0 n54 ns293 0 0.000694864051784
Gc27_294 0 n54 ns294 0 -0.00356030383532
Gc27_295 0 n54 ns295 0 -0.0007072882891
Gc27_296 0 n54 ns296 0 0.000689827766374
Gc27_297 0 n54 ns297 0 0.00145942726621
Gc27_298 0 n54 ns298 0 0.000454149668919
Gc27_299 0 n54 ns299 0 -0.000548645357091
Gc27_300 0 n54 ns300 0 -0.00764065491366
Gc27_301 0 n54 ns301 0 0.00590069128039
Gc27_302 0 n54 ns302 0 -0.000205869096339
Gc27_303 0 n54 ns303 0 5.5496149304e-06
Gc27_304 0 n54 ns304 0 -3.15852747947e-05
Gc27_305 0 n54 ns305 0 5.77063552416e-05
Gc27_306 0 n54 ns306 0 -0.000439253302539
Gc27_307 0 n54 ns307 0 0.000870620622262
Gc27_308 0 n54 ns308 0 -0.000126790784327
Gc27_309 0 n54 ns309 0 0.000167249262197
Gc27_310 0 n54 ns310 0 5.73184101268e-06
Gc27_311 0 n54 ns311 0 0.000127409311151
Gc27_312 0 n54 ns312 0 5.84841599487e-06
Gc27_313 0 n54 ns313 0 1.62113315426e-05
Gc27_314 0 n54 ns314 0 0.000435324735483
Gc27_315 0 n54 ns315 0 -0.00144215307943
Gc27_316 0 n54 ns316 0 -0.000285240318258
Gc27_317 0 n54 ns317 0 0.00079791145112
Gc27_318 0 n54 ns318 0 0.000271775814786
Gc27_319 0 n54 ns319 0 6.05028103548e-05
Gc27_320 0 n54 ns320 0 -0.000767802631237
Gc27_321 0 n54 ns321 0 9.82001682462e-05
Gc27_322 0 n54 ns322 0 0.000504879592569
Gc27_323 0 n54 ns323 0 0.000285159160875
Gc27_324 0 n54 ns324 0 3.61678297557e-05
Gc27_325 0 n54 ns325 0 -0.000170501657283
Gc27_326 0 n54 ns326 0 0.000257023162955
Gc27_327 0 n54 ns327 0 -0.000776912957405
Gc27_328 0 n54 ns328 0 -0.000873380052981
Gc27_329 0 n54 ns329 0 -4.96521103461e-05
Gc27_330 0 n54 ns330 0 0.000481066055768
Gc27_331 0 n54 ns331 0 0.000296223401528
Gc27_332 0 n54 ns332 0 -0.00141827491823
Gc27_333 0 n54 ns333 0 0.000158765239811
Gc27_334 0 n54 ns334 0 0.000495289140419
Gc27_335 0 n54 ns335 0 0.000511242638099
Gc27_336 0 n54 ns336 0 0.000125965781128
Gc27_337 0 n54 ns337 0 -0.000316347436922
Gc27_338 0 n54 ns338 0 0.000249469559132
Gc27_339 0 n54 ns339 0 -0.000377340822715
Gc27_340 0 n54 ns340 0 -3.89114951145e-05
Gc27_341 0 n54 ns341 0 7.56177127933e-06
Gc27_342 0 n54 ns342 0 -2.50374569965e-05
Gc27_343 0 n54 ns343 0 -0.000508829041164
Gc27_344 0 n54 ns344 0 0.000497810403255
Gc27_345 0 n54 ns345 0 0.00501103163567
Gc27_346 0 n54 ns346 0 -0.00128820860742
Gc27_347 0 n54 ns347 0 -0.00055631773323
Gc27_348 0 n54 ns348 0 0.00187520227626
Gc27_349 0 n54 ns349 0 0.000523008632684
Gc27_350 0 n54 ns350 0 -0.000159643528899
Gc27_351 0 n54 ns351 0 -0.000180777766761
Gc27_352 0 n54 ns352 0 0.00126288408008
Gc27_353 0 n54 ns353 0 -0.00137463655414
Gc27_354 0 n54 ns354 0 -8.62496307211e-05
Gc27_355 0 n54 ns355 0 0.00042138390329
Gc27_356 0 n54 ns356 0 -0.00032698446086
Gc27_357 0 n54 ns357 0 0.00035292702748
Gc27_358 0 n54 ns358 0 0.000529948307548
Gc27_359 0 n54 ns359 0 -0.00305132688369
Gc27_360 0 n54 ns360 0 -0.00132432104156
Gc27_361 0 n54 ns361 0 -0.000279453729646
Gc27_362 0 n54 ns362 0 0.000227335723672
Gc27_363 0 n54 ns363 0 0.000512382981909
Gc27_364 0 n54 ns364 0 0.000951774409009
Gc27_365 0 n54 ns365 0 -0.0046180890165
Gc27_366 0 n54 ns366 0 -0.00194710135356
Gc27_367 0 n54 ns367 0 -0.00110652485991
Gc27_368 0 n54 ns368 0 -0.000420626680781
Gc27_369 0 n54 ns369 0 0.00201557399198
Gc27_370 0 n54 ns370 0 -0.0110077700329
Gc27_371 0 n54 ns371 0 -0.00582747559128
Gc27_372 0 n54 ns372 0 -0.00152452198424
Gc27_373 0 n54 ns373 0 0.00270576574691
Gc27_374 0 n54 ns374 0 0.00309358143346
Gc27_375 0 n54 ns375 0 0.000479038672618
Gc27_376 0 n54 ns376 0 -0.068050679843
Gc27_377 0 n54 ns377 0 0.0650594855599
Gc27_378 0 n54 ns378 0 -0.00643325420689
Gc27_379 0 n54 ns379 0 -1.32143788339e-05
Gc27_380 0 n54 ns380 0 3.15182192671e-05
Gc27_381 0 n54 ns381 0 -0.0169748295482
Gc27_382 0 n54 ns382 0 -0.00116163932094
Gc27_383 0 n54 ns383 0 0.021203068758
Gc27_384 0 n54 ns384 0 0.00639889248824
Gc27_385 0 n54 ns385 0 0.0102021284637
Gc27_386 0 n54 ns386 0 0.00156039867709
Gc27_387 0 n54 ns387 0 -0.003417967825
Gc27_388 0 n54 ns388 0 -0.000538674229551
Gc27_389 0 n54 ns389 0 6.92017961219e-06
Gc27_390 0 n54 ns390 0 -0.00134325759586
Gc27_391 0 n54 ns391 0 -0.0140364596491
Gc27_392 0 n54 ns392 0 0.00109735314332
Gc27_393 0 n54 ns393 0 0.00157657445273
Gc27_394 0 n54 ns394 0 9.98819640994e-05
Gc27_395 0 n54 ns395 0 0.000433573917579
Gc27_396 0 n54 ns396 0 0.000453491413049
Gc27_397 0 n54 ns397 0 -5.9588938602e-05
Gc27_398 0 n54 ns398 0 -0.000432587399772
Gc27_399 0 n54 ns399 0 0.000600357922602
Gc27_400 0 n54 ns400 0 0.000560949855738
Gc27_401 0 n54 ns401 0 0.000481802471198
Gc27_402 0 n54 ns402 0 -0.0120007822074
Gc27_403 0 n54 ns403 0 -0.00755133681125
Gc27_404 0 n54 ns404 0 -0.00331484897736
Gc27_405 0 n54 ns405 0 -0.00148918338099
Gc27_406 0 n54 ns406 0 -0.000126447823347
Gc27_407 0 n54 ns407 0 0.00258331782704
Gc27_408 0 n54 ns408 0 0.00778815512523
Gc27_409 0 n54 ns409 0 -0.00616809563493
Gc27_410 0 n54 ns410 0 0.00169791586326
Gc27_411 0 n54 ns411 0 0.00218375456594
Gc27_412 0 n54 ns412 0 0.00343174508523
Gc27_413 0 n54 ns413 0 3.04096832852e-05
Gc27_414 0 n54 ns414 0 -0.113009034796
Gc27_415 0 n54 ns415 0 0.0741769841297
Gc27_416 0 n54 ns416 0 -0.0089173048351
Gc27_417 0 n54 ns417 0 -1.30545042057e-05
Gc27_418 0 n54 ns418 0 2.41677657295e-05
Gc27_419 0 n54 ns419 0 -0.00032051267472
Gc27_420 0 n54 ns420 0 -0.000425629504932
Gc27_421 0 n54 ns421 0 0.00698175853811
Gc27_422 0 n54 ns422 0 -0.00111243400117
Gc27_423 0 n54 ns423 0 -0.000483936856854
Gc27_424 0 n54 ns424 0 0.0018002990602
Gc27_425 0 n54 ns425 0 0.000463033921488
Gc27_426 0 n54 ns426 0 -0.000184127768602
Gc27_427 0 n54 ns427 0 -0.000171990310225
Gc27_428 0 n54 ns428 0 0.00219752399589
Gc27_429 0 n54 ns429 0 -0.00268146325699
Gc27_430 0 n54 ns430 0 -0.000846430908744
Gc27_431 0 n54 ns431 0 0.000991109212884
Gc27_432 0 n54 ns432 0 -6.4091217829e-05
Gc27_433 0 n54 ns433 0 0.000570668106389
Gc27_434 0 n54 ns434 0 -0.000542282619094
Gc27_435 0 n54 ns435 0 -0.00371541226963
Gc27_436 0 n54 ns436 0 -0.000987636366361
Gc27_437 0 n54 ns437 0 0.000439065019006
Gc27_438 0 n54 ns438 0 0.000346583747624
Gc27_439 0 n54 ns439 0 0.000372909362829
Gc27_440 0 n54 ns440 0 0.000891747472101
Gc27_441 0 n54 ns441 0 -0.00548447458612
Gc27_442 0 n54 ns442 0 -0.00299413484159
Gc27_443 0 n54 ns443 0 -0.00107429503432
Gc27_444 0 n54 ns444 0 0.000185452747158
Gc27_445 0 n54 ns445 0 0.00231679185058
Gc27_446 0 n54 ns446 0 -0.0130195278574
Gc27_447 0 n54 ns447 0 -0.00589785432086
Gc27_448 0 n54 ns448 0 -0.000950181537945
Gc27_449 0 n54 ns449 0 0.00316613157906
Gc27_450 0 n54 ns450 0 0.00313423732564
Gc27_451 0 n54 ns451 0 0.000264357826432
Gc27_452 0 n54 ns452 0 -0.073466308649
Gc27_453 0 n54 ns453 0 0.0692579024461
Gc27_454 0 n54 ns454 0 -0.00651684188803
Gc27_455 0 n54 ns455 0 -9.89115831823e-06
Gc27_456 0 n54 ns456 0 1.56067829733e-05
Gc27_457 0 n54 ns457 0 0.000782117659303
Gc27_458 0 n54 ns458 0 -0.000804791426044
Gc27_459 0 n54 ns459 0 0.0102866439355
Gc27_460 0 n54 ns460 0 1.97659477866e-05
Gc27_461 0 n54 ns461 0 0.000737611392616
Gc27_462 0 n54 ns462 0 0.000414971383859
Gc27_463 0 n54 ns463 0 -0.000127175543808
Gc27_464 0 n54 ns464 0 -8.63649761494e-05
Gc27_465 0 n54 ns465 0 -1.09904333047e-05
Gc27_466 0 n54 ns466 0 0.000140672031625
Gc27_467 0 n54 ns467 0 -0.00445775866856
Gc27_468 0 n54 ns468 0 0.000120614921146
Gc27_469 0 n54 ns469 0 0.00121103821152
Gc27_470 0 n54 ns470 0 0.000176359720552
Gc27_471 0 n54 ns471 0 0.000453724823595
Gc27_472 0 n54 ns472 0 -0.00115097629824
Gc27_473 0 n54 ns473 0 -0.000633284202605
Gc27_474 0 n54 ns474 0 -0.000402467674705
Gc27_475 0 n54 ns475 0 -5.49819463606e-06
Gc27_476 0 n54 ns476 0 0.000293815197783
Gc27_477 0 n54 ns477 0 6.0417274817e-05
Gc27_478 0 n54 ns478 0 -0.00223990499532
Gc27_479 0 n54 ns479 0 -0.00495742445288
Gc27_480 0 n54 ns480 0 -0.00156972564043
Gc27_481 0 n54 ns481 0 -9.07373019482e-05
Gc27_482 0 n54 ns482 0 0.000443434457045
Gc27_483 0 n54 ns483 0 0.00151901150492
Gc27_484 0 n54 ns484 0 -0.00903150879204
Gc27_485 0 n54 ns485 0 -0.00539705321007
Gc27_486 0 n54 ns486 0 -0.0015729801029
Gc27_487 0 n54 ns487 0 0.0038594955881
Gc27_488 0 n54 ns488 0 0.00230172978734
Gc27_489 0 n54 ns489 0 -0.000313583207078
Gc27_490 0 n54 ns490 0 -0.0701526948669
Gc27_491 0 n54 ns491 0 0.0611233839472
Gc27_492 0 n54 ns492 0 -0.00291190244751
Gc27_493 0 n54 ns493 0 -9.6675364704e-06
Gc27_494 0 n54 ns494 0 -1.30641681874e-05
Gc27_495 0 n54 ns495 0 0.000509993696522
Gc27_496 0 n54 ns496 0 -0.000942759584893
Gc27_497 0 n54 ns497 0 0.00578680288888
Gc27_498 0 n54 ns498 0 -8.08951433749e-05
Gc27_499 0 n54 ns499 0 0.000336508468898
Gc27_500 0 n54 ns500 0 0.000370188758691
Gc27_501 0 n54 ns501 0 0.000142574463737
Gc27_502 0 n54 ns502 0 2.72538249853e-05
Gc27_503 0 n54 ns503 0 -6.95976541816e-06
Gc27_504 0 n54 ns504 0 -0.000623570604476
Gc27_505 0 n54 ns505 0 -0.00156865347812
Gc27_506 0 n54 ns506 0 0.000293664325567
Gc27_507 0 n54 ns507 0 0.000137071294076
Gc27_508 0 n54 ns508 0 0.000148049311112
Gc27_509 0 n54 ns509 0 0.000241685470248
Gc27_510 0 n54 ns510 0 0.000993051411057
Gc27_511 0 n54 ns511 0 -0.000607827107512
Gc27_512 0 n54 ns512 0 -0.000956811749556
Gc27_513 0 n54 ns513 0 -8.77192828907e-05
Gc27_514 0 n54 ns514 0 8.96966332667e-05
Gc27_515 0 n54 ns515 0 1.48278844284e-05
Gc27_516 0 n54 ns516 0 -0.00115521776726
Gc27_517 0 n54 ns517 0 -0.0024411199962
Gc27_518 0 n54 ns518 0 -0.00108395144362
Gc27_519 0 n54 ns519 0 -0.00095362434911
Gc27_520 0 n54 ns520 0 0.000362283375004
Gc27_521 0 n54 ns521 0 0.00134826086817
Gc27_522 0 n54 ns522 0 -0.00611677225568
Gc27_523 0 n54 ns523 0 -0.00359300207154
Gc27_524 0 n54 ns524 0 -0.000131341421393
Gc27_525 0 n54 ns525 0 0.00325171205012
Gc27_526 0 n54 ns526 0 0.00133177565487
Gc27_527 0 n54 ns527 0 -0.000681737972296
Gc27_528 0 n54 ns528 0 -0.0309216866343
Gc27_529 0 n54 ns529 0 0.025919024425
Gc27_530 0 n54 ns530 0 -0.00102907036507
Gc27_531 0 n54 ns531 0 -4.11561089023e-06
Gc27_532 0 n54 ns532 0 -2.90395030184e-05
Gc27_533 0 n54 ns533 0 0.000594163793595
Gc27_534 0 n54 ns534 0 -0.000753848735821
Gc27_535 0 n54 ns535 0 0.00340689877857
Gc27_536 0 n54 ns536 0 -0.000175325352729
Gc27_537 0 n54 ns537 0 0.000335932892018
Gc27_538 0 n54 ns538 0 0.000257412207642
Gc27_539 0 n54 ns539 0 -3.73351528087e-05
Gc27_540 0 n54 ns540 0 3.7621685715e-06
Gc27_541 0 n54 ns541 0 -4.87479833523e-05
Gc27_542 0 n54 ns542 0 0.000489909207703
Gc27_543 0 n54 ns543 0 -0.000558788807339
Gc27_544 0 n54 ns544 0 -0.000402869206801
Gc27_545 0 n54 ns545 0 -2.19459801234e-05
Gc27_546 0 n54 ns546 0 0.000131667068754
Gc27_547 0 n54 ns547 0 0.000182106997617
Gc27_548 0 n54 ns548 0 -1.30198016086e-05
Gc27_549 0 n54 ns549 0 -0.00124245576198
Gc27_550 0 n54 ns550 0 -0.000406975547515
Gc27_551 0 n54 ns551 0 0.000674910242146
Gc27_552 0 n54 ns552 0 0.000133916946392
Gc27_553 0 n54 ns553 0 -4.99610375112e-05
Gc27_554 0 n54 ns554 0 -0.00031842979559
Gc27_555 0 n54 ns555 0 -0.00140718432018
Gc27_556 0 n54 ns556 0 -0.00136442786569
Gc27_557 0 n54 ns557 0 -0.000596527493297
Gc27_558 0 n54 ns558 0 0.000662110533097
Gc27_559 0 n54 ns559 0 0.000894280048121
Gc27_560 0 n54 ns560 0 -0.00416895474271
Gc27_561 0 n54 ns561 0 -0.00126007947582
Gc27_562 0 n54 ns562 0 0.00063395842071
Gc27_563 0 n54 ns563 0 0.00186605856383
Gc27_564 0 n54 ns564 0 0.00060609995312
Gc27_565 0 n54 ns565 0 -0.000620271476961
Gc27_566 0 n54 ns566 0 -0.0115176516981
Gc27_567 0 n54 ns567 0 0.00915797334633
Gc27_568 0 n54 ns568 0 -0.000326477574817
Gc27_569 0 n54 ns569 0 3.53257674011e-06
Gc27_570 0 n54 ns570 0 -3.48008943943e-05
Gc27_571 0 n54 ns571 0 0.000206246244685
Gc27_572 0 n54 ns572 0 -0.000618020931536
Gc27_573 0 n54 ns573 0 0.00148201517461
Gc27_574 0 n54 ns574 0 -0.000103441349134
Gc27_575 0 n54 ns575 0 0.000205481072499
Gc27_576 0 n54 ns576 0 4.18476825876e-05
Gc27_577 0 n54 ns577 0 9.84873984953e-05
Gc27_578 0 n54 ns578 0 -4.81999106478e-06
Gc27_579 0 n54 ns579 0 -3.04730934854e-06
Gc27_580 0 n54 ns580 0 0.000559314682616
Gc27_581 0 n54 ns581 0 -0.00147850029622
Gc27_582 0 n54 ns582 0 -0.000404954236075
Gc27_583 0 n54 ns583 0 0.000758324259456
Gc27_584 0 n54 ns584 0 0.000285677993622
Gc27_585 0 n54 ns585 0 9.73141632639e-05
Gc27_586 0 n54 ns586 0 -0.000858121011543
Gc27_587 0 n54 ns587 0 -0.000185482241069
Gc27_588 0 n54 ns588 0 0.000451622342104
Gc27_589 0 n54 ns589 0 0.000460678937634
Gc27_590 0 n54 ns590 0 6.83403656501e-05
Gc27_591 0 n54 ns591 0 -0.000178824622369
Gc27_592 0 n54 ns592 0 0.000160701225872
Gc27_593 0 n54 ns593 0 -0.000966217523593
Gc27_594 0 n54 ns594 0 -0.0010948500529
Gc27_595 0 n54 ns595 0 -0.000101955223985
Gc27_596 0 n54 ns596 0 0.00060346422088
Gc27_597 0 n54 ns597 0 0.000410280516807
Gc27_598 0 n54 ns598 0 -0.0020681788469
Gc27_599 0 n54 ns599 0 5.26541273879e-05
Gc27_600 0 n54 ns600 0 0.000631811609965
Gc27_601 0 n54 ns601 0 0.000752455024921
Gc27_602 0 n54 ns602 0 0.000190909131108
Gc27_603 0 n54 ns603 0 -0.000409320229583
Gc27_604 0 n54 ns604 0 -0.00158814165731
Gc27_605 0 n54 ns605 0 0.00107998528958
Gc27_606 0 n54 ns606 0 -8.33600827497e-05
Gc27_607 0 n54 ns607 0 6.13831961413e-06
Gc27_608 0 n54 ns608 0 -2.81244386009e-05
Gc27_609 0 n54 ns609 0 -0.00118301546897
Gc27_610 0 n54 ns610 0 0.000756433718512
Gc27_611 0 n54 ns611 0 -0.000961878406674
Gc27_612 0 n54 ns612 0 0.000748147310588
Gc27_613 0 n54 ns613 0 -0.000683609993464
Gc27_614 0 n54 ns614 0 0.000507367694741
Gc27_615 0 n54 ns615 0 -0.000375878861521
Gc27_616 0 n54 ns616 0 -5.65335181504e-05
Gc27_617 0 n54 ns617 0 -1.23372231776e-05
Gc27_618 0 n54 ns618 0 -0.00277463059775
Gc27_619 0 n54 ns619 0 0.000391302387541
Gc27_620 0 n54 ns620 0 0.000116398027055
Gc27_621 0 n54 ns621 0 -0.000664510393309
Gc27_622 0 n54 ns622 0 0.0002521785329
Gc27_623 0 n54 ns623 0 -0.000247644631587
Gc27_624 0 n54 ns624 0 -0.00207884260774
Gc27_625 0 n54 ns625 0 0.00203363453845
Gc27_626 0 n54 ns626 0 0.000514290472809
Gc27_627 0 n54 ns627 0 -0.000528954747724
Gc27_628 0 n54 ns628 0 0.000290580030145
Gc27_629 0 n54 ns629 0 8.96354127239e-05
Gc27_630 0 n54 ns630 0 0.000661199837668
Gc27_631 0 n54 ns631 0 0.0038671038045
Gc27_632 0 n54 ns632 0 -0.000102996827628
Gc27_633 0 n54 ns633 0 -0.000231246965703
Gc27_634 0 n54 ns634 0 0.000490025318915
Gc27_635 0 n54 ns635 0 -0.00067858732905
Gc27_636 0 n54 ns636 0 0.00315782464687
Gc27_637 0 n54 ns637 0 0.00187082952259
Gc27_638 0 n54 ns638 0 -0.002130080918
Gc27_639 0 n54 ns639 0 5.30627917834e-05
Gc27_640 0 n54 ns640 0 0.00131955743501
Gc27_641 0 n54 ns641 0 -3.72627068082e-05
Gc27_642 0 n54 ns642 0 0.0411385421408
Gc27_643 0 n54 ns643 0 -0.0390389829961
Gc27_644 0 n54 ns644 0 0.00260638831235
Gc27_645 0 n54 ns645 0 -2.41586441689e-06
Gc27_646 0 n54 ns646 0 2.26302362377e-05
Gc27_647 0 n54 ns647 0 -0.00157264291469
Gc27_648 0 n54 ns648 0 0.000933932970593
Gc27_649 0 n54 ns649 0 -0.00147213692107
Gc27_650 0 n54 ns650 0 0.00069116236981
Gc27_651 0 n54 ns651 0 -0.000749922950614
Gc27_652 0 n54 ns652 0 0.000548874787449
Gc27_653 0 n54 ns653 0 -0.000123179672877
Gc27_654 0 n54 ns654 0 -0.000121356768706
Gc27_655 0 n54 ns655 0 -2.06654853315e-05
Gc27_656 0 n54 ns656 0 -0.00240284805918
Gc27_657 0 n54 ns657 0 0.000399147023238
Gc27_658 0 n54 ns658 0 0.0003357724912
Gc27_659 0 n54 ns659 0 -0.000581488396119
Gc27_660 0 n54 ns660 0 0.000338586191162
Gc27_661 0 n54 ns661 0 -0.000368820087787
Gc27_662 0 n54 ns662 0 -0.00163696848221
Gc27_663 0 n54 ns663 0 0.00102044227394
Gc27_664 0 n54 ns664 0 0.000243834785138
Gc27_665 0 n54 ns665 0 -0.000535871554667
Gc27_666 0 n54 ns666 0 0.000338182782725
Gc27_667 0 n54 ns667 0 0.000163826641627
Gc27_668 0 n54 ns668 0 -0.000563674302559
Gc27_669 0 n54 ns669 0 0.0032141601763
Gc27_670 0 n54 ns670 0 2.94435450799e-05
Gc27_671 0 n54 ns671 0 0.000117415867265
Gc27_672 0 n54 ns672 0 0.000695392557065
Gc27_673 0 n54 ns673 0 -0.000963229404354
Gc27_674 0 n54 ns674 0 0.00206860585986
Gc27_675 0 n54 ns675 0 0.00197202904736
Gc27_676 0 n54 ns676 0 -0.00230243611579
Gc27_677 0 n54 ns677 0 -5.0866969929e-05
Gc27_678 0 n54 ns678 0 0.00166802651592
Gc27_679 0 n54 ns679 0 6.26736019551e-05
Gc27_680 0 n54 ns680 0 0.0471105833647
Gc27_681 0 n54 ns681 0 -0.0462599442124
Gc27_682 0 n54 ns682 0 0.00365170526677
Gc27_683 0 n54 ns683 0 -4.55088921127e-07
Gc27_684 0 n54 ns684 0 2.80916945413e-05
Gc27_685 0 n54 ns685 0 -0.00499950713361
Gc27_686 0 n54 ns686 0 -0.000763704788486
Gc27_687 0 n54 ns687 0 -0.00404265558762
Gc27_688 0 n54 ns688 0 0.00036239393312
Gc27_689 0 n54 ns689 0 -0.00139684371477
Gc27_690 0 n54 ns690 0 -0.000330118635974
Gc27_691 0 n54 ns691 0 0.000801427744865
Gc27_692 0 n54 ns692 0 -0.000128887668672
Gc27_693 0 n54 ns693 0 -1.92085312893e-05
Gc27_694 0 n54 ns694 0 -5.78839270105e-05
Gc27_695 0 n54 ns695 0 0.00198985904498
Gc27_696 0 n54 ns696 0 0.000527042200039
Gc27_697 0 n54 ns697 0 -0.000172847080775
Gc27_698 0 n54 ns698 0 0.000359628962071
Gc27_699 0 n54 ns699 0 -0.000505977954372
Gc27_700 0 n54 ns700 0 0.00127995462693
Gc27_701 0 n54 ns701 0 -0.000949736842997
Gc27_702 0 n54 ns702 0 -0.00043739176602
Gc27_703 0 n54 ns703 0 -0.000288376738046
Gc27_704 0 n54 ns704 0 0.000400497249259
Gc27_705 0 n54 ns705 0 0.000292710425384
Gc27_706 0 n54 ns706 0 -0.00169799178494
Gc27_707 0 n54 ns707 0 0.000109900292655
Gc27_708 0 n54 ns708 0 0.000874302621147
Gc27_709 0 n54 ns709 0 0.0022131643833
Gc27_710 0 n54 ns710 0 0.00129308674748
Gc27_711 0 n54 ns711 0 -0.00195105294224
Gc27_712 0 n54 ns712 0 0.000277359682274
Gc27_713 0 n54 ns713 0 0.000806592733215
Gc27_714 0 n54 ns714 0 0.00011973616244
Gc27_715 0 n54 ns715 0 5.1304687272e-05
Gc27_716 0 n54 ns716 0 0.00254967969249
Gc27_717 0 n54 ns717 0 0.000143458524445
Gc27_718 0 n54 ns718 0 0.0249871922609
Gc27_719 0 n54 ns719 0 -0.0244548661408
Gc27_720 0 n54 ns720 0 0.00661558220553
Gc27_721 0 n54 ns721 0 -3.41632859739e-06
Gc27_722 0 n54 ns722 0 2.82033997083e-05
Gc27_723 0 n54 ns723 0 -0.00475174271207
Gc27_724 0 n54 ns724 0 -0.000715104202338
Gc27_725 0 n54 ns725 0 -0.00363000775101
Gc27_726 0 n54 ns726 0 0.000144737497462
Gc27_727 0 n54 ns727 0 -0.000994361955678
Gc27_728 0 n54 ns728 0 -2.45901992545e-05
Gc27_729 0 n54 ns729 0 0.000291155270496
Gc27_730 0 n54 ns730 0 -9.09467091999e-05
Gc27_731 0 n54 ns731 0 -1.4941527964e-05
Gc27_732 0 n54 ns732 0 -0.00235246710892
Gc27_733 0 n54 ns733 0 0.001987796625
Gc27_734 0 n54 ns734 0 0.00104955432323
Gc27_735 0 n54 ns735 0 -0.000188169869698
Gc27_736 0 n54 ns736 0 0.000316027338536
Gc27_737 0 n54 ns737 0 -0.000564952048284
Gc27_738 0 n54 ns738 0 -2.49126079093e-05
Gc27_739 0 n54 ns739 0 0.000952548655447
Gc27_740 0 n54 ns740 0 0.000302206293222
Gc27_741 0 n54 ns741 0 0.000344464931767
Gc27_742 0 n54 ns742 0 0.000585654089396
Gc27_743 0 n54 ns743 0 0.000196513581548
Gc27_744 0 n54 ns744 0 0.000899311047956
Gc27_745 0 n54 ns745 0 0.00151976563517
Gc27_746 0 n54 ns746 0 0.00119887536739
Gc27_747 0 n54 ns747 0 0.00288796400399
Gc27_748 0 n54 ns748 0 0.00134921390988
Gc27_749 0 n54 ns749 0 -0.00220366130339
Gc27_750 0 n54 ns750 0 0.00183728460946
Gc27_751 0 n54 ns751 0 -0.00158118014708
Gc27_752 0 n54 ns752 0 0.00186127545903
Gc27_753 0 n54 ns753 0 0.00145616804374
Gc27_754 0 n54 ns754 0 0.00306136588813
Gc27_755 0 n54 ns755 0 3.15845184896e-05
Gc27_756 0 n54 ns756 0 -0.016677275924
Gc27_757 0 n54 ns757 0 0.0190092965319
Gc27_758 0 n54 ns758 0 0.00690039627582
Gc27_759 0 n54 ns759 0 1.52284375109e-07
Gc27_760 0 n54 ns760 0 1.75608083954e-05
Gc27_761 0 n54 ns761 0 -0.00189918453057
Gc27_762 0 n54 ns762 0 -0.00054574866868
Gc27_763 0 n54 ns763 0 0.00224211630425
Gc27_764 0 n54 ns764 0 0.000632461711054
Gc27_765 0 n54 ns765 0 -0.000294794451002
Gc27_766 0 n54 ns766 0 0.000721431470078
Gc27_767 0 n54 ns767 0 0.000382952524995
Gc27_768 0 n54 ns768 0 -0.000150697911869
Gc27_769 0 n54 ns769 0 -6.63811238685e-05
Gc27_770 0 n54 ns770 0 -0.00136799944479
Gc27_771 0 n54 ns771 0 -0.000611680215605
Gc27_772 0 n54 ns772 0 0.000991976797112
Gc27_773 0 n54 ns773 0 -0.000258244456494
Gc27_774 0 n54 ns774 0 0.000196412008281
Gc27_775 0 n54 ns775 0 -0.000532113503744
Gc27_776 0 n54 ns776 0 -0.00115603786901
Gc27_777 0 n54 ns777 0 -0.00194987851911
Gc27_778 0 n54 ns778 0 -0.000423308375674
Gc27_779 0 n54 ns779 0 0.000309622763169
Gc27_780 0 n54 ns780 0 0.000395348912001
Gc27_781 0 n54 ns781 0 0.000181798724351
Gc27_782 0 n54 ns782 0 -0.00377363021709
Gc27_783 0 n54 ns783 0 0.00146982215515
Gc27_784 0 n54 ns784 0 0.000833630184379
Gc27_785 0 n54 ns785 0 0.0011290207934
Gc27_786 0 n54 ns786 0 0.000550449930246
Gc27_787 0 n54 ns787 0 -0.00151085920942
Gc27_788 0 n54 ns788 0 -0.0021647326859
Gc27_789 0 n54 ns789 0 0.00162021554004
Gc27_790 0 n54 ns790 0 -0.0016940440797
Gc27_791 0 n54 ns791 0 0.000434320618678
Gc27_792 0 n54 ns792 0 0.00200248347317
Gc27_793 0 n54 ns793 0 2.2796712628e-05
Gc27_794 0 n54 ns794 0 0.0415544566191
Gc27_795 0 n54 ns795 0 -0.0445347671707
Gc27_796 0 n54 ns796 0 0.00449740449007
Gc27_797 0 n54 ns797 0 3.08407179305e-06
Gc27_798 0 n54 ns798 0 4.19265741007e-06
Gc27_799 0 n54 ns799 0 -0.00115055753647
Gc27_800 0 n54 ns800 0 0.00217802345338
Gc27_801 0 n54 ns801 0 -0.0046699510012
Gc27_802 0 n54 ns802 0 -3.02594972605e-05
Gc27_803 0 n54 ns803 0 -0.000276620596807
Gc27_804 0 n54 ns804 0 0.000104298375199
Gc27_805 0 n54 ns805 0 -0.000361192354733
Gc27_806 0 n54 ns806 0 -2.03425701845e-05
Gc27_807 0 n54 ns807 0 2.0847346902e-05
Gc27_808 0 n54 ns808 0 -0.00102724946134
Gc27_809 0 n54 ns809 0 0.00153965459262
Gc27_810 0 n54 ns810 0 -6.29844646383e-05
Gc27_811 0 n54 ns811 0 -0.00037539314922
Gc27_812 0 n54 ns812 0 -3.60032014431e-05
Gc27_813 0 n54 ns813 0 -0.000319324608234
Gc27_814 0 n54 ns814 0 -0.000471304776622
Gc27_815 0 n54 ns815 0 0.00176471914684
Gc27_816 0 n54 ns816 0 0.000131570066709
Gc27_817 0 n54 ns817 0 -0.000169588815755
Gc27_818 0 n54 ns818 0 0.000324120500282
Gc27_819 0 n54 ns819 0 -0.000100464316657
Gc27_820 0 n54 ns820 0 0.00200449154909
Gc27_821 0 n54 ns821 0 0.00286761587435
Gc27_822 0 n54 ns822 0 0.000504656181863
Gc27_823 0 n54 ns823 0 0.000253476752724
Gc27_824 0 n54 ns824 0 -0.000124064917418
Gc27_825 0 n54 ns825 0 -0.00105449343342
Gc27_826 0 n54 ns826 0 0.00362665226398
Gc27_827 0 n54 ns827 0 0.000811076009202
Gc27_828 0 n54 ns828 0 -0.00134026177307
Gc27_829 0 n54 ns829 0 0.000878109257633
Gc27_830 0 n54 ns830 0 0.00105059333256
Gc27_831 0 n54 ns831 0 -0.000531819639522
Gc27_832 0 n54 ns832 0 0.045150239383
Gc27_833 0 n54 ns833 0 -0.0408894782498
Gc27_834 0 n54 ns834 0 0.00209643556749
Gc27_835 0 n54 ns835 0 -5.36333947946e-06
Gc27_836 0 n54 ns836 0 -1.99961635432e-05
Gc27_837 0 n54 ns837 0 -0.000697956639842
Gc27_838 0 n54 ns838 0 0.00163917255939
Gc27_839 0 n54 ns839 0 -0.00450243786898
Gc27_840 0 n54 ns840 0 -0.000327706179876
Gc27_841 0 n54 ns841 0 -0.000133876728198
Gc27_842 0 n54 ns842 0 -0.000345387091561
Gc27_843 0 n54 ns843 0 4.97240769922e-05
Gc27_844 0 n54 ns844 0 -1.10651161297e-05
Gc27_845 0 n54 ns845 0 3.17736219371e-05
Gc27_846 0 n54 ns846 0 0.000822568357655
Gc27_847 0 n54 ns847 0 0.00151995925947
Gc27_848 0 n54 ns848 0 -0.000124575972812
Gc27_849 0 n54 ns849 0 2.47356087254e-05
Gc27_850 0 n54 ns850 0 -0.000137746345618
Gc27_851 0 n54 ns851 0 -0.00020162047874
Gc27_852 0 n54 ns852 0 0.00107660659046
Gc27_853 0 n54 ns853 0 0.00033355528002
Gc27_854 0 n54 ns854 0 -0.000319010656759
Gc27_855 0 n54 ns855 0 6.70290051147e-05
Gc27_856 0 n54 ns856 0 0.000166951178975
Gc27_857 0 n54 ns857 0 -0.000129582940991
Gc27_858 0 n54 ns858 0 0.00132799773934
Gc27_859 0 n54 ns859 0 0.00033134284165
Gc27_860 0 n54 ns860 0 0.000557327045076
Gc27_861 0 n54 ns861 0 0.000595873457252
Gc27_862 0 n54 ns862 0 -0.000336752900422
Gc27_863 0 n54 ns863 0 -0.000814350268327
Gc27_864 0 n54 ns864 0 0.00127666452521
Gc27_865 0 n54 ns865 0 0.000181177157714
Gc27_866 0 n54 ns866 0 7.59372855011e-05
Gc27_867 0 n54 ns867 0 0.000983318750933
Gc27_868 0 n54 ns868 0 0.000453536581971
Gc27_869 0 n54 ns869 0 -0.000686225378234
Gc27_870 0 n54 ns870 0 0.0286854033176
Gc27_871 0 n54 ns871 0 -0.0254281553508
Gc27_872 0 n54 ns872 0 0.00111177467889
Gc27_873 0 n54 ns873 0 -6.81272134315e-06
Gc27_874 0 n54 ns874 0 -3.07855418844e-05
Gc27_875 0 n54 ns875 0 0.000110147887587
Gc27_876 0 n54 ns876 0 -0.000300896914547
Gc27_877 0 n54 ns877 0 -8.59129395752e-06
Gc27_878 0 n54 ns878 0 -7.18866702672e-05
Gc27_879 0 n54 ns879 0 4.88912076202e-05
Gc27_880 0 n54 ns880 0 -2.05947250511e-05
Gc27_881 0 n54 ns881 0 3.5602267072e-05
Gc27_882 0 n54 ns882 0 9.92345559381e-06
Gc27_883 0 n54 ns883 0 3.04407352979e-05
Gc27_884 0 n54 ns884 0 9.0809209828e-06
Gc27_885 0 n54 ns885 0 0.000340599088845
Gc27_886 0 n54 ns886 0 0.000333547421188
Gc27_887 0 n54 ns887 0 -0.000198481174249
Gc27_888 0 n54 ns888 0 -0.000209476019042
Gc27_889 0 n54 ns889 0 -8.92164440657e-05
Gc27_890 0 n54 ns890 0 -0.000480403039451
Gc27_891 0 n54 ns891 0 -0.000478043441859
Gc27_892 0 n54 ns892 0 0.000139752507236
Gc27_893 0 n54 ns893 0 0.000626384587232
Gc27_894 0 n54 ns894 0 0.000128445747801
Gc27_895 0 n54 ns895 0 -0.000139067478453
Gc27_896 0 n54 ns896 0 -0.000193409400508
Gc27_897 0 n54 ns897 0 0.000674898256501
Gc27_898 0 n54 ns898 0 0.000966611048567
Gc27_899 0 n54 ns899 0 0.000326711276433
Gc27_900 0 n54 ns900 0 -0.000551972246972
Gc27_901 0 n54 ns901 0 -0.000518908814065
Gc27_902 0 n54 ns902 0 -0.000480505798342
Gc27_903 0 n54 ns903 0 0.000404838462974
Gc27_904 0 n54 ns904 0 0.000505713639447
Gc27_905 0 n54 ns905 0 0.000770667671935
Gc27_906 0 n54 ns906 0 0.000240339545695
Gc27_907 0 n54 ns907 0 -0.000528465253693
Gc27_908 0 n54 ns908 0 0.0127068425012
Gc27_909 0 n54 ns909 0 -0.0116434447244
Gc27_910 0 n54 ns910 0 0.000549050480355
Gc27_911 0 n54 ns911 0 -3.4501107808e-06
Gc27_912 0 n54 ns912 0 -3.24998022782e-05
Gc27_913 0 n54 ns913 0 0.000171739831491
Gc27_914 0 n54 ns914 0 -0.000740696073489
Gc27_915 0 n54 ns915 0 0.000374069862925
Gc27_916 0 n54 ns916 0 9.09258199464e-05
Gc27_917 0 n54 ns917 0 -0.000111032738225
Gc27_918 0 n54 ns918 0 9.1192855505e-05
Gc27_919 0 n54 ns919 0 4.70369852476e-06
Gc27_920 0 n54 ns920 0 1.44728957414e-05
Gc27_921 0 n54 ns921 0 -5.56456941495e-05
Gc27_922 0 n54 ns922 0 -0.000915309725057
Gc27_923 0 n54 ns923 0 0.000466493003514
Gc27_924 0 n54 ns924 0 0.000394870681536
Gc27_925 0 n54 ns925 0 -0.000434883915965
Gc27_926 0 n54 ns926 0 -0.000143358012042
Gc27_927 0 n54 ns927 0 -3.91150958394e-05
Gc27_928 0 n54 ns928 0 -0.000925511837538
Gc27_929 0 n54 ns929 0 0.000453070817707
Gc27_930 0 n54 ns930 0 0.000590247335075
Gc27_931 0 n54 ns931 0 0.000325730275329
Gc27_932 0 n54 ns932 0 6.58056874397e-05
Gc27_933 0 n54 ns933 0 -0.000156489650326
Gc27_934 0 n54 ns934 0 0.00035643227659
Gc27_935 0 n54 ns935 0 0.00116246016949
Gc27_936 0 n54 ns936 0 0.000804357977994
Gc27_937 0 n54 ns937 0 -0.000239232598739
Gc27_938 0 n54 ns938 0 -0.000537088223817
Gc27_939 0 n54 ns939 0 -0.000143328810899
Gc27_940 0 n54 ns940 0 0.000476360131428
Gc27_941 0 n54 ns941 0 0.00070540549815
Gc27_942 0 n54 ns942 0 0.000296139638011
Gc27_943 0 n54 ns943 0 8.66239905158e-05
Gc27_944 0 n54 ns944 0 1.11280363417e-06
Gc27_945 0 n54 ns945 0 -0.000261184787382
Gc27_946 0 n54 ns946 0 0.00951327391478
Gc27_947 0 n54 ns947 0 -0.00833560126792
Gc27_948 0 n54 ns948 0 0.000332812784664
Gc27_949 0 n54 ns949 0 -7.35925759328e-06
Gc27_950 0 n54 ns950 0 -2.68066610406e-05
Gc27_951 0 n54 ns951 0 -0.0022435978003
Gc27_952 0 n54 ns952 0 -0.00120797468923
Gc27_953 0 n54 ns953 0 0.00286644713776
Gc27_954 0 n54 ns954 0 0.000366892410596
Gc27_955 0 n54 ns955 0 -0.000585467983733
Gc27_956 0 n54 ns956 0 0.00033168167199
Gc27_957 0 n54 ns957 0 0.000380088086402
Gc27_958 0 n54 ns958 0 -0.000175983262214
Gc27_959 0 n54 ns959 0 -5.75898026981e-05
Gc27_960 0 n54 ns960 0 -0.000663619020981
Gc27_961 0 n54 ns961 0 0.000206864874551
Gc27_962 0 n54 ns962 0 0.000515395759134
Gc27_963 0 n54 ns963 0 0.000122170079603
Gc27_964 0 n54 ns964 0 0.000492071890871
Gc27_965 0 n54 ns965 0 -0.000436629450174
Gc27_966 0 n54 ns966 0 0.00117023325149
Gc27_967 0 n54 ns967 0 -0.00167138218574
Gc27_968 0 n54 ns968 0 -0.000787838038382
Gc27_969 0 n54 ns969 0 -0.000536624932865
Gc27_970 0 n54 ns970 0 0.000288072308754
Gc27_971 0 n54 ns971 0 0.000355402182831
Gc27_972 0 n54 ns972 0 -0.00353891881951
Gc27_973 0 n54 ns973 0 -0.001856369833
Gc27_974 0 n54 ns974 0 -3.72335073478e-05
Gc27_975 0 n54 ns975 0 0.00156731754644
Gc27_976 0 n54 ns976 0 0.00135508734789
Gc27_977 0 n54 ns977 0 -0.0014174567398
Gc27_978 0 n54 ns978 0 -0.00526959822292
Gc27_979 0 n54 ns979 0 -0.001431464531
Gc27_980 0 n54 ns980 0 -0.0014889573815
Gc27_981 0 n54 ns981 0 0.000718907751762
Gc27_982 0 n54 ns982 0 0.0024935579206
Gc27_983 0 n54 ns983 0 0.00037778353592
Gc27_984 0 n54 ns984 0 0.0210709815082
Gc27_985 0 n54 ns985 0 -0.0286743467252
Gc27_986 0 n54 ns986 0 0.00552010083629
Gc27_987 0 n54 ns987 0 2.11899965594e-06
Gc27_988 0 n54 ns988 0 3.4062909012e-05
Gc27_989 0 n54 ns989 0 -0.00305682334283
Gc27_990 0 n54 ns990 0 0.000164734240505
Gc27_991 0 n54 ns991 0 -0.00140034547455
Gc27_992 0 n54 ns992 0 0.00023694319198
Gc27_993 0 n54 ns993 0 -0.000273318127233
Gc27_994 0 n54 ns994 0 0.000368081056495
Gc27_995 0 n54 ns995 0 -0.000125766176014
Gc27_996 0 n54 ns996 0 -0.000198324411462
Gc27_997 0 n54 ns997 0 -6.43680688595e-05
Gc27_998 0 n54 ns998 0 -0.00372301553068
Gc27_999 0 n54 ns999 0 0.00113904206627
Gc27_1000 0 n54 ns1000 0 0.00146146093526
Gc27_1001 0 n54 ns1001 0 0.000205852465859
Gc27_1002 0 n54 ns1002 0 0.000514574788589
Gc27_1003 0 n54 ns1003 0 -0.000643889464044
Gc27_1004 0 n54 ns1004 0 0.00016689644683
Gc27_1005 0 n54 ns1005 0 0.000584617043561
Gc27_1006 0 n54 ns1006 0 8.72130174438e-05
Gc27_1007 0 n54 ns1007 0 0.000499721197
Gc27_1008 0 n54 ns1008 0 0.000634163304721
Gc27_1009 0 n54 ns1009 0 0.000302657952731
Gc27_1010 0 n54 ns1010 0 -2.65263717053e-05
Gc27_1011 0 n54 ns1011 0 0.000407160800024
Gc27_1012 0 n54 ns1012 0 0.00113392179527
Gc27_1013 0 n54 ns1013 0 0.00327413001171
Gc27_1014 0 n54 ns1014 0 0.00155567081409
Gc27_1015 0 n54 ns1015 0 -0.0023346105305
Gc27_1016 0 n54 ns1016 0 -0.00122242508834
Gc27_1017 0 n54 ns1017 0 -0.00288494147574
Gc27_1018 0 n54 ns1018 0 0.00208633406539
Gc27_1019 0 n54 ns1019 0 0.00200733271797
Gc27_1020 0 n54 ns1020 0 0.00329524196848
Gc27_1021 0 n54 ns1021 0 3.65277047705e-05
Gc27_1022 0 n54 ns1022 0 -0.026677897112
Gc27_1023 0 n54 ns1023 0 0.0257364395305
Gc27_1024 0 n54 ns1024 0 0.00689152873164
Gc27_1025 0 n54 ns1025 0 1.12757585158e-05
Gc27_1026 0 n54 ns1026 0 3.08287282021e-05
Gc27_1027 0 n54 ns1027 0 -0.00190623857525
Gc27_1028 0 n54 ns1028 0 -0.0023035411108
Gc27_1029 0 n54 ns1029 0 0.0051784988277
Gc27_1030 0 n54 ns1030 0 0.00041522427517
Gc27_1031 0 n54 ns1031 0 -0.000422863817717
Gc27_1032 0 n54 ns1032 0 0.000605155274567
Gc27_1033 0 n54 ns1033 0 0.000434412315587
Gc27_1034 0 n54 ns1034 0 -0.000152881751121
Gc27_1035 0 n54 ns1035 0 -8.93369022276e-05
Gc27_1036 0 n54 ns1036 0 -0.00174005301922
Gc27_1037 0 n54 ns1037 0 -0.000349515815257
Gc27_1038 0 n54 ns1038 0 0.00128863418965
Gc27_1039 0 n54 ns1039 0 1.87562368062e-05
Gc27_1040 0 n54 ns1040 0 0.000342507682161
Gc27_1041 0 n54 ns1041 0 -0.000569679335406
Gc27_1042 0 n54 ns1042 0 -0.000103130673497
Gc27_1043 0 n54 ns1043 0 -0.00222175111289
Gc27_1044 0 n54 ns1044 0 -0.00045623432542
Gc27_1045 0 n54 ns1045 0 0.000264258269862
Gc27_1046 0 n54 ns1046 0 0.000428928472736
Gc27_1047 0 n54 ns1047 0 0.000245274522574
Gc27_1048 0 n54 ns1048 0 -0.00419884376352
Gc27_1049 0 n54 ns1049 0 -0.000864954104378
Gc27_1050 0 n54 ns1050 0 0.000874972548933
Gc27_1051 0 n54 ns1051 0 0.00165679051042
Gc27_1052 0 n54 ns1052 0 0.000858009147131
Gc27_1053 0 n54 ns1053 0 -0.00170174507764
Gc27_1054 0 n54 ns1054 0 -0.00575761205095
Gc27_1055 0 n54 ns1055 0 -0.00119333241632
Gc27_1056 0 n54 ns1056 0 -0.00119347831957
Gc27_1057 0 n54 ns1057 0 0.000889438340707
Gc27_1058 0 n54 ns1058 0 0.00246498005023
Gc27_1059 0 n54 ns1059 0 0.000241359364794
Gc27_1060 0 n54 ns1060 0 0.0188078544222
Gc27_1061 0 n54 ns1061 0 -0.0268114861291
Gc27_1062 0 n54 ns1062 0 0.00543810512717
Gc27_1063 0 n54 ns1063 0 2.80146731503e-06
Gc27_1064 0 n54 ns1064 0 1.57672286359e-05
Gc27_1065 0 n54 ns1065 0 -0.00134286486887
Gc27_1066 0 n54 ns1066 0 0.000764735048743
Gc27_1067 0 n54 ns1067 0 -0.00184705452543
Gc27_1068 0 n54 ns1068 0 0.000412217113361
Gc27_1069 0 n54 ns1069 0 -0.000478567207859
Gc27_1070 0 n54 ns1070 0 0.000439748488303
Gc27_1071 0 n54 ns1071 0 -0.000212252938626
Gc27_1072 0 n54 ns1072 0 -5.97912892037e-05
Gc27_1073 0 n54 ns1073 0 -1.23371394673e-06
Gc27_1074 0 n54 ns1074 0 -0.00199889873595
Gc27_1075 0 n54 ns1075 0 0.000666168328714
Gc27_1076 0 n54 ns1076 0 0.000376332817677
Gc27_1077 0 n54 ns1077 0 -0.000486550299638
Gc27_1078 0 n54 ns1078 0 5.89698096623e-05
Gc27_1079 0 n54 ns1079 0 -0.000423716834352
Gc27_1080 0 n54 ns1080 0 -0.0016422103562
Gc27_1081 0 n54 ns1081 0 0.00102037787968
Gc27_1082 0 n54 ns1082 0 0.00017281788439
Gc27_1083 0 n54 ns1083 0 0.000103173841455
Gc27_1084 0 n54 ns1084 0 0.000422901126423
Gc27_1085 0 n54 ns1085 0 -1.32803643427e-05
Gc27_1086 0 n54 ns1086 0 0.000368825669326
Gc27_1087 0 n54 ns1087 0 0.00372150321074
Gc27_1088 0 n54 ns1088 0 0.000736449166763
Gc27_1089 0 n54 ns1089 0 0.000391709398955
Gc27_1090 0 n54 ns1090 0 2.31809960591e-05
Gc27_1091 0 n54 ns1091 0 -0.00126787613958
Gc27_1092 0 n54 ns1092 0 0.00276342926061
Gc27_1093 0 n54 ns1093 0 0.00176017585703
Gc27_1094 0 n54 ns1094 0 -0.00161217230408
Gc27_1095 0 n54 ns1095 0 0.000691005956952
Gc27_1096 0 n54 ns1096 0 0.00136319579844
Gc27_1097 0 n54 ns1097 0 -0.000431652746029
Gc27_1098 0 n54 ns1098 0 0.048156716892
Gc27_1099 0 n54 ns1099 0 -0.0451703007025
Gc27_1100 0 n54 ns1100 0 0.0027595598857
Gc27_1101 0 n54 ns1101 0 -1.9333455747e-06
Gc27_1102 0 n54 ns1102 0 -9.6525093992e-06
Gc27_1103 0 n54 ns1103 0 -0.000959476119213
Gc27_1104 0 n54 ns1104 0 0.00227245043151
Gc27_1105 0 n54 ns1105 0 -0.00576394649839
Gc27_1106 0 n54 ns1106 0 -0.00042909373566
Gc27_1107 0 n54 ns1107 0 -0.000222294471505
Gc27_1108 0 n54 ns1108 0 -0.00036112949613
Gc27_1109 0 n54 ns1109 0 -6.84815822658e-05
Gc27_1110 0 n54 ns1110 0 -3.84667551588e-06
Gc27_1111 0 n54 ns1111 0 2.60980866021e-05
Gc27_1112 0 n54 ns1112 0 0.000768940465534
Gc27_1113 0 n54 ns1113 0 0.00219796455715
Gc27_1114 0 n54 ns1114 0 -0.000354235305631
Gc27_1115 0 n54 ns1115 0 -0.000133350118406
Gc27_1116 0 n54 ns1116 0 -0.000127820874326
Gc27_1117 0 n54 ns1117 0 -0.000235028706943
Gc27_1118 0 n54 ns1118 0 0.0013113293305
Gc27_1119 0 n54 ns1119 0 0.00115937814649
Gc27_1120 0 n54 ns1120 0 -0.000281429867603
Gc27_1121 0 n54 ns1121 0 -0.000281587009445
Gc27_1122 0 n54 ns1122 0 0.000188587664898
Gc27_1123 0 n54 ns1123 0 -0.000146471567185
Gc27_1124 0 n54 ns1124 0 0.00220929427873
Gc27_1125 0 n54 ns1125 0 0.000672788350884
Gc27_1126 0 n54 ns1126 0 0.000362507615565
Gc27_1127 0 n54 ns1127 0 0.00049600534375
Gc27_1128 0 n54 ns1128 0 -0.000243352746139
Gc27_1129 0 n54 ns1129 0 -0.000884619586407
Gc27_1130 0 n54 ns1130 0 0.00232316150764
Gc27_1131 0 n54 ns1131 0 -7.16067189202e-05
Gc27_1132 0 n54 ns1132 0 -0.000410471060832
Gc27_1133 0 n54 ns1133 0 0.00108093405591
Gc27_1134 0 n54 ns1134 0 0.000646288175421
Gc27_1135 0 n54 ns1135 0 -0.000671841604379
Gc27_1136 0 n54 ns1136 0 0.035087428049
Gc27_1137 0 n54 ns1137 0 -0.0310983731326
Gc27_1138 0 n54 ns1138 0 0.00140387558003
Gc27_1139 0 n54 ns1139 0 -7.0948585129e-06
Gc27_1140 0 n54 ns1140 0 -2.52302518805e-05
Gc27_1141 0 n54 ns1141 0 -0.000170523428475
Gc27_1142 0 n54 ns1142 0 4.3958416207e-05
Gc27_1143 0 n54 ns1143 0 -0.000710478314248
Gc27_1144 0 n54 ns1144 0 -0.000156329395615
Gc27_1145 0 n54 ns1145 0 7.80076329043e-05
Gc27_1146 0 n54 ns1146 0 -7.92820556593e-05
Gc27_1147 0 n54 ns1147 0 0.000115038651355
Gc27_1148 0 n54 ns1148 0 2.2790140659e-06
Gc27_1149 0 n54 ns1149 0 3.47538970431e-05
Gc27_1150 0 n54 ns1150 0 0.000377943508513
Gc27_1151 0 n54 ns1151 0 9.80183563906e-05
Gc27_1152 0 n54 ns1152 0 0.000245292222554
Gc27_1153 0 n54 ns1153 0 0.000142224561799
Gc27_1154 0 n54 ns1154 0 -0.000135937650065
Gc27_1155 0 n54 ns1155 0 -0.0001357736392
Gc27_1156 0 n54 ns1156 0 -7.28055457717e-05
Gc27_1157 0 n54 ns1157 0 -0.000731143989867
Gc27_1158 0 n54 ns1158 0 -0.000177525343035
Gc27_1159 0 n54 ns1159 0 0.000660080710508
Gc27_1160 0 n54 ns1160 0 0.000171647284755
Gc27_1161 0 n54 ns1161 0 -9.92385095536e-05
Gc27_1162 0 n54 ns1162 0 -0.000160661142818
Gc27_1163 0 n54 ns1163 0 0.000471021553768
Gc27_1164 0 n54 ns1164 0 0.00089562590449
Gc27_1165 0 n54 ns1165 0 0.000543720863843
Gc27_1166 0 n54 ns1166 0 -0.000489284067615
Gc27_1167 0 n54 ns1167 0 -0.000664755992298
Gc27_1168 0 n54 ns1168 0 -0.00044088221804
Gc27_1169 0 n54 ns1169 0 0.00031549136518
Gc27_1170 0 n54 ns1170 0 0.000481018317113
Gc27_1171 0 n54 ns1171 0 0.000899008193652
Gc27_1172 0 n54 ns1172 0 0.00029571109942
Gc27_1173 0 n54 ns1173 0 -0.000595061587342
Gc27_1174 0 n54 ns1174 0 0.0146712241354
Gc27_1175 0 n54 ns1175 0 -0.0134184671805
Gc27_1176 0 n54 ns1176 0 0.000639603216413
Gc27_1177 0 n54 ns1177 0 -4.01223506513e-06
Gc27_1178 0 n54 ns1178 0 -3.28540872927e-05
Gc27_1179 0 n54 ns1179 0 0.000362630005758
Gc27_1180 0 n54 ns1180 0 -0.00101527356573
Gc27_1181 0 n54 ns1181 0 0.000949375633254
Gc27_1182 0 n54 ns1182 0 9.15963468094e-05
Gc27_1183 0 n54 ns1183 0 -8.86509197334e-05
Gc27_1184 0 n54 ns1184 0 8.54232085987e-05
Gc27_1185 0 n54 ns1185 0 -5.252346314e-05
Gc27_1186 0 n54 ns1186 0 1.0519169533e-05
Gc27_1187 0 n54 ns1187 0 -2.07193420689e-05
Gc27_1188 0 n54 ns1188 0 -0.000976649403967
Gc27_1189 0 n54 ns1189 0 0.000401985280808
Gc27_1190 0 n54 ns1190 0 0.000485458007292
Gc27_1191 0 n54 ns1191 0 -0.000416636210754
Gc27_1192 0 n54 ns1192 0 -0.000172670379529
Gc27_1193 0 n54 ns1193 0 -6.46126410104e-05
Gc27_1194 0 n54 ns1194 0 -0.00111387067768
Gc27_1195 0 n54 ns1195 0 0.000203897220904
Gc27_1196 0 n54 ns1196 0 0.000570196326377
Gc27_1197 0 n54 ns1197 0 0.000536661945647
Gc27_1198 0 n54 ns1198 0 0.000109559213094
Gc27_1199 0 n54 ns1199 0 -0.00016847544983
Gc27_1200 0 n54 ns1200 0 0.000132617528686
Gc27_1201 0 n54 ns1201 0 0.00128199986029
Gc27_1202 0 n54 ns1202 0 0.000972433839074
Gc27_1203 0 n54 ns1203 0 -0.000125298337659
Gc27_1204 0 n54 ns1204 0 -0.000614966666979
Gc27_1205 0 n54 ns1205 0 -0.000254539408718
Gc27_1206 0 n54 ns1206 0 0.000110083680243
Gc27_1207 0 n54 ns1207 0 0.000735144085125
Gc27_1208 0 n54 ns1208 0 0.000410208792605
Gc27_1209 0 n54 ns1209 0 0.000277542934879
Gc27_1210 0 n54 ns1210 0 5.45724405538e-05
Gc27_1211 0 n54 ns1211 0 -0.000352683344168
Gc27_1212 0 n54 ns1212 0 0.0100260497895
Gc27_1213 0 n54 ns1213 0 -0.00899655581298
Gc27_1214 0 n54 ns1214 0 0.000388594031466
Gc27_1215 0 n54 ns1215 0 -3.9642262191e-06
Gc27_1216 0 n54 ns1216 0 -3.03838834745e-05
Gd27_1 0 n54 ni1 0 0.000566609582286
Gd27_2 0 n54 ni2 0 -5.90837364408e-05
Gd27_3 0 n54 ni3 0 -0.00158025475566
Gd27_4 0 n54 ni4 0 -0.00323033585973
Gd27_5 0 n54 ni5 0 -0.000183339327662
Gd27_6 0 n54 ni6 0 0.000236435833749
Gd27_7 0 n54 ni7 0 0.000286501903108
Gd27_8 0 n54 ni8 0 0.000244706903749
Gd27_9 0 n54 ni9 0 -8.31926297263e-05
Gd27_10 0 n54 ni10 0 -0.000301588961175
Gd27_11 0 n54 ni11 0 -0.0067181180134
Gd27_12 0 n54 ni12 0 -0.000464335958693
Gd27_13 0 n54 ni13 0 0.000574403018716
Gd27_14 0 n54 ni14 0 0.00022589812583
Gd27_15 0 n54 ni15 0 0.000249925788124
Gd27_16 0 n54 ni16 0 -2.41489300612e-05
Gd27_17 0 n54 ni17 0 -0.000240550146853
Gd27_18 0 n54 ni18 0 -0.000625187479541
Gd27_19 0 n54 ni19 0 -0.00267605774035
Gd27_20 0 n54 ni20 0 -0.000869386292741
Gd27_21 0 n54 ni21 0 -0.001159368233
Gd27_22 0 n54 ni22 0 9.94965111979e-05
Gd27_23 0 n54 ni23 0 7.42770184258e-05
Gd27_24 0 n54 ni24 0 3.055882835e-05
Gd27_25 0 n54 ni25 0 -0.000102242199675
Gd27_26 0 n54 ni26 0 -0.00172287199156
Gd27_27 0 n54 ni27 0 0.000749808929277
Gd27_28 0 n54 ni28 0 -0.00177096873691
Gd27_29 0 n54 ni29 0 -0.000412987786551
Gd27_30 0 n54 ni30 0 0.000155693601596
Gd27_31 0 n54 ni31 0 -5.32854581871e-05
Gd27_32 0 n54 ni32 0 -6.35751038315e-05
Gc28_1 0 n56 ns1 0 -5.1589447268e-06
Gc28_2 0 n56 ns2 0 4.28400090191e-05
Gc28_3 0 n56 ns3 0 0.00514214920298
Gc28_4 0 n56 ns4 0 9.6245536191e-05
Gc28_5 0 n56 ns5 0 0.000164564827488
Gc28_6 0 n56 ns6 0 0.000373186629105
Gc28_7 0 n56 ns7 0 0.000129295696051
Gc28_8 0 n56 ns8 0 3.66578775336e-05
Gc28_9 0 n56 ns9 0 -7.06692867066e-06
Gc28_10 0 n56 ns10 0 -0.00139159659858
Gc28_11 0 n56 ns11 0 -0.00091966180773
Gc28_12 0 n56 ns12 0 0.000798876128992
Gc28_13 0 n56 ns13 0 -0.000299214003113
Gc28_14 0 n56 ns14 0 -3.93495574413e-05
Gc28_15 0 n56 ns15 0 0.000158507926457
Gc28_16 0 n56 ns16 0 0.00169812725333
Gc28_17 0 n56 ns17 0 -0.000608261618489
Gc28_18 0 n56 ns18 0 -0.00149878516697
Gc28_19 0 n56 ns19 0 -0.000438657874357
Gc28_20 0 n56 ns20 0 5.93689579061e-05
Gc28_21 0 n56 ns21 0 0.000207190407136
Gc28_22 0 n56 ns22 0 -0.00143973493131
Gc28_23 0 n56 ns23 0 -0.00177427754569
Gc28_24 0 n56 ns24 0 -0.000212883509312
Gc28_25 0 n56 ns25 0 -0.00114196559624
Gc28_26 0 n56 ns26 0 -0.000196320877348
Gc28_27 0 n56 ns27 0 0.00123760493388
Gc28_28 0 n56 ns28 0 -0.00545118289403
Gc28_29 0 n56 ns29 0 -0.00419784614072
Gc28_30 0 n56 ns30 0 -0.000665853513347
Gc28_31 0 n56 ns31 0 0.00319507812897
Gc28_32 0 n56 ns32 0 0.00142896611942
Gc28_33 0 n56 ns33 0 -0.000467446960647
Gc28_34 0 n56 ns34 0 -0.0333452917129
Gc28_35 0 n56 ns35 0 0.0281380919336
Gc28_36 0 n56 ns36 0 -0.00113530844295
Gc28_37 0 n56 ns37 0 -4.61426662997e-06
Gc28_38 0 n56 ns38 0 1.20770617218e-05
Gc28_39 0 n56 ns39 0 0.000379461488775
Gc28_40 0 n56 ns40 0 -0.000891091110124
Gc28_41 0 n56 ns41 0 0.0074686517177
Gc28_42 0 n56 ns42 0 0.000285448244885
Gc28_43 0 n56 ns43 0 -0.00013744286379
Gc28_44 0 n56 ns44 0 9.67374667564e-05
Gc28_45 0 n56 ns45 0 6.69353565768e-05
Gc28_46 0 n56 ns46 0 1.86268444552e-05
Gc28_47 0 n56 ns47 0 2.60299618256e-05
Gc28_48 0 n56 ns48 0 -0.00115568720833
Gc28_49 0 n56 ns49 0 -0.0012671289046
Gc28_50 0 n56 ns50 0 0.000603850927319
Gc28_51 0 n56 ns51 0 -0.000195051814071
Gc28_52 0 n56 ns52 0 -6.7763437525e-05
Gc28_53 0 n56 ns53 0 0.000294871871115
Gc28_54 0 n56 ns54 0 0.00111585156685
Gc28_55 0 n56 ns55 0 -0.000431987772393
Gc28_56 0 n56 ns56 0 -0.00136658752147
Gc28_57 0 n56 ns57 0 -0.000401672693
Gc28_58 0 n56 ns58 0 0.000157656673283
Gc28_59 0 n56 ns59 0 0.000190537653853
Gc28_60 0 n56 ns60 0 -0.00178658417653
Gc28_61 0 n56 ns61 0 -0.00227149101624
Gc28_62 0 n56 ns62 0 -0.000265312758788
Gc28_63 0 n56 ns63 0 -0.00108362710579
Gc28_64 0 n56 ns64 0 -0.000215101344837
Gc28_65 0 n56 ns65 0 0.00139942244024
Gc28_66 0 n56 ns66 0 -0.00642995825457
Gc28_67 0 n56 ns67 0 -0.00476849535153
Gc28_68 0 n56 ns68 0 -0.00102339004887
Gc28_69 0 n56 ns69 0 0.00362350458191
Gc28_70 0 n56 ns70 0 0.00176004384449
Gc28_71 0 n56 ns71 0 -0.000470891445945
Gc28_72 0 n56 ns72 0 -0.0440154066629
Gc28_73 0 n56 ns73 0 0.0375253573499
Gc28_74 0 n56 ns74 0 -0.00159130190763
Gc28_75 0 n56 ns75 0 -8.54823270752e-06
Gc28_76 0 n56 ns76 0 1.01111743462e-05
Gc28_77 0 n56 ns77 0 0.000220904303343
Gc28_78 0 n56 ns78 0 -0.00152904537786
Gc28_79 0 n56 ns79 0 0.0116899655143
Gc28_80 0 n56 ns80 0 0.000162034904309
Gc28_81 0 n56 ns81 0 0.000351212043954
Gc28_82 0 n56 ns82 0 0.000514732610625
Gc28_83 0 n56 ns83 0 -0.000472171645899
Gc28_84 0 n56 ns84 0 -0.000154924036681
Gc28_85 0 n56 ns85 0 -2.53594608281e-05
Gc28_86 0 n56 ns86 0 0.00128785152073
Gc28_87 0 n56 ns87 0 -0.00361829689165
Gc28_88 0 n56 ns88 0 -0.00045810927071
Gc28_89 0 n56 ns89 0 0.000846629186792
Gc28_90 0 n56 ns90 0 -4.87314051607e-05
Gc28_91 0 n56 ns91 0 0.000605494945033
Gc28_92 0 n56 ns92 0 -0.00152716957555
Gc28_93 0 n56 ns93 0 -0.00198613949363
Gc28_94 0 n56 ns94 0 -0.000708088622908
Gc28_95 0 n56 ns95 0 0.00035644010286
Gc28_96 0 n56 ns96 0 0.000418833106509
Gc28_97 0 n56 ns97 0 0.000240905995073
Gc28_98 0 n56 ns98 0 -0.00177945589599
Gc28_99 0 n56 ns99 0 -0.00565601290206
Gc28_100 0 n56 ns100 0 -0.00202049304293
Gc28_101 0 n56 ns101 0 -0.000271278696047
Gc28_102 0 n56 ns102 0 0.000343048031732
Gc28_103 0 n56 ns103 0 0.00185538521621
Gc28_104 0 n56 ns104 0 -0.010692982106
Gc28_105 0 n56 ns105 0 -0.00615448950592
Gc28_106 0 n56 ns106 0 -0.00187787211238
Gc28_107 0 n56 ns107 0 0.00382834287635
Gc28_108 0 n56 ns108 0 0.00270024380406
Gc28_109 0 n56 ns109 0 -9.43971308479e-05
Gc28_110 0 n56 ns110 0 -0.0862790411441
Gc28_111 0 n56 ns111 0 0.0765030147223
Gc28_112 0 n56 ns112 0 -0.00418019255316
Gc28_113 0 n56 ns113 0 -9.58987617519e-06
Gc28_114 0 n56 ns114 0 1.24000784805e-05
Gc28_115 0 n56 ns115 0 -0.00257603787887
Gc28_116 0 n56 ns116 0 -0.00296268000347
Gc28_117 0 n56 ns117 0 0.00737413686369
Gc28_118 0 n56 ns118 0 0.000986041750399
Gc28_119 0 n56 ns119 0 -0.00171703949384
Gc28_120 0 n56 ns120 0 0.000636024431036
Gc28_121 0 n56 ns121 0 0.00199173406447
Gc28_122 0 n56 ns122 0 3.50021663731e-05
Gc28_123 0 n56 ns123 0 -0.000211413249749
Gc28_124 0 n56 ns124 0 0.000940570760142
Gc28_125 0 n56 ns125 0 -0.00157706802583
Gc28_126 0 n56 ns126 0 -0.00109030371263
Gc28_127 0 n56 ns127 0 0.000723434094543
Gc28_128 0 n56 ns128 0 -0.000135697967151
Gc28_129 0 n56 ns129 0 0.000547167182685
Gc28_130 0 n56 ns130 0 0.00127541082424
Gc28_131 0 n56 ns131 0 -0.00283933100981
Gc28_132 0 n56 ns132 0 -0.000618333079201
Gc28_133 0 n56 ns133 0 -0.000135882002163
Gc28_134 0 n56 ns134 0 0.000278454065748
Gc28_135 0 n56 ns135 0 0.000233868739725
Gc28_136 0 n56 ns136 0 0.00216025355677
Gc28_137 0 n56 ns137 0 -0.00232602026474
Gc28_138 0 n56 ns138 0 -0.00262129398448
Gc28_139 0 n56 ns139 0 -0.00183768430627
Gc28_140 0 n56 ns140 0 -0.000319326946905
Gc28_141 0 n56 ns141 0 0.00237877061307
Gc28_142 0 n56 ns142 0 -0.0119124444617
Gc28_143 0 n56 ns143 0 -0.00484953196895
Gc28_144 0 n56 ns144 0 0.000288014657217
Gc28_145 0 n56 ns145 0 0.0024484766052
Gc28_146 0 n56 ns146 0 0.00314128678752
Gc28_147 0 n56 ns147 0 0.000207772742475
Gc28_148 0 n56 ns148 0 -0.0367089876528
Gc28_149 0 n56 ns149 0 0.0384251990328
Gc28_150 0 n56 ns150 0 -0.00706845897894
Gc28_151 0 n56 ns151 0 -9.87091212135e-06
Gc28_152 0 n56 ns152 0 8.43981914179e-06
Gc28_153 0 n56 ns153 0 -0.00536485677658
Gc28_154 0 n56 ns154 0 -0.004374244548
Gc28_155 0 n56 ns155 0 0.00723999885481
Gc28_156 0 n56 ns156 0 0.00220493484315
Gc28_157 0 n56 ns157 0 -0.00189123805142
Gc28_158 0 n56 ns158 0 0.000821102724847
Gc28_159 0 n56 ns159 0 0.00298907442328
Gc28_160 0 n56 ns160 0 2.72405277821e-05
Gc28_161 0 n56 ns161 0 -0.000322545666949
Gc28_162 0 n56 ns162 0 -0.00121277598025
Gc28_163 0 n56 ns163 0 -0.00181401599185
Gc28_164 0 n56 ns164 0 -0.00059409380404
Gc28_165 0 n56 ns165 0 0.000829582570523
Gc28_166 0 n56 ns166 0 -7.84934072668e-05
Gc28_167 0 n56 ns167 0 0.000459512579852
Gc28_168 0 n56 ns168 0 0.00287332977764
Gc28_169 0 n56 ns169 0 -0.00186813298392
Gc28_170 0 n56 ns170 0 -0.000537351333266
Gc28_171 0 n56 ns171 0 -0.000904412496729
Gc28_172 0 n56 ns172 0 0.000116798238534
Gc28_173 0 n56 ns173 0 9.13496460786e-05
Gc28_174 0 n56 ns174 0 0.00268166494115
Gc28_175 0 n56 ns175 0 0.0012002609559
Gc28_176 0 n56 ns176 0 -0.00126433143266
Gc28_177 0 n56 ns177 0 -0.00246458977953
Gc28_178 0 n56 ns178 0 -0.00103780872494
Gc28_179 0 n56 ns179 0 0.00197963625777
Gc28_180 0 n56 ns180 0 -0.0138089473629
Gc28_181 0 n56 ns181 0 -0.00472974475261
Gc28_182 0 n56 ns182 0 0.00220444649832
Gc28_183 0 n56 ns183 0 0.00349518450883
Gc28_184 0 n56 ns184 0 0.00355957329551
Gc28_185 0 n56 ns185 0 0.000111737378405
Gc28_186 0 n56 ns186 0 0.0184637544633
Gc28_187 0 n56 ns187 0 -0.00921703848854
Gc28_188 0 n56 ns188 0 -0.00760325297434
Gc28_189 0 n56 ns189 0 -1.14434617888e-05
Gc28_190 0 n56 ns190 0 -7.94349462275e-06
Gc28_191 0 n56 ns191 0 0.000441792105701
Gc28_192 0 n56 ns192 0 -0.00126163337267
Gc28_193 0 n56 ns193 0 0.00975354542756
Gc28_194 0 n56 ns194 0 -0.000332235411776
Gc28_195 0 n56 ns195 0 0.000175397635834
Gc28_196 0 n56 ns196 0 0.000525106762524
Gc28_197 0 n56 ns197 0 -0.000534650471036
Gc28_198 0 n56 ns198 0 -7.98836371164e-05
Gc28_199 0 n56 ns199 0 2.34456141415e-05
Gc28_200 0 n56 ns200 0 0.00165362800542
Gc28_201 0 n56 ns201 0 -0.00214395747217
Gc28_202 0 n56 ns202 0 -0.00037106888055
Gc28_203 0 n56 ns203 0 0.000593896497692
Gc28_204 0 n56 ns204 0 -0.000146132622294
Gc28_205 0 n56 ns205 0 0.000421668007164
Gc28_206 0 n56 ns206 0 -0.00102458659102
Gc28_207 0 n56 ns207 0 -0.00217462713882
Gc28_208 0 n56 ns208 0 -0.000635000284106
Gc28_209 0 n56 ns209 0 0.000202676043514
Gc28_210 0 n56 ns210 0 0.000305071392455
Gc28_211 0 n56 ns211 0 0.000263543221866
Gc28_212 0 n56 ns212 0 -0.000384538147575
Gc28_213 0 n56 ns213 0 -0.00644474149281
Gc28_214 0 n56 ns214 0 -0.00284135466491
Gc28_215 0 n56 ns215 0 -0.000263730156953
Gc28_216 0 n56 ns216 0 0.000530847786895
Gc28_217 0 n56 ns217 0 0.00196071056231
Gc28_218 0 n56 ns218 0 -0.0105908149961
Gc28_219 0 n56 ns219 0 -0.0051178942965
Gc28_220 0 n56 ns220 0 -0.00175577723267
Gc28_221 0 n56 ns221 0 0.00277208205679
Gc28_222 0 n56 ns222 0 0.00264999555196
Gc28_223 0 n56 ns223 0 0.000129048670424
Gc28_224 0 n56 ns224 0 -0.0876173677886
Gc28_225 0 n56 ns225 0 0.0799134334088
Gc28_226 0 n56 ns226 0 -0.00515183059606
Gc28_227 0 n56 ns227 0 -8.33465575947e-06
Gc28_228 0 n56 ns228 0 -1.75130224951e-05
Gc28_229 0 n56 ns229 0 0.000714323393854
Gc28_230 0 n56 ns230 0 -0.0016918180602
Gc28_231 0 n56 ns231 0 0.00918700826538
Gc28_232 0 n56 ns232 0 0.000225139494611
Gc28_233 0 n56 ns233 0 0.00026573526636
Gc28_234 0 n56 ns234 0 0.000150420226175
Gc28_235 0 n56 ns235 0 0.000152082193887
Gc28_236 0 n56 ns236 0 -1.11038888673e-05
Gc28_237 0 n56 ns237 0 5.45212812729e-06
Gc28_238 0 n56 ns238 0 -0.000472565969744
Gc28_239 0 n56 ns239 0 -0.00336555851624
Gc28_240 0 n56 ns240 0 0.000251142786966
Gc28_241 0 n56 ns241 0 0.000823438543538
Gc28_242 0 n56 ns242 0 0.000192669155599
Gc28_243 0 n56 ns243 0 0.000381094380183
Gc28_244 0 n56 ns244 0 -0.000188695457907
Gc28_245 0 n56 ns245 0 -7.66425260143e-05
Gc28_246 0 n56 ns246 0 -0.000519454170608
Gc28_247 0 n56 ns247 0 -0.000232905417669
Gc28_248 0 n56 ns248 0 0.00018394624032
Gc28_249 0 n56 ns249 0 -1.22368701236e-05
Gc28_250 0 n56 ns250 0 -0.00205063710613
Gc28_251 0 n56 ns251 0 -0.00371130460561
Gc28_252 0 n56 ns252 0 -0.00106212066775
Gc28_253 0 n56 ns253 0 -0.000383392132291
Gc28_254 0 n56 ns254 0 0.000318848281661
Gc28_255 0 n56 ns255 0 0.00134250803666
Gc28_256 0 n56 ns256 0 -0.00742942271335
Gc28_257 0 n56 ns257 0 -0.00479229627539
Gc28_258 0 n56 ns258 0 -0.00115996297744
Gc28_259 0 n56 ns259 0 0.0037360990002
Gc28_260 0 n56 ns260 0 0.00192848753965
Gc28_261 0 n56 ns261 0 -0.000461312420721
Gc28_262 0 n56 ns262 0 -0.0532865491569
Gc28_263 0 n56 ns263 0 0.0457799951125
Gc28_264 0 n56 ns264 0 -0.00199491227832
Gc28_265 0 n56 ns265 0 -8.50704171528e-06
Gc28_266 0 n56 ns266 0 -2.36217409271e-05
Gc28_267 0 n56 ns267 0 0.000249961170827
Gc28_268 0 n56 ns268 0 -0.000376949745587
Gc28_269 0 n56 ns269 0 0.00434353847167
Gc28_270 0 n56 ns270 0 -0.00022798204109
Gc28_271 0 n56 ns271 0 0.000435275891724
Gc28_272 0 n56 ns272 0 0.000378917274543
Gc28_273 0 n56 ns273 0 7.89025338612e-05
Gc28_274 0 n56 ns274 0 2.32009840779e-05
Gc28_275 0 n56 ns275 0 -1.68721932878e-05
Gc28_276 0 n56 ns276 0 0.000263185578436
Gc28_277 0 n56 ns277 0 -0.00134555215938
Gc28_278 0 n56 ns278 0 -0.000247789355069
Gc28_279 0 n56 ns279 0 0.000144628657769
Gc28_280 0 n56 ns280 0 0.000212454882211
Gc28_281 0 n56 ns281 0 0.000295940426207
Gc28_282 0 n56 ns282 0 0.000623416487121
Gc28_283 0 n56 ns283 0 -0.00125112146057
Gc28_284 0 n56 ns284 0 -0.000869782619379
Gc28_285 0 n56 ns285 0 0.000429064014987
Gc28_286 0 n56 ns286 0 0.000145584993043
Gc28_287 0 n56 ns287 0 4.14535482397e-06
Gc28_288 0 n56 ns288 0 -0.000472280919572
Gc28_289 0 n56 ns289 0 -0.00193052447381
Gc28_290 0 n56 ns290 0 -0.00125689640917
Gc28_291 0 n56 ns291 0 -0.00120001082243
Gc28_292 0 n56 ns292 0 0.000407595291236
Gc28_293 0 n56 ns293 0 0.00136855238898
Gc28_294 0 n56 ns294 0 -0.00552034549962
Gc28_295 0 n56 ns295 0 -0.00326188168528
Gc28_296 0 n56 ns296 0 0.000140914881348
Gc28_297 0 n56 ns297 0 0.00290379975467
Gc28_298 0 n56 ns298 0 0.00108030389516
Gc28_299 0 n56 ns299 0 -0.000654391437796
Gc28_300 0 n56 ns300 0 -0.025091996097
Gc28_301 0 n56 ns301 0 0.0208821069957
Gc28_302 0 n56 ns302 0 -0.000795282868363
Gc28_303 0 n56 ns303 0 -1.7444002907e-06
Gc28_304 0 n56 ns304 0 -1.76895700373e-05
Gc28_305 0 n56 ns305 0 0.000219488428776
Gc28_306 0 n56 ns306 0 -0.000747479895205
Gc28_307 0 n56 ns307 0 0.00386605250017
Gc28_308 0 n56 ns308 0 0.000202577500164
Gc28_309 0 n56 ns309 0 0.000170528428044
Gc28_310 0 n56 ns310 0 0.000127533445221
Gc28_311 0 n56 ns311 0 -0.000187854089797
Gc28_312 0 n56 ns312 0 -5.42011811652e-05
Gc28_313 0 n56 ns313 0 -4.3692200976e-05
Gc28_314 0 n56 ns314 0 0.000824105488677
Gc28_315 0 n56 ns315 0 -0.000809163935409
Gc28_316 0 n56 ns316 0 -0.000759303853949
Gc28_317 0 n56 ns317 0 3.51918759717e-05
Gc28_318 0 n56 ns318 0 0.000144769211782
Gc28_319 0 n56 ns319 0 0.000280218944991
Gc28_320 0 n56 ns320 0 -0.00069746940021
Gc28_321 0 n56 ns321 0 -0.00169096466136
Gc28_322 0 n56 ns322 0 -0.000360613042478
Gc28_323 0 n56 ns323 0 0.00105383718115
Gc28_324 0 n56 ns324 0 0.000219423466748
Gc28_325 0 n56 ns325 0 -2.31287968693e-06
Gc28_326 0 n56 ns326 0 -0.000401414120598
Gc28_327 0 n56 ns327 0 -0.00104974272203
Gc28_328 0 n56 ns328 0 -0.00124687558102
Gc28_329 0 n56 ns329 0 -0.000619728470183
Gc28_330 0 n56 ns330 0 0.000568464946262
Gc28_331 0 n56 ns331 0 0.000845697172104
Gc28_332 0 n56 ns332 0 -0.00439194644811
Gc28_333 0 n56 ns333 0 -0.00114964587819
Gc28_334 0 n56 ns334 0 0.000701459644845
Gc28_335 0 n56 ns335 0 0.00177101448692
Gc28_336 0 n56 ns336 0 0.000574132175467
Gc28_337 0 n56 ns337 0 -0.000562611760681
Gc28_338 0 n56 ns338 0 -0.0121925389543
Gc28_339 0 n56 ns339 0 0.00958718979535
Gc28_340 0 n56 ns340 0 -0.000317138442496
Gc28_341 0 n56 ns341 0 6.52652557955e-06
Gc28_342 0 n56 ns342 0 -1.49677035708e-05
Gc28_343 0 n56 ns343 0 0.000698439574547
Gc28_344 0 n56 ns344 0 -0.00100270498994
Gc28_345 0 n56 ns345 0 0.0115818697603
Gc28_346 0 n56 ns346 0 0.000323192025189
Gc28_347 0 n56 ns347 0 0.000588099481133
Gc28_348 0 n56 ns348 0 0.000420692958675
Gc28_349 0 n56 ns349 0 -0.00030953100067
Gc28_350 0 n56 ns350 0 -0.000121348385114
Gc28_351 0 n56 ns351 0 -3.38422221443e-05
Gc28_352 0 n56 ns352 0 4.04521922071e-05
Gc28_353 0 n56 ns353 0 -0.0037321857395
Gc28_354 0 n56 ns354 0 8.43042724282e-05
Gc28_355 0 n56 ns355 0 0.000617091067902
Gc28_356 0 n56 ns356 0 2.55905469231e-06
Gc28_357 0 n56 ns357 0 0.000517416664296
Gc28_358 0 n56 ns358 0 -0.000923380239894
Gc28_359 0 n56 ns359 0 -0.00138535158414
Gc28_360 0 n56 ns360 0 -0.00094759991337
Gc28_361 0 n56 ns361 0 0.000183823352246
Gc28_362 0 n56 ns362 0 0.000357737134751
Gc28_363 0 n56 ns363 0 0.000221794054369
Gc28_364 0 n56 ns364 0 -0.00263426161354
Gc28_365 0 n56 ns365 0 -0.00468657392125
Gc28_366 0 n56 ns366 0 -0.00128395106098
Gc28_367 0 n56 ns367 0 -0.000299728796911
Gc28_368 0 n56 ns368 0 0.000222101886863
Gc28_369 0 n56 ns369 0 0.00159010430738
Gc28_370 0 n56 ns370 0 -0.00972332722349
Gc28_371 0 n56 ns371 0 -0.00623758681188
Gc28_372 0 n56 ns372 0 -0.0017814306404
Gc28_373 0 n56 ns373 0 0.00421315489087
Gc28_374 0 n56 ns374 0 0.00246002818029
Gc28_375 0 n56 ns375 0 -0.000247534877137
Gc28_376 0 n56 ns376 0 -0.0780417698905
Gc28_377 0 n56 ns377 0 0.0677948413271
Gc28_378 0 n56 ns378 0 -0.00313594606856
Gc28_379 0 n56 ns379 0 -1.02940427197e-05
Gc28_380 0 n56 ns380 0 1.14564320905e-05
Gc28_381 0 n56 ns381 0 -0.000319782317703
Gc28_382 0 n56 ns382 0 -0.000423942849308
Gc28_383 0 n56 ns383 0 0.00698416456529
Gc28_384 0 n56 ns384 0 -0.00111429025831
Gc28_385 0 n56 ns385 0 -0.000483081261718
Gc28_386 0 n56 ns386 0 0.00180179838218
Gc28_387 0 n56 ns387 0 0.000464319191173
Gc28_388 0 n56 ns388 0 -0.000184270488711
Gc28_389 0 n56 ns389 0 -0.00017239799656
Gc28_390 0 n56 ns390 0 0.00220055138148
Gc28_391 0 n56 ns391 0 -0.00268476714291
Gc28_392 0 n56 ns392 0 -0.00084715882278
Gc28_393 0 n56 ns393 0 0.000992079632654
Gc28_394 0 n56 ns394 0 -6.41270721266e-05
Gc28_395 0 n56 ns395 0 0.000571021297001
Gc28_396 0 n56 ns396 0 -0.000542055141563
Gc28_397 0 n56 ns397 0 -0.00371832176739
Gc28_398 0 n56 ns398 0 -0.000988895616806
Gc28_399 0 n56 ns399 0 0.000439413541273
Gc28_400 0 n56 ns400 0 0.000346623466656
Gc28_401 0 n56 ns401 0 0.000373311569151
Gc28_402 0 n56 ns402 0 0.000889245640829
Gc28_403 0 n56 ns403 0 -0.00548658869918
Gc28_404 0 n56 ns404 0 -0.00299489294929
Gc28_405 0 n56 ns405 0 -0.00107357825359
Gc28_406 0 n56 ns406 0 0.000185998668584
Gc28_407 0 n56 ns407 0 0.00231691504918
Gc28_408 0 n56 ns408 0 -0.0130247304597
Gc28_409 0 n56 ns409 0 -0.00589960952803
Gc28_410 0 n56 ns410 0 -0.000949567472329
Gc28_411 0 n56 ns411 0 0.00316780882766
Gc28_412 0 n56 ns412 0 0.00313467378994
Gc28_413 0 n56 ns413 0 0.000264058698889
Gc28_414 0 n56 ns414 0 -0.0734838963631
Gc28_415 0 n56 ns415 0 0.0692711184399
Gc28_416 0 n56 ns416 0 -0.00651703557461
Gc28_417 0 n56 ns417 0 -9.89875563732e-06
Gc28_418 0 n56 ns418 0 1.56176654692e-05
Gc28_419 0 n56 ns419 0 -0.0170957213972
Gc28_420 0 n56 ns420 0 -0.00135977193244
Gc28_421 0 n56 ns421 0 0.0205039863023
Gc28_422 0 n56 ns422 0 0.00626818664881
Gc28_423 0 n56 ns423 0 0.010290575473
Gc28_424 0 n56 ns424 0 0.00147654297617
Gc28_425 0 n56 ns425 0 -0.0032316195852
Gc28_426 0 n56 ns426 0 -0.000492789551194
Gc28_427 0 n56 ns427 0 3.25873851279e-05
Gc28_428 0 n56 ns428 0 -0.00127811963277
Gc28_429 0 n56 ns429 0 -0.0147836722661
Gc28_430 0 n56 ns430 0 0.00112955337506
Gc28_431 0 n56 ns431 0 0.00217122399913
Gc28_432 0 n56 ns432 0 0.000272780618364
Gc28_433 0 n56 ns433 0 0.000372648830536
Gc28_434 0 n56 ns434 0 0.000260460482643
Gc28_435 0 n56 ns435 0 0.000661466171553
Gc28_436 0 n56 ns436 0 9.54874723582e-05
Gc28_437 0 n56 ns437 0 0.000394330956818
Gc28_438 0 n56 ns438 0 0.00049027859163
Gc28_439 0 n56 ns439 0 0.000323916764375
Gc28_440 0 n56 ns440 0 -0.0117085144297
Gc28_441 0 n56 ns441 0 -0.00792272999711
Gc28_442 0 n56 ns442 0 -0.00367272167942
Gc28_443 0 n56 ns443 0 -0.0012392003512
Gc28_444 0 n56 ns444 0 0.000144572338569
Gc28_445 0 n56 ns445 0 0.00252450045605
Gc28_446 0 n56 ns446 0 0.00834538927481
Gc28_447 0 n56 ns447 0 -0.00539499183622
Gc28_448 0 n56 ns448 0 0.00190286340852
Gc28_449 0 n56 ns449 0 0.00182853560456
Gc28_450 0 n56 ns450 0 0.00327393710248
Gc28_451 0 n56 ns451 0 -2.6293229075e-05
Gc28_452 0 n56 ns452 0 -0.107294218407
Gc28_453 0 n56 ns453 0 0.0694264804256
Gc28_454 0 n56 ns454 0 -0.00878035081305
Gc28_455 0 n56 ns455 0 -1.1166063533e-05
Gc28_456 0 n56 ns456 0 6.6009385276e-07
Gc28_457 0 n56 ns457 0 -0.000162613476093
Gc28_458 0 n56 ns458 0 -0.000249825564929
Gc28_459 0 n56 ns459 0 0.00598754149021
Gc28_460 0 n56 ns460 0 -0.00132753079752
Gc28_461 0 n56 ns461 0 -0.000416717436632
Gc28_462 0 n56 ns462 0 0.00186261713873
Gc28_463 0 n56 ns463 0 0.000527440245765
Gc28_464 0 n56 ns464 0 -0.000161899021462
Gc28_465 0 n56 ns465 0 -0.000185777664685
Gc28_466 0 n56 ns466 0 0.00185257386632
Gc28_467 0 n56 ns467 0 -0.00220957395556
Gc28_468 0 n56 ns468 0 -0.000528806177504
Gc28_469 0 n56 ns469 0 0.000872376385279
Gc28_470 0 n56 ns470 0 -0.000129020096064
Gc28_471 0 n56 ns471 0 0.000441626961338
Gc28_472 0 n56 ns472 0 -0.00018320720165
Gc28_473 0 n56 ns473 0 -0.00321874150531
Gc28_474 0 n56 ns474 0 -0.000884110693623
Gc28_475 0 n56 ns475 0 0.000109969496895
Gc28_476 0 n56 ns476 0 0.00026301275528
Gc28_477 0 n56 ns477 0 0.000342600008581
Gc28_478 0 n56 ns478 0 0.000933967438132
Gc28_479 0 n56 ns479 0 -0.00544606625482
Gc28_480 0 n56 ns480 0 -0.00291158334207
Gc28_481 0 n56 ns481 0 -0.000847321054833
Gc28_482 0 n56 ns482 0 0.000216728661321
Gc28_483 0 n56 ns483 0 0.00214743089372
Gc28_484 0 n56 ns484 0 -0.0122490955809
Gc28_485 0 n56 ns485 0 -0.00510263998182
Gc28_486 0 n56 ns486 0 -0.000830073952441
Gc28_487 0 n56 ns487 0 0.00283979682131
Gc28_488 0 n56 ns488 0 0.0030116646173
Gc28_489 0 n56 ns489 0 0.000219836223683
Gc28_490 0 n56 ns490 0 -0.066140060804
Gc28_491 0 n56 ns491 0 0.0630589758845
Gc28_492 0 n56 ns492 0 -0.00631247766698
Gc28_493 0 n56 ns493 0 -8.38179220092e-06
Gc28_494 0 n56 ns494 0 -6.73471292374e-06
Gc28_495 0 n56 ns495 0 0.000920272446063
Gc28_496 0 n56 ns496 0 -0.000926312051135
Gc28_497 0 n56 ns497 0 0.010387471266
Gc28_498 0 n56 ns498 0 -8.23091368617e-06
Gc28_499 0 n56 ns499 0 0.000762590227695
Gc28_500 0 n56 ns500 0 0.000458729076537
Gc28_501 0 n56 ns501 0 -0.0001489132145
Gc28_502 0 n56 ns502 0 -9.03723583119e-05
Gc28_503 0 n56 ns503 0 -2.16726587381e-05
Gc28_504 0 n56 ns504 0 -2.0413484161e-05
Gc28_505 0 n56 ns505 0 -0.00417005429178
Gc28_506 0 n56 ns506 0 0.000238443192235
Gc28_507 0 n56 ns507 0 0.00106401122501
Gc28_508 0 n56 ns508 0 0.000121928683814
Gc28_509 0 n56 ns509 0 0.000413187597789
Gc28_510 0 n56 ns510 0 -0.000971369803379
Gc28_511 0 n56 ns511 0 -0.000587402689349
Gc28_512 0 n56 ns512 0 -0.00045225707551
Gc28_513 0 n56 ns513 0 -0.000102544260548
Gc28_514 0 n56 ns514 0 0.000266670151479
Gc28_515 0 n56 ns515 0 7.23410108502e-05
Gc28_516 0 n56 ns516 0 -0.00235658905474
Gc28_517 0 n56 ns517 0 -0.00499656256671
Gc28_518 0 n56 ns518 0 -0.00154830932256
Gc28_519 0 n56 ns519 0 1.04244838564e-05
Gc28_520 0 n56 ns520 0 0.000463923770171
Gc28_521 0 n56 ns521 0 0.00145866607011
Gc28_522 0 n56 ns522 0 -0.0090321204412
Gc28_523 0 n56 ns523 0 -0.00528529506786
Gc28_524 0 n56 ns524 0 -0.00153604540479
Gc28_525 0 n56 ns525 0 0.00384726894823
Gc28_526 0 n56 ns526 0 0.00229315549261
Gc28_527 0 n56 ns527 0 -0.000329518747118
Gc28_528 0 n56 ns528 0 -0.0695352319838
Gc28_529 0 n56 ns529 0 0.0605678768606
Gc28_530 0 n56 ns530 0 -0.0028890595606
Gc28_531 0 n56 ns531 0 -8.86120635782e-06
Gc28_532 0 n56 ns532 0 -2.15459312073e-05
Gc28_533 0 n56 ns533 0 0.000311536702109
Gc28_534 0 n56 ns534 0 -0.000646945321012
Gc28_535 0 n56 ns535 0 0.00554639968617
Gc28_536 0 n56 ns536 0 -5.70966660308e-05
Gc28_537 0 n56 ns537 0 0.000373356618015
Gc28_538 0 n56 ns538 0 0.000369242793859
Gc28_539 0 n56 ns539 0 0.000177604341027
Gc28_540 0 n56 ns540 0 2.58320689489e-05
Gc28_541 0 n56 ns541 0 -2.74337473251e-06
Gc28_542 0 n56 ns542 0 -0.000408383173435
Gc28_543 0 n56 ns543 0 -0.00207795171072
Gc28_544 0 n56 ns544 0 0.000149660293649
Gc28_545 0 n56 ns545 0 0.000358357692074
Gc28_546 0 n56 ns546 0 0.000228407255798
Gc28_547 0 n56 ns547 0 0.000300072943412
Gc28_548 0 n56 ns548 0 0.000765146080971
Gc28_549 0 n56 ns549 0 -0.000726231882416
Gc28_550 0 n56 ns550 0 -0.000917205470724
Gc28_551 0 n56 ns551 0 5.52073935416e-05
Gc28_552 0 n56 ns552 0 0.000128599417551
Gc28_553 0 n56 ns553 0 2.0657178135e-06
Gc28_554 0 n56 ns554 0 -0.00100189431167
Gc28_555 0 n56 ns555 0 -0.00245463606877
Gc28_556 0 n56 ns556 0 -0.0011373998957
Gc28_557 0 n56 ns557 0 -0.00111229436222
Gc28_558 0 n56 ns558 0 0.000338566692866
Gc28_559 0 n56 ns559 0 0.001452527754
Gc28_560 0 n56 ns560 0 -0.00622863046271
Gc28_561 0 n56 ns561 0 -0.00388455884137
Gc28_562 0 n56 ns562 0 -0.000191018991118
Gc28_563 0 n56 ns563 0 0.00332948212019
Gc28_564 0 n56 ns564 0 0.00136204670604
Gc28_565 0 n56 ns565 0 -0.000660915691673
Gc28_566 0 n56 ns566 0 -0.0325746957396
Gc28_567 0 n56 ns567 0 0.027361920916
Gc28_568 0 n56 ns568 0 -0.00108034547236
Gc28_569 0 n56 ns569 0 -4.75997890573e-06
Gc28_570 0 n56 ns570 0 -2.06612448706e-05
Gc28_571 0 n56 ns571 0 0.000258514661518
Gc28_572 0 n56 ns572 0 -0.000706762902558
Gc28_573 0 n56 ns573 0 0.00415055369197
Gc28_574 0 n56 ns574 0 6.66689828134e-05
Gc28_575 0 n56 ns575 0 0.000220122970809
Gc28_576 0 n56 ns576 0 0.000169953645258
Gc28_577 0 n56 ns577 0 -0.000107840214533
Gc28_578 0 n56 ns578 0 -1.91165696143e-05
Gc28_579 0 n56 ns579 0 -4.12881955658e-05
Gc28_580 0 n56 ns580 0 0.000905060915971
Gc28_581 0 n56 ns581 0 -0.000842317267202
Gc28_582 0 n56 ns582 0 -0.000755707626119
Gc28_583 0 n56 ns583 0 -9.16823769281e-06
Gc28_584 0 n56 ns584 0 0.000161983555392
Gc28_585 0 n56 ns585 0 0.000324434438313
Gc28_586 0 n56 ns586 0 -0.000306602184315
Gc28_587 0 n56 ns587 0 -0.00180756677421
Gc28_588 0 n56 ns588 0 -0.000577890966008
Gc28_589 0 n56 ns589 0 0.00100783083071
Gc28_590 0 n56 ns590 0 0.000222510069481
Gc28_591 0 n56 ns591 0 7.427782024e-07
Gc28_592 0 n56 ns592 0 -0.000342521316367
Gc28_593 0 n56 ns593 0 -0.00135798635833
Gc28_594 0 n56 ns594 0 -0.00137318748666
Gc28_595 0 n56 ns595 0 -0.000878760441589
Gc28_596 0 n56 ns596 0 0.000574096348136
Gc28_597 0 n56 ns597 0 0.00107408704256
Gc28_598 0 n56 ns598 0 -0.00487468680097
Gc28_599 0 n56 ns599 0 -0.00202437859275
Gc28_600 0 n56 ns600 0 0.000525485198802
Gc28_601 0 n56 ns601 0 0.00218697676184
Gc28_602 0 n56 ns602 0 0.000727072604763
Gc28_603 0 n56 ns603 0 -0.000586631262075
Gc28_604 0 n56 ns604 0 -0.0180698325272
Gc28_605 0 n56 ns605 0 0.0147237286765
Gc28_606 0 n56 ns606 0 -0.000521591175306
Gc28_607 0 n56 ns607 0 2.62080933912e-06
Gc28_608 0 n56 ns608 0 -1.64638446401e-05
Gc28_609 0 n56 ns609 0 -0.00127280505874
Gc28_610 0 n56 ns610 0 0.0027272806989
Gc28_611 0 n56 ns611 0 -0.00445018965127
Gc28_612 0 n56 ns612 0 -0.000194310314485
Gc28_613 0 n56 ns613 0 -0.000366457186576
Gc28_614 0 n56 ns614 0 -0.000455420487962
Gc28_615 0 n56 ns615 0 -0.00011830346454
Gc28_616 0 n56 ns616 0 -2.81497272619e-05
Gc28_617 0 n56 ns617 0 2.26209033619e-06
Gc28_618 0 n56 ns618 0 0.000751813985703
Gc28_619 0 n56 ns619 0 0.00194944822353
Gc28_620 0 n56 ns620 0 -0.000593692522495
Gc28_621 0 n56 ns621 0 0.000161605561839
Gc28_622 0 n56 ns622 0 6.33538529743e-05
Gc28_623 0 n56 ns623 0 -0.000247413564887
Gc28_624 0 n56 ns624 0 0.0022125755087
Gc28_625 0 n56 ns625 0 0.00101026368875
Gc28_626 0 n56 ns626 0 -0.000871500408039
Gc28_627 0 n56 ns627 0 -0.000728238042352
Gc28_628 0 n56 ns628 0 0.00012160662588
Gc28_629 0 n56 ns629 0 2.61762228217e-05
Gc28_630 0 n56 ns630 0 0.00164293462132
Gc28_631 0 n56 ns631 0 -0.000699300250293
Gc28_632 0 n56 ns632 0 -0.000667642486058
Gc28_633 0 n56 ns633 0 0.000954372297195
Gc28_634 0 n56 ns634 0 0.000472280879442
Gc28_635 0 n56 ns635 0 -0.000817599526383
Gc28_636 0 n56 ns636 0 0.000914697580133
Gc28_637 0 n56 ns637 0 -0.00108700892329
Gc28_638 0 n56 ns638 0 -0.000725736722062
Gc28_639 0 n56 ns639 0 0.00144858991669
Gc28_640 0 n56 ns640 0 0.000870315242451
Gc28_641 0 n56 ns641 0 -0.000506034476994
Gc28_642 0 n56 ns642 0 0.0225841559112
Gc28_643 0 n56 ns643 0 -0.020701886339
Gc28_644 0 n56 ns644 0 0.00113040255452
Gc28_645 0 n56 ns645 0 -9.90285698136e-06
Gc28_646 0 n56 ns646 0 1.38732534833e-05
Gc28_647 0 n56 ns647 0 -0.00129571746507
Gc28_648 0 n56 ns648 0 0.00260535067936
Gc28_649 0 n56 ns649 0 -0.00363919347157
Gc28_650 0 n56 ns650 0 -5.52200306718e-05
Gc28_651 0 n56 ns651 0 -0.000321100311363
Gc28_652 0 n56 ns652 0 -0.000163327410596
Gc28_653 0 n56 ns653 0 -0.000234488103614
Gc28_654 0 n56 ns654 0 -3.56596580334e-05
Gc28_655 0 n56 ns655 0 6.58208847839e-06
Gc28_656 0 n56 ns656 0 -0.00017164874133
Gc28_657 0 n56 ns657 0 0.00142961397908
Gc28_658 0 n56 ns658 0 -0.00034855234452
Gc28_659 0 n56 ns659 0 0.000158062628044
Gc28_660 0 n56 ns660 0 0.000124361516367
Gc28_661 0 n56 ns661 0 -0.000353070272173
Gc28_662 0 n56 ns662 0 0.0013743453845
Gc28_663 0 n56 ns663 0 0.00107961524836
Gc28_664 0 n56 ns664 0 -0.000801880307962
Gc28_665 0 n56 ns665 0 -0.000567440597258
Gc28_666 0 n56 ns666 0 0.000233288966557
Gc28_667 0 n56 ns667 0 5.11771572411e-05
Gc28_668 0 n56 ns668 0 0.00131206336165
Gc28_669 0 n56 ns669 0 0.000246860297518
Gc28_670 0 n56 ns670 0 -0.000547458067705
Gc28_671 0 n56 ns671 0 0.00105858953764
Gc28_672 0 n56 ns672 0 0.000532015517353
Gc28_673 0 n56 ns673 0 -0.00105571870934
Gc28_674 0 n56 ns674 0 0.00105932433913
Gc28_675 0 n56 ns675 0 -0.000692733622435
Gc28_676 0 n56 ns676 0 -0.00102095012256
Gc28_677 0 n56 ns677 0 0.00158702673277
Gc28_678 0 n56 ns678 0 0.00112348451898
Gc28_679 0 n56 ns679 0 -0.00055519702982
Gc28_680 0 n56 ns680 0 0.027765240553
Gc28_681 0 n56 ns681 0 -0.0259186065722
Gc28_682 0 n56 ns682 0 0.00152060756359
Gc28_683 0 n56 ns683 0 -7.34884444842e-06
Gc28_684 0 n56 ns684 0 1.55521736606e-05
Gc28_685 0 n56 ns685 0 -0.0013920698021
Gc28_686 0 n56 ns686 0 -1.7740619414e-07
Gc28_687 0 n56 ns687 0 0.0014550141118
Gc28_688 0 n56 ns688 0 0.00073704549216
Gc28_689 0 n56 ns689 0 -0.000529271673787
Gc28_690 0 n56 ns690 0 0.000680506016629
Gc28_691 0 n56 ns691 0 -8.20387622376e-06
Gc28_692 0 n56 ns692 0 -0.000117766173587
Gc28_693 0 n56 ns693 0 7.38803866394e-06
Gc28_694 0 n56 ns694 0 -0.0026821273355
Gc28_695 0 n56 ns695 0 -0.000720768246238
Gc28_696 0 n56 ns696 0 0.00101875527345
Gc28_697 0 n56 ns697 0 -0.00014206714224
Gc28_698 0 n56 ns698 0 0.000256868754285
Gc28_699 0 n56 ns699 0 -0.000587560538313
Gc28_700 0 n56 ns700 0 -0.00215953902839
Gc28_701 0 n56 ns701 0 -0.000805629898865
Gc28_702 0 n56 ns702 0 -0.000223402869791
Gc28_703 0 n56 ns703 0 0.000518959122373
Gc28_704 0 n56 ns704 0 0.000535850246035
Gc28_705 0 n56 ns705 0 0.000173734112261
Gc28_706 0 n56 ns706 0 -0.00236730705106
Gc28_707 0 n56 ns707 0 0.00321074420655
Gc28_708 0 n56 ns708 0 0.000799921567294
Gc28_709 0 n56 ns709 0 0.00105131315933
Gc28_710 0 n56 ns710 0 0.000442174089821
Gc28_711 0 n56 ns711 0 -0.00162255525392
Gc28_712 0 n56 ns712 0 4.88275648002e-06
Gc28_713 0 n56 ns713 0 0.0019195407971
Gc28_714 0 n56 ns714 0 -0.00169138258174
Gc28_715 0 n56 ns715 0 0.000698698803232
Gc28_716 0 n56 ns716 0 0.00178013992481
Gc28_717 0 n56 ns717 0 -0.000260901887997
Gc28_718 0 n56 ns718 0 0.0410775664673
Gc28_719 0 n56 ns719 0 -0.041560678221
Gc28_720 0 n56 ns720 0 0.00350167907447
Gc28_721 0 n56 ns721 0 5.64709175216e-08
Gc28_722 0 n56 ns722 0 1.27907587544e-05
Gc28_723 0 n56 ns723 0 -0.00491628467869
Gc28_724 0 n56 ns724 0 -0.0012268957753
Gc28_725 0 n56 ns725 0 -0.0036917063302
Gc28_726 0 n56 ns726 0 0.000358722048099
Gc28_727 0 n56 ns727 0 -0.00123055822292
Gc28_728 0 n56 ns728 0 -6.87302783143e-05
Gc28_729 0 n56 ns729 0 0.000814923704799
Gc28_730 0 n56 ns730 0 -0.000116326335525
Gc28_731 0 n56 ns731 0 -7.78619397293e-05
Gc28_732 0 n56 ns732 0 -0.000870927547654
Gc28_733 0 n56 ns733 0 0.00201641571107
Gc28_734 0 n56 ns734 0 0.00101017958406
Gc28_735 0 n56 ns735 0 -0.000521273011216
Gc28_736 0 n56 ns736 0 0.00020358362181
Gc28_737 0 n56 ns737 0 -0.000542982344091
Gc28_738 0 n56 ns738 0 0.000332005324508
Gc28_739 0 n56 ns739 0 -0.000716668489224
Gc28_740 0 n56 ns740 0 0.000116388558233
Gc28_741 0 n56 ns741 0 7.56484775422e-05
Gc28_742 0 n56 ns742 0 0.00045571532986
Gc28_743 0 n56 ns743 0 0.000144766772792
Gc28_744 0 n56 ns744 0 -0.0014022770544
Gc28_745 0 n56 ns745 0 0.00106049271718
Gc28_746 0 n56 ns746 0 0.00158693880548
Gc28_747 0 n56 ns747 0 0.00187624286712
Gc28_748 0 n56 ns748 0 0.000787721923663
Gc28_749 0 n56 ns749 0 -0.00198254854896
Gc28_750 0 n56 ns750 0 0.000770695683616
Gc28_751 0 n56 ns751 0 0.00094889081341
Gc28_752 0 n56 ns752 0 0.000218879748831
Gc28_753 0 n56 ns753 0 -1.30199037543e-05
Gc28_754 0 n56 ns754 0 0.00246685469701
Gc28_755 0 n56 ns755 0 9.01521104036e-05
Gc28_756 0 n56 ns756 0 0.0272146554597
Gc28_757 0 n56 ns757 0 -0.026186569847
Gc28_758 0 n56 ns758 0 0.00663616942874
Gc28_759 0 n56 ns759 0 -3.44279400683e-06
Gc28_760 0 n56 ns760 0 7.34483621635e-06
Gc28_761 0 n56 ns761 0 -0.00518081789398
Gc28_762 0 n56 ns762 0 -0.000117897026734
Gc28_763 0 n56 ns763 0 -0.00664647568405
Gc28_764 0 n56 ns764 0 -2.50301183883e-05
Gc28_765 0 n56 ns765 0 -0.000999476378938
Gc28_766 0 n56 ns766 0 -9.06874240105e-05
Gc28_767 0 n56 ns767 0 0.00027888238585
Gc28_768 0 n56 ns768 0 -0.000105219415885
Gc28_769 0 n56 ns769 0 -1.55583705961e-05
Gc28_770 0 n56 ns770 0 -0.00165892542411
Gc28_771 0 n56 ns771 0 0.00302465040183
Gc28_772 0 n56 ns772 0 0.000687493692481
Gc28_773 0 n56 ns773 0 -0.000600278533613
Gc28_774 0 n56 ns774 0 0.000211182613809
Gc28_775 0 n56 ns775 0 -0.000451459687771
Gc28_776 0 n56 ns776 0 0.000285631747765
Gc28_777 0 n56 ns777 0 0.00183996937057
Gc28_778 0 n56 ns778 0 0.000697369843471
Gc28_779 0 n56 ns779 0 -3.64537471636e-05
Gc28_780 0 n56 ns780 0 0.000504633410045
Gc28_781 0 n56 ns781 0 8.15577146913e-05
Gc28_782 0 n56 ns782 0 0.00229753614665
Gc28_783 0 n56 ns783 0 0.00180728110245
Gc28_784 0 n56 ns784 0 0.00137340648922
Gc28_785 0 n56 ns785 0 0.00224385954495
Gc28_786 0 n56 ns786 0 0.00104002805004
Gc28_787 0 n56 ns787 0 -0.00196138225968
Gc28_788 0 n56 ns788 0 0.00345730658743
Gc28_789 0 n56 ns789 0 -0.00144820845245
Gc28_790 0 n56 ns790 0 0.00179948015107
Gc28_791 0 n56 ns791 0 0.00111129402582
Gc28_792 0 n56 ns792 0 0.00291624986948
Gc28_793 0 n56 ns793 0 2.8028216265e-05
Gc28_794 0 n56 ns794 0 -0.00670365871889
Gc28_795 0 n56 ns795 0 0.010944476735
Gc28_796 0 n56 ns796 0 0.00710969537882
Gc28_797 0 n56 ns797 0 -1.25527781196e-06
Gc28_798 0 n56 ns798 0 -3.9865268524e-06
Gc28_799 0 n56 ns799 0 -0.00225385146003
Gc28_800 0 n56 ns800 0 0.000329147344118
Gc28_801 0 n56 ns801 0 -0.0010638881798
Gc28_802 0 n56 ns802 0 0.000399133455041
Gc28_803 0 n56 ns803 0 -0.00037147577344
Gc28_804 0 n56 ns804 0 0.000505433937941
Gc28_805 0 n56 ns805 0 0.000461365917412
Gc28_806 0 n56 ns806 0 -0.000135568791067
Gc28_807 0 n56 ns807 0 -1.6421477689e-05
Gc28_808 0 n56 ns808 0 -0.000183252793635
Gc28_809 0 n56 ns809 0 -3.14603029919e-05
Gc28_810 0 n56 ns810 0 0.000473937980372
Gc28_811 0 n56 ns811 0 -0.000308277306103
Gc28_812 0 n56 ns812 0 0.000178847500167
Gc28_813 0 n56 ns813 0 -0.000415797074899
Gc28_814 0 n56 ns814 0 -0.000657077912121
Gc28_815 0 n56 ns815 0 -0.00151142740943
Gc28_816 0 n56 ns816 0 -0.000336163036407
Gc28_817 0 n56 ns817 0 -1.96788055148e-06
Gc28_818 0 n56 ns818 0 0.000335812052994
Gc28_819 0 n56 ns819 0 0.000146705992002
Gc28_820 0 n56 ns820 0 -0.00277554518258
Gc28_821 0 n56 ns821 0 0.00159789079149
Gc28_822 0 n56 ns822 0 0.00088499500414
Gc28_823 0 n56 ns823 0 0.000720036621609
Gc28_824 0 n56 ns824 0 0.000391313012569
Gc28_825 0 n56 ns825 0 -0.00134674389169
Gc28_826 0 n56 ns826 0 -0.000648939181908
Gc28_827 0 n56 ns827 0 0.0020881023975
Gc28_828 0 n56 ns828 0 -0.00168891513628
Gc28_829 0 n56 ns829 0 -7.93500503652e-06
Gc28_830 0 n56 ns830 0 0.00183109613759
Gc28_831 0 n56 ns831 0 1.33103969733e-05
Gc28_832 0 n56 ns832 0 0.0520780150544
Gc28_833 0 n56 ns833 0 -0.0531135479884
Gc28_834 0 n56 ns834 0 0.00473052229077
Gc28_835 0 n56 ns835 0 1.47395398261e-06
Gc28_836 0 n56 ns836 0 -9.75155726592e-06
Gc28_837 0 n56 ns837 0 -0.00115038110625
Gc28_838 0 n56 ns838 0 0.00217549939077
Gc28_839 0 n56 ns839 0 -0.00468367496494
Gc28_840 0 n56 ns840 0 -3.2644724471e-05
Gc28_841 0 n56 ns841 0 -0.000274755173306
Gc28_842 0 n56 ns842 0 0.000104168065262
Gc28_843 0 n56 ns843 0 -0.000359401695546
Gc28_844 0 n56 ns844 0 -2.03107717328e-05
Gc28_845 0 n56 ns845 0 2.05835175327e-05
Gc28_846 0 n56 ns846 0 -0.00101926727773
Gc28_847 0 n56 ns847 0 0.0015393084386
Gc28_848 0 n56 ns848 0 -6.44873625665e-05
Gc28_849 0 n56 ns849 0 -0.000373887886322
Gc28_850 0 n56 ns850 0 -3.61037278651e-05
Gc28_851 0 n56 ns851 0 -0.000318823077556
Gc28_852 0 n56 ns852 0 -0.000466297583536
Gc28_853 0 n56 ns853 0 0.0017638826617
Gc28_854 0 n56 ns854 0 0.000130824108637
Gc28_855 0 n56 ns855 0 -0.000170300115503
Gc28_856 0 n56 ns856 0 0.000323795928725
Gc28_857 0 n56 ns857 0 -0.000100577485599
Gc28_858 0 n56 ns858 0 0.00200797989218
Gc28_859 0 n56 ns859 0 0.002863932231
Gc28_860 0 n56 ns860 0 0.000504297393238
Gc28_861 0 n56 ns861 0 0.00025326879046
Gc28_862 0 n56 ns862 0 -0.000124180080813
Gc28_863 0 n56 ns863 0 -0.00105394974538
Gc28_864 0 n56 ns864 0 0.00363213026062
Gc28_865 0 n56 ns865 0 0.000811777132718
Gc28_866 0 n56 ns866 0 -0.00133962629831
Gc28_867 0 n56 ns867 0 0.000875915760708
Gc28_868 0 n56 ns868 0 0.00104942173723
Gc28_869 0 n56 ns869 0 -0.000531415159058
Gc28_870 0 n56 ns870 0 0.04518346447
Gc28_871 0 n56 ns871 0 -0.0409148779209
Gc28_872 0 n56 ns872 0 0.00209670492054
Gc28_873 0 n56 ns873 0 -5.30482208344e-06
Gc28_874 0 n56 ns874 0 -1.99335916146e-05
Gc28_875 0 n56 ns875 0 -0.000416252929633
Gc28_876 0 n56 ns876 0 0.000870497090485
Gc28_877 0 n56 ns877 0 -0.00127584426102
Gc28_878 0 n56 ns878 0 -9.87934111631e-05
Gc28_879 0 n56 ns879 0 -3.67596195872e-05
Gc28_880 0 n56 ns880 0 -0.000111167310517
Gc28_881 0 n56 ns881 0 -2.25654707649e-05
Gc28_882 0 n56 ns882 0 -2.8414318276e-05
Gc28_883 0 n56 ns883 0 -2.20535748431e-05
Gc28_884 0 n56 ns884 0 -0.000339713435459
Gc28_885 0 n56 ns885 0 0.000913452500384
Gc28_886 0 n56 ns886 0 0.000392267795392
Gc28_887 0 n56 ns887 0 7.85419645103e-05
Gc28_888 0 n56 ns888 0 -0.000121025563211
Gc28_889 0 n56 ns889 0 -0.000318317862884
Gc28_890 0 n56 ns890 0 0.00059812939955
Gc28_891 0 n56 ns891 0 -0.000120088430885
Gc28_892 0 n56 ns892 0 -0.000418134304596
Gc28_893 0 n56 ns893 0 0.000373361464787
Gc28_894 0 n56 ns894 0 0.000225758670407
Gc28_895 0 n56 ns895 0 -9.3856891229e-05
Gc28_896 0 n56 ns896 0 0.00034610202449
Gc28_897 0 n56 ns897 0 0.00015957503473
Gc28_898 0 n56 ns898 0 0.000484850364447
Gc28_899 0 n56 ns899 0 0.000998926889616
Gc28_900 0 n56 ns900 0 -0.00017185018953
Gc28_901 0 n56 ns901 0 -0.000970774084451
Gc28_902 0 n56 ns902 0 -0.000270358871555
Gc28_903 0 n56 ns903 0 -0.000362299216634
Gc28_904 0 n56 ns904 0 5.47119344187e-05
Gc28_905 0 n56 ns905 0 0.00145091095647
Gc28_906 0 n56 ns906 0 0.000634508410189
Gc28_907 0 n56 ns907 0 -0.000673914181456
Gc28_908 0 n56 ns908 0 0.0178285320455
Gc28_909 0 n56 ns909 0 -0.0165682053263
Gc28_910 0 n56 ns910 0 0.00087167158537
Gc28_911 0 n56 ns911 0 -6.50490930642e-06
Gc28_912 0 n56 ns912 0 -1.81429935785e-05
Gc28_913 0 n56 ns913 0 0.000266464994063
Gc28_914 0 n56 ns914 0 -0.00036803341341
Gc28_915 0 n56 ns915 0 0.00275818105434
Gc28_916 0 n56 ns916 0 0.000137545936784
Gc28_917 0 n56 ns917 0 0.00017225452264
Gc28_918 0 n56 ns918 0 0.000122297095652
Gc28_919 0 n56 ns919 0 3.75749537445e-05
Gc28_920 0 n56 ns920 0 2.02788368273e-05
Gc28_921 0 n56 ns921 0 2.21899697902e-05
Gc28_922 0 n56 ns922 0 -0.000803616445567
Gc28_923 0 n56 ns923 0 -0.00102868802574
Gc28_924 0 n56 ns924 0 0.000770274728794
Gc28_925 0 n56 ns925 0 0.000299256178623
Gc28_926 0 n56 ns926 0 -8.30109918272e-05
Gc28_927 0 n56 ns927 0 -0.000209255546235
Gc28_928 0 n56 ns928 0 -0.000917162344546
Gc28_929 0 n56 ns929 0 -0.00153730247794
Gc28_930 0 n56 ns930 0 -0.000297288160869
Gc28_931 0 n56 ns931 0 0.00109892562071
Gc28_932 0 n56 ns932 0 0.000226353639143
Gc28_933 0 n56 ns933 0 -7.16164112528e-06
Gc28_934 0 n56 ns934 0 -0.00181018821424
Gc28_935 0 n56 ns935 0 0.000454088547103
Gc28_936 0 n56 ns936 0 0.000832689770481
Gc28_937 0 n56 ns937 0 0.00104827319949
Gc28_938 0 n56 ns938 0 -0.000233174303484
Gc28_939 0 n56 ns939 0 -0.000809499145452
Gc28_940 0 n56 ns940 0 -0.00226340551549
Gc28_941 0 n56 ns941 0 0.000627373415301
Gc28_942 0 n56 ns942 0 0.000749647118164
Gc28_943 0 n56 ns943 0 0.00108745407003
Gc28_944 0 n56 ns944 0 0.000363190352377
Gc28_945 0 n56 ns945 0 -0.00059767337513
Gc28_946 0 n56 ns946 0 0.00447074216421
Gc28_947 0 n56 ns947 0 -0.00512036384507
Gc28_948 0 n56 ns948 0 0.000401117676513
Gc28_949 0 n56 ns949 0 -7.80872458697e-06
Gc28_950 0 n56 ns950 0 -1.74014160537e-05
Gc28_951 0 n56 ns951 0 -0.00122683369476
Gc28_952 0 n56 ns952 0 0.000732045390256
Gc28_953 0 n56 ns953 0 -0.000199472190901
Gc28_954 0 n56 ns954 0 0.00056237122563
Gc28_955 0 n56 ns955 0 -0.000588107376547
Gc28_956 0 n56 ns956 0 0.000328228858361
Gc28_957 0 n56 ns957 0 -0.000158249650463
Gc28_958 0 n56 ns958 0 -4.03358528273e-05
Gc28_959 0 n56 ns959 0 3.31294206877e-05
Gc28_960 0 n56 ns960 0 -0.00202211174426
Gc28_961 0 n56 ns961 0 -0.000229567140528
Gc28_962 0 n56 ns962 0 0.000419170488196
Gc28_963 0 n56 ns963 0 2.89165408667e-05
Gc28_964 0 n56 ns964 0 0.000204347093921
Gc28_965 0 n56 ns965 0 -0.000486367473999
Gc28_966 0 n56 ns966 0 -0.00150810379501
Gc28_967 0 n56 ns967 0 0.000140455994451
Gc28_968 0 n56 ns968 0 -0.000375065317803
Gc28_969 0 n56 ns969 0 0.00029714636454
Gc28_970 0 n56 ns970 0 0.000471386372593
Gc28_971 0 n56 ns971 0 0.000135461550606
Gc28_972 0 n56 ns972 0 -0.000825522196973
Gc28_973 0 n56 ns973 0 0.00318242667812
Gc28_974 0 n56 ns974 0 0.000399680891803
Gc28_975 0 n56 ns975 0 0.00101485824466
Gc28_976 0 n56 ns976 0 0.000414361379658
Gc28_977 0 n56 ns977 0 -0.00146338031769
Gc28_978 0 n56 ns978 0 0.00148367542372
Gc28_979 0 n56 ns979 0 0.00172647884862
Gc28_980 0 n56 ns980 0 -0.00156631342
Gc28_981 0 n56 ns981 0 0.000911515071406
Gc28_982 0 n56 ns982 0 0.00147519888777
Gc28_983 0 n56 ns983 0 -0.000421740333386
Gc28_984 0 n56 ns984 0 0.0410730886643
Gc28_985 0 n56 ns985 0 -0.0394906816383
Gc28_986 0 n56 ns986 0 0.00262623751207
Gc28_987 0 n56 ns987 0 -1.64064616157e-06
Gc28_988 0 n56 ns988 0 1.29177678718e-05
Gc28_989 0 n56 ns989 0 -0.00190623901843
Gc28_990 0 n56 ns990 0 -0.00230354066654
Gc28_991 0 n56 ns991 0 0.00517849591886
Gc28_992 0 n56 ns992 0 0.000415224223926
Gc28_993 0 n56 ns993 0 -0.000422864222152
Gc28_994 0 n56 ns994 0 0.00060515498053
Gc28_995 0 n56 ns995 0 0.000434412436903
Gc28_996 0 n56 ns996 0 -0.000152881716697
Gc28_997 0 n56 ns997 0 -8.93368773523e-05
Gc28_998 0 n56 ns998 0 -0.00174005268236
Gc28_999 0 n56 ns999 0 -0.000349514939206
Gc28_1000 0 n56 ns1000 0 0.00128863400092
Gc28_1001 0 n56 ns1001 0 1.87560617674e-05
Gc28_1002 0 n56 ns1002 0 0.000342507636422
Gc28_1003 0 n56 ns1003 0 -0.000569679319545
Gc28_1004 0 n56 ns1004 0 -0.000103130639944
Gc28_1005 0 n56 ns1005 0 -0.00222175049059
Gc28_1006 0 n56 ns1006 0 -0.00045623406618
Gc28_1007 0 n56 ns1007 0 0.000264258156783
Gc28_1008 0 n56 ns1008 0 0.000428928476529
Gc28_1009 0 n56 ns1009 0 0.000245274461519
Gc28_1010 0 n56 ns1010 0 -0.00419884288777
Gc28_1011 0 n56 ns1011 0 -0.000864953146935
Gc28_1012 0 n56 ns1012 0 0.000874972929583
Gc28_1013 0 n56 ns1013 0 0.00165679020715
Gc28_1014 0 n56 ns1014 0 0.000858008891226
Gc28_1015 0 n56 ns1015 0 -0.00170174508981
Gc28_1016 0 n56 ns1016 0 -0.00575760969353
Gc28_1017 0 n56 ns1017 0 -0.00119333075382
Gc28_1018 0 n56 ns1018 0 -0.00119347818194
Gc28_1019 0 n56 ns1019 0 0.00088943743637
Gc28_1020 0 n56 ns1020 0 0.00246497972781
Gc28_1021 0 n56 ns1021 0 0.00024135932472
Gc28_1022 0 n56 ns1022 0 0.018807871735
Gc28_1023 0 n56 ns1023 0 -0.0268115005212
Gc28_1024 0 n56 ns1024 0 0.00543810557658
Gc28_1025 0 n56 ns1025 0 2.80146333877e-06
Gc28_1026 0 n56 ns1026 0 1.57672244404e-05
Gc28_1027 0 n56 ns1027 0 -0.00320308069582
Gc28_1028 0 n56 ns1028 0 -1.02640910782e-06
Gc28_1029 0 n56 ns1029 0 -0.00278626834483
Gc28_1030 0 n56 ns1030 0 0.000136868535549
Gc28_1031 0 n56 ns1031 0 -0.000276001390043
Gc28_1032 0 n56 ns1032 0 0.000407870511943
Gc28_1033 0 n56 ns1033 0 -0.000192894823834
Gc28_1034 0 n56 ns1034 0 -0.000217607161916
Gc28_1035 0 n56 ns1035 0 -8.80853660012e-05
Gc28_1036 0 n56 ns1036 0 -0.00374315324219
Gc28_1037 0 n56 ns1037 0 0.00223503429852
Gc28_1038 0 n56 ns1038 0 0.00141101141081
Gc28_1039 0 n56 ns1039 0 -0.000365718517741
Gc28_1040 0 n56 ns1040 0 0.000358361463653
Gc28_1041 0 n56 ns1041 0 -0.000587857591218
Gc28_1042 0 n56 ns1042 0 2.78972702147e-05
Gc28_1043 0 n56 ns1043 0 0.00153161295291
Gc28_1044 0 n56 ns1044 0 0.000664061303571
Gc28_1045 0 n56 ns1045 0 0.000294499240864
Gc28_1046 0 n56 ns1046 0 0.000588114366403
Gc28_1047 0 n56 ns1047 0 0.000147642738741
Gc28_1048 0 n56 ns1048 0 0.00120451371264
Gc28_1049 0 n56 ns1049 0 0.00100239193046
Gc28_1050 0 n56 ns1050 0 0.00149322559055
Gc28_1051 0 n56 ns1051 0 0.00263540389382
Gc28_1052 0 n56 ns1052 0 0.00115270120027
Gc28_1053 0 n56 ns1053 0 -0.0021441986051
Gc28_1054 0 n56 ns1054 0 0.000106793266522
Gc28_1055 0 n56 ns1055 0 -0.00285865693082
Gc28_1056 0 n56 ns1056 0 0.0020125131119
Gc28_1057 0 n56 ns1057 0 0.00176917025681
Gc28_1058 0 n56 ns1058 0 0.00318709910998
Gc28_1059 0 n56 ns1059 0 3.83810774563e-05
Gc28_1060 0 n56 ns1060 0 -0.0198499897802
Gc28_1061 0 n56 ns1061 0 0.0202844849323
Gc28_1062 0 n56 ns1062 0 0.00701988124067
Gc28_1063 0 n56 ns1063 0 1.04587667661e-05
Gc28_1064 0 n56 ns1064 0 9.21651051479e-06
Gc28_1065 0 n56 ns1065 0 -0.00235791992801
Gc28_1066 0 n56 ns1066 0 -0.00133550843923
Gc28_1067 0 n56 ns1067 0 0.00149858231935
Gc28_1068 0 n56 ns1068 0 0.000153800164189
Gc28_1069 0 n56 ns1069 0 -0.000440337876265
Gc28_1070 0 n56 ns1070 0 0.000426421662932
Gc28_1071 0 n56 ns1071 0 0.000493346938391
Gc28_1072 0 n56 ns1072 0 -0.000149508641091
Gc28_1073 0 n56 ns1073 0 -5.04472789344e-05
Gc28_1074 0 n56 ns1074 0 -0.000460485859685
Gc28_1075 0 n56 ns1075 0 0.000397739580876
Gc28_1076 0 n56 ns1076 0 0.000716033209515
Gc28_1077 0 n56 ns1077 0 -0.000130774374081
Gc28_1078 0 n56 ns1078 0 0.000301374153924
Gc28_1079 0 n56 ns1079 0 -0.000427949633462
Gc28_1080 0 n56 ns1080 0 0.000477064799711
Gc28_1081 0 n56 ns1081 0 -0.00161842288947
Gc28_1082 0 n56 ns1082 0 -0.000295073901685
Gc28_1083 0 n56 ns1083 0 -0.000140103851905
Gc28_1084 0 n56 ns1084 0 0.000344751572964
Gc28_1085 0 n56 ns1085 0 0.000187249196577
Gc28_1086 0 n56 ns1086 0 -0.0029530079144
Gc28_1087 0 n56 ns1087 0 -0.000795393865814
Gc28_1088 0 n56 ns1088 0 0.000912513503018
Gc28_1089 0 n56 ns1089 0 0.00112471459423
Gc28_1090 0 n56 ns1090 0 0.00065920787922
Gc28_1091 0 n56 ns1091 0 -0.00147253363664
Gc28_1092 0 n56 ns1092 0 -0.00413543553902
Gc28_1093 0 n56 ns1093 0 -0.000904439678947
Gc28_1094 0 n56 ns1094 0 -0.00122362349622
Gc28_1095 0 n56 ns1095 0 0.000479068721002
Gc28_1096 0 n56 ns1096 0 0.00230024590976
Gc28_1097 0 n56 ns1097 0 0.000236985309591
Gc28_1098 0 n56 ns1098 0 0.0297893612727
Gc28_1099 0 n56 ns1099 0 -0.0357403626675
Gc28_1100 0 n56 ns1100 0 0.00567900652091
Gc28_1101 0 n56 ns1101 0 1.19515620682e-06
Gc28_1102 0 n56 ns1102 0 -3.11313490152e-06
Gc28_1103 0 n56 ns1103 0 -0.00148561704952
Gc28_1104 0 n56 ns1104 0 0.00113657297987
Gc28_1105 0 n56 ns1105 0 -0.00342960704603
Gc28_1106 0 n56 ns1106 0 0.000331976508811
Gc28_1107 0 n56 ns1107 0 -0.000584232901273
Gc28_1108 0 n56 ns1108 0 0.000280823745418
Gc28_1109 0 n56 ns1109 0 -0.000185825673384
Gc28_1110 0 n56 ns1110 0 -4.74521185825e-05
Gc28_1111 0 n56 ns1111 0 3.58192628362e-05
Gc28_1112 0 n56 ns1112 0 -0.00143818600366
Gc28_1113 0 n56 ns1113 0 0.00099908258903
Gc28_1114 0 n56 ns1114 0 0.000117265838445
Gc28_1115 0 n56 ns1115 0 -0.000508029219927
Gc28_1116 0 n56 ns1116 0 5.12701797173e-05
Gc28_1117 0 n56 ns1117 0 -0.000371371141629
Gc28_1118 0 n56 ns1118 0 -0.00141935505125
Gc28_1119 0 n56 ns1119 0 0.00122183266479
Gc28_1120 0 n56 ns1120 0 0.000207383998332
Gc28_1121 0 n56 ns1121 0 -2.72462323096e-05
Gc28_1122 0 n56 ns1122 0 0.000401229349342
Gc28_1123 0 n56 ns1123 0 -2.69631358242e-05
Gc28_1124 0 n56 ns1124 0 0.000823018697273
Gc28_1125 0 n56 ns1125 0 0.00384107840551
Gc28_1126 0 n56 ns1126 0 0.000781850634205
Gc28_1127 0 n56 ns1127 0 0.000212716054439
Gc28_1128 0 n56 ns1128 0 -5.53364974797e-05
Gc28_1129 0 n56 ns1129 0 -0.00120469939687
Gc28_1130 0 n56 ns1130 0 0.00355623147654
Gc28_1131 0 n56 ns1131 0 0.00211216490528
Gc28_1132 0 n56 ns1132 0 -0.00158710161473
Gc28_1133 0 n56 ns1133 0 0.000429397394772
Gc28_1134 0 n56 ns1134 0 0.00126265548543
Gc28_1135 0 n56 ns1135 0 -0.000440834390668
Gc28_1136 0 n56 ns1136 0 0.0537912978409
Gc28_1137 0 n56 ns1137 0 -0.0497730672252
Gc28_1138 0 n56 ns1138 0 0.00288334351081
Gc28_1139 0 n56 ns1139 0 -3.01381692306e-06
Gc28_1140 0 n56 ns1140 0 -1.8009307266e-05
Gc28_1141 0 n56 ns1141 0 -0.00077287295603
Gc28_1142 0 n56 ns1142 0 0.00171794335184
Gc28_1143 0 n56 ns1143 0 -0.00350148189419
Gc28_1144 0 n56 ns1144 0 -0.000251334555522
Gc28_1145 0 n56 ns1145 0 -0.00014505770657
Gc28_1146 0 n56 ns1146 0 -0.00018949859332
Gc28_1147 0 n56 ns1147 0 -0.000147791531797
Gc28_1148 0 n56 ns1148 0 -2.34118105505e-05
Gc28_1149 0 n56 ns1149 0 -1.22188306052e-05
Gc28_1150 0 n56 ns1150 0 -6.01997736187e-05
Gc28_1151 0 n56 ns1151 0 0.00185210506682
Gc28_1152 0 n56 ns1152 0 -1.87215837042e-06
Gc28_1153 0 n56 ns1153 0 -0.0001400403576
Gc28_1154 0 n56 ns1154 0 -0.000125261550338
Gc28_1155 0 n56 ns1155 0 -0.000312569018502
Gc28_1156 0 n56 ns1156 0 0.000999244783437
Gc28_1157 0 n56 ns1157 0 0.000891254410522
Gc28_1158 0 n56 ns1158 0 -0.000331271663426
Gc28_1159 0 n56 ns1159 0 -9.52211346007e-05
Gc28_1160 0 n56 ns1160 0 0.000221920700148
Gc28_1161 0 n56 ns1161 0 -0.000127817714875
Gc28_1162 0 n56 ns1162 0 0.00156907815095
Gc28_1163 0 n56 ns1163 0 0.000520024099355
Gc28_1164 0 n56 ns1164 0 0.000301593420124
Gc28_1165 0 n56 ns1165 0 0.000754747942329
Gc28_1166 0 n56 ns1166 0 -0.000133497790202
Gc28_1167 0 n56 ns1167 0 -0.000978845002369
Gc28_1168 0 n56 ns1168 0 0.00120757274958
Gc28_1169 0 n56 ns1169 0 -0.000522210285052
Gc28_1170 0 n56 ns1170 0 -0.000427069622907
Gc28_1171 0 n56 ns1171 0 0.00143772734403
Gc28_1172 0 n56 ns1172 0 0.000779821564016
Gc28_1173 0 n56 ns1173 0 -0.000665696075478
Gc28_1174 0 n56 ns1174 0 0.0272517447237
Gc28_1175 0 n56 ns1175 0 -0.0246893622744
Gc28_1176 0 n56 ns1176 0 0.00122597075414
Gc28_1177 0 n56 ns1177 0 -7.00774723895e-06
Gc28_1178 0 n56 ns1178 0 -1.88492087475e-05
Gc28_1179 0 n56 ns1179 0 0.000113660453271
Gc28_1180 0 n56 ns1180 0 -0.000752757971293
Gc28_1181 0 n56 ns1181 0 0.00273887619776
Gc28_1182 0 n56 ns1182 0 0.000121979723156
Gc28_1183 0 n56 ns1183 0 2.05392991815e-05
Gc28_1184 0 n56 ns1184 0 1.17767871319e-05
Gc28_1185 0 n56 ns1185 0 9.04825291666e-05
Gc28_1186 0 n56 ns1186 0 1.45954682145e-05
Gc28_1187 0 n56 ns1187 0 1.115301948e-05
Gc28_1188 0 n56 ns1188 0 -0.000703259019605
Gc28_1189 0 n56 ns1189 0 -0.000658670815121
Gc28_1190 0 n56 ns1190 0 0.000748259111953
Gc28_1191 0 n56 ns1191 0 0.000339874783866
Gc28_1192 0 n56 ns1192 0 -8.94989400583e-05
Gc28_1193 0 n56 ns1193 0 -0.000269390419519
Gc28_1194 0 n56 ns1194 0 -0.000567066865265
Gc28_1195 0 n56 ns1195 0 -0.00143052071154
Gc28_1196 0 n56 ns1196 0 -0.00041255517201
Gc28_1197 0 n56 ns1197 0 0.00106144870381
Gc28_1198 0 n56 ns1198 0 0.000256403482987
Gc28_1199 0 n56 ns1199 0 -2.46411187001e-05
Gc28_1200 0 n56 ns1200 0 -0.00145982519989
Gc28_1201 0 n56 ns1201 0 0.000345438218958
Gc28_1202 0 n56 ns1202 0 0.000821243895651
Gc28_1203 0 n56 ns1203 0 0.00112709391809
Gc28_1204 0 n56 ns1204 0 -0.000252600770001
Gc28_1205 0 n56 ns1205 0 -0.000912944242491
Gc28_1206 0 n56 ns1206 0 -0.00200530737016
Gc28_1207 0 n56 ns1207 0 8.64124265656e-05
Gc28_1208 0 n56 ns1208 0 0.0004994524912
Gc28_1209 0 n56 ns1209 0 0.00126843876213
Gc28_1210 0 n56 ns1210 0 0.000454151151005
Gc28_1211 0 n56 ns1211 0 -0.000583457234805
Gc28_1212 0 n56 ns1212 0 0.00410225454025
Gc28_1213 0 n56 ns1213 0 -0.00484600205868
Gc28_1214 0 n56 ns1214 0 0.000418656903467
Gc28_1215 0 n56 ns1215 0 -5.00089181283e-06
Gc28_1216 0 n56 ns1216 0 -1.82156837288e-05
Gd28_1 0 n56 ni1 0 0.000268108649454
Gd28_2 0 n56 ni2 0 0.000243277256127
Gd28_3 0 n56 ni3 0 -8.26855832593e-05
Gd28_4 0 n56 ni4 0 -0.00169471238389
Gd28_5 0 n56 ni5 0 -0.00301363108831
Gd28_6 0 n56 ni6 0 -0.000101411553488
Gd28_7 0 n56 ni7 0 0.000238339074459
Gd28_8 0 n56 ni8 0 0.000205302786152
Gd28_9 0 n56 ni9 0 4.48620712663e-05
Gd28_10 0 n56 ni10 0 0.00051203405321
Gd28_11 0 n56 ni11 0 -0.000463273885614
Gd28_12 0 n56 ni12 0 -0.00686617161117
Gd28_13 0 n56 ni13 0 -0.000346805420974
Gd28_14 0 n56 ni14 0 0.000614274687352
Gd28_15 0 n56 ni15 0 0.00018924863636
Gd28_16 0 n56 ni16 0 8.35061491245e-05
Gd28_17 0 n56 ni17 0 0.000235847450193
Gd28_18 0 n56 ni18 0 0.000228167993466
Gd28_19 0 n56 ni19 0 -0.000713717142729
Gd28_20 0 n56 ni20 0 -0.00275765121942
Gd28_21 0 n56 ni21 0 -0.00107259034448
Gd28_22 0 n56 ni22 0 -0.00125493105011
Gd28_23 0 n56 ni23 0 9.76897705547e-05
Gd28_24 0 n56 ni24 0 0.000159672404491
Gd28_25 0 n56 ni25 0 0.000250696908311
Gd28_26 0 n56 ni26 0 -0.00029282789209
Gd28_27 0 n56 ni27 0 -0.00177096897517
Gd28_28 0 n56 ni28 0 0.000564006585502
Gd28_29 0 n56 ni29 0 -0.00191187026211
Gd28_30 0 n56 ni30 0 -0.00046813334718
Gd28_31 0 n56 ni31 0 0.000200057600568
Gd28_32 0 n56 ni32 0 2.54709594097e-05
Gc29_1 0 n58 ns1 0 0.000119701453991
Gc29_2 0 n58 ns2 0 -0.000583829300371
Gc29_3 0 n58 ns3 0 0.00436627555747
Gc29_4 0 n58 ns4 0 0.000196216556528
Gc29_5 0 n58 ns5 0 0.000166713579467
Gc29_6 0 n58 ns6 0 0.000210015924796
Gc29_7 0 n58 ns7 0 -0.000166842980486
Gc29_8 0 n58 ns8 0 -1.76778681115e-05
Gc29_9 0 n58 ns9 0 -7.05095762169e-05
Gc29_10 0 n58 ns10 0 0.000619541362872
Gc29_11 0 n58 ns11 0 -0.000245764661319
Gc29_12 0 n58 ns12 0 -0.000593044580098
Gc29_13 0 n58 ns13 0 -0.00043466213617
Gc29_14 0 n58 ns14 0 2.87569966511e-05
Gc29_15 0 n58 ns15 0 0.000305717873045
Gc29_16 0 n58 ns16 0 2.74921097624e-05
Gc29_17 0 n58 ns17 0 -0.00210552023996
Gc29_18 0 n58 ns18 0 -0.000919404200355
Gc29_19 0 n58 ns19 0 0.000990258885091
Gc29_20 0 n58 ns20 0 0.000229454252133
Gc29_21 0 n58 ns21 0 9.82616535782e-05
Gc29_22 0 n58 ns22 0 -0.000590585589777
Gc29_23 0 n58 ns23 0 -0.0011481278812
Gc29_24 0 n58 ns24 0 -0.00114756137057
Gc29_25 0 n58 ns25 0 -0.000935149232642
Gc29_26 0 n58 ns26 0 0.000440390805984
Gc29_27 0 n58 ns27 0 0.00106002291922
Gc29_28 0 n58 ns28 0 -0.00495392003749
Gc29_29 0 n58 ns29 0 -0.00215376534056
Gc29_30 0 n58 ns30 0 0.000443156097585
Gc29_31 0 n58 ns31 0 0.00223557367809
Gc29_32 0 n58 ns32 0 0.000771188165436
Gc29_33 0 n58 ns33 0 -0.000553252564851
Gc29_34 0 n58 ns34 0 -0.0189602179504
Gc29_35 0 n58 ns35 0 0.015391050487
Gc29_36 0 n58 ns36 0 -0.000530494315557
Gc29_37 0 n58 ns37 0 3.58353086413e-06
Gc29_38 0 n58 ns38 0 -6.40187266736e-06
Gc29_39 0 n58 ns39 0 0.000226605363505
Gc29_40 0 n58 ns40 0 -0.000924167956336
Gc29_41 0 n58 ns41 0 0.00556662244677
Gc29_42 0 n58 ns42 0 0.000239451645557
Gc29_43 0 n58 ns43 0 0.000136628874268
Gc29_44 0 n58 ns44 0 0.000217262268242
Gc29_45 0 n58 ns45 0 -0.000141498912636
Gc29_46 0 n58 ns46 0 -3.02028020599e-06
Gc29_47 0 n58 ns47 0 -3.90134272928e-05
Gc29_48 0 n58 ns48 0 0.000367114452973
Gc29_49 0 n58 ns49 0 -0.000567342626847
Gc29_50 0 n58 ns50 0 -0.000486609863406
Gc29_51 0 n58 ns51 0 -0.000377303971877
Gc29_52 0 n58 ns52 0 7.30798875719e-05
Gc29_53 0 n58 ns53 0 0.00035469071836
Gc29_54 0 n58 ns54 0 0.000314420331954
Gc29_55 0 n58 ns55 0 -0.00208829304319
Gc29_56 0 n58 ns56 0 -0.00111890524905
Gc29_57 0 n58 ns57 0 0.000892042270905
Gc29_58 0 n58 ns58 0 0.000236937777392
Gc29_59 0 n58 ns59 0 9.80245227397e-05
Gc29_60 0 n58 ns60 0 -0.000812327844216
Gc29_61 0 n58 ns61 0 -0.00160816779576
Gc29_62 0 n58 ns62 0 -0.00129310282392
Gc29_63 0 n58 ns63 0 -0.0011371799255
Gc29_64 0 n58 ns64 0 0.000467153582933
Gc29_65 0 n58 ns65 0 0.00131617761831
Gc29_66 0 n58 ns66 0 -0.00603364159758
Gc29_67 0 n58 ns67 0 -0.00296127490078
Gc29_68 0 n58 ns68 0 0.000362629162868
Gc29_69 0 n58 ns69 0 0.00281691789459
Gc29_70 0 n58 ns70 0 0.00100436570089
Gc29_71 0 n58 ns71 0 -0.000641809680796
Gc29_72 0 n58 ns72 0 -0.0262327906823
Gc29_73 0 n58 ns73 0 0.021564146452
Gc29_74 0 n58 ns74 0 -0.000761037978672
Gc29_75 0 n58 ns75 0 -4.8679797545e-08
Gc29_76 0 n58 ns76 0 -7.46983437559e-06
Gc29_77 0 n58 ns77 0 0.000645313088975
Gc29_78 0 n58 ns78 0 -0.00151768777798
Gc29_79 0 n58 ns79 0 0.00805736294949
Gc29_80 0 n58 ns80 0 0.000183920054533
Gc29_81 0 n58 ns81 0 9.44970339076e-06
Gc29_82 0 n58 ns82 0 4.76681731556e-05
Gc29_83 0 n58 ns83 0 0.000150313603475
Gc29_84 0 n58 ns84 0 1.53085564113e-05
Gc29_85 0 n58 ns85 0 4.96993473466e-05
Gc29_86 0 n58 ns86 0 -0.000440270755931
Gc29_87 0 n58 ns87 0 -0.00260030953652
Gc29_88 0 n58 ns88 0 0.00013278842345
Gc29_89 0 n58 ns89 0 0.000566729780229
Gc29_90 0 n58 ns90 0 0.000200875680021
Gc29_91 0 n58 ns91 0 0.000400506311676
Gc29_92 0 n58 ns92 0 0.000278423430735
Gc29_93 0 n58 ns93 0 -0.000354057608535
Gc29_94 0 n58 ns94 0 -0.00081118883528
Gc29_95 0 n58 ns95 0 -8.54526833129e-05
Gc29_96 0 n58 ns96 0 0.000194932840644
Gc29_97 0 n58 ns97 0 9.48591814954e-06
Gc29_98 0 n58 ns98 0 -0.00156825112721
Gc29_99 0 n58 ns99 0 -0.00294934136744
Gc29_100 0 n58 ns100 0 -0.00103162835603
Gc29_101 0 n58 ns101 0 -0.000943334119317
Gc29_102 0 n58 ns102 0 0.000253856894615
Gc29_103 0 n58 ns103 0 0.00153048980448
Gc29_104 0 n58 ns104 0 -0.00718870291439
Gc29_105 0 n58 ns105 0 -0.00446581898714
Gc29_106 0 n58 ns106 0 -0.000633299379926
Gc29_107 0 n58 ns107 0 0.00370966878364
Gc29_108 0 n58 ns108 0 0.00170568675149
Gc29_109 0 n58 ns109 0 -0.000612087546501
Gc29_110 0 n58 ns110 0 -0.0439368136135
Gc29_111 0 n58 ns111 0 0.0372914789989
Gc29_112 0 n58 ns112 0 -0.00155244165909
Gc29_113 0 n58 ns113 0 -7.00267935561e-06
Gc29_114 0 n58 ns114 0 -1.15812145054e-05
Gc29_115 0 n58 ns115 0 0.000293018398206
Gc29_116 0 n58 ns116 0 -0.00115784888171
Gc29_117 0 n58 ns117 0 0.0101494808067
Gc29_118 0 n58 ns118 0 -0.000151185655732
Gc29_119 0 n58 ns119 0 0.00053552492205
Gc29_120 0 n58 ns120 0 0.000600354678903
Gc29_121 0 n58 ns121 0 -0.000315575072376
Gc29_122 0 n58 ns122 0 -0.000121430635576
Gc29_123 0 n58 ns123 0 -2.66026668904e-05
Gc29_124 0 n58 ns124 0 0.00103185601325
Gc29_125 0 n58 ns125 0 -0.00385034032845
Gc29_126 0 n58 ns126 0 -0.000174569934115
Gc29_127 0 n58 ns127 0 0.00114739572013
Gc29_128 0 n58 ns128 0 2.17799974474e-05
Gc29_129 0 n58 ns129 0 0.000474497817221
Gc29_130 0 n58 ns130 0 -0.00142009275789
Gc29_131 0 n58 ns131 0 -0.00123328466671
Gc29_132 0 n58 ns132 0 -0.000339059447534
Gc29_133 0 n58 ns133 0 3.21154701083e-05
Gc29_134 0 n58 ns134 0 0.0003287700651
Gc29_135 0 n58 ns135 0 0.000133837412242
Gc29_136 0 n58 ns136 0 -0.00148043775961
Gc29_137 0 n58 ns137 0 -0.00576227241198
Gc29_138 0 n58 ns138 0 -0.00210522378397
Gc29_139 0 n58 ns139 0 -5.16844955694e-05
Gc29_140 0 n58 ns140 0 0.000457733479816
Gc29_141 0 n58 ns141 0 0.00172053219943
Gc29_142 0 n58 ns142 0 -0.00976292508101
Gc29_143 0 n58 ns143 0 -0.00526569019176
Gc29_144 0 n58 ns144 0 -0.00172627280349
Gc29_145 0 n58 ns145 0 0.00341873315876
Gc29_146 0 n58 ns146 0 0.00253817319878
Gc29_147 0 n58 ns147 0 -0.000139000685852
Gc29_148 0 n58 ns148 0 -0.0774012002146
Gc29_149 0 n58 ns149 0 0.0690139026025
Gc29_150 0 n58 ns150 0 -0.0039320699535
Gc29_151 0 n58 ns151 0 -9.16811929317e-06
Gc29_152 0 n58 ns152 0 -1.21802026887e-05
Gc29_153 0 n58 ns153 0 -0.00243124578781
Gc29_154 0 n58 ns154 0 -0.00307012860187
Gc29_155 0 n58 ns155 0 0.00714037945878
Gc29_156 0 n58 ns156 0 0.000924165716751
Gc29_157 0 n58 ns157 0 -0.00170154865303
Gc29_158 0 n58 ns158 0 0.000683407441227
Gc29_159 0 n58 ns159 0 0.00198045463026
Gc29_160 0 n58 ns160 0 3.99828299762e-05
Gc29_161 0 n58 ns161 0 -0.00022634794793
Gc29_162 0 n58 ns162 0 0.00057322743925
Gc29_163 0 n58 ns163 0 -0.00100603381465
Gc29_164 0 n58 ns164 0 -0.000824557735617
Gc29_165 0 n58 ns165 0 0.000485061181972
Gc29_166 0 n58 ns166 0 -0.000228266235842
Gc29_167 0 n58 ns167 0 0.00044678976003
Gc29_168 0 n58 ns168 0 0.00160939882463
Gc29_169 0 n58 ns169 0 -0.00257949715778
Gc29_170 0 n58 ns170 0 -0.000629884479437
Gc29_171 0 n58 ns171 0 -0.000374413264491
Gc29_172 0 n58 ns172 0 0.000215882561105
Gc29_173 0 n58 ns173 0 0.000237055409792
Gc29_174 0 n58 ns174 0 0.00203080302534
Gc29_175 0 n58 ns175 0 -0.0023040576085
Gc29_176 0 n58 ns176 0 -0.00254465333646
Gc29_177 0 n58 ns177 0 -0.00162584099596
Gc29_178 0 n58 ns178 0 -0.000290075741599
Gc29_179 0 n58 ns179 0 0.002234113132
Gc29_180 0 n58 ns180 0 -0.0115461360737
Gc29_181 0 n58 ns181 0 -0.00431948868899
Gc29_182 0 n58 ns182 0 0.000384898293986
Gc29_183 0 n58 ns183 0 0.00226783522447
Gc29_184 0 n58 ns184 0 0.00307286240813
Gc29_185 0 n58 ns185 0 0.000170478747254
Gc29_186 0 n58 ns186 0 -0.0326123701546
Gc29_187 0 n58 ns187 0 0.0349150584806
Gc29_188 0 n58 ns188 0 -0.00694789151013
Gc29_189 0 n58 ns189 0 -8.56146529375e-06
Gc29_190 0 n58 ns190 0 -8.28477275091e-06
Gc29_191 0 n58 ns191 0 -0.00538255946531
Gc29_192 0 n58 ns192 0 -0.00436866893576
Gc29_193 0 n58 ns193 0 0.00720233971327
Gc29_194 0 n58 ns194 0 0.00220483642561
Gc29_195 0 n58 ns195 0 -0.00190248584944
Gc29_196 0 n58 ns196 0 0.0008174179747
Gc29_197 0 n58 ns197 0 0.0029970475082
Gc29_198 0 n58 ns198 0 2.87481585277e-05
Gc29_199 0 n58 ns199 0 -0.000323339395552
Gc29_200 0 n58 ns200 0 -0.00120589467811
Gc29_201 0 n58 ns201 0 -0.00181465917515
Gc29_202 0 n58 ns202 0 -0.000596902002064
Gc29_203 0 n58 ns203 0 0.00083209498154
Gc29_204 0 n58 ns204 0 -7.7838378855e-05
Gc29_205 0 n58 ns205 0 0.000461131645593
Gc29_206 0 n58 ns206 0 0.00287524348093
Gc29_207 0 n58 ns207 0 -0.00186445652405
Gc29_208 0 n58 ns208 0 -0.000536688433349
Gc29_209 0 n58 ns209 0 -0.000906164901023
Gc29_210 0 n58 ns210 0 0.000117286052331
Gc29_211 0 n58 ns211 0 9.0743627454e-05
Gc29_212 0 n58 ns212 0 0.00268937554712
Gc29_213 0 n58 ns213 0 0.00120300321616
Gc29_214 0 n58 ns214 0 -0.00126534077418
Gc29_215 0 n58 ns215 0 -0.00247029697562
Gc29_216 0 n58 ns216 0 -0.00103900594796
Gc29_217 0 n58 ns217 0 0.00198467771114
Gc29_218 0 n58 ns218 0 -0.0137957858386
Gc29_219 0 n58 ns219 0 -0.00470268331204
Gc29_220 0 n58 ns220 0 0.00221246302867
Gc29_221 0 n58 ns221 0 0.00348780598073
Gc29_222 0 n58 ns222 0 0.00355750180189
Gc29_223 0 n58 ns223 0 0.000106272200561
Gc29_224 0 n58 ns224 0 0.0186977833719
Gc29_225 0 n58 ns225 0 -0.00941518235364
Gc29_226 0 n58 ns226 0 -0.0075973016094
Gc29_227 0 n58 ns227 0 -1.14793182221e-05
Gc29_228 0 n58 ns228 0 -7.68829327118e-06
Gc29_229 0 n58 ns229 0 0.000200390560982
Gc29_230 0 n58 ns230 0 -0.00108591764038
Gc29_231 0 n58 ns231 0 0.00986692091089
Gc29_232 0 n58 ns232 0 -0.000248163760652
Gc29_233 0 n58 ns233 0 0.000174922451279
Gc29_234 0 n58 ns234 0 0.000484301296493
Gc29_235 0 n58 ns235 0 -0.000510702753627
Gc29_236 0 n58 ns236 0 -8.36376128712e-05
Gc29_237 0 n58 ns237 0 3.36677744394e-05
Gc29_238 0 n58 ns238 0 0.00202294111957
Gc29_239 0 n58 ns239 0 -0.00276918218302
Gc29_240 0 n58 ns240 0 -0.000633525335198
Gc29_241 0 n58 ns241 0 0.000848360900516
Gc29_242 0 n58 ns242 0 -4.78809936766e-05
Gc29_243 0 n58 ns243 0 0.000523303214395
Gc29_244 0 n58 ns244 0 -0.00134840195771
Gc29_245 0 n58 ns245 0 -0.00244588663403
Gc29_246 0 n58 ns246 0 -0.000629088949644
Gc29_247 0 n58 ns247 0 0.000439097909574
Gc29_248 0 n58 ns248 0 0.000365874243302
Gc29_249 0 n58 ns249 0 0.000261629165276
Gc29_250 0 n58 ns250 0 -0.000251767409172
Gc29_251 0 n58 ns251 0 -0.00646471975561
Gc29_252 0 n58 ns252 0 -0.00291684171812
Gc29_253 0 n58 ns253 0 -0.0004793982591
Gc29_254 0 n58 ns254 0 0.000499804434447
Gc29_255 0 n58 ns255 0 0.00210717414344
Gc29_256 0 n58 ns256 0 -0.0109174532647
Gc29_257 0 n58 ns257 0 -0.0056273672753
Gc29_258 0 n58 ns258 0 -0.00184818073502
Gc29_259 0 n58 ns259 0 0.00293652543432
Gc29_260 0 n58 ns260 0 0.00271213273129
Gc29_261 0 n58 ns261 0 0.000164030507524
Gc29_262 0 n58 ns262 0 -0.0914148819339
Gc29_263 0 n58 ns263 0 0.0831755694968
Gc29_264 0 n58 ns264 0 -0.00526443956739
Gc29_265 0 n58 ns265 0 -1.0146982066e-05
Gc29_266 0 n58 ns266 0 -2.30348584727e-07
Gc29_267 0 n58 ns267 0 0.000603806527812
Gc29_268 0 n58 ns268 0 -0.00202051221414
Gc29_269 0 n58 ns269 0 0.0107601108837
Gc29_270 0 n58 ns270 0 0.000566893352253
Gc29_271 0 n58 ns271 0 8.10948957528e-05
Gc29_272 0 n58 ns272 0 6.73492181311e-05
Gc29_273 0 n58 ns273 0 -2.85564697555e-05
Gc29_274 0 n58 ns274 0 -4.81093803361e-05
Gc29_275 0 n58 ns275 0 8.83366969818e-06
Gc29_276 0 n58 ns276 0 -0.000275433550281
Gc29_277 0 n58 ns277 0 -0.00310520109553
Gc29_278 0 n58 ns278 0 -1.72417241236e-05
Gc29_279 0 n58 ns279 0 0.000505960033915
Gc29_280 0 n58 ns280 0 0.000120801664619
Gc29_281 0 n58 ns281 0 0.000505263858201
Gc29_282 0 n58 ns282 0 -0.000301915905914
Gc29_283 0 n58 ns283 0 -0.000829306626397
Gc29_284 0 n58 ns284 0 -0.000884457872287
Gc29_285 0 n58 ns285 0 9.38976264628e-05
Gc29_286 0 n58 ns286 0 0.000272325948248
Gc29_287 0 n58 ns287 0 9.45461400167e-05
Gc29_288 0 n58 ns288 0 -0.00236094849701
Gc29_289 0 n58 ns289 0 -0.00360818158188
Gc29_290 0 n58 ns290 0 -0.000981929214228
Gc29_291 0 n58 ns291 0 -0.000597599027574
Gc29_292 0 n58 ns292 0 0.000206965878796
Gc29_293 0 n58 ns293 0 0.00147450943753
Gc29_294 0 n58 ns294 0 -0.00839845187819
Gc29_295 0 n58 ns295 0 -0.0056728124927
Gc29_296 0 n58 ns296 0 -0.0012989405962
Gc29_297 0 n58 ns297 0 0.00414713070409
Gc29_298 0 n58 ns298 0 0.00209024390405
Gc29_299 0 n58 ns299 0 -0.00041780892364
Gc29_300 0 n58 ns300 0 -0.0622508733004
Gc29_301 0 n58 ns301 0 0.053336010142
Gc29_302 0 n58 ns302 0 -0.00224618279882
Gc29_303 0 n58 ns303 0 -8.82273697564e-06
Gc29_304 0 n58 ns304 0 6.08050491464e-07
Gc29_305 0 n58 ns305 0 -1.97813064873e-05
Gc29_306 0 n58 ns306 0 0.0002184300449
Gc29_307 0 n58 ns307 0 0.00408366859702
Gc29_308 0 n58 ns308 0 -7.51819919469e-05
Gc29_309 0 n58 ns309 0 0.00029698941979
Gc29_310 0 n58 ns310 0 0.000422422589304
Gc29_311 0 n58 ns311 0 -1.06906720536e-05
Gc29_312 0 n58 ns312 0 3.39061120384e-05
Gc29_313 0 n58 ns313 0 -4.24029118475e-05
Gc29_314 0 n58 ns314 0 -0.00047877320376
Gc29_315 0 n58 ns315 0 -9.88689595587e-05
Gc29_316 0 n58 ns316 0 0.000222491929057
Gc29_317 0 n58 ns317 0 -0.000619155314091
Gc29_318 0 n58 ns318 0 -4.90666418397e-05
Gc29_319 0 n58 ns319 0 0.000204705893889
Gc29_320 0 n58 ns320 0 0.00146408154045
Gc29_321 0 n58 ns321 0 -0.00144593980608
Gc29_322 0 n58 ns322 0 -0.00148131466753
Gc29_323 0 n58 ns323 0 0.000153038419968
Gc29_324 0 n58 ns324 0 0.000114031895937
Gc29_325 0 n58 ns325 0 0.00019166679741
Gc29_326 0 n58 ns326 0 -0.000832204731786
Gc29_327 0 n58 ns327 0 -0.00137375537941
Gc29_328 0 n58 ns328 0 -0.000580977899913
Gc29_329 0 n58 ns329 0 -0.00131546358024
Gc29_330 0 n58 ns330 0 1.19005829382e-06
Gc29_331 0 n58 ns331 0 0.00126667265289
Gc29_332 0 n58 ns332 0 -0.00512264434742
Gc29_333 0 n58 ns333 0 -0.00356037668108
Gc29_334 0 n58 ns334 0 -0.000173479052937
Gc29_335 0 n58 ns335 0 0.00288777408868
Gc29_336 0 n58 ns336 0 0.00115203368701
Gc29_337 0 n58 ns337 0 -0.000534038109308
Gc29_338 0 n58 ns338 0 -0.0257173234059
Gc29_339 0 n58 ns339 0 0.0214200228041
Gc29_340 0 n58 ns340 0 -0.000820585798306
Gc29_341 0 n58 ns341 0 -1.19352181126e-06
Gc29_342 0 n58 ns342 0 3.62952741487e-06
Gc29_343 0 n58 ns343 0 0.000257225431819
Gc29_344 0 n58 ns344 0 -0.000955251245811
Gc29_345 0 n58 ns345 0 0.00672045370299
Gc29_346 0 n58 ns346 0 0.000148187697727
Gc29_347 0 n58 ns347 0 0.000296830347718
Gc29_348 0 n58 ns348 0 0.00033282472577
Gc29_349 0 n58 ns349 0 6.93586925615e-05
Gc29_350 0 n58 ns350 0 -1.21857720865e-07
Gc29_351 0 n58 ns351 0 2.70202537786e-06
Gc29_352 0 n58 ns352 0 -0.000311260234276
Gc29_353 0 n58 ns353 0 -0.00210278909526
Gc29_354 0 n58 ns354 0 -7.87626796124e-06
Gc29_355 0 n58 ns355 0 0.000265365620551
Gc29_356 0 n58 ns356 0 0.00021565584376
Gc29_357 0 n58 ns357 0 0.000370313620887
Gc29_358 0 n58 ns358 0 0.000624133357561
Gc29_359 0 n58 ns359 0 -0.00112890772836
Gc29_360 0 n58 ns360 0 -0.00107095087842
Gc29_361 0 n58 ns361 0 0.000246070797737
Gc29_362 0 n58 ns362 0 0.000174054331644
Gc29_363 0 n58 ns363 0 4.84052750904e-05
Gc29_364 0 n58 ns364 0 -0.00123358883359
Gc29_365 0 n58 ns365 0 -0.00250778748311
Gc29_366 0 n58 ns366 0 -0.0011711337431
Gc29_367 0 n58 ns367 0 -0.00117503873634
Gc29_368 0 n58 ns368 0 0.000333645358519
Gc29_369 0 n58 ns369 0 0.00152140078296
Gc29_370 0 n58 ns370 0 -0.00695179324751
Gc29_371 0 n58 ns371 0 -0.00439133224569
Gc29_372 0 n58 ns372 0 -0.000239854340064
Gc29_373 0 n58 ns373 0 0.00359449295989
Gc29_374 0 n58 ns374 0 0.00146036193493
Gc29_375 0 n58 ns375 0 -0.000643674059212
Gc29_376 0 n58 ns376 0 -0.0383847863905
Gc29_377 0 n58 ns377 0 0.0322224472047
Gc29_378 0 n58 ns378 0 -0.00123572920594
Gc29_379 0 n58 ns379 0 -4.91536741183e-06
Gc29_380 0 n58 ns380 0 -8.00087149368e-06
Gc29_381 0 n58 ns381 0 0.000787627177807
Gc29_382 0 n58 ns382 0 -0.000790686310038
Gc29_383 0 n58 ns383 0 0.0102739206616
Gc29_384 0 n58 ns384 0 1.37510894929e-05
Gc29_385 0 n58 ns385 0 0.000742054776255
Gc29_386 0 n58 ns386 0 0.000418120868324
Gc29_387 0 n58 ns387 0 -0.000126533101642
Gc29_388 0 n58 ns388 0 -8.63666998683e-05
Gc29_389 0 n58 ns389 0 -1.11346367047e-05
Gc29_390 0 n58 ns390 0 0.000143891901648
Gc29_391 0 n58 ns391 0 -0.00446210405988
Gc29_392 0 n58 ns392 0 0.000120791482239
Gc29_393 0 n58 ns393 0 0.0012125464715
Gc29_394 0 n58 ns394 0 0.000176660229855
Gc29_395 0 n58 ns395 0 0.000453801151371
Gc29_396 0 n58 ns396 0 -0.0011498350802
Gc29_397 0 n58 ns397 0 -0.000635893747329
Gc29_398 0 n58 ns398 0 -0.000403680803453
Gc29_399 0 n58 ns399 0 -5.04939031739e-06
Gc29_400 0 n58 ns400 0 0.000293792344929
Gc29_401 0 n58 ns401 0 6.06507596316e-05
Gc29_402 0 n58 ns402 0 -0.00223867605859
Gc29_403 0 n58 ns403 0 -0.00495953741755
Gc29_404 0 n58 ns404 0 -0.00157075802226
Gc29_405 0 n58 ns405 0 -9.15206757488e-05
Gc29_406 0 n58 ns406 0 0.000443587060794
Gc29_407 0 n58 ns407 0 0.00151957620755
Gc29_408 0 n58 ns408 0 -0.00903502261297
Gc29_409 0 n58 ns409 0 -0.00540216684761
Gc29_410 0 n58 ns410 0 -0.00157315623676
Gc29_411 0 n58 ns411 0 0.0038614656734
Gc29_412 0 n58 ns412 0 0.00230230802081
Gc29_413 0 n58 ns413 0 -0.000313534508862
Gc29_414 0 n58 ns414 0 -0.0701678944165
Gc29_415 0 n58 ns415 0 0.0611359837885
Gc29_416 0 n58 ns416 0 -0.00291237606599
Gc29_417 0 n58 ns417 0 -9.66774697975e-06
Gc29_418 0 n58 ns418 0 -1.31821265089e-05
Gc29_419 0 n58 ns419 0 -0.000155343984618
Gc29_420 0 n58 ns420 0 -0.000260504986012
Gc29_421 0 n58 ns421 0 0.00599334152066
Gc29_422 0 n58 ns422 0 -0.00132388471546
Gc29_423 0 n58 ns423 0 -0.000422698152151
Gc29_424 0 n58 ns424 0 0.00185844706181
Gc29_425 0 n58 ns425 0 0.00052382277338
Gc29_426 0 n58 ns426 0 -0.000162129943896
Gc29_427 0 n58 ns427 0 -0.000184562449879
Gc29_428 0 n58 ns428 0 0.00184686449611
Gc29_429 0 n58 ns429 0 -0.00219832324733
Gc29_430 0 n58 ns430 0 -0.000529129991172
Gc29_431 0 n58 ns431 0 0.000868750912679
Gc29_432 0 n58 ns432 0 -0.000129791434713
Gc29_433 0 n58 ns433 0 0.000441510033347
Gc29_434 0 n58 ns434 0 -0.000186365117156
Gc29_435 0 n58 ns435 0 -0.0032135375596
Gc29_436 0 n58 ns436 0 -0.00088193970835
Gc29_437 0 n58 ns437 0 0.000110273570927
Gc29_438 0 n58 ns438 0 0.000263477213036
Gc29_439 0 n58 ns439 0 0.000341945449703
Gc29_440 0 n58 ns440 0 0.000933004648071
Gc29_441 0 n58 ns441 0 -0.00543744484815
Gc29_442 0 n58 ns442 0 -0.00290807646501
Gc29_443 0 n58 ns443 0 -0.000846427366181
Gc29_444 0 n58 ns444 0 0.000216057745623
Gc29_445 0 n58 ns445 0 0.00214567705436
Gc29_446 0 n58 ns446 0 -0.0122417117464
Gc29_447 0 n58 ns447 0 -0.00509246718158
Gc29_448 0 n58 ns448 0 -0.00082793991136
Gc29_449 0 n58 ns449 0 0.00283693126092
Gc29_450 0 n58 ns450 0 0.00301014506407
Gc29_451 0 n58 ns451 0 0.000219038934037
Gc29_452 0 n58 ns452 0 -0.0660574061587
Gc29_453 0 n58 ns453 0 0.0629858108258
Gc29_454 0 n58 ns454 0 -0.00630953851774
Gc29_455 0 n58 ns455 0 -8.37710714593e-06
Gc29_456 0 n58 ns456 0 -6.87132006691e-06
Gc29_457 0 n58 ns457 0 -0.0168278534395
Gc29_458 0 n58 ns458 0 -0.00157571093319
Gc29_459 0 n58 ns459 0 0.0208828869596
Gc29_460 0 n58 ns460 0 0.00623416140269
Gc29_461 0 n58 ns461 0 0.010289229249
Gc29_462 0 n58 ns462 0 0.00152976508833
Gc29_463 0 n58 ns463 0 -0.0033006513636
Gc29_464 0 n58 ns464 0 -0.00050841554557
Gc29_465 0 n58 ns465 0 2.75128701025e-05
Gc29_466 0 n58 ns466 0 -0.00155800171484
Gc29_467 0 n58 ns467 0 -0.0143935425195
Gc29_468 0 n58 ns468 0 0.00127432988791
Gc29_469 0 n58 ns469 0 0.00198020951132
Gc29_470 0 n58 ns470 0 0.000210817079364
Gc29_471 0 n58 ns471 0 0.000321151436733
Gc29_472 0 n58 ns472 0 0.000384863569241
Gc29_473 0 n58 ns473 0 0.000732410952977
Gc29_474 0 n58 ns474 0 6.16858986545e-05
Gc29_475 0 n58 ns475 0 0.000314118389916
Gc29_476 0 n58 ns476 0 0.000468922529656
Gc29_477 0 n58 ns477 0 0.000335590151587
Gc29_478 0 n58 ns478 0 -0.0118549005531
Gc29_479 0 n58 ns479 0 -0.00792471582213
Gc29_480 0 n58 ns480 0 -0.00364406887741
Gc29_481 0 n58 ns481 0 -0.00113076363114
Gc29_482 0 n58 ns482 0 0.000165726240517
Gc29_483 0 n58 ns483 0 0.00245934866901
Gc29_484 0 n58 ns484 0 0.00827134087703
Gc29_485 0 n58 ns485 0 -0.00525266581247
Gc29_486 0 n58 ns486 0 0.00195201308719
Gc29_487 0 n58 ns487 0 0.00182735196115
Gc29_488 0 n58 ns488 0 0.00326873623599
Gc29_489 0 n58 ns489 0 -4.62052811234e-05
Gc29_490 0 n58 ns490 0 -0.1072026089
Gc29_491 0 n58 ns491 0 0.069315742602
Gc29_492 0 n58 ns492 0 -0.00877289759092
Gc29_493 0 n58 ns493 0 -1.09150061092e-05
Gc29_494 0 n58 ns494 0 -8.23207225513e-06
Gc29_495 0 n58 ns495 0 -0.000355408965012
Gc29_496 0 n58 ns496 0 4.53856399384e-05
Gc29_497 0 n58 ns497 0 0.00570832803291
Gc29_498 0 n58 ns498 0 -0.0013237439514
Gc29_499 0 n58 ns499 0 -0.000358781884862
Gc29_500 0 n58 ns500 0 0.00187280983446
Gc29_501 0 n58 ns501 0 0.000579955114154
Gc29_502 0 n58 ns502 0 -0.000160980162558
Gc29_503 0 n58 ns503 0 -0.000186061523244
Gc29_504 0 n58 ns504 0 0.00208964409363
Gc29_505 0 n58 ns505 0 -0.0027701487737
Gc29_506 0 n58 ns506 0 -0.000671051383013
Gc29_507 0 n58 ns507 0 0.00111544575453
Gc29_508 0 n58 ns508 0 -4.37954409684e-05
Gc29_509 0 n58 ns509 0 0.000500634792641
Gc29_510 0 n58 ns510 0 -0.000408671569856
Gc29_511 0 n58 ns511 0 -0.00333840529285
Gc29_512 0 n58 ns512 0 -0.000844744214142
Gc29_513 0 n58 ns513 0 0.000249675588225
Gc29_514 0 n58 ns514 0 0.000300863574143
Gc29_515 0 n58 ns515 0 0.000330181857958
Gc29_516 0 n58 ns516 0 0.00109402612455
Gc29_517 0 n58 ns517 0 -0.00546709118555
Gc29_518 0 n58 ns518 0 -0.00296657411238
Gc29_519 0 n58 ns519 0 -0.00100734879331
Gc29_520 0 n58 ns520 0 0.000192878405194
Gc29_521 0 n58 ns521 0 0.0022526416608
Gc29_522 0 n58 ns522 0 -0.0123501949718
Gc29_523 0 n58 ns523 0 -0.00539845470771
Gc29_524 0 n58 ns524 0 -0.000890193950346
Gc29_525 0 n58 ns525 0 0.00291578179153
Gc29_526 0 n58 ns526 0 0.0030404123509
Gc29_527 0 n58 ns527 0 0.000240657914474
Gc29_528 0 n58 ns528 0 -0.0677524011149
Gc29_529 0 n58 ns529 0 0.0644737795118
Gc29_530 0 n58 ns530 0 -0.00636376716763
Gc29_531 0 n58 ns531 0 -9.90308658628e-06
Gc29_532 0 n58 ns532 0 2.93758579538e-06
Gc29_533 0 n58 ns533 0 0.000757195105192
Gc29_534 0 n58 ns534 0 -0.00110340421102
Gc29_535 0 n58 ns535 0 0.0115445257726
Gc29_536 0 n58 ns536 0 0.00025188388119
Gc29_537 0 n58 ns537 0 0.000641959453634
Gc29_538 0 n58 ns538 0 0.000365923639337
Gc29_539 0 n58 ns539 0 -0.000251748485795
Gc29_540 0 n58 ns540 0 -0.000116713223474
Gc29_541 0 n58 ns541 0 -5.91589746042e-06
Gc29_542 0 n58 ns542 0 0.000361840573299
Gc29_543 0 n58 ns543 0 -0.00444181924638
Gc29_544 0 n58 ns544 0 -0.000110913807658
Gc29_545 0 n58 ns545 0 0.00106414877546
Gc29_546 0 n58 ns546 0 0.00014868799796
Gc29_547 0 n58 ns547 0 0.000555113201956
Gc29_548 0 n58 ns548 0 -0.00126979764719
Gc29_549 0 n58 ns549 0 -0.00119752988019
Gc29_550 0 n58 ns550 0 -0.00064315261479
Gc29_551 0 n58 ns551 0 0.000239720193192
Gc29_552 0 n58 ns552 0 0.000353997344084
Gc29_553 0 n58 ns553 0 0.000127316494889
Gc29_554 0 n58 ns554 0 -0.00251412556461
Gc29_555 0 n58 ns555 0 -0.00501425363614
Gc29_556 0 n58 ns556 0 -0.00159304917919
Gc29_557 0 n58 ns557 0 -0.000200021385299
Gc29_558 0 n58 ns558 0 0.000418783498464
Gc29_559 0 n58 ns559 0 0.00161712566721
Gc29_560 0 n58 ns560 0 -0.00990841143615
Gc29_561 0 n58 ns561 0 -0.00607359610806
Gc29_562 0 n58 ns562 0 -0.00163693311694
Gc29_563 0 n58 ns563 0 0.00420314904486
Gc29_564 0 n58 ns564 0 0.00242528523328
Gc29_565 0 n58 ns565 0 -0.000296603838762
Gc29_566 0 n58 ns566 0 -0.0774107092153
Gc29_567 0 n58 ns567 0 0.0672318941263
Gc29_568 0 n58 ns568 0 -0.00311440472451
Gc29_569 0 n58 ns569 0 -9.44551243875e-06
Gc29_570 0 n58 ns570 0 1.73472003064e-07
Gc29_571 0 n58 ns571 0 8.36227271077e-05
Gc29_572 0 n58 ns572 0 -0.000495757292943
Gc29_573 0 n58 ns573 0 0.00621366452001
Gc29_574 0 n58 ns574 0 0.000228042710468
Gc29_575 0 n58 ns575 0 0.000163724088738
Gc29_576 0 n58 ns576 0 0.000346060770671
Gc29_577 0 n58 ns577 0 5.1584730706e-06
Gc29_578 0 n58 ns578 0 6.54504881155e-06
Gc29_579 0 n58 ns579 0 -2.27635532041e-05
Gc29_580 0 n58 ns580 0 -0.00071152956828
Gc29_581 0 n58 ns581 0 -0.000998985949212
Gc29_582 0 n58 ns582 0 0.000255505334729
Gc29_583 0 n58 ns583 0 -0.000358665133944
Gc29_584 0 n58 ns584 0 9.97999024347e-06
Gc29_585 0 n58 ns585 0 0.000310717279937
Gc29_586 0 n58 ns586 0 0.00122493721665
Gc29_587 0 n58 ns587 0 -0.00128832691358
Gc29_588 0 n58 ns588 0 -0.00149218792094
Gc29_589 0 n58 ns589 0 8.43003481757e-05
Gc29_590 0 n58 ns590 0 0.000159206169772
Gc29_591 0 n58 ns591 0 0.000175567390152
Gc29_592 0 n58 ns592 0 -0.00136220774595
Gc29_593 0 n58 ns593 0 -0.00202129429843
Gc29_594 0 n58 ns594 0 -0.000678325084212
Gc29_595 0 n58 ns595 0 -0.00129967773545
Gc29_596 0 n58 ns596 0 3.01036957718e-05
Gc29_597 0 n58 ns597 0 0.00145378575885
Gc29_598 0 n58 ns598 0 -0.00643621467024
Gc29_599 0 n58 ns599 0 -0.00452045073441
Gc29_600 0 n58 ns600 0 -0.000461211639303
Gc29_601 0 n58 ns601 0 0.00352888689224
Gc29_602 0 n58 ns602 0 0.00148684030226
Gc29_603 0 n58 ns603 0 -0.0005663044404
Gc29_604 0 n58 ns604 0 -0.0376438144683
Gc29_605 0 n58 ns605 0 0.031683005263
Gc29_606 0 n58 ns606 0 -0.00123559860085
Gc29_607 0 n58 ns607 0 -5.80049800131e-06
Gc29_608 0 n58 ns608 0 2.33811093637e-06
Gc29_609 0 n58 ns609 0 -0.000141665751845
Gc29_610 0 n58 ns610 0 -0.00025902204602
Gc29_611 0 n58 ns611 0 0.00257781219127
Gc29_612 0 n58 ns612 0 7.63206159728e-05
Gc29_613 0 n58 ns613 0 3.00744096281e-05
Gc29_614 0 n58 ns614 0 -7.17527817397e-05
Gc29_615 0 n58 ns615 0 0.00018048942146
Gc29_616 0 n58 ns616 0 1.69042779684e-05
Gc29_617 0 n58 ns617 0 3.15870983558e-05
Gc29_618 0 n58 ns618 0 -0.000117592075928
Gc29_619 0 n58 ns619 0 -0.00106312064106
Gc29_620 0 n58 ns620 0 0.000541680836664
Gc29_621 0 n58 ns621 0 0.000672777722445
Gc29_622 0 n58 ns622 0 9.22686842662e-07
Gc29_623 0 n58 ns623 0 -0.000257911211756
Gc29_624 0 n58 ns624 0 -0.000109331723403
Gc29_625 0 n58 ns625 0 -0.0018537057104
Gc29_626 0 n58 ns626 0 -0.000781570833004
Gc29_627 0 n58 ns627 0 0.000993824262924
Gc29_628 0 n58 ns628 0 0.000242474181809
Gc29_629 0 n58 ns629 0 5.90958963393e-05
Gc29_630 0 n58 ns630 0 -0.00181191297508
Gc29_631 0 n58 ns631 0 -0.000220891856573
Gc29_632 0 n58 ns632 0 0.000532146933805
Gc29_633 0 n58 ns633 0 0.00136839102821
Gc29_634 0 n58 ns634 0 -3.0219718504e-05
Gc29_635 0 n58 ns635 0 -0.000943286616884
Gc29_636 0 n58 ns636 0 -0.00249421314849
Gc29_637 0 n58 ns637 0 -0.000146038505681
Gc29_638 0 n58 ns638 0 0.000481905234977
Gc29_639 0 n58 ns639 0 0.00137589222053
Gc29_640 0 n58 ns640 0 0.000505018831979
Gc29_641 0 n58 ns641 0 -0.000563700545404
Gc29_642 0 n58 ns642 0 0.00105990074588
Gc29_643 0 n58 ns643 0 -0.00230712300167
Gc29_644 0 n58 ns644 0 0.000350342575194
Gc29_645 0 n58 ns645 0 -7.72765246494e-06
Gc29_646 0 n58 ns646 0 -7.55339363116e-06
Gc29_647 0 n58 ns647 0 -0.00038272368009
Gc29_648 0 n58 ns648 0 0.000611812024845
Gc29_649 0 n58 ns649 0 0.00104021373799
Gc29_650 0 n58 ns650 0 -4.19116027408e-05
Gc29_651 0 n58 ns651 0 0.000131631355652
Gc29_652 0 n58 ns652 0 -3.94526525529e-05
Gc29_653 0 n58 ns653 0 0.00013730546804
Gc29_654 0 n58 ns654 0 -3.20687084111e-06
Gc29_655 0 n58 ns655 0 3.40577155919e-06
Gc29_656 0 n58 ns656 0 5.72747992736e-06
Gc29_657 0 n58 ns657 0 -0.000591130410439
Gc29_658 0 n58 ns658 0 0.000485193958681
Gc29_659 0 n58 ns659 0 0.000626261675269
Gc29_660 0 n58 ns660 0 -2.5529674362e-05
Gc29_661 0 n58 ns661 0 -0.000319530419474
Gc29_662 0 n58 ns662 0 0.000425502527532
Gc29_663 0 n58 ns663 0 -0.00154697142715
Gc29_664 0 n58 ns664 0 -0.000906491540413
Gc29_665 0 n58 ns665 0 0.000800071337781
Gc29_666 0 n58 ns666 0 0.000253989945269
Gc29_667 0 n58 ns667 0 3.36066119743e-05
Gc29_668 0 n58 ns668 0 -0.00127802162956
Gc29_669 0 n58 ns669 0 -0.000446110943585
Gc29_670 0 n58 ns670 0 0.000426209569212
Gc29_671 0 n58 ns671 0 0.00148855921525
Gc29_672 0 n58 ns672 0 8.13625331685e-06
Gc29_673 0 n58 ns673 0 -0.00107981557768
Gc29_674 0 n58 ns674 0 -0.00215540457375
Gc29_675 0 n58 ns675 0 -0.000582763451325
Gc29_676 0 n58 ns676 0 0.000305933241442
Gc29_677 0 n58 ns677 0 0.00167020018412
Gc29_678 0 n58 ns678 0 0.000653762563527
Gc29_679 0 n58 ns679 0 -0.000646222111066
Gc29_680 0 n58 ns680 0 0.00546845535169
Gc29_681 0 n58 ns681 0 -0.0062336695454
Gc29_682 0 n58 ns682 0 0.000541585241408
Gc29_683 0 n58 ns683 0 -6.50826561163e-06
Gc29_684 0 n58 ns684 0 -6.81351463512e-06
Gc29_685 0 n58 ns685 0 -0.000925976908991
Gc29_686 0 n58 ns686 0 0.00160278113363
Gc29_687 0 n58 ns687 0 -0.00265615823249
Gc29_688 0 n58 ns688 0 -1.987924769e-05
Gc29_689 0 n58 ns689 0 -0.000225392569602
Gc29_690 0 n58 ns690 0 5.90524623236e-05
Gc29_691 0 n58 ns691 0 -0.000320065213582
Gc29_692 0 n58 ns692 0 -3.68119511857e-05
Gc29_693 0 n58 ns693 0 -2.53074146496e-05
Gc29_694 0 n58 ns694 0 -0.0011576658532
Gc29_695 0 n58 ns695 0 0.00170399035623
Gc29_696 0 n58 ns696 0 0.000155859292427
Gc29_697 0 n58 ns697 0 -0.000278913561491
Gc29_698 0 n58 ns698 0 -4.93135090324e-05
Gc29_699 0 n58 ns699 0 -0.000406490096664
Gc29_700 0 n58 ns700 0 0.000323675518376
Gc29_701 0 n58 ns701 0 0.0013691456281
Gc29_702 0 n58 ns702 0 -0.000210772414818
Gc29_703 0 n58 ns703 0 -0.000160549422338
Gc29_704 0 n58 ns704 0 0.000304733121288
Gc29_705 0 n58 ns705 0 -0.000102067663534
Gc29_706 0 n58 ns706 0 0.00155959361982
Gc29_707 0 n58 ns707 0 0.00137991515322
Gc29_708 0 n58 ns708 0 0.000228041418786
Gc29_709 0 n58 ns709 0 0.000744269163203
Gc29_710 0 n58 ns710 0 7.00451579786e-06
Gc29_711 0 n58 ns711 0 -0.00112103017188
Gc29_712 0 n58 ns712 0 0.00155364132487
Gc29_713 0 n58 ns713 0 -0.000337978846722
Gc29_714 0 n58 ns714 0 -0.000872745594836
Gc29_715 0 n58 ns715 0 0.00151669894037
Gc29_716 0 n58 ns716 0 0.00103853042892
Gc29_717 0 n58 ns717 0 -0.000640257082044
Gc29_718 0 n58 ns718 0 0.030794522127
Gc29_719 0 n58 ns719 0 -0.0283669468726
Gc29_720 0 n58 ns720 0 0.00155402576577
Gc29_721 0 n58 ns721 0 -5.61739519945e-06
Gc29_722 0 n58 ns722 0 -8.59175555342e-06
Gc29_723 0 n58 ns723 0 -0.00175105249333
Gc29_724 0 n58 ns724 0 0.000593996643193
Gc29_725 0 n58 ns725 0 -0.00168290269232
Gc29_726 0 n58 ns726 0 0.000500416229029
Gc29_727 0 n58 ns727 0 -0.000504080287582
Gc29_728 0 n58 ns728 0 0.000618992616201
Gc29_729 0 n58 ns729 0 1.2664838262e-06
Gc29_730 0 n58 ns730 0 -0.000127672120154
Gc29_731 0 n58 ns731 0 5.1371707549e-06
Gc29_732 0 n58 ns732 0 -0.00189204014141
Gc29_733 0 n58 ns733 0 0.000308199737509
Gc29_734 0 n58 ns734 0 0.000631100158399
Gc29_735 0 n58 ns735 0 -0.000538670855024
Gc29_736 0 n58 ns736 0 0.000151263279114
Gc29_737 0 n58 ns737 0 -0.000465070047114
Gc29_738 0 n58 ns738 0 -0.00182276171457
Gc29_739 0 n58 ns739 0 9.13436613409e-05
Gc29_740 0 n58 ns740 0 0.000173306760055
Gc29_741 0 n58 ns741 0 0.000129377021528
Gc29_742 0 n58 ns742 0 0.00045039258395
Gc29_743 0 n58 ns743 0 5.79153372591e-05
Gc29_744 0 n58 ns744 0 -0.000933057824935
Gc29_745 0 n58 ns745 0 0.00350936907126
Gc29_746 0 n58 ns746 0 0.000977046695789
Gc29_747 0 n58 ns747 0 0.000397660972362
Gc29_748 0 n58 ns748 0 0.000128966807893
Gc29_749 0 n58 ns749 0 -0.00137324517964
Gc29_750 0 n58 ns750 0 0.00172661124634
Gc29_751 0 n58 ns751 0 0.00210413742139
Gc29_752 0 n58 ns752 0 -0.00175526813716
Gc29_753 0 n58 ns753 0 0.000315584526026
Gc29_754 0 n58 ns754 0 0.0016198339288
Gc29_755 0 n58 ns755 0 -0.00025683860516
Gc29_756 0 n58 ns756 0 0.0516519194871
Gc29_757 0 n58 ns757 0 -0.0501129315375
Gc29_758 0 n58 ns758 0 0.00372243114901
Gc29_759 0 n58 ns759 0 -7.44961991216e-07
Gc29_760 0 n58 ns760 0 -8.63674427893e-06
Gc29_761 0 n58 ns761 0 -0.0052868509562
Gc29_762 0 n58 ns762 0 -0.000363467019695
Gc29_763 0 n58 ns763 0 -0.00702660026913
Gc29_764 0 n58 ns764 0 0.000138233858326
Gc29_765 0 n58 ns765 0 -0.00132777832061
Gc29_766 0 n58 ns766 0 -0.000301451269337
Gc29_767 0 n58 ns767 0 0.000893685473137
Gc29_768 0 n58 ns768 0 -9.95666471883e-05
Gc29_769 0 n58 ns769 0 -2.6670286851e-05
Gc29_770 0 n58 ns770 0 0.000311733374525
Gc29_771 0 n58 ns771 0 0.00262647607921
Gc29_772 0 n58 ns772 0 0.000489073051546
Gc29_773 0 n58 ns773 0 -0.000578308519479
Gc29_774 0 n58 ns774 0 0.000184211985714
Gc29_775 0 n58 ns775 0 -0.000426159720173
Gc29_776 0 n58 ns776 0 0.000827580458283
Gc29_777 0 n58 ns777 0 -0.000262801256498
Gc29_778 0 n58 ns778 0 0.000213011163737
Gc29_779 0 n58 ns779 0 -0.000235767352193
Gc29_780 0 n58 ns780 0 0.000396662435031
Gc29_781 0 n58 ns781 0 0.000107333966856
Gc29_782 0 n58 ns782 0 -0.000389621064187
Gc29_783 0 n58 ns783 0 0.00120777660751
Gc29_784 0 n58 ns784 0 0.00164801878337
Gc29_785 0 n58 ns785 0 0.00146211968569
Gc29_786 0 n58 ns786 0 0.000623466596538
Gc29_787 0 n58 ns787 0 -0.00181913553068
Gc29_788 0 n58 ns788 0 0.00232652601449
Gc29_789 0 n58 ns789 0 0.00145506142451
Gc29_790 0 n58 ns790 0 0.000230191870897
Gc29_791 0 n58 ns791 0 -0.000474515011518
Gc29_792 0 n58 ns792 0 0.00228918683783
Gc29_793 0 n58 ns793 0 7.86008931485e-05
Gc29_794 0 n58 ns794 0 0.0380612752904
Gc29_795 0 n58 ns795 0 -0.0350331929087
Gc29_796 0 n58 ns796 0 0.00687604239593
Gc29_797 0 n58 ns797 0 -4.21018913761e-06
Gc29_798 0 n58 ns798 0 -6.70948761909e-06
Gc29_799 0 n58 ns799 0 -0.00524277226262
Gc29_800 0 n58 ns800 0 -0.00016494800633
Gc29_801 0 n58 ns801 0 -0.00665874480408
Gc29_802 0 n58 ns802 0 7.51809007317e-07
Gc29_803 0 n58 ns803 0 -0.00103041032765
Gc29_804 0 n58 ns804 0 -0.000113366907022
Gc29_805 0 n58 ns805 0 0.000279970230877
Gc29_806 0 n58 ns806 0 -0.00010329292578
Gc29_807 0 n58 ns807 0 -1.31727221654e-05
Gc29_808 0 n58 ns808 0 -0.00165150531128
Gc29_809 0 n58 ns809 0 0.00306928118033
Gc29_810 0 n58 ns810 0 0.00068027682224
Gc29_811 0 n58 ns811 0 -0.00061349427518
Gc29_812 0 n58 ns812 0 0.00020731738131
Gc29_813 0 n58 ns813 0 -0.000452282597546
Gc29_814 0 n58 ns814 0 0.000288257207365
Gc29_815 0 n58 ns815 0 0.00185267983259
Gc29_816 0 n58 ns816 0 0.000700893706716
Gc29_817 0 n58 ns817 0 -3.91279845686e-05
Gc29_818 0 n58 ns818 0 0.000505335351288
Gc29_819 0 n58 ns819 0 8.00306135885e-05
Gc29_820 0 n58 ns820 0 0.0023101275417
Gc29_821 0 n58 ns821 0 0.00183387160628
Gc29_822 0 n58 ns822 0 0.0013844855065
Gc29_823 0 n58 ns823 0 0.0022465691294
Gc29_824 0 n58 ns824 0 0.00103617186988
Gc29_825 0 n58 ns825 0 -0.00196883994313
Gc29_826 0 n58 ns826 0 0.00351244927249
Gc29_827 0 n58 ns827 0 -0.00140277281601
Gc29_828 0 n58 ns828 0 0.00180692973851
Gc29_829 0 n58 ns829 0 0.00109662073279
Gc29_830 0 n58 ns830 0 0.00291213906678
Gc29_831 0 n58 ns831 0 2.25955120469e-05
Gc29_832 0 n58 ns832 0 -0.0063414396085
Gc29_833 0 n58 ns833 0 0.0106610089285
Gc29_834 0 n58 ns834 0 0.00711849406472
Gc29_835 0 n58 ns835 0 -1.55457591672e-06
Gc29_836 0 n58 ns836 0 -4.10850300435e-06
Gc29_837 0 n58 ns837 0 -0.00190368590908
Gc29_838 0 n58 ns838 0 -0.000538461778313
Gc29_839 0 n58 ns839 0 0.00224924513325
Gc29_840 0 n58 ns840 0 0.000633279833854
Gc29_841 0 n58 ns841 0 -0.000290536850284
Gc29_842 0 n58 ns842 0 0.000725983347221
Gc29_843 0 n58 ns843 0 0.000381331836326
Gc29_844 0 n58 ns844 0 -0.000151109426061
Gc29_845 0 n58 ns845 0 -6.72429982619e-05
Gc29_846 0 n58 ns846 0 -0.00137681791257
Gc29_847 0 n58 ns847 0 -0.00061984716139
Gc29_848 0 n58 ns848 0 0.000994944112596
Gc29_849 0 n58 ns849 0 -0.000256362486571
Gc29_850 0 n58 ns850 0 0.000196435581412
Gc29_851 0 n58 ns851 0 -0.000533200495036
Gc29_852 0 n58 ns852 0 -0.00115916017252
Gc29_853 0 n58 ns853 0 -0.00194943947879
Gc29_854 0 n58 ns854 0 -0.0004244334627
Gc29_855 0 n58 ns855 0 0.000311551997209
Gc29_856 0 n58 ns856 0 0.000396061576428
Gc29_857 0 n58 ns857 0 0.000181706057376
Gc29_858 0 n58 ns858 0 -0.00377264492853
Gc29_859 0 n58 ns859 0 0.00146874786841
Gc29_860 0 n58 ns860 0 0.000831478224414
Gc29_861 0 n58 ns861 0 0.00113133539762
Gc29_862 0 n58 ns862 0 0.000551376997174
Gc29_863 0 n58 ns863 0 -0.00151202828554
Gc29_864 0 n58 ns864 0 -0.00217336177772
Gc29_865 0 n58 ns865 0 0.00161145693685
Gc29_866 0 n58 ns866 0 -0.00169309421833
Gc29_867 0 n58 ns867 0 0.000441714378393
Gc29_868 0 n58 ns868 0 0.00200394128286
Gc29_869 0 n58 ns869 0 2.09032399936e-05
Gc29_870 0 n58 ns870 0 0.04148553818
Gc29_871 0 n58 ns871 0 -0.0444732464244
Gc29_872 0 n58 ns872 0 0.00449401886197
Gc29_873 0 n58 ns873 0 3.06068597842e-06
Gc29_874 0 n58 ns874 0 4.60981087877e-06
Gc29_875 0 n58 ns875 0 -0.000871210876293
Gc29_876 0 n58 ns876 0 0.00173408735258
Gc29_877 0 n58 ns877 0 -0.00179663752803
Gc29_878 0 n58 ns878 0 0.000168349745827
Gc29_879 0 n58 ns879 0 -0.000285248226972
Gc29_880 0 n58 ns880 0 0.000164720495952
Gc29_881 0 n58 ns881 0 -0.000328742273215
Gc29_882 0 n58 ns882 0 -3.3992832801e-06
Gc29_883 0 n58 ns883 0 1.59265149656e-05
Gc29_884 0 n58 ns884 0 -0.00170727584796
Gc29_885 0 n58 ns885 0 0.000467277781987
Gc29_886 0 n58 ns886 0 0.000302420505363
Gc29_887 0 n58 ns887 0 4.58360270742e-05
Gc29_888 0 n58 ns888 0 7.03346720275e-05
Gc29_889 0 n58 ns889 0 -0.000432885862405
Gc29_890 0 n58 ns890 0 -0.000764482701304
Gc29_891 0 n58 ns891 0 0.00085289384017
Gc29_892 0 n58 ns892 0 -0.000274348443513
Gc29_893 0 n58 ns893 0 0.000208010811608
Gc29_894 0 n58 ns894 0 0.000404492237899
Gc29_895 0 n58 ns895 0 1.60689709678e-05
Gc29_896 0 n58 ns896 0 0.000607068501056
Gc29_897 0 n58 ns897 0 0.00253477120053
Gc29_898 0 n58 ns898 0 0.000318745316552
Gc29_899 0 n58 ns899 0 0.000896433581943
Gc29_900 0 n58 ns900 0 0.000189672436884
Gc29_901 0 n58 ns901 0 -0.00129451662515
Gc29_902 0 n58 ns902 0 0.00197132066444
Gc29_903 0 n58 ns903 0 0.00061757966521
Gc29_904 0 n58 ns904 0 -0.00128677359699
Gc29_905 0 n58 ns905 0 0.00124204615658
Gc29_906 0 n58 ns906 0 0.00120553644868
Gc29_907 0 n58 ns907 0 -0.000528323035844
Gc29_908 0 n58 ns908 0 0.0350374555877
Gc29_909 0 n58 ns909 0 -0.0327234180058
Gc29_910 0 n58 ns910 0 0.00189126489967
Gc29_911 0 n58 ns911 0 -4.60010224754e-06
Gc29_912 0 n58 ns912 0 2.05190051864e-06
Gc29_913 0 n58 ns913 0 -0.000855481355902
Gc29_914 0 n58 ns914 0 0.00176924176691
Gc29_915 0 n58 ns915 0 -0.00171120508015
Gc29_916 0 n58 ns916 0 -9.03763626242e-05
Gc29_917 0 n58 ns917 0 -0.000132428789838
Gc29_918 0 n58 ns918 0 -0.000324412416998
Gc29_919 0 n58 ns919 0 3.83545871957e-05
Gc29_920 0 n58 ns920 0 -4.0528733695e-05
Gc29_921 0 n58 ns921 0 1.1362011103e-05
Gc29_922 0 n58 ns922 0 0.000617951669056
Gc29_923 0 n58 ns923 0 0.000655428964301
Gc29_924 0 n58 ns924 0 -9.04318568184e-05
Gc29_925 0 n58 ns925 0 0.000513814746632
Gc29_926 0 n58 ns926 0 4.36526971038e-05
Gc29_927 0 n58 ns927 0 -0.000281609066981
Gc29_928 0 n58 ns928 0 0.00169890265411
Gc29_929 0 n58 ns929 0 -0.000513110329664
Gc29_930 0 n58 ns930 0 -0.00106813723559
Gc29_931 0 n58 ns931 0 -7.86319718018e-06
Gc29_932 0 n58 ns932 0 0.000157937741982
Gc29_933 0 n58 ns933 0 6.31002958606e-05
Gc29_934 0 n58 ns934 0 -7.26984264352e-06
Gc29_935 0 n58 ns935 0 -0.00110774037347
Gc29_936 0 n58 ns936 0 -0.000307873890214
Gc29_937 0 n58 ns937 0 0.00135936048983
Gc29_938 0 n58 ns938 0 0.000360569128573
Gc29_939 0 n58 ns939 0 -0.000919125610852
Gc29_940 0 n58 ns940 0 -0.00109861578347
Gc29_941 0 n58 ns941 0 -0.000992370365867
Gc29_942 0 n58 ns942 0 -0.000100774538191
Gc29_943 0 n58 ns943 0 0.00164811445392
Gc29_944 0 n58 ns944 0 0.000754858384969
Gc29_945 0 n58 ns945 0 -0.000584623174958
Gc29_946 0 n58 ns946 0 0.0117038778465
Gc29_947 0 n58 ns947 0 -0.011466514309
Gc29_948 0 n58 ns948 0 0.00074665464997
Gc29_949 0 n58 ns949 0 -9.96757860051e-06
Gc29_950 0 n58 ns950 0 3.8645194627e-06
Gc29_951 0 n58 ns951 0 -0.000613645009292
Gc29_952 0 n58 ns952 0 0.00146006920995
Gc29_953 0 n58 ns953 0 -0.00216776047263
Gc29_954 0 n58 ns954 0 -0.00015653719378
Gc29_955 0 n58 ns955 0 -0.000181902209061
Gc29_956 0 n58 ns956 0 -0.00016344301112
Gc29_957 0 n58 ns957 0 -0.000125824240651
Gc29_958 0 n58 ns958 0 -9.07556850572e-06
Gc29_959 0 n58 ns959 0 -1.71796338162e-05
Gc29_960 0 n58 ns960 0 -0.000513215272364
Gc29_961 0 n58 ns961 0 0.00139467598056
Gc29_962 0 n58 ns962 0 0.000224136218244
Gc29_963 0 n58 ns963 0 2.66156319192e-05
Gc29_964 0 n58 ns964 0 -8.38564358885e-05
Gc29_965 0 n58 ns965 0 -0.000376580170066
Gc29_966 0 n58 ns966 0 0.000741893229638
Gc29_967 0 n58 ns967 0 0.000533960738402
Gc29_968 0 n58 ns968 0 -0.000455966445436
Gc29_969 0 n58 ns969 0 0.0001180428758
Gc29_970 0 n58 ns970 0 0.000271150610565
Gc29_971 0 n58 ns971 0 -8.56281000543e-05
Gc29_972 0 n58 ns972 0 0.000954016978312
Gc29_973 0 n58 ns973 0 0.000553380491298
Gc29_974 0 n58 ns974 0 0.00029964188071
Gc29_975 0 n58 ns975 0 0.00103200677591
Gc29_976 0 n58 ns976 0 -3.24159655016e-05
Gc29_977 0 n58 ns977 0 -0.00110909820698
Gc29_978 0 n58 ns978 0 0.000639325566123
Gc29_979 0 n58 ns979 0 -0.000424524089642
Gc29_980 0 n58 ns980 0 -0.000388168334772
Gc29_981 0 n58 ns981 0 0.00152097414916
Gc29_982 0 n58 ns982 0 0.000822518040697
Gc29_983 0 n58 ns983 0 -0.000666865952182
Gc29_984 0 n58 ns984 0 0.0237892080871
Gc29_985 0 n58 ns985 0 -0.0219178042109
Gc29_986 0 n58 ns986 0 0.00115959967983
Gc29_987 0 n58 ns987 0 -6.22592448969e-06
Gc29_988 0 n58 ns988 0 -7.59043048839e-06
Gc29_989 0 n58 ns989 0 -0.00134286432001
Gc29_990 0 n58 ns990 0 0.000764734762305
Gc29_991 0 n58 ns991 0 -0.00184704931873
Gc29_992 0 n58 ns992 0 0.000412217304048
Gc29_993 0 n58 ns993 0 -0.000478566201076
Gc29_994 0 n58 ns994 0 0.000439749264384
Gc29_995 0 n58 ns995 0 -0.000212253215708
Gc29_996 0 n58 ns996 0 -5.9791395978e-05
Gc29_997 0 n58 ns997 0 -1.23378736761e-06
Gc29_998 0 n58 ns998 0 -0.00199889961299
Gc29_999 0 n58 ns999 0 0.000666166236608
Gc29_1000 0 n58 ns1000 0 0.000376333310069
Gc29_1001 0 n58 ns1001 0 -0.000486549883131
Gc29_1002 0 n58 ns1002 0 5.89699241641e-05
Gc29_1003 0 n58 ns1003 0 -0.000423716885958
Gc29_1004 0 n58 ns1004 0 -0.00164221042155
Gc29_1005 0 n58 ns1005 0 0.00102037658879
Gc29_1006 0 n58 ns1006 0 0.000172817353822
Gc29_1007 0 n58 ns1007 0 0.00010317405871
Gc29_1008 0 n58 ns1008 0 0.00042290111137
Gc29_1009 0 n58 ns1009 0 -1.32802384682e-05
Gc29_1010 0 n58 ns1010 0 0.000368823977629
Gc29_1011 0 n58 ns1011 0 0.00372150114892
Gc29_1012 0 n58 ns1012 0 0.000736448333397
Gc29_1013 0 n58 ns1013 0 0.000391709944527
Gc29_1014 0 n58 ns1014 0 2.31815197524e-05
Gc29_1015 0 n58 ns1015 0 -0.00126787605951
Gc29_1016 0 n58 ns1016 0 0.00276342443926
Gc29_1017 0 n58 ns1017 0 0.00176017232602
Gc29_1018 0 n58 ns1018 0 -0.00161217256853
Gc29_1019 0 n58 ns1019 0 0.000691007804216
Gc29_1020 0 n58 ns1020 0 0.00136319643974
Gc29_1021 0 n58 ns1021 0 -0.00043165266685
Gc29_1022 0 n58 ns1022 0 0.0481566807333
Gc29_1023 0 n58 ns1023 0 -0.0451702704651
Gc29_1024 0 n58 ns1024 0 0.00275955890366
Gc29_1025 0 n58 ns1025 0 -1.93333725505e-06
Gc29_1026 0 n58 ns1026 0 -9.65250318091e-06
Gc29_1027 0 n58 ns1027 0 -0.0023579198542
Gc29_1028 0 n58 ns1028 0 -0.00133550832597
Gc29_1029 0 n58 ns1029 0 0.00149858423778
Gc29_1030 0 n58 ns1030 0 0.000153800292247
Gc29_1031 0 n58 ns1031 0 -0.000440337380237
Gc29_1032 0 n58 ns1032 0 0.000426422067686
Gc29_1033 0 n58 ns1033 0 0.000493346831619
Gc29_1034 0 n58 ns1034 0 -0.000149508696045
Gc29_1035 0 n58 ns1035 0 -5.04473264484e-05
Gc29_1036 0 n58 ns1036 0 -0.000460486338204
Gc29_1037 0 n58 ns1037 0 0.000397738473509
Gc29_1038 0 n58 ns1038 0 0.00071603347618
Gc29_1039 0 n58 ns1039 0 -0.00013077413968
Gc29_1040 0 n58 ns1040 0 0.000301374222303
Gc29_1041 0 n58 ns1041 0 -0.000427949663669
Gc29_1042 0 n58 ns1042 0 0.000477064748098
Gc29_1043 0 n58 ns1043 0 -0.00161842348594
Gc29_1044 0 n58 ns1044 0 -0.0002950741424
Gc29_1045 0 n58 ns1045 0 -0.000140103753429
Gc29_1046 0 n58 ns1046 0 0.00034475156239
Gc29_1047 0 n58 ns1047 0 0.000187249256506
Gc29_1048 0 n58 ns1048 0 -0.00295300874933
Gc29_1049 0 n58 ns1049 0 -0.000795394764082
Gc29_1050 0 n58 ns1050 0 0.000912513136808
Gc29_1051 0 n58 ns1051 0 0.00112471488685
Gc29_1052 0 n58 ns1052 0 0.00065920813044
Gc29_1053 0 n58 ns1053 0 -0.00147253362477
Gc29_1054 0 n58 ns1054 0 -0.00413543759852
Gc29_1055 0 n58 ns1055 0 -0.000904440925886
Gc29_1056 0 n58 ns1056 0 -0.0012236235261
Gc29_1057 0 n58 ns1057 0 0.000479069440217
Gc29_1058 0 n58 ns1058 0 0.00230024615646
Gc29_1059 0 n58 ns1059 0 0.000236985320101
Gc29_1060 0 n58 ns1060 0 0.0297893476758
Gc29_1061 0 n58 ns1061 0 -0.035740351421
Gc29_1062 0 n58 ns1062 0 0.00567900618665
Gc29_1063 0 n58 ns1063 0 1.19515866807e-06
Gc29_1064 0 n58 ns1064 0 -3.11313304823e-06
Gc29_1065 0 n58 ns1065 0 -0.00328234435799
Gc29_1066 0 n58 ns1066 0 0.000566132217156
Gc29_1067 0 n58 ns1067 0 -0.00448061587843
Gc29_1068 0 n58 ns1068 0 1.78570599846e-05
Gc29_1069 0 n58 ns1069 0 -0.000325773768274
Gc29_1070 0 n58 ns1070 0 0.000298344778683
Gc29_1071 0 n58 ns1071 0 -0.000157133518428
Gc29_1072 0 n58 ns1072 0 -0.000207759271223
Gc29_1073 0 n58 ns1073 0 -5.9445123345e-05
Gc29_1074 0 n58 ns1074 0 -0.00321558112175
Gc29_1075 0 n58 ns1075 0 0.00245174540815
Gc29_1076 0 n58 ns1076 0 0.0011782873842
Gc29_1077 0 n58 ns1077 0 -0.000354156010266
Gc29_1078 0 n58 ns1078 0 0.000360078823838
Gc29_1079 0 n58 ns1079 0 -0.000538676520012
Gc29_1080 0 n58 ns1080 0 0.000229390821568
Gc29_1081 0 n58 ns1081 0 0.00170339819919
Gc29_1082 0 n58 ns1082 0 0.00069199333276
Gc29_1083 0 n58 ns1083 0 0.000174505444215
Gc29_1084 0 n58 ns1084 0 0.000567421868933
Gc29_1085 0 n58 ns1085 0 0.000136643592612
Gc29_1086 0 n58 ns1086 0 0.00163105382169
Gc29_1087 0 n58 ns1087 0 0.00109611955959
Gc29_1088 0 n58 ns1088 0 0.00152520099206
Gc29_1089 0 n58 ns1089 0 0.00245505106821
Gc29_1090 0 n58 ns1090 0 0.00108024647526
Gc29_1091 0 n58 ns1091 0 -0.00207437225543
Gc29_1092 0 n58 ns1092 0 0.000842412169673
Gc29_1093 0 n58 ns1093 0 -0.002553188724
Gc29_1094 0 n58 ns1094 0 0.00202782196556
Gc29_1095 0 n58 ns1095 0 0.00152276064179
Gc29_1096 0 n58 ns1096 0 0.00309189022015
Gc29_1097 0 n58 ns1097 0 3.33130005678e-05
Gc29_1098 0 n58 ns1098 0 -0.0146554894593
Gc29_1099 0 n58 ns1099 0 0.0160459808954
Gc29_1100 0 n58 ns1100 0 0.00712833335406
Gc29_1101 0 n58 ns1101 0 1.04459219312e-05
Gc29_1102 0 n58 ns1102 0 1.09559635911e-06
Gc29_1103 0 n58 ns1103 0 -0.00212774751774
Gc29_1104 0 n58 ns1104 0 -0.00197868109982
Gc29_1105 0 n58 ns1105 0 0.00387062125447
Gc29_1106 0 n58 ns1106 0 0.000345215396928
Gc29_1107 0 n58 ns1107 0 -0.000398118572894
Gc29_1108 0 n58 ns1108 0 0.000575487509627
Gc29_1109 0 n58 ns1109 0 0.000400226575543
Gc29_1110 0 n58 ns1110 0 -0.000167812610837
Gc29_1111 0 n58 ns1111 0 -8.28087887726e-05
Gc29_1112 0 n58 ns1112 0 -0.00132480451057
Gc29_1113 0 n58 ns1113 0 0.000107242742387
Gc29_1114 0 n58 ns1114 0 0.00106872941601
Gc29_1115 0 n58 ns1115 0 -0.000154821376805
Gc29_1116 0 n58 ns1116 0 0.000301449202775
Gc29_1117 0 n58 ns1117 0 -0.000507445916173
Gc29_1118 0 n58 ns1118 0 0.000140631945833
Gc29_1119 0 n58 ns1119 0 -0.00186733001571
Gc29_1120 0 n58 ns1120 0 -0.000334843818608
Gc29_1121 0 n58 ns1121 0 5.13031857969e-05
Gc29_1122 0 n58 ns1122 0 0.000380385033271
Gc29_1123 0 n58 ns1123 0 0.000205462769569
Gc29_1124 0 n58 ns1124 0 -0.00360815899927
Gc29_1125 0 n58 ns1125 0 -0.000899647604145
Gc29_1126 0 n58 ns1126 0 0.000868575451801
Gc29_1127 0 n58 ns1127 0 0.00139135252935
Gc29_1128 0 n58 ns1128 0 0.000765462606727
Gc29_1129 0 n58 ns1129 0 -0.00157684421472
Gc29_1130 0 n58 ns1130 0 -0.00522561022506
Gc29_1131 0 n58 ns1131 0 -0.00129540974889
Gc29_1132 0 n58 ns1132 0 -0.00123386371337
Gc29_1133 0 n58 ns1133 0 0.000819585387271
Gc29_1134 0 n58 ns1134 0 0.00242922977256
Gc29_1135 0 n58 ns1135 0 0.000240894813968
Gc29_1136 0 n58 ns1136 0 0.0221648498596
Gc29_1137 0 n58 ns1137 0 -0.0295141888294
Gc29_1138 0 n58 ns1138 0 0.0055064919145
Gc29_1139 0 n58 ns1139 0 1.83458807486e-06
Gc29_1140 0 n58 ns1140 0 3.77884880094e-06
Gc29_1141 0 n58 ns1141 0 -0.0011140655889
Gc29_1142 0 n58 ns1142 0 0.000386478738862
Gc29_1143 0 n58 ns1143 0 0.000108672433157
Gc29_1144 0 n58 ns1144 0 0.000582728782594
Gc29_1145 0 n58 ns1145 0 -0.000520074962423
Gc29_1146 0 n58 ns1146 0 0.000469788222591
Gc29_1147 0 n58 ns1147 0 -0.00020958537605
Gc29_1148 0 n58 ns1148 0 -4.46481030158e-05
Gc29_1149 0 n58 ns1149 0 -1.2061212196e-06
Gc29_1150 0 n58 ns1150 0 -0.00257793663876
Gc29_1151 0 n58 ns1151 0 -4.68089280685e-06
Gc29_1152 0 n58 ns1152 0 0.000662351935748
Gc29_1153 0 n58 ns1153 0 -0.000244103488233
Gc29_1154 0 n58 ns1154 0 0.000118239249597
Gc29_1155 0 n58 ns1155 0 -0.000506366061313
Gc29_1156 0 n58 ns1156 0 -0.00194840322802
Gc29_1157 0 n58 ns1157 0 0.000452424506661
Gc29_1158 0 n58 ns1158 0 -4.60304955287e-05
Gc29_1159 0 n58 ns1159 0 0.00039564822377
Gc29_1160 0 n58 ns1160 0 0.000487361907072
Gc29_1161 0 n58 ns1161 0 5.30188776401e-05
Gc29_1162 0 n58 ns1162 0 -0.000532810731774
Gc29_1163 0 n58 ns1163 0 0.00363544410251
Gc29_1164 0 n58 ns1164 0 0.000681652649445
Gc29_1165 0 n58 ns1165 0 0.00079031832616
Gc29_1166 0 n58 ns1166 0 0.000187424050015
Gc29_1167 0 n58 ns1167 0 -0.00143544986277
Gc29_1168 0 n58 ns1168 0 0.00175009559444
Gc29_1169 0 n58 ns1169 0 0.00170985347705
Gc29_1170 0 n58 ns1170 0 -0.00156206846566
Gc29_1171 0 n58 ns1171 0 0.000901779664151
Gc29_1172 0 n58 ns1172 0 0.00145059655393
Gc29_1173 0 n58 ns1173 0 -0.00043632822325
Gc29_1174 0 n58 ns1174 0 0.0418791897729
Gc29_1175 0 n58 ns1175 0 -0.0400944455339
Gc29_1176 0 n58 ns1176 0 0.00262749348925
Gc29_1177 0 n58 ns1177 0 -2.08214619831e-06
Gc29_1178 0 n58 ns1178 0 8.43114476887e-07
Gc29_1179 0 n58 ns1179 0 -0.000869835050218
Gc29_1180 0 n58 ns1180 0 0.00214763099841
Gc29_1181 0 n58 ns1181 0 -0.00238568125863
Gc29_1182 0 n58 ns1182 0 -0.000177500702246
Gc29_1183 0 n58 ns1183 0 -0.000146427792981
Gc29_1184 0 n58 ns1184 0 -0.000267340446666
Gc29_1185 0 n58 ns1185 0 -9.09803004663e-05
Gc29_1186 0 n58 ns1186 0 -1.98237202393e-05
Gc29_1187 0 n58 ns1187 0 1.72135715006e-05
Gc29_1188 0 n58 ns1188 0 0.000232381792007
Gc29_1189 0 n58 ns1189 0 0.000968749159243
Gc29_1190 0 n58 ns1190 0 -9.33337373733e-05
Gc29_1191 0 n58 ns1191 0 0.000405857922702
Gc29_1192 0 n58 ns1192 0 3.72598771375e-05
Gc29_1193 0 n58 ns1193 0 -0.000347194531042
Gc29_1194 0 n58 ns1194 0 0.00147118837811
Gc29_1195 0 n58 ns1195 0 5.17173331985e-05
Gc29_1196 0 n58 ns1196 0 -0.000965449105494
Gc29_1197 0 n58 ns1197 0 -7.83360085548e-05
Gc29_1198 0 n58 ns1198 0 0.000227919602527
Gc29_1199 0 n58 ns1199 0 3.69428312795e-05
Gc29_1200 0 n58 ns1200 0 0.000507976765178
Gc29_1201 0 n58 ns1201 0 -0.000410728265715
Gc29_1202 0 n58 ns1202 0 -0.000254388053153
Gc29_1203 0 n58 ns1203 0 0.00134781687431
Gc29_1204 0 n58 ns1204 0 0.000356014715259
Gc29_1205 0 n58 ns1205 0 -0.00109204724362
Gc29_1206 0 n58 ns1206 0 -0.000212226547006
Gc29_1207 0 n58 ns1207 0 -0.000868732787984
Gc29_1208 0 n58 ns1208 0 -0.000438475986482
Gc29_1209 0 n58 ns1209 0 0.00173403922938
Gc29_1210 0 n58 ns1210 0 0.000925100194208
Gc29_1211 0 n58 ns1211 0 -0.000630500637803
Gc29_1212 0 n58 ns1212 0 0.0191469287371
Gc29_1213 0 n58 ns1213 0 -0.0181569274872
Gc29_1214 0 n58 ns1214 0 0.00108122545553
Gc29_1215 0 n58 ns1215 0 -8.20426680717e-06
Gc29_1216 0 n58 ns1216 0 4.79644349144e-06
Gd29_1 0 n58 ni1 0 6.73183759677e-05
Gd29_2 0 n58 ni2 0 5.05812337531e-05
Gd29_3 0 n58 ni3 0 0.000185263090554
Gd29_4 0 n58 ni4 0 2.92823388181e-05
Gd29_5 0 n58 ni5 0 -0.00164741160963
Gd29_6 0 n58 ni6 0 -0.00302603318289
Gd29_7 0 n58 ni7 0 -0.00018466033496
Gd29_8 0 n58 ni8 0 0.000123052075009
Gd29_9 0 n58 ni9 0 0.000267458876733
Gd29_10 0 n58 ni10 0 0.000104539493156
Gd29_11 0 n58 ni11 0 0.000581387464064
Gd29_12 0 n58 ni12 0 -0.000346566762709
Gd29_13 0 n58 ni13 0 -0.00677371275586
Gd29_14 0 n58 ni14 0 -0.000381798062884
Gd29_15 0 n58 ni15 0 0.000494031558253
Gd29_16 0 n58 ni16 0 0.000145218216603
Gd29_17 0 n58 ni17 0 5.5944997596e-05
Gd29_18 0 n58 ni18 0 0.000178916519186
Gd29_19 0 n58 ni19 0 0.000161614685953
Gd29_20 0 n58 ni20 0 -0.000875707283437
Gd29_21 0 n58 ni21 0 -0.0028673875483
Gd29_22 0 n58 ni22 0 -0.00112468930046
Gd29_23 0 n58 ni23 0 -0.00115844470532
Gd29_24 0 n58 ni24 0 0.000253167411031
Gd29_25 0 n58 ni25 0 0.000206939595292
Gd29_26 0 n58 ni26 0 0.000281392157325
Gd29_27 0 n58 ni27 0 -0.000412987335815
Gd29_28 0 n58 ni28 0 -0.00191187010079
Gd29_29 0 n58 ni29 0 0.000607785102011
Gd29_30 0 n58 ni30 0 -0.00186706046996
Gd29_31 0 n58 ni31 0 -0.00032332789074
Gd29_32 0 n58 ni32 0 0.000342648562617
Gc30_1 0 n60 ns1 0 0.000110361356888
Gc30_2 0 n60 ns2 0 -0.000915544902323
Gc30_3 0 n60 ns3 0 0.00255322922864
Gc30_4 0 n60 ns4 0 0.000107298423459
Gc30_5 0 n60 ns5 0 8.92099500253e-05
Gc30_6 0 n60 ns6 0 -3.85977130148e-05
Gc30_7 0 n60 ns7 0 -1.78932921012e-05
Gc30_8 0 n60 ns8 0 -2.61399441405e-05
Gc30_9 0 n60 ns9 0 1.34880297915e-05
Gc30_10 0 n60 ns10 0 0.000705242135202
Gc30_11 0 n60 ns11 0 -0.00145934787606
Gc30_12 0 n60 ns12 0 -0.000604520665628
Gc30_13 0 n60 ns13 0 0.000671926981603
Gc30_14 0 n60 ns14 0 0.000279644485233
Gc30_15 0 n60 ns15 0 0.000175177120804
Gc30_16 0 n60 ns16 0 -0.00102509044317
Gc30_17 0 n60 ns17 0 -0.000543820184217
Gc30_18 0 n60 ns18 0 0.000334680277019
Gc30_19 0 n60 ns19 0 0.000657209740363
Gc30_20 0 n60 ns20 0 0.000115612517236
Gc30_21 0 n60 ns21 0 -0.000144794096844
Gc30_22 0 n60 ns22 0 -2.04908967768e-05
Gc30_23 0 n60 ns23 0 -0.000996150468365
Gc30_24 0 n60 ns24 0 -0.00114033145955
Gc30_25 0 n60 ns25 0 -0.000173844030645
Gc30_26 0 n60 ns26 0 0.000605219352888
Gc30_27 0 n60 ns27 0 0.000483932738715
Gc30_28 0 n60 ns28 0 -0.00274603877841
Gc30_29 0 n60 ns29 0 -0.000328111741417
Gc30_30 0 n60 ns30 0 0.00062482393813
Gc30_31 0 n60 ns31 0 0.00098956325802
Gc30_32 0 n60 ns32 0 0.000277608072887
Gc30_33 0 n60 ns33 0 -0.000408220607469
Gc30_34 0 n60 ns34 0 -0.00589798906817
Gc30_35 0 n60 ns35 0 0.00460400838855
Gc30_36 0 n60 ns36 0 -0.00018449088471
Gc30_37 0 n60 ns37 0 8.18809120334e-06
Gc30_38 0 n60 ns38 0 -2.17812822323e-05
Gc30_39 0 n60 ns39 0 0.000239557854236
Gc30_40 0 n60 ns40 0 -0.00101199285832
Gc30_41 0 n60 ns41 0 0.00324963139587
Gc30_42 0 n60 ns42 0 6.51468964295e-05
Gc30_43 0 n60 ns43 0 0.000179911951773
Gc30_44 0 n60 ns44 0 4.21300082126e-05
Gc30_45 0 n60 ns45 0 -1.37158782122e-05
Gc30_46 0 n60 ns46 0 -2.06987253981e-05
Gc30_47 0 n60 ns47 0 -1.12169750524e-05
Gc30_48 0 n60 ns48 0 0.000858544143557
Gc30_49 0 n60 ns49 0 -0.00153792488235
Gc30_50 0 n60 ns50 0 -0.000699927646993
Gc30_51 0 n60 ns51 0 0.000607091618063
Gc30_52 0 n60 ns52 0 0.000291438657351
Gc30_53 0 n60 ns53 0 0.000223084656111
Gc30_54 0 n60 ns54 0 -0.000959654523878
Gc30_55 0 n60 ns55 0 -0.000947990917976
Gc30_56 0 n60 ns56 0 0.0001593849902
Gc30_57 0 n60 ns57 0 0.000829116804726
Gc30_58 0 n60 ns58 0 0.00015003808765
Gc30_59 0 n60 ns59 0 -0.000134646883456
Gc30_60 0 n60 ns60 0 -0.00012092605595
Gc30_61 0 n60 ns61 0 -0.00127697360605
Gc30_62 0 n60 ns62 0 -0.00138016394161
Gc30_63 0 n60 ns63 0 -0.000315182830565
Gc30_64 0 n60 ns64 0 0.000712001179939
Gc30_65 0 n60 ns65 0 0.000667429602391
Gc30_66 0 n60 ns66 0 -0.00349561175203
Gc30_67 0 n60 ns67 0 -0.000884477412383
Gc30_68 0 n60 ns68 0 0.000586359373453
Gc30_69 0 n60 ns69 0 0.00135467322062
Gc30_70 0 n60 ns70 0 0.000413378314428
Gc30_71 0 n60 ns71 0 -0.000452345860957
Gc30_72 0 n60 ns72 0 -0.010966929074
Gc30_73 0 n60 ns73 0 0.00886811072532
Gc30_74 0 n60 ns74 0 -0.000324257817806
Gc30_75 0 n60 ns75 0 6.34101554268e-06
Gc30_76 0 n60 ns76 0 -2.37963685965e-05
Gc30_77 0 n60 ns77 0 0.000496634329986
Gc30_78 0 n60 ns78 0 -0.000799372707824
Gc30_79 0 n60 ns79 0 0.0042115911126
Gc30_80 0 n60 ns80 0 -0.000100563650293
Gc30_81 0 n60 ns81 0 0.000291113460461
Gc30_82 0 n60 ns82 0 0.000291465149806
Gc30_83 0 n60 ns83 0 2.82154084961e-06
Gc30_84 0 n60 ns84 0 2.82846037763e-05
Gc30_85 0 n60 ns85 0 -3.3595151741e-05
Gc30_86 0 n60 ns86 0 8.28080515195e-05
Gc30_87 0 n60 ns87 0 -0.000747988000873
Gc30_88 0 n60 ns88 0 -0.000210337971589
Gc30_89 0 n60 ns89 0 -8.45308452141e-05
Gc30_90 0 n60 ns90 0 0.000144984437968
Gc30_91 0 n60 ns91 0 0.000225355836796
Gc30_92 0 n60 ns92 0 0.000362832214347
Gc30_93 0 n60 ns93 0 -0.00128639203354
Gc30_94 0 n60 ns94 0 -0.00071847330996
Gc30_95 0 n60 ns95 0 0.000585221672389
Gc30_96 0 n60 ns96 0 0.000156591010285
Gc30_97 0 n60 ns97 0 -1.54086592104e-05
Gc30_98 0 n60 ns98 0 -0.000474891446823
Gc30_99 0 n60 ns99 0 -0.00163977415174
Gc30_100 0 n60 ns100 0 -0.00136645920543
Gc30_101 0 n60 ns101 0 -0.000945374482088
Gc30_102 0 n60 ns102 0 0.000572552122215
Gc30_103 0 n60 ns103 0 0.0011922245695
Gc30_104 0 n60 ns104 0 -0.00508845160345
Gc30_105 0 n60 ns105 0 -0.00201183301364
Gc30_106 0 n60 ns106 0 0.000542620222556
Gc30_107 0 n60 ns107 0 0.00241180875287
Gc30_108 0 n60 ns108 0 0.000835342841054
Gc30_109 0 n60 ns109 0 -0.000705760431284
Gc30_110 0 n60 ns110 0 -0.0169578881992
Gc30_111 0 n60 ns111 0 0.0137129805736
Gc30_112 0 n60 ns112 0 -0.000491869317705
Gc30_113 0 n60 ns113 0 3.83047897282e-07
Gc30_114 0 n60 ns114 0 -3.0384690782e-05
Gc30_115 0 n60 ns115 0 0.000898009395431
Gc30_116 0 n60 ns116 0 -0.00172302957916
Gc30_117 0 n60 ns117 0 0.00790712563013
Gc30_118 0 n60 ns118 0 8.20183752581e-05
Gc30_119 0 n60 ns119 0 2.20275906261e-05
Gc30_120 0 n60 ns120 0 8.78945132401e-05
Gc30_121 0 n60 ns121 0 0.000139891595907
Gc30_122 0 n60 ns122 0 2.25496626477e-05
Gc30_123 0 n60 ns123 0 3.83526914018e-05
Gc30_124 0 n60 ns124 0 -0.000757219817119
Gc30_125 0 n60 ns125 0 -0.00198270372346
Gc30_126 0 n60 ns126 0 0.000380125702363
Gc30_127 0 n60 ns127 0 0.000321023473762
Gc30_128 0 n60 ns128 0 0.000104430921208
Gc30_129 0 n60 ns129 0 0.000301194240985
Gc30_130 0 n60 ns130 0 0.000621858451016
Gc30_131 0 n60 ns131 0 -8.94542941613e-05
Gc30_132 0 n60 ns132 0 -0.000819401059814
Gc30_133 0 n60 ns133 0 -0.000327655700359
Gc30_134 0 n60 ns134 0 0.000130381280976
Gc30_135 0 n60 ns135 0 1.23052707749e-05
Gc30_136 0 n60 ns136 0 -0.00167878733142
Gc30_137 0 n60 ns137 0 -0.0029304561774
Gc30_138 0 n60 ns138 0 -0.000954294653526
Gc30_139 0 n60 ns139 0 -0.000730016575415
Gc30_140 0 n60 ns140 0 0.000281725877774
Gc30_141 0 n60 ns141 0 0.00138030348357
Gc30_142 0 n60 ns142 0 -0.00681790197876
Gc30_143 0 n60 ns143 0 -0.00399035993598
Gc30_144 0 n60 ns144 0 -0.000559705349616
Gc30_145 0 n60 ns145 0 0.00353642783092
Gc30_146 0 n60 ns146 0 0.00164121369052
Gc30_147 0 n60 ns147 0 -0.000636957890636
Gc30_148 0 n60 ns148 0 -0.0402506880681
Gc30_149 0 n60 ns149 0 0.0341451432278
Gc30_150 0 n60 ns150 0 -0.00144597222134
Gc30_151 0 n60 ns151 0 -5.99719327691e-06
Gc30_152 0 n60 ns152 0 -2.71844319726e-05
Gc30_153 0 n60 ns153 0 0.000295447166458
Gc30_154 0 n60 ns154 0 -0.00114723081446
Gc30_155 0 n60 ns155 0 0.0101522990462
Gc30_156 0 n60 ns156 0 -0.000154558516374
Gc30_157 0 n60 ns157 0 0.000535007576096
Gc30_158 0 n60 ns158 0 0.000600231196195
Gc30_159 0 n60 ns159 0 -0.00031329878845
Gc30_160 0 n60 ns160 0 -0.000121042780845
Gc30_161 0 n60 ns161 0 -2.67971239592e-05
Gc30_162 0 n60 ns162 0 0.00103290838325
Gc30_163 0 n60 ns163 0 -0.00385871126079
Gc30_164 0 n60 ns164 0 -0.000174585715609
Gc30_165 0 n60 ns165 0 0.0011500001746
Gc30_166 0 n60 ns166 0 2.25160754699e-05
Gc30_167 0 n60 ns167 0 0.000475799031335
Gc30_168 0 n60 ns168 0 -0.00142021980208
Gc30_169 0 n60 ns169 0 -0.00123236707896
Gc30_170 0 n60 ns170 0 -0.000340489510735
Gc30_171 0 n60 ns171 0 3.16500630664e-05
Gc30_172 0 n60 ns172 0 0.000329332031441
Gc30_173 0 n60 ns173 0 0.000133625156934
Gc30_174 0 n60 ns174 0 -0.00148549731829
Gc30_175 0 n60 ns175 0 -0.00576853624894
Gc30_176 0 n60 ns176 0 -0.00210775402766
Gc30_177 0 n60 ns177 0 -5.28328051074e-05
Gc30_178 0 n60 ns178 0 0.000459315887667
Gc30_179 0 n60 ns179 0 0.00172363633215
Gc30_180 0 n60 ns180 0 -0.00977623575807
Gc30_181 0 n60 ns181 0 -0.00526676419069
Gc30_182 0 n60 ns182 0 -0.0017236584194
Gc30_183 0 n60 ns183 0 0.00342451949627
Gc30_184 0 n60 ns184 0 0.00253960579458
Gc30_185 0 n60 ns185 0 -0.0001415931201
Gc30_186 0 n60 ns186 0 -0.0774302527709
Gc30_187 0 n60 ns187 0 0.0690348881182
Gc30_188 0 n60 ns188 0 -0.00393202808151
Gc30_189 0 n60 ns189 0 -9.2112299294e-06
Gc30_190 0 n60 ns190 0 -1.19617525645e-05
Gc30_191 0 n60 ns191 0 -0.00258754446965
Gc30_192 0 n60 ns192 0 -0.00291730184762
Gc30_193 0 n60 ns193 0 0.00733083329947
Gc30_194 0 n60 ns194 0 0.000985420310043
Gc30_195 0 n60 ns195 0 -0.00172267342567
Gc30_196 0 n60 ns196 0 0.000647465361736
Gc30_197 0 n60 ns197 0 0.00199634678886
Gc30_198 0 n60 ns198 0 3.33202503244e-05
Gc30_199 0 n60 ns199 0 -0.000213975027076
Gc30_200 0 n60 ns200 0 0.000929090175433
Gc30_201 0 n60 ns201 0 -0.00160677018246
Gc30_202 0 n60 ns202 0 -0.00108618106703
Gc30_203 0 n60 ns203 0 0.000732196000545
Gc30_204 0 n60 ns204 0 -0.000132981576588
Gc30_205 0 n60 ns205 0 0.000548707460365
Gc30_206 0 n60 ns206 0 0.00126341526559
Gc30_207 0 n60 ns207 0 -0.00284732849131
Gc30_208 0 n60 ns208 0 -0.000619384099607
Gc30_209 0 n60 ns209 0 -0.000131917408935
Gc30_210 0 n60 ns210 0 0.000280584840393
Gc30_211 0 n60 ns211 0 0.000234063795521
Gc30_212 0 n60 ns212 0 0.00215122859774
Gc30_213 0 n60 ns213 0 -0.0023401574911
Gc30_214 0 n60 ns214 0 -0.00263009879651
Gc30_215 0 n60 ns215 0 -0.00183863186646
Gc30_216 0 n60 ns216 0 -0.000315556123557
Gc30_217 0 n60 ns217 0 0.00238666028744
Gc30_218 0 n60 ns218 0 -0.0119360911026
Gc30_219 0 n60 ns219 0 -0.00483262222726
Gc30_220 0 n60 ns220 0 0.00029842513641
Gc30_221 0 n60 ns221 0 0.00245290154623
Gc30_222 0 n60 ns222 0 0.00314329556076
Gc30_223 0 n60 ns223 0 0.000198768257418
Gc30_224 0 n60 ns224 0 -0.0366787425052
Gc30_225 0 n60 ns225 0 0.0383937107768
Gc30_226 0 n60 ns226 0 -0.00706494710163
Gc30_227 0 n60 ns227 0 -1.00234662335e-05
Gc30_228 0 n60 ns228 0 8.78521960948e-06
Gc30_229 0 n60 ns229 0 -0.00539205622124
Gc30_230 0 n60 ns230 0 -0.00495568473255
Gc30_231 0 n60 ns231 0 0.00904909243851
Gc30_232 0 n60 ns232 0 0.00256407516568
Gc30_233 0 n60 ns233 0 -0.00209996163373
Gc30_234 0 n60 ns234 0 0.000705644734989
Gc30_235 0 n60 ns235 0 0.00280190886289
Gc30_236 0 n60 ns236 0 -7.13138940258e-06
Gc30_237 0 n60 ns237 0 -0.000312380867107
Gc30_238 0 n60 ns238 0 -0.00100964586746
Gc30_239 0 n60 ns239 0 -0.00149365983978
Gc30_240 0 n60 ns240 0 -0.000873007176263
Gc30_241 0 n60 ns241 0 0.000496849288083
Gc30_242 0 n60 ns242 0 -0.000153596036273
Gc30_243 0 n60 ns243 0 0.000583932038803
Gc30_244 0 n60 ns244 0 0.00276877156893
Gc30_245 0 n60 ns245 0 -0.00259791775283
Gc30_246 0 n60 ns246 0 -0.00089665052364
Gc30_247 0 n60 ns247 0 -0.000582038794334
Gc30_248 0 n60 ns248 0 0.000204843358944
Gc30_249 0 n60 ns249 0 0.000195900964214
Gc30_250 0 n60 ns250 0 0.0023869904108
Gc30_251 0 n60 ns251 0 0.00132519377923
Gc30_252 0 n60 ns252 0 -0.00117795275791
Gc30_253 0 n60 ns253 0 -0.00268693770448
Gc30_254 0 n60 ns254 0 -0.00115328890824
Gc30_255 0 n60 ns255 0 0.00211117232143
Gc30_256 0 n60 ns256 0 -0.0147552030787
Gc30_257 0 n60 ns257 0 -0.00567964076204
Gc30_258 0 n60 ns258 0 0.00203405996526
Gc30_259 0 n60 ns259 0 0.00391850133423
Gc30_260 0 n60 ns260 0 0.00372598894792
Gc30_261 0 n60 ns261 0 0.00016580914909
Gc30_262 0 n60 ns262 0 0.00886174720566
Gc30_263 0 n60 ns263 0 -0.00109795654926
Gc30_264 0 n60 ns264 0 -0.00787504771357
Gc30_265 0 n60 ns265 0 -1.33823441291e-05
Gc30_266 0 n60 ns266 0 1.59857258003e-05
Gc30_267 0 n60 ns267 0 6.71260527294e-05
Gc30_268 0 n60 ns268 0 -0.000574154671213
Gc30_269 0 n60 ns269 0 0.00924614735039
Gc30_270 0 n60 ns270 0 -0.000218280108359
Gc30_271 0 n60 ns271 0 6.17809660324e-05
Gc30_272 0 n60 ns272 0 0.000556817309491
Gc30_273 0 n60 ns273 0 -0.000575507162652
Gc30_274 0 n60 ns274 0 -8.11295851198e-05
Gc30_275 0 n60 ns275 0 6.41716149173e-06
Gc30_276 0 n60 ns276 0 0.00138488700143
Gc30_277 0 n60 ns277 0 -0.00143082111745
Gc30_278 0 n60 ns278 0 -0.000183046061458
Gc30_279 0 n60 ns279 0 8.85367576394e-05
Gc30_280 0 n60 ns280 0 -0.000317927161122
Gc30_281 0 n60 ns281 0 0.000424442710646
Gc30_282 0 n60 ns282 0 -0.000506062865589
Gc30_283 0 n60 ns283 0 -0.0025145046865
Gc30_284 0 n60 ns284 0 -0.00117547861353
Gc30_285 0 n60 ns285 0 0.000128360306683
Gc30_286 0 n60 ns286 0 0.000332210976177
Gc30_287 0 n60 ns287 0 0.000437253551385
Gc30_288 0 n60 ns288 0 -0.000411174640211
Gc30_289 0 n60 ns289 0 -0.00577034046965
Gc30_290 0 n60 ns290 0 -0.00215171904972
Gc30_291 0 n60 ns291 0 -0.000644196901691
Gc30_292 0 n60 ns292 0 2.61118370655e-05
Gc30_293 0 n60 ns293 0 0.00198693042645
Gc30_294 0 n60 ns294 0 -0.0100800463685
Gc30_295 0 n60 ns295 0 -0.00595747415708
Gc30_296 0 n60 ns296 0 -0.00225917884883
Gc30_297 0 n60 ns297 0 0.00285466252672
Gc30_298 0 n60 ns298 0 0.00276621991694
Gc30_299 0 n60 ns299 0 0.000304511490342
Gc30_300 0 n60 ns300 0 -0.0912921598059
Gc30_301 0 n60 ns301 0 0.0832400064029
Gc30_302 0 n60 ns302 0 -0.00528832564372
Gc30_303 0 n60 ns303 0 -1.25962537588e-05
Gc30_304 0 n60 ns304 0 2.08522204627e-05
Gc30_305 0 n60 ns305 0 0.000364485671691
Gc30_306 0 n60 ns306 0 -0.00122474295453
Gc30_307 0 n60 ns307 0 0.00842047266796
Gc30_308 0 n60 ns308 0 0.000497657230377
Gc30_309 0 n60 ns309 0 -0.000149996571904
Gc30_310 0 n60 ns310 0 -9.45740791517e-05
Gc30_311 0 n60 ns311 0 0.000174369770445
Gc30_312 0 n60 ns312 0 -1.02026465836e-05
Gc30_313 0 n60 ns313 0 4.84658877935e-05
Gc30_314 0 n60 ns314 0 -0.00135898951282
Gc30_315 0 n60 ns315 0 -0.0028490713606
Gc30_316 0 n60 ns316 0 0.000835192683897
Gc30_317 0 n60 ns317 0 0.000705672787742
Gc30_318 0 n60 ns318 0 2.1307843177e-05
Gc30_319 0 n60 ns319 0 0.000215064206904
Gc30_320 0 n60 ns320 0 0.000226650697263
Gc30_321 0 n60 ns321 0 0.000808493281718
Gc30_322 0 n60 ns322 0 -0.000568303946652
Gc30_323 0 n60 ns323 0 -0.000959732151447
Gc30_324 0 n60 ns324 0 6.57811979313e-05
Gc30_325 0 n60 ns325 0 0.000110666966755
Gc30_326 0 n60 ns326 0 -0.00246579260328
Gc30_327 0 n60 ns327 0 -0.00298385914315
Gc30_328 0 n60 ns328 0 9.63928914354e-05
Gc30_329 0 n60 ns329 0 -1.49487860577e-05
Gc30_330 0 n60 ns330 0 -0.000278412407429
Gc30_331 0 n60 ns331 0 0.000823026293522
Gc30_332 0 n60 ns332 0 -0.00567321717628
Gc30_333 0 n60 ns333 0 -0.00472563662242
Gc30_334 0 n60 ns334 0 -0.00189469067533
Gc30_335 0 n60 ns335 0 0.00313663371944
Gc30_336 0 n60 ns336 0 0.00190688299511
Gc30_337 0 n60 ns337 0 -0.000105381903969
Gc30_338 0 n60 ns338 0 -0.0526182953874
Gc30_339 0 n60 ns339 0 0.0456310791029
Gc30_340 0 n60 ns340 0 -0.00207762928161
Gc30_341 0 n60 ns341 0 -7.42637085526e-06
Gc30_342 0 n60 ns342 0 1.65300193076e-05
Gc30_343 0 n60 ns343 0 0.000405376848801
Gc30_344 0 n60 ns344 0 -0.00053548901634
Gc30_345 0 n60 ns345 0 0.00317594592911
Gc30_346 0 n60 ns346 0 -0.000160366200997
Gc30_347 0 n60 ns347 0 0.000329033888436
Gc30_348 0 n60 ns348 0 0.000226492242495
Gc30_349 0 n60 ns349 0 7.21057677738e-06
Gc30_350 0 n60 ns350 0 9.30884401989e-06
Gc30_351 0 n60 ns351 0 -4.39809847416e-05
Gc30_352 0 n60 ns352 0 0.000682475842455
Gc30_353 0 n60 ns353 0 -0.000898007373045
Gc30_354 0 n60 ns354 0 -0.000520895682517
Gc30_355 0 n60 ns355 0 0.000142174848108
Gc30_356 0 n60 ns356 0 0.000189146206615
Gc30_357 0 n60 ns357 0 0.000225675677936
Gc30_358 0 n60 ns358 0 -0.000169471238136
Gc30_359 0 n60 ns359 0 -0.00130051406687
Gc30_360 0 n60 ns360 0 -0.000368643668844
Gc30_361 0 n60 ns361 0 0.000764949068744
Gc30_362 0 n60 ns362 0 0.000159077597791
Gc30_363 0 n60 ns363 0 -6.08093971852e-05
Gc30_364 0 n60 ns364 0 -0.000196327295079
Gc30_365 0 n60 ns365 0 -0.00139200032793
Gc30_366 0 n60 ns366 0 -0.001390784597
Gc30_367 0 n60 ns367 0 -0.000704758414981
Gc30_368 0 n60 ns368 0 0.000641527953213
Gc30_369 0 n60 ns369 0 0.000961211550938
Gc30_370 0 n60 ns370 0 -0.00416616227191
Gc30_371 0 n60 ns371 0 -0.00138866784069
Gc30_372 0 n60 ns372 0 0.000596238679302
Gc30_373 0 n60 ns373 0 0.00188237164034
Gc30_374 0 n60 ns374 0 0.00061552958635
Gc30_375 0 n60 ns375 0 -0.00060485697973
Gc30_376 0 n60 ns376 0 -0.0120211662629
Gc30_377 0 n60 ns377 0 0.00961675518307
Gc30_378 0 n60 ns378 0 -0.000345295348145
Gc30_379 0 n60 ns379 0 2.55669064311e-06
Gc30_380 0 n60 ns380 0 -2.7043932097e-05
Gc30_381 0 n60 ns381 0 0.000513818571636
Gc30_382 0 n60 ns382 0 -0.000947738110372
Gc30_383 0 n60 ns383 0 0.00581202289351
Gc30_384 0 n60 ns384 0 -7.94288526676e-05
Gc30_385 0 n60 ns385 0 0.00033971819516
Gc30_386 0 n60 ns386 0 0.000373154320532
Gc30_387 0 n60 ns387 0 0.000140485452653
Gc30_388 0 n60 ns388 0 2.65937510451e-05
Gc30_389 0 n60 ns389 0 -7.1592468038e-06
Gc30_390 0 n60 ns390 0 -0.00063048839607
Gc30_391 0 n60 ns391 0 -0.0015755200338
Gc30_392 0 n60 ns392 0 0.000296101381299
Gc30_393 0 n60 ns393 0 0.000137986903592
Gc30_394 0 n60 ns394 0 0.000148450642209
Gc30_395 0 n60 ns395 0 0.00024139023658
Gc30_396 0 n60 ns396 0 0.000989504661263
Gc30_397 0 n60 ns397 0 -0.000611799754219
Gc30_398 0 n60 ns398 0 -0.000957945086796
Gc30_399 0 n60 ns399 0 -8.58078027433e-05
Gc30_400 0 n60 ns400 0 9.00217004397e-05
Gc30_401 0 n60 ns401 0 1.53855115604e-05
Gc30_402 0 n60 ns402 0 -0.00116225584614
Gc30_403 0 n60 ns403 0 -0.00244396267703
Gc30_404 0 n60 ns404 0 -0.00108527816144
Gc30_405 0 n60 ns405 0 -0.000951688549007
Gc30_406 0 n60 ns406 0 0.000363469745385
Gc30_407 0 n60 ns407 0 0.00134807475424
Gc30_408 0 n60 ns408 0 -0.00613137942515
Gc30_409 0 n60 ns409 0 -0.00360019637917
Gc30_410 0 n60 ns410 0 -0.000131923225004
Gc30_411 0 n60 ns411 0 0.00325601154215
Gc30_412 0 n60 ns412 0 0.00133342278651
Gc30_413 0 n60 ns413 0 -0.000681335417675
Gc30_414 0 n60 ns414 0 -0.0310330664065
Gc30_415 0 n60 ns415 0 0.0260113593617
Gc30_416 0 n60 ns416 0 -0.00103187220026
Gc30_417 0 n60 ns417 0 -4.08384801881e-06
Gc30_418 0 n60 ns418 0 -2.91011480952e-05
Gc30_419 0 n60 ns419 0 0.000920244452949
Gc30_420 0 n60 ns420 0 -0.000919758033594
Gc30_421 0 n60 ns421 0 0.0103696883867
Gc30_422 0 n60 ns422 0 -1.32408961092e-05
Gc30_423 0 n60 ns423 0 0.000761580058766
Gc30_424 0 n60 ns424 0 0.000456039825896
Gc30_425 0 n60 ns425 0 -0.00014677779169
Gc30_426 0 n60 ns426 0 -8.93751878707e-05
Gc30_427 0 n60 ns427 0 -2.10501796092e-05
Gc30_428 0 n60 ns428 0 -9.89367500435e-06
Gc30_429 0 n60 ns429 0 -0.00416625479785
Gc30_430 0 n60 ns430 0 0.000235165229434
Gc30_431 0 n60 ns431 0 0.00106434784634
Gc30_432 0 n60 ns432 0 0.000121707573185
Gc30_433 0 n60 ns433 0 0.000414041688115
Gc30_434 0 n60 ns434 0 -0.000967531616421
Gc30_435 0 n60 ns435 0 -0.000585674377538
Gc30_436 0 n60 ns436 0 -0.000452372288066
Gc30_437 0 n60 ns437 0 -0.000103776633094
Gc30_438 0 n60 ns438 0 0.000266504186766
Gc30_439 0 n60 ns439 0 7.20580931199e-05
Gc30_440 0 n60 ns440 0 -0.00235046237726
Gc30_441 0 n60 ns441 0 -0.00499510648105
Gc30_442 0 n60 ns442 0 -0.0015477346244
Gc30_443 0 n60 ns443 0 8.37468976133e-06
Gc30_444 0 n60 ns444 0 0.000463067481335
Gc30_445 0 n60 ns445 0 0.00145908909416
Gc30_446 0 n60 ns446 0 -0.00902257159238
Gc30_447 0 n60 ns447 0 -0.00528481888503
Gc30_448 0 n60 ns448 0 -0.00153703281996
Gc30_449 0 n60 ns449 0 0.00384532762532
Gc30_450 0 n60 ns450 0 0.00229249506538
Gc30_451 0 n60 ns451 0 -0.000329251294131
Gc30_452 0 n60 ns452 0 -0.0694821239536
Gc30_453 0 n60 ns453 0 0.060524832847
Gc30_454 0 n60 ns454 0 -0.00288795693686
Gc30_455 0 n60 ns455 0 -8.86551689329e-06
Gc30_456 0 n60 ns456 0 -2.16165316996e-05
Gc30_457 0 n60 ns457 0 -0.000355809547959
Gc30_458 0 n60 ns458 0 4.75404809289e-05
Gc30_459 0 n60 ns459 0 0.00571498013842
Gc30_460 0 n60 ns460 0 -0.00132474880629
Gc30_461 0 n60 ns461 0 -0.000357489703057
Gc30_462 0 n60 ns462 0 0.00187456667793
Gc30_463 0 n60 ns463 0 0.000580844792541
Gc30_464 0 n60 ns464 0 -0.000161227729003
Gc30_465 0 n60 ns465 0 -0.000186535308391
Gc30_466 0 n60 ns466 0 0.00209081072057
Gc30_467 0 n60 ns467 0 -0.00277576877323
Gc30_468 0 n60 ns468 0 -0.000671219111377
Gc30_469 0 n60 ns469 0 0.00111710928714
Gc30_470 0 n60 ns470 0 -4.36176418999e-05
Gc30_471 0 n60 ns471 0 0.00050092314924
Gc30_472 0 n60 ns472 0 -0.000409738773781
Gc30_473 0 n60 ns473 0 -0.00334126787931
Gc30_474 0 n60 ns474 0 -0.00084582501217
Gc30_475 0 n60 ns475 0 0.000250364335052
Gc30_476 0 n60 ns476 0 0.000301088019643
Gc30_477 0 n60 ns477 0 0.00033050797096
Gc30_478 0 n60 ns478 0 0.00108964007904
Gc30_479 0 n60 ns479 0 -0.00546941665531
Gc30_480 0 n60 ns480 0 -0.00296731458689
Gc30_481 0 n60 ns481 0 -0.00100589440539
Gc30_482 0 n60 ns482 0 0.000193818130015
Gc30_483 0 n60 ns483 0 0.00225255246328
Gc30_484 0 n60 ns484 0 -0.012356838325
Gc30_485 0 n60 ns485 0 -0.00540214017697
Gc30_486 0 n60 ns486 0 -0.000890218014872
Gc30_487 0 n60 ns487 0 0.00291854955408
Gc30_488 0 n60 ns488 0 0.00304114983357
Gc30_489 0 n60 ns489 0 0.000240482574822
Gc30_490 0 n60 ns490 0 -0.0677841387861
Gc30_491 0 n60 ns491 0 0.064497045658
Gc30_492 0 n60 ns492 0 -0.00636373639156
Gc30_493 0 n60 ns493 0 -9.92198012676e-06
Gc30_494 0 n60 ns494 0 2.83349154054e-06
Gc30_495 0 n60 ns495 0 -0.0171208928913
Gc30_496 0 n60 ns496 0 -0.00160737153331
Gc30_497 0 n60 ns497 0 0.021590644373
Gc30_498 0 n60 ns498 0 0.00650478260473
Gc30_499 0 n60 ns499 0 0.0101740701765
Gc30_500 0 n60 ns500 0 0.00142307245936
Gc30_501 0 n60 ns501 0 -0.00338590750744
Gc30_502 0 n60 ns502 0 -0.000529778637891
Gc30_503 0 n60 ns503 0 4.38979506508e-05
Gc30_504 0 n60 ns504 0 -0.00109985405652
Gc30_505 0 n60 ns505 0 -0.014663682644
Gc30_506 0 n60 ns506 0 0.000898727187235
Gc30_507 0 n60 ns507 0 0.00198799508292
Gc30_508 0 n60 ns508 0 0.000238201683163
Gc30_509 0 n60 ns509 0 0.000469570376053
Gc30_510 0 n60 ns510 0 0.000108936708997
Gc30_511 0 n60 ns511 0 0.000140046728256
Gc30_512 0 n60 ns512 0 -0.00012149411831
Gc30_513 0 n60 ns513 0 0.000649769927904
Gc30_514 0 n60 ns514 0 0.000556272870289
Gc30_515 0 n60 ns515 0 0.000387675760001
Gc30_516 0 n60 ns516 0 -0.0119236108912
Gc30_517 0 n60 ns517 0 -0.00785453755564
Gc30_518 0 n60 ns518 0 -0.00363037171269
Gc30_519 0 n60 ns519 0 -0.00137332690784
Gc30_520 0 n60 ns520 0 7.75059909662e-05
Gc30_521 0 n60 ns521 0 0.00260876941349
Gc30_522 0 n60 ns522 0 0.0075731663438
Gc30_523 0 n60 ns523 0 -0.00595299771768
Gc30_524 0 n60 ns524 0 0.00186209875368
Gc30_525 0 n60 ns525 0 0.00215664626661
Gc30_526 0 n60 ns526 0 0.00339648877092
Gc30_527 0 n60 ns527 0 -2.46950916511e-05
Gc30_528 0 n60 ns528 0 -0.112453695618
Gc30_529 0 n60 ns529 0 0.0736524550664
Gc30_530 0 n60 ns530 0 -0.00890226375241
Gc30_531 0 n60 ns531 0 -1.11632521446e-05
Gc30_532 0 n60 ns532 0 1.28415903262e-05
Gc30_533 0 n60 ns533 0 -0.000349992058355
Gc30_534 0 n60 ns534 0 -5.77541529001e-05
Gc30_535 0 n60 ns535 0 0.00642882683616
Gc30_536 0 n60 ns536 0 -0.00112270167087
Gc30_537 0 n60 ns537 0 -0.000588186172846
Gc30_538 0 n60 ns538 0 0.00183780763678
Gc30_539 0 n60 ns539 0 0.000426487334688
Gc30_540 0 n60 ns540 0 -0.000177995407652
Gc30_541 0 n60 ns541 0 -0.000203170896461
Gc30_542 0 n60 ns542 0 0.00189474311076
Gc30_543 0 n60 ns543 0 -0.00158874113915
Gc30_544 0 n60 ns544 0 -0.000609630662204
Gc30_545 0 n60 ns545 0 0.000378443509822
Gc30_546 0 n60 ns546 0 -0.000271056380895
Gc30_547 0 n60 ns547 0 0.000520583010256
Gc30_548 0 n60 ns548 0 5.15201845708e-05
Gc30_549 0 n60 ns549 0 -0.00386533818775
Gc30_550 0 n60 ns550 0 -0.00140044570531
Gc30_551 0 n60 ns551 0 0.00028137130317
Gc30_552 0 n60 ns552 0 0.000336482186486
Gc30_553 0 n60 ns553 0 0.000496838390504
Gc30_554 0 n60 ns554 0 0.000809300156756
Gc30_555 0 n60 ns555 0 -0.00497169538465
Gc30_556 0 n60 ns556 0 -0.0024908106669
Gc30_557 0 n60 ns557 0 -0.00122084395667
Gc30_558 0 n60 ns558 0 -0.000128266949978
Gc30_559 0 n60 ns559 0 0.00225820935363
Gc30_560 0 n60 ns560 0 -0.0124332805627
Gc30_561 0 n60 ns561 0 -0.00602479955788
Gc30_562 0 n60 ns562 0 -0.00117779890925
Gc30_563 0 n60 ns563 0 0.00310478158586
Gc30_564 0 n60 ns564 0 0.00315896981134
Gc30_565 0 n60 ns565 0 0.000333193745132
Gc30_566 0 n60 ns566 0 -0.0723796323688
Gc30_567 0 n60 ns567 0 0.0684318182537
Gc30_568 0 n60 ns568 0 -0.00650214773289
Gc30_569 0 n60 ns569 0 -1.17375913501e-05
Gc30_570 0 n60 ns570 0 2.62815211489e-05
Gc30_571 0 n60 ns571 0 0.000439437043332
Gc30_572 0 n60 ns572 0 -0.000244667491183
Gc30_573 0 n60 ns573 0 0.00964423279647
Gc30_574 0 n60 ns574 0 0.000184530057165
Gc30_575 0 n60 ns575 0 0.000518305467
Gc30_576 0 n60 ns576 0 0.000372237620977
Gc30_577 0 n60 ns577 0 -0.000210333921588
Gc30_578 0 n60 ns578 0 -9.17542949179e-05
Gc30_579 0 n60 ns579 0 1.87430508921e-05
Gc30_580 0 n60 ns580 0 -0.000869760201477
Gc30_581 0 n60 ns581 0 -0.00348611529065
Gc30_582 0 n60 ns582 0 0.000754829006039
Gc30_583 0 n60 ns583 0 0.000744551612526
Gc30_584 0 n60 ns584 0 -4.50226396918e-05
Gc30_585 0 n60 ns585 0 0.000298024209003
Gc30_586 0 n60 ns586 0 -0.000379489392137
Gc30_587 0 n60 ns587 0 -0.000102408452674
Gc30_588 0 n60 ns588 0 -0.000727446278111
Gc30_589 0 n60 ns589 0 -0.000630628859809
Gc30_590 0 n60 ns590 0 0.000195077100225
Gc30_591 0 n60 ns591 0 0.00021596464525
Gc30_592 0 n60 ns592 0 -0.00254297606939
Gc30_593 0 n60 ns593 0 -0.00421791123911
Gc30_594 0 n60 ns594 0 -0.000502964952554
Gc30_595 0 n60 ns595 0 -6.72006068773e-06
Gc30_596 0 n60 ns596 0 -0.00016070069474
Gc30_597 0 n60 ns597 0 0.00117872798602
Gc30_598 0 n60 ns598 0 -0.00766071362837
Gc30_599 0 n60 ns599 0 -0.00577019859314
Gc30_600 0 n60 ns600 0 -0.00226406721785
Gc30_601 0 n60 ns601 0 0.00357176681933
Gc30_602 0 n60 ns602 0 0.00235196735293
Gc30_603 0 n60 ns603 0 -3.13091236232e-05
Gc30_604 0 n60 ns604 0 -0.071364772838
Gc30_605 0 n60 ns605 0 0.0625487071302
Gc30_606 0 n60 ns606 0 -0.00303169367333
Gc30_607 0 n60 ns607 0 -1.10373805559e-05
Gc30_608 0 n60 ns608 0 1.74708250387e-05
Gc30_609 0 n60 ns609 0 0.000399518787442
Gc30_610 0 n60 ns610 0 -0.00124912657959
Gc30_611 0 n60 ns611 0 0.00222013841733
Gc30_612 0 n60 ns612 0 0.000187631796765
Gc30_613 0 n60 ns613 0 -0.000128552899278
Gc30_614 0 n60 ns614 0 0.000104435215065
Gc30_615 0 n60 ns615 0 1.72658591688e-05
Gc30_616 0 n60 ns616 0 3.38840946152e-05
Gc30_617 0 n60 ns617 0 -3.71014414581e-05
Gc30_618 0 n60 ns618 0 -0.00138307316487
Gc30_619 0 n60 ns619 0 -6.57302391331e-05
Gc30_620 0 n60 ns620 0 0.000720328305075
Gc30_621 0 n60 ns621 0 -0.00025078452304
Gc30_622 0 n60 ns622 0 -0.000139637633954
Gc30_623 0 n60 ns623 0 -0.000128765160848
Gc30_624 0 n60 ns624 0 -0.00135595128177
Gc30_625 0 n60 ns625 0 -0.000149338768431
Gc30_626 0 n60 ns626 0 0.000459442360328
Gc30_627 0 n60 ns627 0 0.00074574369092
Gc30_628 0 n60 ns628 0 0.000154608228257
Gc30_629 0 n60 ns629 0 -0.000135041790183
Gc30_630 0 n60 ns630 0 -0.00044298941526
Gc30_631 0 n60 ns631 0 0.00129008411245
Gc30_632 0 n60 ns632 0 0.000973206460455
Gc30_633 0 n60 ns633 0 0.000135592254209
Gc30_634 0 n60 ns634 0 -0.000524119525082
Gc30_635 0 n60 ns635 0 -0.000376884370107
Gc30_636 0 n60 ns636 0 -0.00043876034457
Gc30_637 0 n60 ns637 0 0.000800544801002
Gc30_638 0 n60 ns638 0 0.000452394688593
Gc30_639 0 n60 ns639 0 0.000363328464716
Gc30_640 0 n60 ns640 0 9.43851448592e-05
Gc30_641 0 n60 ns641 0 -0.000355377141967
Gc30_642 0 n60 ns642 0 0.00653811477768
Gc30_643 0 n60 ns643 0 -0.00616741100014
Gc30_644 0 n60 ns644 0 0.000315761695023
Gc30_645 0 n60 ns645 0 -7.36842128994e-06
Gc30_646 0 n60 ns646 0 -2.3864237715e-05
Gc30_647 0 n60 ns647 0 0.000373743342775
Gc30_648 0 n60 ns648 0 -0.000869786621082
Gc30_649 0 n60 ns649 0 0.00249774411004
Gc30_650 0 n60 ns650 0 6.09700890382e-05
Gc30_651 0 n60 ns651 0 0.000198905018893
Gc30_652 0 n60 ns652 0 0.000282301544571
Gc30_653 0 n60 ns653 0 -9.06949841599e-08
Gc30_654 0 n60 ns654 0 2.64868878027e-06
Gc30_655 0 n60 ns655 0 -3.43695304187e-05
Gc30_656 0 n60 ns656 0 -0.00120979735713
Gc30_657 0 n60 ns657 0 -0.000505621306276
Gc30_658 0 n60 ns658 0 0.000812325654222
Gc30_659 0 n60 ns659 0 -8.09833877858e-05
Gc30_660 0 n60 ns660 0 -0.000144961106716
Gc30_661 0 n60 ns661 0 -0.000162767181672
Gc30_662 0 n60 ns662 0 -0.00125779772551
Gc30_663 0 n60 ns663 0 -0.000659231060907
Gc30_664 0 n60 ns664 0 0.000243026645881
Gc30_665 0 n60 ns665 0 0.000920890994901
Gc30_666 0 n60 ns666 0 0.000184191560974
Gc30_667 0 n60 ns667 0 -0.00011761706187
Gc30_668 0 n60 ns668 0 -0.000805454719163
Gc30_669 0 n60 ns669 0 0.00100667317399
Gc30_670 0 n60 ns670 0 0.00103967303016
Gc30_671 0 n60 ns671 0 0.000384999455443
Gc30_672 0 n60 ns672 0 -0.000532906391194
Gc30_673 0 n60 ns673 0 -0.000533048164792
Gc30_674 0 n60 ns674 0 -0.00107155781009
Gc30_675 0 n60 ns675 0 0.000164007987981
Gc30_676 0 n60 ns676 0 0.000370822000679
Gc30_677 0 n60 ns677 0 0.000765197917783
Gc30_678 0 n60 ns678 0 0.000245977586808
Gc30_679 0 n60 ns679 0 -0.000394940348946
Gc30_680 0 n60 ns680 0 0.00259199664779
Gc30_681 0 n60 ns681 0 -0.00297936327585
Gc30_682 0 n60 ns682 0 0.000246390105827
Gc30_683 0 n60 ns683 0 -3.98520329648e-06
Gc30_684 0 n60 ns684 0 -2.56477466638e-05
Gc30_685 0 n60 ns685 0 -0.00050684665192
Gc30_686 0 n60 ns686 0 0.000885041238201
Gc30_687 0 n60 ns687 0 -0.00181440529101
Gc30_688 0 n60 ns688 0 -0.000312114556248
Gc30_689 0 n60 ns689 0 0.000114521461329
Gc30_690 0 n60 ns690 0 -0.00013595168225
Gc30_691 0 n60 ns691 0 0.000130011830351
Gc30_692 0 n60 ns692 0 -9.76511945965e-06
Gc30_693 0 n60 ns693 0 1.31419443783e-05
Gc30_694 0 n60 ns694 0 0.00079545168937
Gc30_695 0 n60 ns695 0 0.000581759983361
Gc30_696 0 n60 ns696 0 8.42361368283e-05
Gc30_697 0 n60 ns697 0 0.000190547622939
Gc30_698 0 n60 ns698 0 -0.000141982127621
Gc30_699 0 n60 ns699 0 -0.000200060323359
Gc30_700 0 n60 ns700 0 0.00073943687392
Gc30_701 0 n60 ns701 0 -0.000598202970684
Gc30_702 0 n60 ns702 0 -0.000484519004303
Gc30_703 0 n60 ns703 0 0.000412871140309
Gc30_704 0 n60 ns704 0 0.000172446597299
Gc30_705 0 n60 ns705 0 -8.92797250956e-05
Gc30_706 0 n60 ns706 0 0.000160495234499
Gc30_707 0 n60 ns707 0 -7.15543299338e-05
Gc30_708 0 n60 ns708 0 0.000636339684834
Gc30_709 0 n60 ns709 0 0.000843737612705
Gc30_710 0 n60 ns710 0 -0.000318650804217
Gc30_711 0 n60 ns711 0 -0.000848564050544
Gc30_712 0 n60 ns712 0 -0.000397611779589
Gc30_713 0 n60 ns713 0 -0.000317041976568
Gc30_714 0 n60 ns714 0 0.000256738550804
Gc30_715 0 n60 ns715 0 0.00128094144819
Gc30_716 0 n60 ns716 0 0.000489512246551
Gc30_717 0 n60 ns717 0 -0.000655097594738
Gc30_718 0 n60 ns718 0 0.0163985153173
Gc30_719 0 n60 ns719 0 -0.0150839425069
Gc30_720 0 n60 ns720 0 0.000762884404378
Gc30_721 0 n60 ns721 0 -4.96809968495e-06
Gc30_722 0 n60 ns722 0 -2.60259774597e-05
Gc30_723 0 n60 ns723 0 -0.00126676131595
Gc30_724 0 n60 ns724 0 0.00246578395045
Gc30_725 0 n60 ns725 0 -0.00605642586542
Gc30_726 0 n60 ns726 0 -0.000264338918876
Gc30_727 0 n60 ns727 0 -0.000307823079313
Gc30_728 0 n60 ns728 0 -0.000167571186615
Gc30_729 0 n60 ns729 0 -0.000229643486878
Gc30_730 0 n60 ns730 0 -1.85188419478e-05
Gc30_731 0 n60 ns731 0 2.53155807596e-05
Gc30_732 0 n60 ns732 0 6.03541695126e-05
Gc30_733 0 n60 ns733 0 0.00228629572097
Gc30_734 0 n60 ns734 0 -0.000372275853282
Gc30_735 0 n60 ns735 0 -0.000323218239873
Gc30_736 0 n60 ns736 0 -6.56918700353e-05
Gc30_737 0 n60 ns737 0 -0.00028501968061
Gc30_738 0 n60 ns738 0 0.000820842921996
Gc30_739 0 n60 ns739 0 0.00181657823447
Gc30_740 0 n60 ns740 0 -0.000113323261225
Gc30_741 0 n60 ns741 0 -0.00047162549316
Gc30_742 0 n60 ns742 0 0.000244392539723
Gc30_743 0 n60 ns743 0 -0.000138591753544
Gc30_744 0 n60 ns744 0 0.00257721912944
Gc30_745 0 n60 ns745 0 0.00153931181179
Gc30_746 0 n60 ns746 0 0.000297790199383
Gc30_747 0 n60 ns747 0 0.000324282132827
Gc30_748 0 n60 ns748 0 -0.000161967931943
Gc30_749 0 n60 ns749 0 -0.000955248367119
Gc30_750 0 n60 ns750 0 0.00315608726939
Gc30_751 0 n60 ns751 0 0.000184033662793
Gc30_752 0 n60 ns752 0 -0.000867388702829
Gc30_753 0 n60 ns753 0 0.00103779661396
Gc30_754 0 n60 ns754 0 0.000855213758223
Gc30_755 0 n60 ns755 0 -0.000645685748084
Gc30_756 0 n60 ns756 0 0.0418631125011
Gc30_757 0 n60 ns757 0 -0.0373942509358
Gc30_758 0 n60 ns758 0 0.00179957189565
Gc30_759 0 n60 ns759 0 -6.52599131156e-06
Gc30_760 0 n60 ns760 0 -2.19140188242e-05
Gc30_761 0 n60 ns761 0 -0.00175288536285
Gc30_762 0 n60 ns762 0 0.000598712485368
Gc30_763 0 n60 ns763 0 -0.00167649485307
Gc30_764 0 n60 ns764 0 0.000500674004761
Gc30_765 0 n60 ns765 0 -0.00050206048459
Gc30_766 0 n60 ns766 0 0.000621277702858
Gc30_767 0 n60 ns767 0 -1.14660118378e-07
Gc30_768 0 n60 ns768 0 -0.000128203732584
Gc30_769 0 n60 ns769 0 4.88370234547e-06
Gc30_770 0 n60 ns770 0 -0.00189485318657
Gc30_771 0 n60 ns771 0 0.0003085145858
Gc30_772 0 n60 ns772 0 0.000631745863201
Gc30_773 0 n60 ns773 0 -0.000539075520179
Gc30_774 0 n60 ns774 0 0.000151194647558
Gc30_775 0 n60 ns775 0 -0.000466118905515
Gc30_776 0 n60 ns776 0 -0.00182081055135
Gc30_777 0 n60 ns777 0 9.11492403435e-05
Gc30_778 0 n60 ns778 0 0.000170972022358
Gc30_779 0 n60 ns779 0 0.000128916002669
Gc30_780 0 n60 ns780 0 0.000450904571326
Gc30_781 0 n60 ns781 0 5.78943248071e-05
Gc30_782 0 n60 ns782 0 -0.000933394769723
Gc30_783 0 n60 ns783 0 0.00350539987782
Gc30_784 0 n60 ns784 0 0.000974953421095
Gc30_785 0 n60 ns785 0 0.000400298974885
Gc30_786 0 n60 ns786 0 0.000129888843316
Gc30_787 0 n60 ns787 0 -0.0013750065485
Gc30_788 0 n60 ns788 0 0.00171692347413
Gc30_789 0 n60 ns789 0 0.0020960119625
Gc30_790 0 n60 ns790 0 -0.00175514854099
Gc30_791 0 n60 ns791 0 0.000322305993746
Gc30_792 0 n60 ns792 0 0.00162169482546
Gc30_793 0 n60 ns793 0 -0.000258638187848
Gc30_794 0 n60 ns794 0 0.051601777369
Gc30_795 0 n60 ns795 0 -0.0500715548026
Gc30_796 0 n60 ns796 0 0.00372094652045
Gc30_797 0 n60 ns797 0 -8.16218047688e-07
Gc30_798 0 n60 ns798 0 -8.42251914341e-06
Gc30_799 0 n60 ns799 0 -0.00494149676099
Gc30_800 0 n60 ns800 0 -0.00122678908835
Gc30_801 0 n60 ns801 0 -0.00374363113076
Gc30_802 0 n60 ns802 0 0.00036712016209
Gc30_803 0 n60 ns803 0 -0.0012502571096
Gc30_804 0 n60 ns804 0 -7.80298868295e-05
Gc30_805 0 n60 ns805 0 0.00081981499172
Gc30_806 0 n60 ns806 0 -0.000115253944289
Gc30_807 0 n60 ns807 0 -7.77579277732e-05
Gc30_808 0 n60 ns808 0 -0.000874968830204
Gc30_809 0 n60 ns809 0 0.00204316260051
Gc30_810 0 n60 ns810 0 0.00101099748108
Gc30_811 0 n60 ns811 0 -0.000529001040324
Gc30_812 0 n60 ns812 0 0.000201867631215
Gc30_813 0 n60 ns813 0 -0.000545794935705
Gc30_814 0 n60 ns814 0 0.00032693936735
Gc30_815 0 n60 ns815 0 -0.000704849211947
Gc30_816 0 n60 ns816 0 0.000122100354945
Gc30_817 0 n60 ns817 0 7.59638645211e-05
Gc30_818 0 n60 ns818 0 0.000458278753191
Gc30_819 0 n60 ns819 0 0.000142799413713
Gc30_820 0 n60 ns820 0 -0.0013862054894
Gc30_821 0 n60 ns821 0 0.00108828616004
Gc30_822 0 n60 ns822 0 0.00160072148566
Gc30_823 0 n60 ns823 0 0.00187299368938
Gc30_824 0 n60 ns824 0 0.000780481430399
Gc30_825 0 n60 ns825 0 -0.00198989431991
Gc30_826 0 n60 ns826 0 0.000815509322622
Gc30_827 0 n60 ns827 0 0.000980554319734
Gc30_828 0 n60 ns828 0 0.000221794286173
Gc30_829 0 n60 ns829 0 -2.45279872336e-05
Gc30_830 0 n60 ns830 0 0.00246357540511
Gc30_831 0 n60 ns831 0 8.32679388279e-05
Gc30_832 0 n60 ns832 0 0.0275788922942
Gc30_833 0 n60 ns833 0 -0.0264882282599
Gc30_834 0 n60 ns834 0 0.00664187751568
Gc30_835 0 n60 ns835 0 -3.732592385e-06
Gc30_836 0 n60 ns836 0 7.48228298882e-06
Gc30_837 0 n60 ns837 0 -0.00480739857662
Gc30_838 0 n60 ns838 0 -0.00075803826792
Gc30_839 0 n60 ns839 0 -0.00365426237195
Gc30_840 0 n60 ns840 0 0.000165203182888
Gc30_841 0 n60 ns841 0 -0.001022817124
Gc30_842 0 n60 ns842 0 -4.56362387546e-05
Gc30_843 0 n60 ns843 0 0.000298960460588
Gc30_844 0 n60 ns844 0 -8.79573553306e-05
Gc30_845 0 n60 ns845 0 -1.40822160558e-05
Gc30_846 0 n60 ns846 0 -0.00234198201676
Gc30_847 0 n60 ns847 0 0.00202017129152
Gc30_848 0 n60 ns848 0 0.00104440156361
Gc30_849 0 n60 ns849 0 -0.000195491600299
Gc30_850 0 n60 ns850 0 0.000313543471623
Gc30_851 0 n60 ns851 0 -0.000566014964912
Gc30_852 0 n60 ns852 0 -2.39342830111e-05
Gc30_853 0 n60 ns853 0 0.000960971748061
Gc30_854 0 n60 ns854 0 0.00030550049422
Gc30_855 0 n60 ns855 0 0.000345320426258
Gc30_856 0 n60 ns856 0 0.000587641162448
Gc30_857 0 n60 ns857 0 0.000194934242694
Gc30_858 0 n60 ns858 0 0.00091239356764
Gc30_859 0 n60 ns859 0 0.00154702420882
Gc30_860 0 n60 ns860 0 0.00121424416265
Gc30_861 0 n60 ns861 0 0.00288923652197
Gc30_862 0 n60 ns862 0 0.00134275981514
Gc30_863 0 n60 ns863 0 -0.00221200049748
Gc30_864 0 n60 ns864 0 0.00188938554746
Gc30_865 0 n60 ns865 0 -0.00153357533664
Gc30_866 0 n60 ns866 0 0.00186996591081
Gc30_867 0 n60 ns867 0 0.00144031719615
Gc30_868 0 n60 ns868 0 0.00305695454442
Gc30_869 0 n60 ns869 0 2.48160048746e-05
Gc30_870 0 n60 ns870 0 -0.0162266842314
Gc30_871 0 n60 ns871 0 0.0186420242702
Gc30_872 0 n60 ns872 0 0.00690907605498
Gc30_873 0 n60 ns873 0 9.71297072277e-08
Gc30_874 0 n60 ns874 0 1.78300969089e-05
Gc30_875 0 n60 ns875 0 -0.00202832170792
Gc30_876 0 n60 ns876 0 0.00012724346813
Gc30_877 0 n60 ns877 0 0.00181866530025
Gc30_878 0 n60 ns878 0 0.000631601817709
Gc30_879 0 n60 ns879 0 -0.000404796001786
Gc30_880 0 n60 ns880 0 0.000504673109606
Gc30_881 0 n60 ns881 0 0.000371900184631
Gc30_882 0 n60 ns882 0 -0.000167171533159
Gc30_883 0 n60 ns883 0 -1.62324763705e-05
Gc30_884 0 n60 ns884 0 -0.000574648211478
Gc30_885 0 n60 ns885 0 -0.000761507636379
Gc30_886 0 n60 ns886 0 0.000526565035256
Gc30_887 0 n60 ns887 0 0.000121057289194
Gc30_888 0 n60 ns888 0 0.000360479064452
Gc30_889 0 n60 ns889 0 -0.00049443730287
Gc30_890 0 n60 ns890 0 -0.000201683412672
Gc30_891 0 n60 ns891 0 -0.00222350418219
Gc30_892 0 n60 ns892 0 -0.000994710049478
Gc30_893 0 n60 ns893 0 -5.41217711464e-05
Gc30_894 0 n60 ns894 0 0.00033642514152
Gc30_895 0 n60 ns895 0 0.000333735352025
Gc30_896 0 n60 ns896 0 -0.00410131419987
Gc30_897 0 n60 ns897 0 0.000438405249319
Gc30_898 0 n60 ns898 0 9.03167913183e-05
Gc30_899 0 n60 ns899 0 0.00147046438471
Gc30_900 0 n60 ns900 0 0.00106953350376
Gc30_901 0 n60 ns901 0 -0.00146784963442
Gc30_902 0 n60 ns902 0 -0.0027736413569
Gc30_903 0 n60 ns903 0 0.00134131126536
Gc30_904 0 n60 ns904 0 -0.00181447373904
Gc30_905 0 n60 ns905 0 0.000543840285869
Gc30_906 0 n60 ns906 0 0.00210077006037
Gc30_907 0 n60 ns907 0 8.84189517205e-05
Gc30_908 0 n60 ns908 0 0.0383112136738
Gc30_909 0 n60 ns909 0 -0.0419599154688
Gc30_910 0 n60 ns910 0 0.00445708090547
Gc30_911 0 n60 ns911 0 3.1329007415e-06
Gc30_912 0 n60 ns912 0 2.65527783546e-05
Gc30_913 0 n60 ns913 0 -0.00117355732158
Gc30_914 0 n60 ns914 0 0.00251335014901
Gc30_915 0 n60 ns915 0 -0.00398867328036
Gc30_916 0 n60 ns916 0 0.000220479034203
Gc30_917 0 n60 ns917 0 -0.000501118600114
Gc30_918 0 n60 ns918 0 7.80503758977e-05
Gc30_919 0 n60 ns919 0 -0.00053481809435
Gc30_920 0 n60 ns920 0 -3.34703113778e-05
Gc30_921 0 n60 ns921 0 -7.75898240806e-06
Gc30_922 0 n60 ns922 0 -0.00158726862328
Gc30_923 0 n60 ns923 0 0.00168508339
Gc30_924 0 n60 ns924 0 -0.000363987275286
Gc30_925 0 n60 ns925 0 -0.000448767168534
Gc30_926 0 n60 ns926 0 0.000149132429609
Gc30_927 0 n60 ns927 0 -0.000237125314248
Gc30_928 0 n60 ns928 0 -0.000159907790036
Gc30_929 0 n60 ns929 0 0.0026811035081
Gc30_930 0 n60 ns930 0 0.000134757492296
Gc30_931 0 n60 ns931 0 -0.000880931288872
Gc30_932 0 n60 ns932 0 0.000209156317798
Gc30_933 0 n60 ns933 0 9.90597843539e-06
Gc30_934 0 n60 ns934 0 0.00235674733565
Gc30_935 0 n60 ns935 0 0.00234729530879
Gc30_936 0 n60 ns936 0 -0.000512342254133
Gc30_937 0 n60 ns937 0 5.10971307458e-06
Gc30_938 0 n60 ns938 0 0.000463679301242
Gc30_939 0 n60 ns939 0 -0.000645865204609
Gc30_940 0 n60 ns940 0 0.00358712449747
Gc30_941 0 n60 ns941 0 0.000271873254296
Gc30_942 0 n60 ns942 0 -0.00189209766065
Gc30_943 0 n60 ns943 0 0.00066985905409
Gc30_944 0 n60 ns944 0 0.00113416921116
Gc30_945 0 n60 ns945 0 -0.000210281060752
Gc30_946 0 n60 ns946 0 0.0366489007901
Gc30_947 0 n60 ns947 0 -0.0335884385821
Gc30_948 0 n60 ns948 0 0.00190250282922
Gc30_949 0 n60 ns949 0 -6.38501765079e-06
Gc30_950 0 n60 ns950 0 1.82614516358e-05
Gc30_951 0 n60 ns951 0 -2.29126631435e-05
Gc30_952 0 n60 ns952 0 -0.000378405806343
Gc30_953 0 n60 ns953 0 0.0010203205453
Gc30_954 0 n60 ns954 0 -4.54381356321e-05
Gc30_955 0 n60 ns955 0 0.000155699173142
Gc30_956 0 n60 ns956 0 6.61743128048e-05
Gc30_957 0 n60 ns957 0 4.96974802284e-05
Gc30_958 0 n60 ns958 0 -1.57027605395e-05
Gc30_959 0 n60 ns959 0 5.63360114578e-06
Gc30_960 0 n60 ns960 0 -0.000249188122748
Gc30_961 0 n60 ns961 0 -0.000151430218507
Gc30_962 0 n60 ns962 0 0.000510192158561
Gc30_963 0 n60 ns963 0 0.00013168265392
Gc30_964 0 n60 ns964 0 -0.000133880612332
Gc30_965 0 n60 ns965 0 -0.00019359721693
Gc30_966 0 n60 ns966 0 -0.000305051242846
Gc30_967 0 n60 ns967 0 -0.00091079462025
Gc30_968 0 n60 ns968 0 -0.000207543694056
Gc30_969 0 n60 ns969 0 0.000791382342043
Gc30_970 0 n60 ns970 0 0.000195424322379
Gc30_971 0 n60 ns971 0 -8.62023571935e-05
Gc30_972 0 n60 ns972 0 -0.000624044678816
Gc30_973 0 n60 ns973 0 0.000362304135773
Gc30_974 0 n60 ns974 0 0.000848483022926
Gc30_975 0 n60 ns975 0 0.000730081420281
Gc30_976 0 n60 ns976 0 -0.000407816628174
Gc30_977 0 n60 ns977 0 -0.00073177977841
Gc30_978 0 n60 ns978 0 -0.00127219020848
Gc30_979 0 n60 ns979 0 -2.90664298701e-05
Gc30_980 0 n60 ns980 0 0.000464888158107
Gc30_981 0 n60 ns981 0 0.00116935294071
Gc30_982 0 n60 ns982 0 0.000397884063833
Gc30_983 0 n60 ns983 0 -0.000589405116272
Gc30_984 0 n60 ns984 0 0.00882957565376
Gc30_985 0 n60 ns985 0 -0.00864896568784
Gc30_986 0 n60 ns986 0 0.000510592310961
Gc30_987 0 n60 ns987 0 -3.3827738624e-06
Gc30_988 0 n60 ns988 0 -2.64846291583e-05
Gc30_989 0 n60 ns989 0 -0.000959476142087
Gc30_990 0 n60 ns990 0 0.00227245056961
Gc30_991 0 n60 ns991 0 -0.00576394551308
Gc30_992 0 n60 ns992 0 -0.000429093711137
Gc30_993 0 n60 ns993 0 -0.000222294210743
Gc30_994 0 n60 ns994 0 -0.000361129281643
Gc30_995 0 n60 ns995 0 -6.84816123097e-05
Gc30_996 0 n60 ns996 0 -3.84670085614e-06
Gc30_997 0 n60 ns997 0 2.60980548816e-05
Gc30_998 0 n60 ns998 0 0.000768940246676
Gc30_999 0 n60 ns999 0 0.0021979639875
Gc30_1000 0 n60 ns1000 0 -0.000354235171386
Gc30_1001 0 n60 ns1001 0 -0.000133349991206
Gc30_1002 0 n60 ns1002 0 -0.00012782083818
Gc30_1003 0 n60 ns1003 0 -0.000235028723093
Gc30_1004 0 n60 ns1004 0 0.00131132931196
Gc30_1005 0 n60 ns1005 0 0.00115937784142
Gc30_1006 0 n60 ns1006 0 -0.000281429994225
Gc30_1007 0 n60 ns1007 0 -0.000281586958877
Gc30_1008 0 n60 ns1008 0 0.000188587660931
Gc30_1009 0 n60 ns1009 0 -0.000146471535652
Gc30_1010 0 n60 ns1010 0 0.0022092938819
Gc30_1011 0 n60 ns1011 0 0.000672787899185
Gc30_1012 0 n60 ns1012 0 0.000362507435033
Gc30_1013 0 n60 ns1013 0 0.000496005466773
Gc30_1014 0 n60 ns1014 0 -0.000243352630351
Gc30_1015 0 n60 ns1015 0 -0.000884619569146
Gc30_1016 0 n60 ns1016 0 0.00232316038952
Gc30_1017 0 n60 ns1017 0 -7.16074154963e-05
Gc30_1018 0 n60 ns1018 0 -0.000410471074962
Gc30_1019 0 n60 ns1019 0 0.00108093448262
Gc30_1020 0 n60 ns1020 0 0.000646288324762
Gc30_1021 0 n60 ns1021 0 -0.000671841608229
Gc30_1022 0 n60 ns1022 0 0.0350874216108
Gc30_1023 0 n60 ns1023 0 -0.0310983679277
Gc30_1024 0 n60 ns1024 0 0.00140387545701
Gc30_1025 0 n60 ns1025 0 -7.09485732363e-06
Gc30_1026 0 n60 ns1026 0 -2.52302462782e-05
Gc30_1027 0 n60 ns1027 0 -0.00148561753935
Gc30_1028 0 n60 ns1028 0 0.00113657334438
Gc30_1029 0 n60 ns1029 0 -0.00342960969941
Gc30_1030 0 n60 ns1030 0 0.000331976519246
Gc30_1031 0 n60 ns1031 0 -0.000584233383818
Gc30_1032 0 n60 ns1032 0 0.000280823424045
Gc30_1033 0 n60 ns1033 0 -0.000185825557234
Gc30_1034 0 n60 ns1034 0 -4.74520814124e-05
Gc30_1035 0 n60 ns1035 0 3.5819287523e-05
Gc30_1036 0 n60 ns1036 0 -0.00143818582018
Gc30_1037 0 n60 ns1037 0 0.000999083466951
Gc30_1038 0 n60 ns1038 0 0.000117265687668
Gc30_1039 0 n60 ns1039 0 -0.000508029396604
Gc30_1040 0 n60 ns1040 0 5.12701410141e-05
Gc30_1041 0 n60 ns1041 0 -0.000371371136055
Gc30_1042 0 n60 ns1042 0 -0.0014193550832
Gc30_1043 0 n60 ns1043 0 0.0012218332895
Gc30_1044 0 n60 ns1044 0 0.00020738426368
Gc30_1045 0 n60 ns1045 0 -2.72463297184e-05
Gc30_1046 0 n60 ns1046 0 0.000401229353765
Gc30_1047 0 n60 ns1047 0 -2.69631929727e-05
Gc30_1048 0 n60 ns1048 0 0.000823019399755
Gc30_1049 0 n60 ns1049 0 0.00384107943312
Gc30_1050 0 n60 ns1050 0 0.000781851044392
Gc30_1051 0 n60 ns1051 0 0.000212715843001
Gc30_1052 0 n60 ns1052 0 -5.53367338e-05
Gc30_1053 0 n60 ns1053 0 -0.00120469946043
Gc30_1054 0 n60 ns1054 0 0.0035562337528
Gc30_1055 0 n60 ns1055 0 0.00211216687783
Gc30_1056 0 n60 ns1056 0 -0.00158710138777
Gc30_1057 0 n60 ns1057 0 0.000429396458404
Gc30_1058 0 n60 ns1058 0 0.00126265515541
Gc30_1059 0 n60 ns1059 0 -0.000440834462406
Gc30_1060 0 n60 ns1060 0 0.0537913172087
Gc30_1061 0 n60 ns1061 0 -0.0497730835956
Gc30_1062 0 n60 ns1062 0 0.00288334408704
Gc30_1063 0 n60 ns1063 0 -3.01382195064e-06
Gc30_1064 0 n60 ns1064 0 -1.80093108492e-05
Gc30_1065 0 n60 ns1065 0 -0.0021277476703
Gc30_1066 0 n60 ns1066 0 -0.0019786811139
Gc30_1067 0 n60 ns1067 0 0.00387062034265
Gc30_1068 0 n60 ns1068 0 0.000345215403115
Gc30_1069 0 n60 ns1069 0 -0.000398118814956
Gc30_1070 0 n60 ns1070 0 0.000575487345476
Gc30_1071 0 n60 ns1071 0 0.000400226646648
Gc30_1072 0 n60 ns1072 0 -0.000167812588171
Gc30_1073 0 n60 ns1073 0 -8.28087776824e-05
Gc30_1074 0 n60 ns1074 0 -0.00132480438881
Gc30_1075 0 n60 ns1075 0 0.000107243084223
Gc30_1076 0 n60 ns1076 0 0.00106872932446
Gc30_1077 0 n60 ns1077 0 -0.000154821433343
Gc30_1078 0 n60 ns1078 0 0.000301449193371
Gc30_1079 0 n60 ns1079 0 -0.000507445903222
Gc30_1080 0 n60 ns1080 0 0.000140631919625
Gc30_1081 0 n60 ns1081 0 -0.0018673297752
Gc30_1082 0 n60 ns1082 0 -0.000334843714452
Gc30_1083 0 n60 ns1083 0 5.13031521646e-05
Gc30_1084 0 n60 ns1084 0 0.000380385035222
Gc30_1085 0 n60 ns1085 0 0.000205462748311
Gc30_1086 0 n60 ns1086 0 -0.00360815877419
Gc30_1087 0 n60 ns1087 0 -0.000899647174426
Gc30_1088 0 n60 ns1088 0 0.000868575624944
Gc30_1089 0 n60 ns1089 0 0.00139135247615
Gc30_1090 0 n60 ns1090 0 0.000765462518965
Gc30_1091 0 n60 ns1091 0 -0.00157684425554
Gc30_1092 0 n60 ns1092 0 -0.00522560925044
Gc30_1093 0 n60 ns1093 0 -0.0012954088636
Gc30_1094 0 n60 ns1094 0 -0.00123386362987
Gc30_1095 0 n60 ns1095 0 0.000819584948283
Gc30_1096 0 n60 ns1096 0 0.0024292296226
Gc30_1097 0 n60 ns1097 0 0.000240894798275
Gc30_1098 0 n60 ns1098 0 0.0221648572952
Gc30_1099 0 n60 ns1099 0 -0.0295141950381
Gc30_1100 0 n60 ns1100 0 0.00550649210896
Gc30_1101 0 n60 ns1101 0 1.83458520631e-06
Gc30_1102 0 n60 ns1102 0 3.77884747588e-06
Gc30_1103 0 n60 ns1103 0 -0.00305851574204
Gc30_1104 0 n60 ns1104 0 -9.65220112915e-05
Gc30_1105 0 n60 ns1105 0 -0.00138019046935
Gc30_1106 0 n60 ns1106 0 0.000244453889017
Gc30_1107 0 n60 ns1107 0 -0.000257145106999
Gc30_1108 0 n60 ns1108 0 0.000472002457011
Gc30_1109 0 n60 ns1109 0 -0.000125641804759
Gc30_1110 0 n60 ns1110 0 -0.000192311187231
Gc30_1111 0 n60 ns1111 0 -0.000103954150248
Gc30_1112 0 n60 ns1112 0 -0.00420853682352
Gc30_1113 0 n60 ns1113 0 0.00142030927473
Gc30_1114 0 n60 ns1114 0 0.00168776379016
Gc30_1115 0 n60 ns1115 0 -6.73393919547e-05
Gc30_1116 0 n60 ns1116 0 0.000428142638989
Gc30_1117 0 n60 ns1117 0 -0.000662449971623
Gc30_1118 0 n60 ns1118 0 -0.000242603867575
Gc30_1119 0 n60 ns1119 0 0.000943065173775
Gc30_1120 0 n60 ns1120 0 0.000435746850938
Gc30_1121 0 n60 ns1121 0 0.000576179041455
Gc30_1122 0 n60 ns1122 0 0.00064851059147
Gc30_1123 0 n60 ns1123 0 0.000214917777665
Gc30_1124 0 n60 ns1124 0 0.000356910676489
Gc30_1125 0 n60 ns1125 0 0.000902763047951
Gc30_1126 0 n60 ns1126 0 0.00144311589215
Gc30_1127 0 n60 ns1127 0 0.00301698393601
Gc30_1128 0 n60 ns1128 0 0.00130902609973
Gc30_1129 0 n60 ns1129 0 -0.00230618588386
Gc30_1130 0 n60 ns1130 0 -0.00076394493539
Gc30_1131 0 n60 ns1131 0 -0.0028680728797
Gc30_1132 0 n60 ns1132 0 0.00206374379827
Gc30_1133 0 n60 ns1133 0 0.00193968447305
Gc30_1134 0 n60 ns1134 0 0.00326009507727
Gc30_1135 0 n60 ns1135 0 3.14683744283e-05
Gc30_1136 0 n60 ns1136 0 -0.0249634527185
Gc30_1137 0 n60 ns1137 0 0.0243978009069
Gc30_1138 0 n60 ns1138 0 0.00691934009944
Gc30_1139 0 n60 ns1139 0 1.03730700119e-05
Gc30_1140 0 n60 ns1140 0 1.98072269211e-05
Gc30_1141 0 n60 ns1141 0 -0.0019793849937
Gc30_1142 0 n60 ns1142 0 -0.00181240145717
Gc30_1143 0 n60 ns1143 0 0.00520491070486
Gc30_1144 0 n60 ns1144 0 0.000370814093318
Gc30_1145 0 n60 ns1145 0 -0.000387820242355
Gc30_1146 0 n60 ns1146 0 0.000505348853974
Gc30_1147 0 n60 ns1147 0 0.000423012849895
Gc30_1148 0 n60 ns1148 0 -0.000171641421153
Gc30_1149 0 n60 ns1149 0 -4.18106569623e-05
Gc30_1150 0 n60 ns1150 0 -0.00105295438144
Gc30_1151 0 n60 ns1151 0 -0.000681652201444
Gc30_1152 0 n60 ns1152 0 0.000977394618296
Gc30_1153 0 n60 ns1153 0 0.000362736283079
Gc30_1154 0 n60 ns1154 0 0.000457281139946
Gc30_1155 0 n60 ns1155 0 -0.000546157273419
Gc30_1156 0 n60 ns1156 0 0.000570764331521
Gc30_1157 0 n60 ns1157 0 -0.00267438161397
Gc30_1158 0 n60 ns1158 0 -0.000943718844561
Gc30_1159 0 n60 ns1159 0 8.75119369677e-05
Gc30_1160 0 n60 ns1160 0 0.000394825353521
Gc30_1161 0 n60 ns1161 0 0.000364473419096
Gc30_1162 0 n60 ns1162 0 -0.00464753949973
Gc30_1163 0 n60 ns1163 0 -0.0017410291907
Gc30_1164 0 n60 ns1164 0 0.000351874150363
Gc30_1165 0 n60 ns1165 0 0.00197413607999
Gc30_1166 0 n60 ns1166 0 0.00123246464463
Gc30_1167 0 n60 ns1167 0 -0.0016994258517
Gc30_1168 0 n60 ns1168 0 -0.00661254163162
Gc30_1169 0 n60 ns1169 0 -0.00158539442308
Gc30_1170 0 n60 ns1170 0 -0.00123347130687
Gc30_1171 0 n60 ns1171 0 0.00112449347294
Gc30_1172 0 n60 ns1172 0 0.00257594501627
Gc30_1173 0 n60 ns1173 0 0.000260842576663
Gc30_1174 0 n60 ns1174 0 0.0144771598523
Gc30_1175 0 n60 ns1175 0 -0.0233340037998
Gc30_1176 0 n60 ns1176 0 0.00536325698999
Gc30_1177 0 n60 ns1177 0 2.40922936689e-06
Gc30_1178 0 n60 ns1178 0 2.69927392179e-05
Gc30_1179 0 n60 ns1179 0 -0.00147283502034
Gc30_1180 0 n60 ns1180 0 0.00169542588102
Gc30_1181 0 n60 ns1181 0 -0.00274798683932
Gc30_1182 0 n60 ns1182 0 0.000468832933508
Gc30_1183 0 n60 ns1183 0 -0.000696872122042
Gc30_1184 0 n60 ns1184 0 0.000262058430589
Gc30_1185 0 n60 ns1185 0 -0.000246159014692
Gc30_1186 0 n60 ns1186 0 -6.43873026737e-05
Gc30_1187 0 n60 ns1187 0 -9.90269472057e-06
Gc30_1188 0 n60 ns1188 0 -0.00177507894107
Gc30_1189 0 n60 ns1189 0 0.00084773318775
Gc30_1190 0 n60 ns1190 0 -7.0545194839e-05
Gc30_1191 0 n60 ns1191 0 -0.000325853916733
Gc30_1192 0 n60 ns1192 0 0.000246311707468
Gc30_1193 0 n60 ns1193 0 -0.000360383696234
Gc30_1194 0 n60 ns1194 0 -0.000797628267251
Gc30_1195 0 n60 ns1195 0 0.00157963856911
Gc30_1196 0 n60 ns1196 0 -9.23245084303e-05
Gc30_1197 0 n60 ns1197 0 -0.000572689842408
Gc30_1198 0 n60 ns1198 0 0.000317301246111
Gc30_1199 0 n60 ns1199 0 0.000109976511045
Gc30_1200 0 n60 ns1200 0 0.000710097408368
Gc30_1201 0 n60 ns1201 0 0.00288163773696
Gc30_1202 0 n60 ns1202 0 -0.000246726517266
Gc30_1203 0 n60 ns1203 0 0.000373572549857
Gc30_1204 0 n60 ns1204 0 0.000614563709504
Gc30_1205 0 n60 ns1205 0 -0.000995498363922
Gc30_1206 0 n60 ns1206 0 0.00289447668564
Gc30_1207 0 n60 ns1207 0 0.00139956503033
Gc30_1208 0 n60 ns1208 0 -0.00203613323588
Gc30_1209 0 n60 ns1209 0 0.000535118707397
Gc30_1210 0 n60 ns1210 0 0.00143648600615
Gc30_1211 0 n60 ns1211 0 -0.000210746612305
Gc30_1212 0 n60 ns1212 0 0.0451098466237
Gc30_1213 0 n60 ns1213 0 -0.0426001190144
Gc30_1214 0 n60 ns1214 0 0.00272324793289
Gc30_1215 0 n60 ns1215 0 -3.10223491424e-06
Gc30_1216 0 n60 ns1216 0 2.23047872769e-05
Gd30_1 0 n60 ni1 0 -0.000140775429124
Gd30_2 0 n60 ni2 0 -7.40675421858e-05
Gd30_3 0 n60 ni3 0 0.000196064073578
Gd30_4 0 n60 ni4 0 0.000266576586507
Gd30_5 0 n60 ni5 0 3.38776042059e-05
Gd30_6 0 n60 ni6 0 -0.00169455585231
Gd30_7 0 n60 ni7 0 -0.00315131312574
Gd30_8 0 n60 ni8 0 -9.23321303411e-05
Gd30_9 0 n60 ni9 0 0.000197797874594
Gd30_10 0 n60 ni10 0 0.000206164145473
Gd30_11 0 n60 ni11 0 0.000227650254381
Gd30_12 0 n60 ni12 0 0.00061576736821
Gd30_13 0 n60 ni13 0 -0.000380952758404
Gd30_14 0 n60 ni14 0 -0.0069337581565
Gd30_15 0 n60 ni15 0 -0.000377070590198
Gd30_16 0 n60 ni16 0 0.000567156740365
Gd30_17 0 n60 ni17 0 -3.92471940422e-05
Gd30_18 0 n60 ni18 0 0.00012303092243
Gd30_19 0 n60 ni19 0 6.3358011648e-05
Gd30_20 0 n60 ni20 0 6.63501705564e-05
Gd30_21 0 n60 ni21 0 -0.00087395275403
Gd30_22 0 n60 ni22 0 -0.00277753608274
Gd30_23 0 n60 ni23 0 -0.00091751004211
Gd30_24 0 n60 ni24 0 -0.00103492059715
Gd30_25 0 n60 ni25 0 0.000297616010197
Gd30_26 0 n60 ni26 0 -5.85645192847e-06
Gd30_27 0 n60 ni27 0 0.000155693691567
Gd30_28 0 n60 ni28 0 -0.000468133620841
Gd30_29 0 n60 ni29 0 -0.00186706060504
Gd30_30 0 n60 ni30 0 0.000667575778727
Gd30_31 0 n60 ni31 0 -0.00165522842385
Gd30_32 0 n60 ni32 0 -0.000203601248917
Gc31_1 0 n62 ns1 0 -5.89887989911e-05
Gc31_2 0 n62 ns2 0 4.01176403473e-05
Gc31_3 0 n62 ns3 0 -0.000895811986492
Gc31_4 0 n62 ns4 0 -0.000234445301913
Gc31_5 0 n62 ns5 0 0.000174814510461
Gc31_6 0 n62 ns6 0 5.94686664144e-05
Gc31_7 0 n62 ns7 0 0.000203629470973
Gc31_8 0 n62 ns8 0 3.75902672364e-05
Gc31_9 0 n62 ns9 0 -5.86488728905e-06
Gc31_10 0 n62 ns10 0 -0.000167844393247
Gc31_11 0 n62 ns11 0 -0.000768517252888
Gc31_12 0 n62 ns12 0 0.000174815125072
Gc31_13 0 n62 ns13 0 0.000546507428978
Gc31_14 0 n62 ns14 0 0.000164118916983
Gc31_15 0 n62 ns15 0 -8.93479433958e-05
Gc31_16 0 n62 ns16 0 -0.000241264656297
Gc31_17 0 n62 ns17 0 0.000718531728033
Gc31_18 0 n62 ns18 0 0.000522169569217
Gc31_19 0 n62 ns19 0 -0.000157950102129
Gc31_20 0 n62 ns20 0 -5.3180375136e-05
Gc31_21 0 n62 ns21 0 -0.000158010243714
Gc31_22 0 n62 ns22 0 0.000454573132957
Gc31_23 0 n62 ns23 0 -0.00038061477299
Gc31_24 0 n62 ns24 0 -0.000449817474892
Gc31_25 0 n62 ns25 0 5.8412347899e-05
Gc31_26 0 n62 ns26 0 0.000274653838242
Gc31_27 0 n62 ns27 0 7.67410511691e-05
Gc31_28 0 n62 ns28 0 5.9061984282e-05
Gc31_29 0 n62 ns29 0 0.000823633890708
Gc31_30 0 n62 ns30 0 0.000384989854409
Gc31_31 0 n62 ns31 0 -1.95809460394e-05
Gc31_32 0 n62 ns32 0 -3.95163618853e-05
Gc31_33 0 n62 ns33 0 -0.000230667450454
Gc31_34 0 n62 ns34 0 0.00851742289102
Gc31_35 0 n62 ns35 0 -0.00725741748562
Gc31_36 0 n62 ns36 0 0.000190635540505
Gc31_37 0 n62 ns37 0 6.17193474951e-06
Gc31_38 0 n62 ns38 0 -2.787956885e-05
Gc31_39 0 n62 ns39 0 0.000179324163377
Gc31_40 0 n62 ns40 0 -0.000330521743962
Gc31_41 0 n62 ns41 0 -0.00012915361431
Gc31_42 0 n62 ns42 0 -0.00024105851974
Gc31_43 0 n62 ns43 0 0.000163560992805
Gc31_44 0 n62 ns44 0 3.21834771942e-05
Gc31_45 0 n62 ns45 0 0.000169381139664
Gc31_46 0 n62 ns46 0 2.82932070988e-05
Gc31_47 0 n62 ns47 0 5.125356962e-06
Gc31_48 0 n62 ns48 0 -2.78824705358e-05
Gc31_49 0 n62 ns49 0 -0.000883154845355
Gc31_50 0 n62 ns50 0 4.85023670834e-05
Gc31_51 0 n62 ns51 0 0.00061996270498
Gc31_52 0 n62 ns52 0 0.000198940439694
Gc31_53 0 n62 ns53 0 -6.25353480909e-05
Gc31_54 0 n62 ns54 0 -0.000413122095998
Gc31_55 0 n62 ns55 0 0.000618386956986
Gc31_56 0 n62 ns56 0 0.00058252426348
Gc31_57 0 n62 ns57 0 -4.36414463136e-05
Gc31_58 0 n62 ns58 0 -3.6957723618e-05
Gc31_59 0 n62 ns59 0 -0.000185434718481
Gc31_60 0 n62 ns60 0 0.000367074827981
Gc31_61 0 n62 ns61 0 -0.000568539054022
Gc31_62 0 n62 ns62 0 -0.000656962174419
Gc31_63 0 n62 ns63 0 9.7011660896e-05
Gc31_64 0 n62 ns64 0 0.000409072376163
Gc31_65 0 n62 ns65 0 0.00012607617205
Gc31_66 0 n62 ns66 0 -0.000438894349017
Gc31_67 0 n62 ns67 0 0.000776745006141
Gc31_68 0 n62 ns68 0 0.000486787984178
Gc31_69 0 n62 ns69 0 0.000136659388236
Gc31_70 0 n62 ns70 0 -1.05278754991e-06
Gc31_71 0 n62 ns71 0 -0.00029156318942
Gc31_72 0 n62 ns72 0 0.00650375816613
Gc31_73 0 n62 ns73 0 -0.00559926491198
Gc31_74 0 n62 ns74 0 0.000132287265999
Gc31_75 0 n62 ns75 0 5.72183218335e-06
Gc31_76 0 n62 ns76 0 -3.05365249333e-05
Gc31_77 0 n62 ns77 0 0.00061540822252
Gc31_78 0 n62 ns78 0 -0.00137157311959
Gc31_79 0 n62 ns79 0 0.00339031076917
Gc31_80 0 n62 ns80 0 7.80849827086e-06
Gc31_81 0 n62 ns81 0 0.000190966375506
Gc31_82 0 n62 ns82 0 0.000103462801824
Gc31_83 0 n62 ns83 0 -6.70387901472e-05
Gc31_84 0 n62 ns84 0 -2.34917591303e-05
Gc31_85 0 n62 ns85 0 -1.99286810728e-05
Gc31_86 0 n62 ns86 0 0.000376365910874
Gc31_87 0 n62 ns87 0 -0.000943062658032
Gc31_88 0 n62 ns88 0 -0.000406801073468
Gc31_89 0 n62 ns89 0 0.000355629293171
Gc31_90 0 n62 ns90 0 0.0002012619436
Gc31_91 0 n62 ns91 0 0.000112982145783
Gc31_92 0 n62 ns92 0 -0.000681921116115
Gc31_93 0 n62 ns93 0 -0.000683482213874
Gc31_94 0 n62 ns94 0 0.000160322592873
Gc31_95 0 n62 ns95 0 0.000611880537067
Gc31_96 0 n62 ns96 0 9.19861895405e-05
Gc31_97 0 n62 ns97 0 -0.000131264509328
Gc31_98 0 n62 ns98 0 -0.000291987116952
Gc31_99 0 n62 ns99 0 -0.00124037809241
Gc31_100 0 n62 ns100 0 -0.00130980069944
Gc31_101 0 n62 ns101 0 -8.88709271107e-05
Gc31_102 0 n62 ns102 0 0.00075086917534
Gc31_103 0 n62 ns103 0 0.00051574966594
Gc31_104 0 n62 ns104 0 -0.00324911202226
Gc31_105 0 n62 ns105 0 -0.000410070765443
Gc31_106 0 n62 ns106 0 0.000684868940724
Gc31_107 0 n62 ns107 0 0.00121441583933
Gc31_108 0 n62 ns108 0 0.000353973551716
Gc31_109 0 n62 ns109 0 -0.000488955400513
Gc31_110 0 n62 ns110 0 -0.00798401687451
Gc31_111 0 n62 ns111 0 0.00628973449825
Gc31_112 0 n62 ns112 0 -0.000230186504473
Gc31_113 0 n62 ns113 0 7.78675835572e-06
Gc31_114 0 n62 ns114 0 -3.71546983937e-05
Gc31_115 0 n62 ns115 0 0.000501385616077
Gc31_116 0 n62 ns116 0 -0.000803315920147
Gc31_117 0 n62 ns117 0 0.00421065129687
Gc31_118 0 n62 ns118 0 -9.88097189432e-05
Gc31_119 0 n62 ns119 0 0.000291938499419
Gc31_120 0 n62 ns120 0 0.000292967050162
Gc31_121 0 n62 ns121 0 2.39388077341e-06
Gc31_122 0 n62 ns122 0 2.78294699942e-05
Gc31_123 0 n62 ns123 0 -3.3824327356e-05
Gc31_124 0 n62 ns124 0 7.75941270148e-05
Gc31_125 0 n62 ns125 0 -0.000750996760145
Gc31_126 0 n62 ns126 0 -0.000207689704075
Gc31_127 0 n62 ns127 0 -8.36284851004e-05
Gc31_128 0 n62 ns128 0 0.000145039405315
Gc31_129 0 n62 ns129 0 0.000224558763455
Gc31_130 0 n62 ns130 0 0.000362486749707
Gc31_131 0 n62 ns131 0 -0.0012851892296
Gc31_132 0 n62 ns132 0 -0.000718391570139
Gc31_133 0 n62 ns133 0 0.000583705632794
Gc31_134 0 n62 ns134 0 0.000156147085884
Gc31_135 0 n62 ns135 0 -1.49836566444e-05
Gc31_136 0 n62 ns136 0 -0.000478445355715
Gc31_137 0 n62 ns137 0 -0.00163822272015
Gc31_138 0 n62 ns138 0 -0.00136320048569
Gc31_139 0 n62 ns139 0 -0.000942917503637
Gc31_140 0 n62 ns140 0 0.000571194590126
Gc31_141 0 n62 ns141 0 0.00119003504567
Gc31_142 0 n62 ns142 0 -0.00508435884259
Gc31_143 0 n62 ns143 0 -0.00200982694206
Gc31_144 0 n62 ns144 0 0.000541124525392
Gc31_145 0 n62 ns145 0 0.00240909325789
Gc31_146 0 n62 ns146 0 0.000834881257618
Gc31_147 0 n62 ns147 0 -0.000704634966169
Gc31_148 0 n62 ns148 0 -0.0169664345132
Gc31_149 0 n62 ns149 0 0.0137222353224
Gc31_150 0 n62 ns150 0 -0.000492588634366
Gc31_151 0 n62 ns151 0 3.8045027071e-07
Gc31_152 0 n62 ns152 0 -2.96850980167e-05
Gc31_153 0 n62 ns153 0 0.000648961803468
Gc31_154 0 n62 ns154 0 -0.00152821153272
Gc31_155 0 n62 ns155 0 0.00806406566479
Gc31_156 0 n62 ns156 0 0.000189309104539
Gc31_157 0 n62 ns157 0 9.01836147914e-06
Gc31_158 0 n62 ns158 0 4.73679934636e-05
Gc31_159 0 n62 ns159 0 0.000147176088214
Gc31_160 0 n62 ns160 0 1.47370294995e-05
Gc31_161 0 n62 ns161 0 5.00783002834e-05
Gc31_162 0 n62 ns162 0 -0.000443861292129
Gc31_163 0 n62 ns163 0 -0.00259863253466
Gc31_164 0 n62 ns164 0 0.000132294319868
Gc31_165 0 n62 ns165 0 0.000565213701805
Gc31_166 0 n62 ns166 0 0.000201008682229
Gc31_167 0 n62 ns167 0 0.000400463953261
Gc31_168 0 n62 ns168 0 0.000276389867452
Gc31_169 0 n62 ns169 0 -0.00035640736645
Gc31_170 0 n62 ns170 0 -0.000811028104133
Gc31_171 0 n62 ns171 0 -8.3840826216e-05
Gc31_172 0 n62 ns172 0 0.000194927897129
Gc31_173 0 n62 ns173 0 9.50484870767e-06
Gc31_174 0 n62 ns174 0 -0.00157232125647
Gc31_175 0 n62 ns175 0 -0.0029485921911
Gc31_176 0 n62 ns176 0 -0.00103182937047
Gc31_177 0 n62 ns177 0 -0.000940368441688
Gc31_178 0 n62 ns178 0 0.000254914658652
Gc31_179 0 n62 ns179 0 0.00152875579613
Gc31_180 0 n62 ns180 0 -0.00718899769344
Gc31_181 0 n62 ns181 0 -0.00445880255318
Gc31_182 0 n62 ns182 0 -0.000631367189753
Gc31_183 0 n62 ns183 0 0.00370670997773
Gc31_184 0 n62 ns184 0 0.00170453896908
Gc31_185 0 n62 ns185 0 -0.000612002973615
Gc31_186 0 n62 ns186 0 -0.0439258580721
Gc31_187 0 n62 ns187 0 0.0372819289118
Gc31_188 0 n62 ns188 0 -0.00155209718376
Gc31_189 0 n62 ns189 0 -7.05763383756e-06
Gc31_190 0 n62 ns190 0 -1.10898702389e-05
Gc31_191 0 n62 ns191 0 0.000214280786352
Gc31_192 0 n62 ns192 0 -0.00149750435491
Gc31_193 0 n62 ns193 0 0.0116418653878
Gc31_194 0 n62 ns194 0 0.000158196439464
Gc31_195 0 n62 ns195 0 0.00036257138536
Gc31_196 0 n62 ns196 0 0.000522555067893
Gc31_197 0 n62 ns197 0 -0.000466700886209
Gc31_198 0 n62 ns198 0 -0.000154895908739
Gc31_199 0 n62 ns199 0 -2.73663924542e-05
Gc31_200 0 n62 ns200 0 0.00129483813987
Gc31_201 0 n62 ns201 0 -0.00364468189651
Gc31_202 0 n62 ns202 0 -0.000457632780425
Gc31_203 0 n62 ns203 0 0.000854252715712
Gc31_204 0 n62 ns204 0 -4.61642593823e-05
Gc31_205 0 n62 ns205 0 0.000606923740078
Gc31_206 0 n62 ns206 0 -0.00152202170658
Gc31_207 0 n62 ns207 0 -0.00199335607699
Gc31_208 0 n62 ns208 0 -0.000711986520442
Gc31_209 0 n62 ns209 0 0.000356597937916
Gc31_210 0 n62 ns210 0 0.000418396056755
Gc31_211 0 n62 ns211 0 0.000240920287563
Gc31_212 0 n62 ns212 0 -0.00178035406487
Gc31_213 0 n62 ns213 0 -0.0056671550876
Gc31_214 0 n62 ns214 0 -0.00202592183472
Gc31_215 0 n62 ns215 0 -0.000272394757955
Gc31_216 0 n62 ns216 0 0.000345921191034
Gc31_217 0 n62 ns217 0 0.00185807575861
Gc31_218 0 n62 ns218 0 -0.0106976440322
Gc31_219 0 n62 ns219 0 -0.00615802607565
Gc31_220 0 n62 ns220 0 -0.00187520094845
Gc31_221 0 n62 ns221 0 0.0038309589971
Gc31_222 0 n62 ns222 0 0.00270004658723
Gc31_223 0 n62 ns223 0 -9.59657441433e-05
Gc31_224 0 n62 ns224 0 -0.0862458657721
Gc31_225 0 n62 ns225 0 0.0764738703585
Gc31_226 0 n62 ns226 0 -0.00417859611972
Gc31_227 0 n62 ns227 0 -9.60791588039e-06
Gc31_228 0 n62 ns228 0 1.27778774935e-05
Gc31_229 0 n62 ns229 0 -0.00262482520428
Gc31_230 0 n62 ns230 0 -0.00250150912441
Gc31_231 0 n62 ns231 0 0.00678970408118
Gc31_232 0 n62 ns232 0 0.000989032652507
Gc31_233 0 n62 ns233 0 -0.00183156006151
Gc31_234 0 n62 ns234 0 0.000721702499866
Gc31_235 0 n62 ns235 0 0.00192790460874
Gc31_236 0 n62 ns236 0 3.4347008337e-05
Gc31_237 0 n62 ns237 0 -0.000239383189299
Gc31_238 0 n62 ns238 0 0.000300508835038
Gc31_239 0 n62 ns239 0 -0.000223093751287
Gc31_240 0 n62 ns240 0 -0.000640764398084
Gc31_241 0 n62 ns241 0 -4.07776723442e-05
Gc31_242 0 n62 ns242 0 -0.000406395921588
Gc31_243 0 n62 ns243 0 0.000449066394749
Gc31_244 0 n62 ns244 0 0.00211367487421
Gc31_245 0 n62 ns245 0 -0.00290023905551
Gc31_246 0 n62 ns246 0 -0.00116105442947
Gc31_247 0 n62 ns247 0 -0.000446043875487
Gc31_248 0 n62 ns248 0 0.000246356759075
Gc31_249 0 n62 ns249 0 0.000407619593908
Gc31_250 0 n62 ns250 0 0.00200551541843
Gc31_251 0 n62 ns251 0 -0.00162818095946
Gc31_252 0 n62 ns252 0 -0.00186006633248
Gc31_253 0 n62 ns253 0 -0.00200830794789
Gc31_254 0 n62 ns254 0 -0.00079099208004
Gc31_255 0 n62 ns255 0 0.00226469826287
Gc31_256 0 n62 ns256 0 -0.0110790961992
Gc31_257 0 n62 ns257 0 -0.00518365268292
Gc31_258 0 n62 ns258 0 -0.000122694266262
Gc31_259 0 n62 ns259 0 0.00237336163424
Gc31_260 0 n62 ns260 0 0.00319631654134
Gc31_261 0 n62 ns261 0 0.00034457094598
Gc31_262 0 n62 ns262 0 -0.0366984528567
Gc31_263 0 n62 ns263 0 0.0385908236384
Gc31_264 0 n62 ns264 0 -0.00709720187032
Gc31_265 0 n62 ns265 0 -1.32852002488e-05
Gc31_266 0 n62 ns266 0 2.9250988436e-05
Gc31_267 0 n62 ns267 0 -0.00557084977372
Gc31_268 0 n62 ns268 0 -0.00412770138267
Gc31_269 0 n62 ns269 0 0.00640957050957
Gc31_270 0 n62 ns270 0 0.00236009498198
Gc31_271 0 n62 ns271 0 -0.00221246532507
Gc31_272 0 n62 ns272 0 0.000659682126109
Gc31_273 0 n62 ns273 0 0.00297526977215
Gc31_274 0 n62 ns274 0 1.09828717572e-05
Gc31_275 0 n62 ns275 0 -0.000278159861924
Gc31_276 0 n62 ns276 0 -0.00202960555016
Gc31_277 0 n62 ns277 0 -0.00117897410918
Gc31_278 0 n62 ns278 0 -3.98922165648e-05
Gc31_279 0 n62 ns279 0 0.000683744111159
Gc31_280 0 n62 ns280 0 -0.000253912173029
Gc31_281 0 n62 ns281 0 0.000284582150319
Gc31_282 0 n62 ns282 0 0.00327647696779
Gc31_283 0 n62 ns283 0 -0.000926192340043
Gc31_284 0 n62 ns284 0 -0.000519802860137
Gc31_285 0 n62 ns285 0 -0.00162590877995
Gc31_286 0 n62 ns286 0 -2.65808892492e-06
Gc31_287 0 n62 ns287 0 0.000200354300269
Gc31_288 0 n62 ns288 0 0.00245993156606
Gc31_289 0 n62 ns289 0 0.00200999266482
Gc31_290 0 n62 ns290 0 -6.28692854827e-05
Gc31_291 0 n62 ns291 0 -0.00212789371311
Gc31_292 0 n62 ns292 0 -0.00167732304338
Gc31_293 0 n62 ns293 0 0.0014390807124
Gc31_294 0 n62 ns294 0 -0.0116393054765
Gc31_295 0 n62 ns295 0 -0.00486530341871
Gc31_296 0 n62 ns296 0 0.001281812407
Gc31_297 0 n62 ns297 0 0.00285570124656
Gc31_298 0 n62 ns298 0 0.00354348146545
Gc31_299 0 n62 ns299 0 0.00052018114858
Gc31_300 0 n62 ns300 0 0.0175678830488
Gc31_301 0 n62 ns301 0 -0.00776920030788
Gc31_302 0 n62 ns302 0 -0.00776808716872
Gc31_303 0 n62 ns303 0 -1.47612207263e-05
Gc31_304 0 n62 ns304 0 2.62159645985e-05
Gc31_305 0 n62 ns305 0 0.000224987610014
Gc31_306 0 n62 ns306 0 -0.000306877172278
Gc31_307 0 n62 ns307 0 0.00738651647675
Gc31_308 0 n62 ns308 0 -9.56348300427e-05
Gc31_309 0 n62 ns309 0 -6.8894300754e-05
Gc31_310 0 n62 ns310 0 0.000250876905481
Gc31_311 0 n62 ns311 0 -0.00075550755949
Gc31_312 0 n62 ns312 0 -0.000132925929749
Gc31_313 0 n62 ns313 0 1.67254813163e-05
Gc31_314 0 n62 ns314 0 0.00188271423808
Gc31_315 0 n62 ns315 0 -0.00168474879358
Gc31_316 0 n62 ns316 0 -0.000455938004416
Gc31_317 0 n62 ns317 0 0.00075226889816
Gc31_318 0 n62 ns318 0 -0.000259424539243
Gc31_319 0 n62 ns319 0 0.000210655184946
Gc31_320 0 n62 ns320 0 -0.00223542807732
Gc31_321 0 n62 ns321 0 -0.0017496558183
Gc31_322 0 n62 ns322 0 0.000127454890697
Gc31_323 0 n62 ns323 0 0.000153428145615
Gc31_324 0 n62 ns324 0 0.000248879473411
Gc31_325 0 n62 ns325 0 0.000318450268662
Gc31_326 0 n62 ns326 0 -0.00026363594496
Gc31_327 0 n62 ns327 0 -0.00554785568864
Gc31_328 0 n62 ns328 0 -0.00204551890704
Gc31_329 0 n62 ns329 0 0.000795664114399
Gc31_330 0 n62 ns330 0 0.000211612160505
Gc31_331 0 n62 ns331 0 0.000990280083319
Gc31_332 0 n62 ns332 0 -0.00772330798668
Gc31_333 0 n62 ns333 0 -0.00315470966212
Gc31_334 0 n62 ns334 0 -0.00218631715063
Gc31_335 0 n62 ns335 0 0.000893692160437
Gc31_336 0 n62 ns336 0 0.00222668242917
Gc31_337 0 n62 ns337 0 0.000668272887766
Gc31_338 0 n62 ns338 0 -0.0773488974474
Gc31_339 0 n62 ns339 0 0.0718407841166
Gc31_340 0 n62 ns340 0 -0.0050592655596
Gc31_341 0 n62 ns341 0 -6.82201428464e-06
Gc31_342 0 n62 ns342 0 2.30458745776e-05
Gc31_343 0 n62 ns343 0 0.000517262815702
Gc31_344 0 n62 ns344 0 -0.00105025250648
Gc31_345 0 n62 ns345 0 0.00193424780288
Gc31_346 0 n62 ns346 0 -0.000114426858007
Gc31_347 0 n62 ns347 0 0.000140890488385
Gc31_348 0 n62 ns348 0 2.69718708201e-05
Gc31_349 0 n62 ns349 0 3.64151831707e-05
Gc31_350 0 n62 ns350 0 -5.16056846431e-06
Gc31_351 0 n62 ns351 0 -2.40938167359e-07
Gc31_352 0 n62 ns352 0 0.000288383814184
Gc31_353 0 n62 ns353 0 -0.000897117962469
Gc31_354 0 n62 ns354 0 -0.000254459175237
Gc31_355 0 n62 ns355 0 0.000508921404228
Gc31_356 0 n62 ns356 0 0.000200522328329
Gc31_357 0 n62 ns357 0 3.53497325169e-05
Gc31_358 0 n62 ns358 0 -0.000649647759368
Gc31_359 0 n62 ns359 0 -5.70843048417e-05
Gc31_360 0 n62 ns360 0 0.000417139186462
Gc31_361 0 n62 ns361 0 0.000326204971146
Gc31_362 0 n62 ns362 0 3.20952003574e-05
Gc31_363 0 n62 ns363 0 -0.000166770197825
Gc31_364 0 n62 ns364 0 -2.60348395533e-05
Gc31_365 0 n62 ns365 0 -0.000931392149377
Gc31_366 0 n62 ns366 0 -0.00103961481646
Gc31_367 0 n62 ns367 0 7.47901942198e-05
Gc31_368 0 n62 ns368 0 0.00063472960981
Gc31_369 0 n62 ns369 0 0.000296188396056
Gc31_370 0 n62 ns370 0 -0.00198337594429
Gc31_371 0 n62 ns371 0 0.000356767833615
Gc31_372 0 n62 ns372 0 0.000693650820038
Gc31_373 0 n62 ns373 0 0.000679132569619
Gc31_374 0 n62 ns374 0 0.000160745167391
Gc31_375 0 n62 ns375 0 -0.000431978937909
Gc31_376 0 n62 ns376 0 -0.000350446617541
Gc31_377 0 n62 ns377 0 -1.09106879933e-05
Gc31_378 0 n62 ns378 0 -4.24312587839e-05
Gc31_379 0 n62 ns379 0 7.30590650989e-06
Gc31_380 0 n62 ns380 0 -3.41779854164e-05
Gc31_381 0 n62 ns381 0 0.000597361183443
Gc31_382 0 n62 ns382 0 -0.000755000708065
Gc31_383 0 n62 ns383 0 0.00340679317557
Gc31_384 0 n62 ns384 0 -0.00017686356505
Gc31_385 0 n62 ns385 0 0.000334241179726
Gc31_386 0 n62 ns386 0 0.000255727165869
Gc31_387 0 n62 ns387 0 -3.72345530863e-05
Gc31_388 0 n62 ns388 0 4.01077283704e-06
Gc31_389 0 n62 ns389 0 -4.83323951554e-05
Gc31_390 0 n62 ns390 0 0.000492465094444
Gc31_391 0 n62 ns391 0 -0.000554714506257
Gc31_392 0 n62 ns392 0 -0.000404140551201
Gc31_393 0 n62 ns393 0 -2.26461109804e-05
Gc31_394 0 n62 ns394 0 0.000131369122693
Gc31_395 0 n62 ns395 0 0.000182316467757
Gc31_396 0 n62 ns396 0 -1.22288092202e-05
Gc31_397 0 n62 ns397 0 -0.00124079828832
Gc31_398 0 n62 ns398 0 -0.000406617509529
Gc31_399 0 n62 ns399 0 0.000674192840866
Gc31_400 0 n62 ns400 0 0.000133834043367
Gc31_401 0 n62 ns401 0 -5.00527453373e-05
Gc31_402 0 n62 ns402 0 -0.000317780864926
Gc31_403 0 n62 ns403 0 -0.00140572054322
Gc31_404 0 n62 ns404 0 -0.00136330251958
Gc31_405 0 n62 ns405 0 -0.000596383970119
Gc31_406 0 n62 ns406 0 0.000661548749814
Gc31_407 0 n62 ns407 0 0.000893794961771
Gc31_408 0 n62 ns408 0 -0.00416637849146
Gc31_409 0 n62 ns409 0 -0.00125817739214
Gc31_410 0 n62 ns410 0 0.000633983896672
Gc31_411 0 n62 ns411 0 0.0018652972616
Gc31_412 0 n62 ns412 0 0.000605820928738
Gc31_413 0 n62 ns413 0 -0.000620313565917
Gc31_414 0 n62 ns414 0 -0.0114941121754
Gc31_415 0 n62 ns415 0 0.00913715513206
Gc31_416 0 n62 ns416 0 -0.000325594181297
Gc31_417 0 n62 ns417 0 3.57317974949e-06
Gc31_418 0 n62 ns418 0 -3.46687201036e-05
Gc31_419 0 n62 ns419 0 0.000313732298856
Gc31_420 0 n62 ns420 0 -0.000648956641299
Gc31_421 0 n62 ns421 0 0.00556009490993
Gc31_422 0 n62 ns422 0 -5.34057606225e-05
Gc31_423 0 n62 ns423 0 0.000378134071942
Gc31_424 0 n62 ns424 0 0.000374410473255
Gc31_425 0 n62 ns425 0 0.000175143459803
Gc31_426 0 n62 ns426 0 2.46817937994e-05
Gc31_427 0 n62 ns427 0 -3.46946167783e-06
Gc31_428 0 n62 ns428 0 -0.000419469999898
Gc31_429 0 n62 ns429 0 -0.00208782545938
Gc31_430 0 n62 ns430 0 0.000153702862199
Gc31_431 0 n62 ns431 0 0.000359579655801
Gc31_432 0 n62 ns432 0 0.000229223715682
Gc31_433 0 n62 ns433 0 0.000299361598442
Gc31_434 0 n62 ns434 0 0.000761163880165
Gc31_435 0 n62 ns435 0 -0.000730603703753
Gc31_436 0 n62 ns436 0 -0.000918180069218
Gc31_437 0 n62 ns437 0 5.73505612635e-05
Gc31_438 0 n62 ns438 0 0.000128831920034
Gc31_439 0 n62 ns439 0 2.54634173646e-06
Gc31_440 0 n62 ns440 0 -0.00100963017706
Gc31_441 0 n62 ns441 0 -0.00245709483483
Gc31_442 0 n62 ns442 0 -0.00113867419333
Gc31_443 0 n62 ns443 0 -0.0011094916586
Gc31_444 0 n62 ns444 0 0.000340079475286
Gc31_445 0 n62 ns445 0 0.00145177240928
Gc31_446 0 n62 ns446 0 -0.00624098445879
Gc31_447 0 n62 ns447 0 -0.00388649787638
Gc31_448 0 n62 ns448 0 -0.000189643479444
Gc31_449 0 n62 ns449 0 0.00333233161838
Gc31_450 0 n62 ns450 0 0.00136289709094
Gc31_451 0 n62 ns451 0 -0.000661219087571
Gc31_452 0 n62 ns452 0 -0.0326345644562
Gc31_453 0 n62 ns453 0 0.0274097240958
Gc31_454 0 n62 ns454 0 -0.00108151127803
Gc31_455 0 n62 ns455 0 -4.68742255995e-06
Gc31_456 0 n62 ns456 0 -2.05698712052e-05
Gc31_457 0 n62 ns457 0 0.000756150678741
Gc31_458 0 n62 ns458 0 -0.00108826243875
Gc31_459 0 n62 ns459 0 0.0115141801593
Gc31_460 0 n62 ns460 0 0.000245652849645
Gc31_461 0 n62 ns461 0 0.000646603201984
Gc31_462 0 n62 ns462 0 0.000367246813228
Gc31_463 0 n62 ns463 0 -0.000249191617754
Gc31_464 0 n62 ns464 0 -0.000116126811389
Gc31_465 0 n62 ns465 0 -5.91824783488e-06
Gc31_466 0 n62 ns466 0 0.000374516363845
Gc31_467 0 n62 ns467 0 -0.00444706947084
Gc31_468 0 n62 ns468 0 -0.000113787941132
Gc31_469 0 n62 ns469 0 0.00106690502499
Gc31_470 0 n62 ns470 0 0.00014902372979
Gc31_471 0 n62 ns471 0 0.000556104659666
Gc31_472 0 n62 ns472 0 -0.00126501781358
Gc31_473 0 n62 ns473 0 -0.00119915977445
Gc31_474 0 n62 ns474 0 -0.000644388005108
Gc31_475 0 n62 ns475 0 0.000238499328708
Gc31_476 0 n62 ns476 0 0.000353607971255
Gc31_477 0 n62 ns477 0 0.000127264427291
Gc31_478 0 n62 ns478 0 -0.00250895297016
Gc31_479 0 n62 ns479 0 -0.00501738164699
Gc31_480 0 n62 ns480 0 -0.00159382345375
Gc31_481 0 n62 ns481 0 -0.000201441542889
Gc31_482 0 n62 ns482 0 0.000418544210647
Gc31_483 0 n62 ns483 0 0.00161774121231
Gc31_484 0 n62 ns484 0 -0.00990179364416
Gc31_485 0 n62 ns485 0 -0.00607798766462
Gc31_486 0 n62 ns486 0 -0.00163858453896
Gc31_487 0 n62 ns487 0 0.00420283787561
Gc31_488 0 n62 ns488 0 0.00242519422595
Gc31_489 0 n62 ns489 0 -0.000296115437936
Gc31_490 0 n62 ns490 0 -0.0773731223853
Gc31_491 0 n62 ns491 0 0.0672013380695
Gc31_492 0 n62 ns492 0 -0.00311341597005
Gc31_493 0 n62 ns493 0 -9.45653529606e-06
Gc31_494 0 n62 ns494 0 6.4386839485e-08
Gc31_495 0 n62 ns495 0 -0.000351873163557
Gc31_496 0 n62 ns496 0 -6.92329193272e-05
Gc31_497 0 n62 ns497 0 0.0064133091034
Gc31_498 0 n62 ns498 0 -0.00111734955288
Gc31_499 0 n62 ns499 0 -0.000593154503933
Gc31_500 0 n62 ns500 0 0.00183178933566
Gc31_501 0 n62 ns501 0 0.00042497957017
Gc31_502 0 n62 ns502 0 -0.000177514333899
Gc31_503 0 n62 ns503 0 -0.000202070641383
Gc31_504 0 n62 ns504 0 0.00189762538895
Gc31_505 0 n62 ns505 0 -0.00157849814812
Gc31_506 0 n62 ns506 0 -0.00061201924302
Gc31_507 0 n62 ns507 0 0.000375851820218
Gc31_508 0 n62 ns508 0 -0.000271767234652
Gc31_509 0 n62 ns509 0 0.000520962975602
Gc31_510 0 n62 ns510 0 5.35526353997e-05
Gc31_511 0 n62 ns511 0 -0.00385979463962
Gc31_512 0 n62 ns512 0 -0.00139874969562
Gc31_513 0 n62 ns513 0 0.000279837441081
Gc31_514 0 n62 ns514 0 0.000336307517466
Gc31_515 0 n62 ns515 0 0.000496060044139
Gc31_516 0 n62 ns516 0 0.000815346866592
Gc31_517 0 n62 ns517 0 -0.00496538238299
Gc31_518 0 n62 ns518 0 -0.00248807733095
Gc31_519 0 n62 ns519 0 -0.00122210104878
Gc31_520 0 n62 ns520 0 -0.000129597019906
Gc31_521 0 n62 ns521 0 0.0022573161082
Gc31_522 0 n62 ns522 0 -0.0124150563917
Gc31_523 0 n62 ns523 0 -0.00601457111972
Gc31_524 0 n62 ns524 0 -0.00117741632901
Gc31_525 0 n62 ns525 0 0.00309845592762
Gc31_526 0 n62 ns526 0 0.00315663245999
Gc31_527 0 n62 ns527 0 0.000333282268135
Gc31_528 0 n62 ns528 0 -0.0722578127448
Gc31_529 0 n62 ns529 0 0.0683309631974
Gc31_530 0 n62 ns530 0 -0.00649924323466
Gc31_531 0 n62 ns531 0 -1.17412181322e-05
Gc31_532 0 n62 ns532 0 2.60557467004e-05
Gc31_533 0 n62 ns533 0 -0.0175784498745
Gc31_534 0 n62 ns534 0 -0.000670616688188
Gc31_535 0 n62 ns535 0 0.0193269064371
Gc31_536 0 n62 ns536 0 0.00641293588721
Gc31_537 0 n62 ns537 0 0.0101744385657
Gc31_538 0 n62 ns538 0 0.00146903280807
Gc31_539 0 n62 ns539 0 -0.00325288011053
Gc31_540 0 n62 ns540 0 -0.000491405831049
Gc31_541 0 n62 ns541 0 4.83132696435e-05
Gc31_542 0 n62 ns542 0 -0.00208406679537
Gc31_543 0 n62 ns543 0 -0.0139766011284
Gc31_544 0 n62 ns544 0 0.00171247412991
Gc31_545 0 n62 ns545 0 0.00175965660608
Gc31_546 0 n62 ns546 0 6.03895641496e-05
Gc31_547 0 n62 ns547 0 0.000240188873238
Gc31_548 0 n62 ns548 0 0.00110778549578
Gc31_549 0 n62 ns549 0 0.00113678665619
Gc31_550 0 n62 ns550 0 -0.000255823173031
Gc31_551 0 n62 ns551 0 -0.000236955554921
Gc31_552 0 n62 ns552 0 0.000391916919877
Gc31_553 0 n62 ns553 0 0.000480979464064
Gc31_554 0 n62 ns554 0 -0.0118973513675
Gc31_555 0 n62 ns555 0 -0.00716823193252
Gc31_556 0 n62 ns556 0 -0.00257508203305
Gc31_557 0 n62 ns557 0 -0.00120546543013
Gc31_558 0 n62 ns558 0 -0.00049807743299
Gc31_559 0 n62 ns559 0 0.00219634851461
Gc31_560 0 n62 ns560 0 0.00996950315771
Gc31_561 0 n62 ns561 0 -0.00595845863012
Gc31_562 0 n62 ns562 0 0.00109713961718
Gc31_563 0 n62 ns563 0 0.00155836438798
Gc31_564 0 n62 ns564 0 0.00334516766444
Gc31_565 0 n62 ns565 0 0.000279160747986
Gc31_566 0 n62 ns566 0 -0.107518342529
Gc31_567 0 n62 ns567 0 0.0699490360075
Gc31_568 0 n62 ns568 0 -0.00883634390807
Gc31_569 0 n62 ns569 0 -1.46481867982e-05
Gc31_570 0 n62 ns570 0 2.9174974979e-05
Gc31_571 0 n62 ns571 0 -0.00034437681234
Gc31_572 0 n62 ns572 0 -0.000471111757251
Gc31_573 0 n62 ns573 0 0.00563655319452
Gc31_574 0 n62 ns574 0 -0.000861045107234
Gc31_575 0 n62 ns575 0 -0.000925541454509
Gc31_576 0 n62 ns576 0 0.00140662922955
Gc31_577 0 n62 ns577 0 0.00041480823762
Gc31_578 0 n62 ns578 0 -0.000190583149358
Gc31_579 0 n62 ns579 0 -0.000147468290885
Gc31_580 0 n62 ns580 0 0.00157107100733
Gc31_581 0 n62 ns581 0 -0.00187739261381
Gc31_582 0 n62 ns582 0 -0.000392911169207
Gc31_583 0 n62 ns583 0 0.00101170919372
Gc31_584 0 n62 ns584 0 -0.000253939318483
Gc31_585 0 n62 ns585 0 0.000271588248022
Gc31_586 0 n62 ns586 0 -0.000994590366165
Gc31_587 0 n62 ns587 0 -0.00233785076919
Gc31_588 0 n62 ns588 0 -0.000271150479832
Gc31_589 0 n62 ns589 0 -0.000233700088607
Gc31_590 0 n62 ns590 0 0.000192246839602
Gc31_591 0 n62 ns591 0 0.000389594290384
Gc31_592 0 n62 ns592 0 0.000673685570896
Gc31_593 0 n62 ns593 0 -0.00465793434973
Gc31_594 0 n62 ns594 0 -0.00188532850775
Gc31_595 0 n62 ns595 0 7.96101246415e-05
Gc31_596 0 n62 ns596 0 -0.000227445943936
Gc31_597 0 n62 ns597 0 0.00126980044927
Gc31_598 0 n62 ns598 0 -0.00968866650942
Gc31_599 0 n62 ns599 0 -0.00418402201235
Gc31_600 0 n62 ns600 0 -0.00169766130468
Gc31_601 0 n62 ns601 0 0.00150028784776
Gc31_602 0 n62 ns602 0 0.00281653404983
Gc31_603 0 n62 ns603 0 0.000787884570848
Gc31_604 0 n62 ns604 0 -0.0650801987087
Gc31_605 0 n62 ns605 0 0.0629523374699
Gc31_606 0 n62 ns606 0 -0.0064740816443
Gc31_607 0 n62 ns607 0 -9.21413086571e-06
Gc31_608 0 n62 ns608 0 2.95962729397e-05
Gc31_609 0 n62 ns609 0 -4.20541269196e-06
Gc31_610 0 n62 ns610 0 -0.000132530711979
Gc31_611 0 n62 ns611 0 -0.00141358133053
Gc31_612 0 n62 ns612 0 -0.000114424403108
Gc31_613 0 n62 ns613 0 -0.000107908841249
Gc31_614 0 n62 ns614 0 -2.64193003666e-05
Gc31_615 0 n62 ns615 0 -3.36058340079e-05
Gc31_616 0 n62 ns616 0 -1.57224131993e-05
Gc31_617 0 n62 ns617 0 -1.98935477138e-05
Gc31_618 0 n62 ns618 0 5.87411287701e-05
Gc31_619 0 n62 ns619 0 0.00106742198999
Gc31_620 0 n62 ns620 0 -0.00012008819652
Gc31_621 0 n62 ns621 0 -0.000496069537282
Gc31_622 0 n62 ns622 0 -0.000127333901305
Gc31_623 0 n62 ns623 0 6.00984327171e-05
Gc31_624 0 n62 ns624 0 -0.00013622605485
Gc31_625 0 n62 ns625 0 0.000860922863565
Gc31_626 0 n62 ns626 0 0.000514911722798
Gc31_627 0 n62 ns627 0 -0.000166369356968
Gc31_628 0 n62 ns628 0 -3.83129820931e-05
Gc31_629 0 n62 ns629 0 -0.000140013389428
Gc31_630 0 n62 ns630 0 0.00104198166452
Gc31_631 0 n62 ns631 0 0.000652616295996
Gc31_632 0 n62 ns632 0 0.000430846644974
Gc31_633 0 n62 ns633 0 -0.000520307725856
Gc31_634 0 n62 ns634 0 -0.000420540986476
Gc31_635 0 n62 ns635 0 0.000110793087083
Gc31_636 0 n62 ns636 0 0.000990471222648
Gc31_637 0 n62 ns637 0 0.000477921165529
Gc31_638 0 n62 ns638 0 0.000184210445919
Gc31_639 0 n62 ns639 0 -7.09735420031e-05
Gc31_640 0 n62 ns640 0 -5.28206047038e-05
Gc31_641 0 n62 ns641 0 -0.000181480713779
Gc31_642 0 n62 ns642 0 0.0117234383171
Gc31_643 0 n62 ns643 0 -0.0100105775634
Gc31_644 0 n62 ns644 0 0.000364005424711
Gc31_645 0 n62 ns645 0 -7.82327794252e-06
Gc31_646 0 n62 ns646 0 -2.71449301617e-05
Gc31_647 0 n62 ns647 0 0.0001227797165
Gc31_648 0 n62 ns648 0 -0.000232222118591
Gc31_649 0 n62 ns649 0 -0.00141987858316
Gc31_650 0 n62 ns650 0 -0.00012857801992
Gc31_651 0 n62 ns651 0 -8.63611921999e-05
Gc31_652 0 n62 ns652 0 1.3500490039e-06
Gc31_653 0 n62 ns653 0 -4.93952098585e-05
Gc31_654 0 n62 ns654 0 -1.18339244679e-05
Gc31_655 0 n62 ns655 0 -1.44765492962e-05
Gc31_656 0 n62 ns656 0 -8.25962359252e-05
Gc31_657 0 n62 ns657 0 0.00108106446395
Gc31_658 0 n62 ns658 0 -2.98476134465e-05
Gc31_659 0 n62 ns659 0 -0.000553911910257
Gc31_660 0 n62 ns660 0 -0.000160189105707
Gc31_661 0 n62 ns661 0 5.27526594481e-05
Gc31_662 0 n62 ns662 0 -0.000388396050373
Gc31_663 0 n62 ns663 0 0.000872194657419
Gc31_664 0 n62 ns664 0 0.000631722543774
Gc31_665 0 n62 ns665 0 -3.55017870621e-05
Gc31_666 0 n62 ns666 0 -1.16049387582e-05
Gc31_667 0 n62 ns667 0 -0.000174149320374
Gc31_668 0 n62 ns668 0 0.00108801371711
Gc31_669 0 n62 ns669 0 0.000944871872174
Gc31_670 0 n62 ns670 0 0.000641466663549
Gc31_671 0 n62 ns671 0 -0.000563894870295
Gc31_672 0 n62 ns672 0 -0.000555791768382
Gc31_673 0 n62 ns673 0 6.47098779395e-05
Gc31_674 0 n62 ns674 0 0.00112537926827
Gc31_675 0 n62 ns675 0 0.000634517818707
Gc31_676 0 n62 ns676 0 0.000241554149642
Gc31_677 0 n62 ns677 0 -6.80086847339e-05
Gc31_678 0 n62 ns678 0 -6.22250787426e-05
Gc31_679 0 n62 ns679 0 -0.000232017655957
Gc31_680 0 n62 ns680 0 0.0137290667006
Gc31_681 0 n62 ns681 0 -0.0117572398608
Gc31_682 0 n62 ns682 0 0.000426913548292
Gc31_683 0 n62 ns683 0 -4.86926016039e-06
Gc31_684 0 n62 ns684 0 -3.05379322319e-05
Gc31_685 0 n62 ns685 0 0.000149742700603
Gc31_686 0 n62 ns686 0 -0.000141357357407
Gc31_687 0 n62 ns687 0 -0.000874021641821
Gc31_688 0 n62 ns688 0 -0.000244479427245
Gc31_689 0 n62 ns689 0 0.000107691065079
Gc31_690 0 n62 ns690 0 3.67136205593e-05
Gc31_691 0 n62 ns691 0 0.000120989406737
Gc31_692 0 n62 ns692 0 3.03410863701e-05
Gc31_693 0 n62 ns693 0 1.60921508576e-05
Gc31_694 0 n62 ns694 0 0.000102950542935
Gc31_695 0 n62 ns695 0 0.000111441721326
Gc31_696 0 n62 ns696 0 0.000255598494307
Gc31_697 0 n62 ns697 0 -0.000121117953758
Gc31_698 0 n62 ns698 0 -0.000164276775043
Gc31_699 0 n62 ns699 0 -3.5490349728e-05
Gc31_700 0 n62 ns700 0 -0.00074001686444
Gc31_701 0 n62 ns701 0 -0.000190180137507
Gc31_702 0 n62 ns702 0 0.000348258318157
Gc31_703 0 n62 ns703 0 0.000600084597573
Gc31_704 0 n62 ns704 0 0.00012223989388
Gc31_705 0 n62 ns705 0 -0.00015883492383
Gc31_706 0 n62 ns706 0 0.000247910403883
Gc31_707 0 n62 ns707 0 0.00117652458565
Gc31_708 0 n62 ns708 0 0.00111904336351
Gc31_709 0 n62 ns709 0 -4.24954136465e-05
Gc31_710 0 n62 ns710 0 -0.000710543743901
Gc31_711 0 n62 ns711 0 -0.000368269406886
Gc31_712 0 n62 ns712 0 0.000590046378981
Gc31_713 0 n62 ns713 0 0.0006761971802
Gc31_714 0 n62 ns714 0 0.000358453129051
Gc31_715 0 n62 ns715 0 0.000281003770862
Gc31_716 0 n62 ns716 0 6.26641416395e-05
Gc31_717 0 n62 ns717 0 -0.00039649642304
Gc31_718 0 n62 ns718 0 0.0137836655291
Gc31_719 0 n62 ns719 0 -0.0120920684813
Gc31_720 0 n62 ns720 0 0.000488606312346
Gc31_721 0 n62 ns721 0 -3.61791499735e-06
Gc31_722 0 n62 ns722 0 -3.4682514561e-05
Gc31_723 0 n62 ns723 0 -0.000500094111469
Gc31_724 0 n62 ns724 0 0.00087081810239
Gc31_725 0 n62 ns725 0 -0.00181264729921
Gc31_726 0 n62 ns726 0 -0.000312159135337
Gc31_727 0 n62 ns727 0 0.00011127687111
Gc31_728 0 n62 ns728 0 -0.000137895982767
Gc31_729 0 n62 ns729 0 0.00013092927827
Gc31_730 0 n62 ns730 0 -9.34924272058e-06
Gc31_731 0 n62 ns731 0 1.3043324167e-05
Gc31_732 0 n62 ns732 0 0.000794154389611
Gc31_733 0 n62 ns733 0 0.000586414973979
Gc31_734 0 n62 ns734 0 8.33927812921e-05
Gc31_735 0 n62 ns735 0 0.000189500697664
Gc31_736 0 n62 ns736 0 -0.00014174543716
Gc31_737 0 n62 ns737 0 -0.000199908735183
Gc31_738 0 n62 ns738 0 0.000738175846695
Gc31_739 0 n62 ns739 0 -0.000592468177264
Gc31_740 0 n62 ns740 0 -0.000482357357001
Gc31_741 0 n62 ns741 0 0.000411496594133
Gc31_742 0 n62 ns742 0 0.00017248883607
Gc31_743 0 n62 ns743 0 -8.94362752456e-05
Gc31_744 0 n62 ns744 0 0.000165317423715
Gc31_745 0 n62 ns745 0 -6.64481381412e-05
Gc31_746 0 n62 ns746 0 0.000636198629153
Gc31_747 0 n62 ns747 0 0.000841620034503
Gc31_748 0 n62 ns748 0 -0.000318574619128
Gc31_749 0 n62 ns749 0 -0.000847748689041
Gc31_750 0 n62 ns750 0 -0.000388295763596
Gc31_751 0 n62 ns751 0 -0.000310082832214
Gc31_752 0 n62 ns752 0 0.000256284344364
Gc31_753 0 n62 ns753 0 0.00127701967068
Gc31_754 0 n62 ns754 0 0.000488618792936
Gc31_755 0 n62 ns755 0 -0.000654595171231
Gc31_756 0 n62 ns756 0 0.0164616108783
Gc31_757 0 n62 ns757 0 -0.0151372971984
Gc31_758 0 n62 ns758 0 0.000764599882959
Gc31_759 0 n62 ns759 0 -4.96679564535e-06
Gc31_760 0 n62 ns760 0 -2.56588340476e-05
Gc31_761 0 n62 ns761 0 -0.000919558301785
Gc31_762 0 n62 ns762 0 0.00159442964013
Gc31_763 0 n62 ns763 0 -0.00264392556707
Gc31_764 0 n62 ns764 0 -1.82847367854e-05
Gc31_765 0 n62 ns765 0 -0.000226568571581
Gc31_766 0 n62 ns766 0 5.83397768667e-05
Gc31_767 0 n62 ns767 0 -0.000322368392034
Gc31_768 0 n62 ns768 0 -3.72173053512e-05
Gc31_769 0 n62 ns769 0 -2.47072963046e-05
Gc31_770 0 n62 ns770 0 -0.00116270181426
Gc31_771 0 n62 ns771 0 0.00170860530155
Gc31_772 0 n62 ns772 0 0.000157615107663
Gc31_773 0 n62 ns773 0 -0.000280694477672
Gc31_774 0 n62 ns774 0 -4.98981694911e-05
Gc31_775 0 n62 ns775 0 -0.000407110216867
Gc31_776 0 n62 ns776 0 0.000321348982766
Gc31_777 0 n62 ns777 0 0.00136878859972
Gc31_778 0 n62 ns778 0 -0.00020999131743
Gc31_779 0 n62 ns779 0 -0.000158951913339
Gc31_780 0 n62 ns780 0 0.000305001959884
Gc31_781 0 n62 ns781 0 -0.000102221015395
Gc31_782 0 n62 ns782 0 0.00155688660889
Gc31_783 0 n62 ns783 0 0.00138278464925
Gc31_784 0 n62 ns784 0 0.000229680540607
Gc31_785 0 n62 ns785 0 0.000744804968077
Gc31_786 0 n62 ns786 0 6.55194035118e-06
Gc31_787 0 n62 ns787 0 -0.0011214629868
Gc31_788 0 n62 ns788 0 0.00155288160973
Gc31_789 0 n62 ns789 0 -0.000333820869363
Gc31_790 0 n62 ns790 0 -0.000871744536538
Gc31_791 0 n62 ns791 0 0.0015151186672
Gc31_792 0 n62 ns792 0 0.00103794187932
Gc31_793 0 n62 ns793 0 -0.0006400114174
Gc31_794 0 n62 ns794 0 0.0307948598891
Gc31_795 0 n62 ns795 0 -0.0283683539374
Gc31_796 0 n62 ns796 0 0.00155415295407
Gc31_797 0 n62 ns797 0 -5.64790496193e-06
Gc31_798 0 n62 ns798 0 -8.26581513383e-06
Gc31_799 0 n62 ns799 0 -0.00139140079434
Gc31_800 0 n62 ns800 0 2.97575423521e-06
Gc31_801 0 n62 ns801 0 0.00144665328827
Gc31_802 0 n62 ns802 0 0.000729697692849
Gc31_803 0 n62 ns803 0 -0.000527694762225
Gc31_804 0 n62 ns804 0 0.000680469735401
Gc31_805 0 n62 ns805 0 -6.02128965481e-06
Gc31_806 0 n62 ns806 0 -0.000117247587522
Gc31_807 0 n62 ns807 0 7.36778016604e-06
Gc31_808 0 n62 ns808 0 -0.00266996778545
Gc31_809 0 n62 ns809 0 -0.000718533766218
Gc31_810 0 n62 ns810 0 0.00101590832957
Gc31_811 0 n62 ns811 0 -0.000141114281633
Gc31_812 0 n62 ns812 0 0.000255914949737
Gc31_813 0 n62 ns813 0 -0.000587399774536
Gc31_814 0 n62 ns814 0 -0.00215440995679
Gc31_815 0 n62 ns815 0 -0.000806775333594
Gc31_816 0 n62 ns816 0 -0.000225208769953
Gc31_817 0 n62 ns817 0 0.000518878585116
Gc31_818 0 n62 ns818 0 0.000535985766211
Gc31_819 0 n62 ns819 0 0.000173256367242
Gc31_820 0 n62 ns820 0 -0.00236325570704
Gc31_821 0 n62 ns821 0 0.00320673537612
Gc31_822 0 n62 ns822 0 0.000799900710811
Gc31_823 0 n62 ns823 0 0.00105254639529
Gc31_824 0 n62 ns824 0 0.000441479211356
Gc31_825 0 n62 ns825 0 -0.00162368500936
Gc31_826 0 n62 ns826 0 4.83322351446e-06
Gc31_827 0 n62 ns827 0 0.00191223070084
Gc31_828 0 n62 ns828 0 -0.00169173911293
Gc31_829 0 n62 ns829 0 0.000702288888722
Gc31_830 0 n62 ns830 0 0.0017806459375
Gc31_831 0 n62 ns831 0 -0.000261662518885
Gc31_832 0 n62 ns832 0 0.0410743004521
Gc31_833 0 n62 ns833 0 -0.0415566920988
Gc31_834 0 n62 ns834 0 0.00350104831633
Gc31_835 0 n62 ns835 0 6.77272597226e-08
Gc31_836 0 n62 ns836 0 1.30101759077e-05
Gc31_837 0 n62 ns837 0 -0.00501440598917
Gc31_838 0 n62 ns838 0 -0.000764355360197
Gc31_839 0 n62 ns839 0 -0.00405457919969
Gc31_840 0 n62 ns840 0 0.000356265110448
Gc31_841 0 n62 ns841 0 -0.00139548307063
Gc31_842 0 n62 ns842 0 -0.00033036685006
Gc31_843 0 n62 ns843 0 0.000805003309158
Gc31_844 0 n62 ns844 0 -0.000128176612321
Gc31_845 0 n62 ns845 0 -1.94029413915e-05
Gc31_846 0 n62 ns846 0 -4.12317672189e-05
Gc31_847 0 n62 ns847 0 0.00198908444543
Gc31_848 0 n62 ns848 0 0.000521972935179
Gc31_849 0 n62 ns849 0 -0.000171305122945
Gc31_850 0 n62 ns850 0 0.000358877001776
Gc31_851 0 n62 ns851 0 -0.000504565350623
Gc31_852 0 n62 ns852 0 0.00128562187012
Gc31_853 0 n62 ns853 0 -0.000950522891759
Gc31_854 0 n62 ns854 0 -0.000439113265285
Gc31_855 0 n62 ns855 0 -0.000288870094715
Gc31_856 0 n62 ns856 0 0.00040013969993
Gc31_857 0 n62 ns857 0 0.000292681875847
Gc31_858 0 n62 ns858 0 -0.00169233315121
Gc31_859 0 n62 ns859 0 0.000107005734032
Gc31_860 0 n62 ns860 0 0.000874616098133
Gc31_861 0 n62 ns861 0 0.00221476534351
Gc31_862 0 n62 ns862 0 0.00129294918481
Gc31_863 0 n62 ns863 0 -0.00195162622324
Gc31_864 0 n62 ns864 0 0.000282602836012
Gc31_865 0 n62 ns865 0 0.000803137891881
Gc31_866 0 n62 ns866 0 0.000122095950917
Gc31_867 0 n62 ns867 0 5.27297692612e-05
Gc31_868 0 n62 ns868 0 0.00254999355387
Gc31_869 0 n62 ns869 0 0.000143443333456
Gc31_870 0 n62 ns870 0 0.0250158752747
Gc31_871 0 n62 ns871 0 -0.024475340238
Gc31_872 0 n62 ns872 0 0.00661977894061
Gc31_873 0 n62 ns873 0 -3.44436944024e-06
Gc31_874 0 n62 ns874 0 2.84949208947e-05
Gc31_875 0 n62 ns875 0 -0.00474384577214
Gc31_876 0 n62 ns876 0 8.04405843956e-05
Gc31_877 0 n62 ns877 0 -0.00648073436237
Gc31_878 0 n62 ns878 0 0.000109210256008
Gc31_879 0 n62 ns879 0 -0.00126874189009
Gc31_880 0 n62 ns880 0 -0.000166789273011
Gc31_881 0 n62 ns881 0 0.0001148304122
Gc31_882 0 n62 ns882 0 -0.000106885001138
Gc31_883 0 n62 ns883 0 -2.98814423538e-05
Gc31_884 0 n62 ns884 0 -0.00220958669276
Gc31_885 0 n62 ns885 0 0.00329113496499
Gc31_886 0 n62 ns886 0 0.000386609459264
Gc31_887 0 n62 ns887 0 -0.000689565021861
Gc31_888 0 n62 ns888 0 0.000389716028434
Gc31_889 0 n62 ns889 0 -0.00036265014055
Gc31_890 0 n62 ns890 0 0.000454412756878
Gc31_891 0 n62 ns891 0 0.00283636294596
Gc31_892 0 n62 ns892 0 0.000793032086204
Gc31_893 0 n62 ns893 0 -0.000691751094485
Gc31_894 0 n62 ns894 0 0.000402232880032
Gc31_895 0 n62 ns895 0 0.000180701911506
Gc31_896 0 n62 ns896 0 0.00270989654208
Gc31_897 0 n62 ns897 0 0.00162956221522
Gc31_898 0 n62 ns898 0 0.000463552880203
Gc31_899 0 n62 ns899 0 0.00196062349376
Gc31_900 0 n62 ns900 0 0.00159026206228
Gc31_901 0 n62 ns901 0 -0.00156722824238
Gc31_902 0 n62 ns902 0 0.00395887605053
Gc31_903 0 n62 ns903 0 -0.00135280053116
Gc31_904 0 n62 ns904 0 0.00127883846913
Gc31_905 0 n62 ns905 0 0.000683295121306
Gc31_906 0 n62 ns906 0 0.00294569060217
Gc31_907 0 n62 ns907 0 0.000323742301209
Gc31_908 0 n62 ns908 0 -0.00932859487418
Gc31_909 0 n62 ns909 0 0.0131499020332
Gc31_910 0 n62 ns910 0 0.00707627061388
Gc31_911 0 n62 ns911 0 -1.30079935935e-06
Gc31_912 0 n62 ns912 0 3.01958481858e-05
Gc31_913 0 n62 ns913 0 -0.00160051414073
Gc31_914 0 n62 ns914 0 -0.00163244720163
Gc31_915 0 n62 ns915 0 0.00475186333157
Gc31_916 0 n62 ns916 0 0.00104786024638
Gc31_917 0 n62 ns917 0 -0.000413266343411
Gc31_918 0 n62 ns918 0 0.00083718597604
Gc31_919 0 n62 ns919 0 0.000539914550588
Gc31_920 0 n62 ns920 0 -0.000135234524823
Gc31_921 0 n62 ns921 0 -4.79821045925e-05
Gc31_922 0 n62 ns922 0 -0.00139435474713
Gc31_923 0 n62 ns923 0 -0.002062999887
Gc31_924 0 n62 ns924 0 0.00083356518533
Gc31_925 0 n62 ns925 0 -0.000309122918515
Gc31_926 0 n62 ns926 0 0.000344250296304
Gc31_927 0 n62 ns927 0 -0.000223980996166
Gc31_928 0 n62 ns928 0 -0.00234634896755
Gc31_929 0 n62 ns929 0 -0.00235004850536
Gc31_930 0 n62 ns930 0 -4.18796396581e-05
Gc31_931 0 n62 ns931 0 0.000172475812022
Gc31_932 0 n62 ns932 0 0.00022173178693
Gc31_933 0 n62 ns933 0 0.00033088386515
Gc31_934 0 n62 ns934 0 -0.00504699527984
Gc31_935 0 n62 ns935 0 0.00182059998685
Gc31_936 0 n62 ns936 0 0.000478749607505
Gc31_937 0 n62 ns937 0 0.000411737514545
Gc31_938 0 n62 ns938 0 0.000838776182925
Gc31_939 0 n62 ns939 0 -0.000815507240736
Gc31_940 0 n62 ns940 0 -0.00255661942568
Gc31_941 0 n62 ns941 0 0.00266404976402
Gc31_942 0 n62 ns942 0 -0.00186823468817
Gc31_943 0 n62 ns943 0 -0.000773623270829
Gc31_944 0 n62 ns944 0 0.00175924393115
Gc31_945 0 n62 ns945 0 0.000532175713587
Gc31_946 0 n62 ns946 0 0.0300588566528
Gc31_947 0 n62 ns947 0 -0.0347267108815
Gc31_948 0 n62 ns948 0 0.00429230280215
Gc31_949 0 n62 ns949 0 2.56271701146e-06
Gc31_950 0 n62 ns950 0 2.87000725458e-05
Gc31_951 0 n62 ns951 0 0.000181861313497
Gc31_952 0 n62 ns952 0 -0.000421880780955
Gc31_953 0 n62 ns953 0 -0.00142990907738
Gc31_954 0 n62 ns954 0 -0.00011208682853
Gc31_955 0 n62 ns955 0 -0.000129186395425
Gc31_956 0 n62 ns956 0 -5.69902870172e-05
Gc31_957 0 n62 ns957 0 5.32706348381e-05
Gc31_958 0 n62 ns958 0 2.97915069667e-05
Gc31_959 0 n62 ns959 0 8.83708108912e-06
Gc31_960 0 n62 ns960 0 -0.000107357944521
Gc31_961 0 n62 ns961 0 0.000667216308255
Gc31_962 0 n62 ns962 0 0.000134843334805
Gc31_963 0 n62 ns963 0 -0.000381453636041
Gc31_964 0 n62 ns964 0 -0.000169867667381
Gc31_965 0 n62 ns965 0 1.48199884979e-05
Gc31_966 0 n62 ns966 0 -0.000783280490231
Gc31_967 0 n62 ns967 0 0.000450583389416
Gc31_968 0 n62 ns968 0 0.00061104298662
Gc31_969 0 n62 ns969 0 0.000348062170197
Gc31_970 0 n62 ns970 0 7.41881935339e-05
Gc31_971 0 n62 ns971 0 -0.000187130202946
Gc31_972 0 n62 ns972 0 0.000790810154587
Gc31_973 0 n62 ns973 0 0.00139937249477
Gc31_974 0 n62 ns974 0 0.00102595270939
Gc31_975 0 n62 ns975 0 -0.000398740183963
Gc31_976 0 n62 ns976 0 -0.000728447619039
Gc31_977 0 n62 ns977 0 -0.000149224826344
Gc31_978 0 n62 ns978 0 0.00120932038312
Gc31_979 0 n62 ns979 0 0.00111862708615
Gc31_980 0 n62 ns980 0 0.000417818440335
Gc31_981 0 n62 ns981 0 -5.62859611087e-05
Gc31_982 0 n62 ns982 0 -7.28154115166e-05
Gc31_983 0 n62 ns983 0 -0.000358727988417
Gc31_984 0 n62 ns984 0 0.0176697477213
Gc31_985 0 n62 ns985 0 -0.0152275402555
Gc31_986 0 n62 ns986 0 0.000555207277483
Gc31_987 0 n62 ns987 0 -3.72027707632e-06
Gc31_988 0 n62 ns988 0 -3.35876016022e-05
Gc31_989 0 n62 ns989 0 -0.000170523039308
Gc31_990 0 n62 ns990 0 4.39583528067e-05
Gc31_991 0 n62 ns991 0 -0.000710474249811
Gc31_992 0 n62 ns992 0 -0.000156329391338
Gc31_993 0 n62 ns993 0 7.80084527311e-05
Gc31_994 0 n62 ns994 0 -7.92814521602e-05
Gc31_995 0 n62 ns995 0 0.00011503852326
Gc31_996 0 n62 ns996 0 2.27895121574e-06
Gc31_997 0 n62 ns997 0 3.47538280836e-05
Gc31_998 0 n62 ns998 0 0.000377943077135
Gc31_999 0 n62 ns999 0 9.80166693064e-05
Gc31_1000 0 n62 ns1000 0 0.000245292553654
Gc31_1001 0 n62 ns1001 0 0.000142224923477
Gc31_1002 0 n62 ns1002 0 -0.000135937565829
Gc31_1003 0 n62 ns1003 0 -0.000135773664118
Gc31_1004 0 n62 ns1004 0 -7.28055125059e-05
Gc31_1005 0 n62 ns1005 0 -0.000731145065038
Gc31_1006 0 n62 ns1006 0 -0.000177525796762
Gc31_1007 0 n62 ns1007 0 0.000660080865584
Gc31_1008 0 n62 ns1008 0 0.000171647267477
Gc31_1009 0 n62 ns1009 0 -9.92384071395e-05
Gc31_1010 0 n62 ns1010 0 -0.000160662453108
Gc31_1011 0 n62 ns1011 0 0.00047101981046
Gc31_1012 0 n62 ns1012 0 0.00089562520562
Gc31_1013 0 n62 ns1013 0 0.000543721287506
Gc31_1014 0 n62 ns1014 0 -0.000489283640725
Gc31_1015 0 n62 ns1015 0 -0.000664755913101
Gc31_1016 0 n62 ns1016 0 -0.000440886185757
Gc31_1017 0 n62 ns1017 0 0.000315488382809
Gc31_1018 0 n62 ns1018 0 0.00048101809111
Gc31_1019 0 n62 ns1019 0 0.000899009775162
Gc31_1020 0 n62 ns1020 0 0.000295711651457
Gc31_1021 0 n62 ns1021 0 -0.000595061534231
Gc31_1022 0 n62 ns1022 0 0.0146711955433
Gc31_1023 0 n62 ns1023 0 -0.0134184434059
Gc31_1024 0 n62 ns1024 0 0.000639602482576
Gc31_1025 0 n62 ns1025 0 -4.01222492247e-06
Gc31_1026 0 n62 ns1026 0 -3.28540797424e-05
Gc31_1027 0 n62 ns1027 0 -0.000772873660501
Gc31_1028 0 n62 ns1028 0 0.00171794408687
Gc31_1029 0 n62 ns1029 0 -0.00350148565173
Gc31_1030 0 n62 ns1030 0 -0.000251334658345
Gc31_1031 0 n62 ns1031 0 -0.000145058148176
Gc31_1032 0 n62 ns1032 0 -0.000189498886468
Gc31_1033 0 n62 ns1033 0 -0.000147791284142
Gc31_1034 0 n62 ns1034 0 -2.34117650323e-05
Gc31_1035 0 n62 ns1035 0 -1.22188330525e-05
Gc31_1036 0 n62 ns1036 0 -6.01993368898e-05
Gc31_1037 0 n62 ns1037 0 0.00185210583165
Gc31_1038 0 n62 ns1038 0 -1.87237698901e-06
Gc31_1039 0 n62 ns1039 0 -0.000140040464113
Gc31_1040 0 n62 ns1040 0 -0.000125261572674
Gc31_1041 0 n62 ns1041 0 -0.000312568988938
Gc31_1042 0 n62 ns1042 0 0.000999244759069
Gc31_1043 0 n62 ns1043 0 0.000891255095519
Gc31_1044 0 n62 ns1044 0 -0.000331271364895
Gc31_1045 0 n62 ns1045 0 -9.52212291392e-05
Gc31_1046 0 n62 ns1046 0 0.000221920714459
Gc31_1047 0 n62 ns1047 0 -0.0001278177809
Gc31_1048 0 n62 ns1048 0 0.00156907917216
Gc31_1049 0 n62 ns1049 0 0.000520025350804
Gc31_1050 0 n62 ns1050 0 0.000301593946274
Gc31_1051 0 n62 ns1051 0 0.000754747567328
Gc31_1052 0 n62 ns1052 0 -0.000133498134572
Gc31_1053 0 n62 ns1053 0 -0.000978845027318
Gc31_1054 0 n62 ns1054 0 0.00120757577195
Gc31_1055 0 n62 ns1055 0 -0.0005222081922
Gc31_1056 0 n62 ns1056 0 -0.000427069489761
Gc31_1057 0 n62 ns1057 0 0.00143772618042
Gc31_1058 0 n62 ns1058 0 0.00077982115791
Gc31_1059 0 n62 ns1059 0 -0.000665696107722
Gc31_1060 0 n62 ns1060 0 0.0272517661272
Gc31_1061 0 n62 ns1061 0 -0.0246893800208
Gc31_1062 0 n62 ns1062 0 0.00122597129646
Gc31_1063 0 n62 ns1063 0 -7.0077534649e-06
Gc31_1064 0 n62 ns1064 0 -1.88492109986e-05
Gc31_1065 0 n62 ns1065 0 -0.00111406601127
Gc31_1066 0 n62 ns1066 0 0.000386478760179
Gc31_1067 0 n62 ns1067 0 0.000108669829942
Gc31_1068 0 n62 ns1068 0 0.00058272885081
Gc31_1069 0 n62 ns1069 0 -0.000520075626109
Gc31_1070 0 n62 ns1070 0 0.000469787788789
Gc31_1071 0 n62 ns1071 0 -0.000209585265245
Gc31_1072 0 n62 ns1072 0 -4.46480582115e-05
Gc31_1073 0 n62 ns1073 0 -1.2060829143e-06
Gc31_1074 0 n62 ns1074 0 -0.00257793652507
Gc31_1075 0 n62 ns1075 0 -4.67974343366e-06
Gc31_1076 0 n62 ns1076 0 0.000662351763719
Gc31_1077 0 n62 ns1077 0 -0.000244103733688
Gc31_1078 0 n62 ns1078 0 0.000118239199903
Gc31_1079 0 n62 ns1079 0 -0.00050636605945
Gc31_1080 0 n62 ns1080 0 -0.00194840332274
Gc31_1081 0 n62 ns1081 0 0.00045242527229
Gc31_1082 0 n62 ns1082 0 -4.60301650252e-05
Gc31_1083 0 n62 ns1083 0 0.000395648126035
Gc31_1084 0 n62 ns1084 0 0.000487361917625
Gc31_1085 0 n62 ns1085 0 5.30188101789e-05
Gc31_1086 0 n62 ns1086 0 -0.000532809948288
Gc31_1087 0 n62 ns1087 0 0.00363544538415
Gc31_1088 0 n62 ns1088 0 0.000681653150223
Gc31_1089 0 n62 ns1089 0 0.000790318088683
Gc31_1090 0 n62 ns1090 0 0.000187423769757
Gc31_1091 0 n62 ns1091 0 -0.00143544994782
Gc31_1092 0 n62 ns1092 0 0.00175009827748
Gc31_1093 0 n62 ns1093 0 0.00170985582673
Gc31_1094 0 n62 ns1094 0 -0.00156206822119
Gc31_1095 0 n62 ns1095 0 0.00090177853003
Gc31_1096 0 n62 ns1096 0 0.00145059615897
Gc31_1097 0 n62 ns1097 0 -0.000436328290362
Gc31_1098 0 n62 ns1098 0 0.0418792113218
Gc31_1099 0 n62 ns1099 0 -0.0400944636617
Gc31_1100 0 n62 ns1100 0 0.00262749410158
Gc31_1101 0 n62 ns1101 0 -2.08215245788e-06
Gc31_1102 0 n62 ns1102 0 8.431097866e-07
Gc31_1103 0 n62 ns1103 0 -0.00197938530545
Gc31_1104 0 n62 ns1104 0 -0.00181240113124
Gc31_1105 0 n62 ns1105 0 0.00520490916698
Gc31_1106 0 n62 ns1106 0 0.000370814088431
Gc31_1107 0 n62 ns1107 0 -0.000387820446252
Gc31_1108 0 n62 ns1108 0 0.000505348720522
Gc31_1109 0 n62 ns1109 0 0.000423012925066
Gc31_1110 0 n62 ns1110 0 -0.00017164140463
Gc31_1111 0 n62 ns1111 0 -4.18106518128e-05
Gc31_1112 0 n62 ns1112 0 -0.00105295425247
Gc31_1113 0 n62 ns1113 0 -0.000681651833231
Gc31_1114 0 n62 ns1114 0 0.000977394539771
Gc31_1115 0 n62 ns1115 0 0.000362736217359
Gc31_1116 0 n62 ns1116 0 0.0004572811261
Gc31_1117 0 n62 ns1117 0 -0.000546157267336
Gc31_1118 0 n62 ns1118 0 0.000570764336674
Gc31_1119 0 n62 ns1119 0 -0.00267438130819
Gc31_1120 0 n62 ns1120 0 -0.000943718714768
Gc31_1121 0 n62 ns1121 0 8.75118796015e-05
Gc31_1122 0 n62 ns1122 0 0.000394825353294
Gc31_1123 0 n62 ns1123 0 0.000364473389589
Gc31_1124 0 n62 ns1124 0 -0.00464753909428
Gc31_1125 0 n62 ns1125 0 -0.00174102871778
Gc31_1126 0 n62 ns1126 0 0.000351874345966
Gc31_1127 0 n62 ns1127 0 0.00197413594176
Gc31_1128 0 n62 ns1128 0 0.00123246451717
Gc31_1129 0 n62 ns1129 0 -0.0016994258646
Gc31_1130 0 n62 ns1130 0 -0.00661254052288
Gc31_1131 0 n62 ns1131 0 -0.00158539354952
Gc31_1132 0 n62 ns1132 0 -0.00123347120693
Gc31_1133 0 n62 ns1133 0 0.00112449305282
Gc31_1134 0 n62 ns1134 0 0.00257594486762
Gc31_1135 0 n62 ns1135 0 0.000260842539064
Gc31_1136 0 n62 ns1136 0 0.0144771696153
Gc31_1137 0 n62 ns1137 0 -0.0233340120844
Gc31_1138 0 n62 ns1138 0 0.00536325729401
Gc31_1139 0 n62 ns1139 0 2.40922563941e-06
Gc31_1140 0 n62 ns1140 0 2.69927394838e-05
Gc31_1141 0 n62 ns1141 0 -0.00306548684965
Gc31_1142 0 n62 ns1142 0 0.000902835258475
Gc31_1143 0 n62 ns1143 0 -0.00346544817948
Gc31_1144 0 n62 ns1144 0 0.000172982919715
Gc31_1145 0 n62 ns1145 0 -0.000401401525692
Gc31_1146 0 n62 ns1146 0 0.00028133207849
Gc31_1147 0 n62 ns1147 0 -0.000307630705334
Gc31_1148 0 n62 ns1148 0 -0.000239109554896
Gc31_1149 0 n62 ns1149 0 -8.54155584145e-05
Gc31_1150 0 n62 ns1150 0 -0.00363755530113
Gc31_1151 0 n62 ns1151 0 0.0024047412785
Gc31_1152 0 n62 ns1152 0 0.00100456051744
Gc31_1153 0 n62 ns1153 0 -0.000211737495216
Gc31_1154 0 n62 ns1154 0 0.000549858171003
Gc31_1155 0 n62 ns1155 0 -0.000536852088846
Gc31_1156 0 n62 ns1156 0 0.000826931370343
Gc31_1157 0 n62 ns1157 0 0.00204406981138
Gc31_1158 0 n62 ns1158 0 0.000386921289658
Gc31_1159 0 n62 ns1159 0 -0.000345679453034
Gc31_1160 0 n62 ns1160 0 0.000491704242775
Gc31_1161 0 n62 ns1161 0 0.000275904219369
Gc31_1162 0 n62 ns1162 0 0.00142996843384
Gc31_1163 0 n62 ns1163 0 0.000190563378708
Gc31_1164 0 n62 ns1164 0 0.000523286913701
Gc31_1165 0 n62 ns1165 0 0.00266921759342
Gc31_1166 0 n62 ns1166 0 0.00175721838937
Gc31_1167 0 n62 ns1167 0 -0.00190172408994
Gc31_1168 0 n62 ns1168 0 0.000124610625629
Gc31_1169 0 n62 ns1169 0 -0.00319060870027
Gc31_1170 0 n62 ns1170 0 0.00158261847919
Gc31_1171 0 n62 ns1171 0 0.00166545244644
Gc31_1172 0 n62 ns1172 0 0.00329031995852
Gc31_1173 0 n62 ns1173 0 0.000248703726685
Gc31_1174 0 n62 ns1174 0 -0.0228652218476
Gc31_1175 0 n62 ns1175 0 0.0227418037264
Gc31_1176 0 n62 ns1176 0 0.00698858752758
Gc31_1177 0 n62 ns1177 0 1.01868777951e-05
Gc31_1178 0 n62 ns1178 0 3.78474631001e-05
Gc31_1179 0 n62 ns1179 0 -0.0017641507266
Gc31_1180 0 n62 ns1180 0 -0.0023790947931
Gc31_1181 0 n62 ns1181 0 0.00558677288244
Gc31_1182 0 n62 ns1182 0 0.000696551366124
Gc31_1183 0 n62 ns1183 0 -0.000469832603642
Gc31_1184 0 n62 ns1184 0 0.000727985999666
Gc31_1185 0 n62 ns1185 0 0.000343451696025
Gc31_1186 0 n62 ns1186 0 -0.000147225692603
Gc31_1187 0 n62 ns1187 0 -8.38362706081e-05
Gc31_1188 0 n62 ns1188 0 -0.00188282410921
Gc31_1189 0 n62 ns1189 0 -0.00100776154826
Gc31_1190 0 n62 ns1190 0 0.000885601107239
Gc31_1191 0 n62 ns1191 0 -0.000174290915504
Gc31_1192 0 n62 ns1192 0 0.000487728630579
Gc31_1193 0 n62 ns1193 0 -0.000284555788119
Gc31_1194 0 n62 ns1194 0 -0.00083525506439
Gc31_1195 0 n62 ns1195 0 -0.00159382000337
Gc31_1196 0 n62 ns1196 0 -1.99346058725e-06
Gc31_1197 0 n62 ns1197 0 -0.000251017385419
Gc31_1198 0 n62 ns1198 0 0.000246241815935
Gc31_1199 0 n62 ns1199 0 0.000341500597489
Gc31_1200 0 n62 ns1200 0 -0.0041851843466
Gc31_1201 0 n62 ns1201 0 -0.000446109202767
Gc31_1202 0 n62 ns1202 0 0.00026414956826
Gc31_1203 0 n62 ns1203 0 0.000768189869701
Gc31_1204 0 n62 ns1204 0 0.00117592251512
Gc31_1205 0 n62 ns1205 0 -0.00096487333029
Gc31_1206 0 n62 ns1206 0 -0.00501122274583
Gc31_1207 0 n62 ns1207 0 -0.000664956202262
Gc31_1208 0 n62 ns1208 0 -0.0017745743452
Gc31_1209 0 n62 ns1209 0 -9.81859742172e-05
Gc31_1210 0 n62 ns1210 0 0.00234272925985
Gc31_1211 0 n62 ns1211 0 0.000738170561283
Gc31_1212 0 n62 ns1212 0 0.0139863420442
Gc31_1213 0 n62 ns1213 0 -0.0226232390107
Gc31_1214 0 n62 ns1214 0 0.00537123124103
Gc31_1215 0 n62 ns1215 0 2.37574184786e-06
Gc31_1216 0 n62 ns1216 0 3.29894062654e-05
Gd31_1 0 n62 ni1 0 -5.79882435901e-05
Gd31_2 0 n62 ni2 0 -7.57424219395e-06
Gd31_3 0 n62 ni3 0 3.29819342387e-05
Gd31_4 0 n62 ni4 0 0.000197882835492
Gd31_5 0 n62 ni5 0 0.000184178878764
Gd31_6 0 n62 ni6 0 -7.92644178088e-05
Gd31_7 0 n62 ni7 0 -0.00157308294304
Gd31_8 0 n62 ni8 0 -0.00305388803814
Gd31_9 0 n62 ni9 0 1.16548481875e-05
Gd31_10 0 n62 ni10 0 4.27947102535e-05
Gd31_11 0 n62 ni11 0 0.000251797025562
Gd31_12 0 n62 ni12 0 0.000190136577173
Gd31_13 0 n62 ni13 0 0.000496669197634
Gd31_14 0 n62 ni14 0 -0.000383619482412
Gd31_15 0 n62 ni15 0 -0.00692729055448
Gd31_16 0 n62 ni16 0 -0.000502773786942
Gd31_17 0 n62 ni17 0 -8.53605175287e-05
Gd31_18 0 n62 ni18 0 -4.2104306066e-05
Gd31_19 0 n62 ni19 0 5.39357559331e-05
Gd31_20 0 n62 ni20 0 6.24150273322e-05
Gd31_21 0 n62 ni21 0 0.000163603439725
Gd31_22 0 n62 ni22 0 -0.000713176780127
Gd31_23 0 n62 ni23 0 -0.002685647361
Gd31_24 0 n62 ni24 0 -0.000733215047415
Gd31_25 0 n62 ni25 0 -0.00125377022809
Gd31_26 0 n62 ni26 0 -0.000100457740543
Gd31_27 0 n62 ni27 0 -5.32850581834e-05
Gd31_28 0 n62 ni28 0 0.00020005727817
Gd31_29 0 n62 ni29 0 -0.000323328243548
Gd31_30 0 n62 ni30 0 -0.0016552285597
Gd31_31 0 n62 ni31 0 0.000946112277705
Gd31_32 0 n62 ni32 0 -0.00171851826526
Gc32_1 0 n64 ns1 0 6.44856500565e-05
Gc32_2 0 n64 ns2 0 -0.00042347190611
Gc32_3 0 n64 ns3 0 -0.000512171382339
Gc32_4 0 n64 ns4 0 -3.49133499109e-05
Gc32_5 0 n64 ns5 0 -0.000102307131704
Gc32_6 0 n64 ns6 0 -5.13895348571e-05
Gc32_7 0 n64 ns7 0 3.86543871974e-05
Gc32_8 0 n64 ns8 0 2.46979311133e-05
Gc32_9 0 n64 ns9 0 -1.02277929802e-05
Gc32_10 0 n64 ns10 0 -0.000434142860356
Gc32_11 0 n64 ns11 0 0.000698008411512
Gc32_12 0 n64 ns12 0 0.000278435623897
Gc32_13 0 n64 ns13 0 -0.000205288370757
Gc32_14 0 n64 ns14 0 -7.33695046829e-05
Gc32_15 0 n64 ns15 0 -0.00012074596205
Gc32_16 0 n64 ns16 0 0.000283895608548
Gc32_17 0 n64 ns17 0 0.000614981746215
Gc32_18 0 n64 ns18 0 0.000186738799727
Gc32_19 0 n64 ns19 0 -0.000318904359037
Gc32_20 0 n64 ns20 0 -7.7864068658e-05
Gc32_21 0 n64 ns21 0 -5.20886867065e-05
Gc32_22 0 n64 ns22 0 0.000173651562278
Gc32_23 0 n64 ns23 0 4.00641580033e-05
Gc32_24 0 n64 ns24 0 -2.25419383585e-05
Gc32_25 0 n64 ns25 0 0.000147433126153
Gc32_26 0 n64 ns26 0 7.12529397048e-05
Gc32_27 0 n64 ns27 0 -9.6459114186e-05
Gc32_28 0 n64 ns28 0 0.000551232609691
Gc32_29 0 n64 ns29 0 0.00100574779496
Gc32_30 0 n64 ns30 0 0.00027661142921
Gc32_31 0 n64 ns31 0 -0.000229896927012
Gc32_32 0 n64 ns32 0 -9.8586166278e-05
Gc32_33 0 n64 ns33 0 -0.000144730039941
Gc32_34 0 n64 ns34 0 0.00904530782535
Gc32_35 0 n64 ns35 0 -0.00764117208752
Gc32_36 0 n64 ns36 0 0.000198664982023
Gc32_37 0 n64 ns37 0 6.74978359744e-06
Gc32_38 0 n64 ns38 0 -2.65078353884e-05
Gc32_39 0 n64 ns39 0 8.43630618103e-05
Gc32_40 0 n64 ns40 0 -0.000396629597489
Gc32_41 0 n64 ns41 0 -0.000738121506703
Gc32_42 0 n64 ns42 0 -0.000125758204377
Gc32_43 0 n64 ns43 0 -2.66622513193e-05
Gc32_44 0 n64 ns44 0 -8.59185929916e-06
Gc32_45 0 n64 ns45 0 0.000106922656267
Gc32_46 0 n64 ns46 0 3.4113854949e-05
Gc32_47 0 n64 ns47 0 -1.63204743266e-05
Gc32_48 0 n64 ns48 0 -0.000425148772754
Gc32_49 0 n64 ns49 0 0.000445825165891
Gc32_50 0 n64 ns50 0 0.000323190281805
Gc32_51 0 n64 ns51 0 -5.51128334321e-05
Gc32_52 0 n64 ns52 0 -3.45249898087e-05
Gc32_53 0 n64 ns53 0 -0.000140746059246
Gc32_54 0 n64 ns54 0 0.000250628157568
Gc32_55 0 n64 ns55 0 0.000724306857965
Gc32_56 0 n64 ns56 0 0.000276792649981
Gc32_57 0 n64 ns57 0 -0.000349240035786
Gc32_58 0 n64 ns58 0 -9.00138145726e-05
Gc32_59 0 n64 ns59 0 -8.14471991428e-05
Gc32_60 0 n64 ns60 0 0.000252637247647
Gc32_61 0 n64 ns61 0 -6.51749446037e-05
Gc32_62 0 n64 ns62 0 -0.000109072664878
Gc32_63 0 n64 ns63 0 0.000172819606464
Gc32_64 0 n64 ns64 0 0.000126472788707
Gc32_65 0 n64 ns65 0 -9.07125924651e-05
Gc32_66 0 n64 ns66 0 0.000605444459993
Gc32_67 0 n64 ns67 0 0.00105798742924
Gc32_68 0 n64 ns68 0 0.000303786444494
Gc32_69 0 n64 ns69 0 -0.000240020674417
Gc32_70 0 n64 ns70 0 -0.000107928075307
Gc32_71 0 n64 ns71 0 -0.000167474529243
Gc32_72 0 n64 ns72 0 0.00965715211322
Gc32_73 0 n64 ns73 0 -0.00810892558617
Gc32_74 0 n64 ns74 0 0.000202943709466
Gc32_75 0 n64 ns75 0 5.00680333272e-06
Gc32_76 0 n64 ns76 0 -2.82276581459e-05
Gc32_77 0 n64 ns77 0 0.000187003985084
Gc32_78 0 n64 ns78 0 -0.000331973863721
Gc32_79 0 n64 ns79 0 -0.000153621620037
Gc32_80 0 n64 ns80 0 -0.000248380476539
Gc32_81 0 n64 ns81 0 0.000165968264436
Gc32_82 0 n64 ns82 0 3.1460373346e-05
Gc32_83 0 n64 ns83 0 0.000173709158599
Gc32_84 0 n64 ns84 0 2.9309357503e-05
Gc32_85 0 n64 ns85 0 4.97220759109e-06
Gc32_86 0 n64 ns86 0 -1.26700964147e-05
Gc32_87 0 n64 ns87 0 -0.000885702529572
Gc32_88 0 n64 ns88 0 4.42904617714e-05
Gc32_89 0 n64 ns89 0 0.00062314488417
Gc32_90 0 n64 ns90 0 0.000199370943866
Gc32_91 0 n64 ns91 0 -6.14394507051e-05
Gc32_92 0 n64 ns92 0 -0.000409132041309
Gc32_93 0 n64 ns93 0 0.000621360890338
Gc32_94 0 n64 ns94 0 0.000583872597094
Gc32_95 0 n64 ns95 0 -4.58550004467e-05
Gc32_96 0 n64 ns96 0 -3.74490195224e-05
Gc32_97 0 n64 ns97 0 -0.000186179074544
Gc32_98 0 n64 ns98 0 0.000375389772155
Gc32_99 0 n64 ns99 0 -0.000569893121417
Gc32_100 0 n64 ns100 0 -0.000656910794589
Gc32_101 0 n64 ns101 0 9.52274084445e-05
Gc32_102 0 n64 ns102 0 0.000408288941821
Gc32_103 0 n64 ns103 0 0.000126495260616
Gc32_104 0 n64 ns104 0 -0.000425388462206
Gc32_105 0 n64 ns105 0 0.000774969726874
Gc32_106 0 n64 ns106 0 0.000484164867
Gc32_107 0 n64 ns107 0 0.000133807925952
Gc32_108 0 n64 ns108 0 -1.95603559473e-06
Gc32_109 0 n64 ns109 0 -0.000290522693194
Gc32_110 0 n64 ns110 0 0.00656358992283
Gc32_111 0 n64 ns111 0 -0.00564802857647
Gc32_112 0 n64 ns112 0 0.000134005374031
Gc32_113 0 n64 ns113 0 5.68563233982e-06
Gc32_114 0 n64 ns114 0 -3.07446432185e-05
Gc32_115 0 n64 ns115 0 0.000256830198524
Gc32_116 0 n64 ns116 0 -0.00103863701178
Gc32_117 0 n64 ns117 0 0.00325825205283
Gc32_118 0 n64 ns118 0 6.47682527795e-05
Gc32_119 0 n64 ns119 0 0.000173842293728
Gc32_120 0 n64 ns120 0 3.62049053616e-05
Gc32_121 0 n64 ns121 0 -1.53329200282e-05
Gc32_122 0 n64 ns122 0 -2.02295893939e-05
Gc32_123 0 n64 ns123 0 -9.82419977275e-06
Gc32_124 0 n64 ns124 0 0.000864715177606
Gc32_125 0 n64 ns125 0 -0.00152012955406
Gc32_126 0 n64 ns126 0 -0.000703866769532
Gc32_127 0 n64 ns127 0 0.000602021617197
Gc32_128 0 n64 ns128 0 0.000289811284665
Gc32_129 0 n64 ns129 0 0.000223616544782
Gc32_130 0 n64 ns130 0 -0.000956557449217
Gc32_131 0 n64 ns131 0 -0.000942327762777
Gc32_132 0 n64 ns132 0 0.000160967039541
Gc32_133 0 n64 ns133 0 0.000826882850827
Gc32_134 0 n64 ns134 0 0.000149742844218
Gc32_135 0 n64 ns135 0 -0.000135208305348
Gc32_136 0 n64 ns136 0 -0.000116658627569
Gc32_137 0 n64 ns137 0 -0.0012739253775
Gc32_138 0 n64 ns138 0 -0.00137846350694
Gc32_139 0 n64 ns139 0 -0.000315357131529
Gc32_140 0 n64 ns140 0 0.00071105631469
Gc32_141 0 n64 ns141 0 0.000666679249707
Gc32_142 0 n64 ns142 0 -0.00348555578009
Gc32_143 0 n64 ns143 0 -0.000880418570777
Gc32_144 0 n64 ns144 0 0.000584911133513
Gc32_145 0 n64 ns145 0 0.00135090779188
Gc32_146 0 n64 ns146 0 0.000412396913749
Gc32_147 0 n64 ns147 0 -0.000451367858581
Gc32_148 0 n64 ns148 0 -0.0109263753362
Gc32_149 0 n64 ns149 0 0.00883440710952
Gc32_150 0 n64 ns150 0 -0.000323126405664
Gc32_151 0 n64 ns151 0 6.4043147568e-06
Gc32_152 0 n64 ns152 0 -2.33805795379e-05
Gc32_153 0 n64 ns153 0 0.000234731816135
Gc32_154 0 n64 ns154 0 -0.000938746976417
Gc32_155 0 n64 ns155 0 0.00555681642363
Gc32_156 0 n64 ns156 0 0.000235874168578
Gc32_157 0 n64 ns157 0 0.000136237095369
Gc32_158 0 n64 ns158 0 0.000215317005996
Gc32_159 0 n64 ns159 0 -0.000137505176882
Gc32_160 0 n64 ns160 0 -2.14517207086e-06
Gc32_161 0 n64 ns161 0 -3.94041888133e-05
Gc32_162 0 n64 ns162 0 0.000383147679675
Gc32_163 0 n64 ns163 0 -0.0005668122149
Gc32_164 0 n64 ns164 0 -0.000492251909297
Gc32_165 0 n64 ns165 0 -0.000376424180805
Gc32_166 0 n64 ns166 0 7.29843776527e-05
Gc32_167 0 n64 ns167 0 0.000356236289869
Gc32_168 0 n64 ns168 0 0.000318707397019
Gc32_169 0 n64 ns169 0 -0.00208919986847
Gc32_170 0 n64 ns170 0 -0.00111905573281
Gc32_171 0 n64 ns171 0 0.0008908646148
Gc32_172 0 n64 ns172 0 0.000236406746389
Gc32_173 0 n64 ns173 0 9.76035630943e-05
Gc32_174 0 n64 ns174 0 -0.000810204711857
Gc32_175 0 n64 ns175 0 -0.0016133849875
Gc32_176 0 n64 ns176 0 -0.00129668886519
Gc32_177 0 n64 ns177 0 -0.00113522965018
Gc32_178 0 n64 ns178 0 0.00046970525816
Gc32_179 0 n64 ns179 0 0.00131594845145
Gc32_180 0 n64 ns180 0 -0.00602902463025
Gc32_181 0 n64 ns181 0 -0.00295367066477
Gc32_182 0 n64 ns182 0 0.000365070392532
Gc32_183 0 n64 ns183 0 0.00281350479196
Gc32_184 0 n64 ns184 0 0.00100287395112
Gc32_185 0 n64 ns185 0 -0.000642275254525
Gc32_186 0 n64 ns186 0 -0.0261554798874
Gc32_187 0 n64 ns187 0 0.0214981330418
Gc32_188 0 n64 ns188 0 -0.000758713747519
Gc32_189 0 n64 ns189 0 4.8504345691e-08
Gc32_190 0 n64 ns190 0 -6.95478125844e-06
Gc32_191 0 n64 ns191 0 0.000396194999136
Gc32_192 0 n64 ns192 0 -0.000907786682148
Gc32_193 0 n64 ns193 0 0.0074896380704
Gc32_194 0 n64 ns194 0 0.000282646948327
Gc32_195 0 n64 ns195 0 -0.000144753361096
Gc32_196 0 n64 ns196 0 9.08473163447e-05
Gc32_197 0 n64 ns197 0 6.54766039841e-05
Gc32_198 0 n64 ns198 0 1.95506193388e-05
Gc32_199 0 n64 ns199 0 2.77109808779e-05
Gc32_200 0 n64 ns200 0 -0.00115304188098
Gc32_201 0 n64 ns201 0 -0.00125120122236
Gc32_202 0 n64 ns202 0 0.000600159171968
Gc32_203 0 n64 ns203 0 -0.000199724635885
Gc32_204 0 n64 ns204 0 -6.83545311965e-05
Gc32_205 0 n64 ns205 0 0.000295849504552
Gc32_206 0 n64 ns206 0 0.00111818338733
Gc32_207 0 n64 ns207 0 -0.000430463778238
Gc32_208 0 n64 ns208 0 -0.00136729856527
Gc32_209 0 n64 ns209 0 -0.000400830275021
Gc32_210 0 n64 ns210 0 0.000158062421356
Gc32_211 0 n64 ns211 0 0.000189951651397
Gc32_212 0 n64 ns212 0 -0.00178775968413
Gc32_213 0 n64 ns213 0 -0.0022696406002
Gc32_214 0 n64 ns214 0 -0.000268307626739
Gc32_215 0 n64 ns215 0 -0.00108480886985
Gc32_216 0 n64 ns216 0 -0.000212716434331
Gc32_217 0 n64 ns217 0 0.00140121729092
Gc32_218 0 n64 ns218 0 -0.00643691742551
Gc32_219 0 n64 ns219 0 -0.00475755966758
Gc32_220 0 n64 ns220 0 -0.0010171146069
Gc32_221 0 n64 ns221 0 0.00362375745719
Gc32_222 0 n64 ns222 0 0.00175894032888
Gc32_223 0 n64 ns223 0 -0.000473374796203
Gc32_224 0 n64 ns224 0 -0.0439543541027
Gc32_225 0 n64 ns225 0 0.0374659874423
Gc32_226 0 n64 ns226 0 -0.00158783187991
Gc32_227 0 n64 ns227 0 -8.5119762892e-06
Gc32_228 0 n64 ns228 0 1.04850526584e-05
Gc32_229 0 n64 ns229 0 -6.0013500394e-05
Gc32_230 0 n64 ns230 0 -0.000826487430528
Gc32_231 0 n64 ns231 0 0.00945070026152
Gc32_232 0 n64 ns232 0 0.000112683123802
Gc32_233 0 n64 ns233 0 0.000168033471355
Gc32_234 0 n64 ns234 0 0.000396960843487
Gc32_235 0 n64 ns235 0 -0.000373797102235
Gc32_236 0 n64 ns236 0 -0.000140398734207
Gc32_237 0 n64 ns237 0 2.61422577241e-05
Gc32_238 0 n64 ns238 0 0.000105404625189
Gc32_239 0 n64 ns239 0 -0.00318475014932
Gc32_240 0 n64 ns240 0 0.00039600145015
Gc32_241 0 n64 ns241 0 0.00098166412504
Gc32_242 0 n64 ns242 0 -0.000154660172375
Gc32_243 0 n64 ns243 0 0.000291887644211
Gc32_244 0 n64 ns244 0 -0.00105692711259
Gc32_245 0 n64 ns245 0 -0.000287354047243
Gc32_246 0 n64 ns246 0 -0.000313978490905
Gc32_247 0 n64 ns247 0 -0.000682810834495
Gc32_248 0 n64 ns248 0 0.000208859118276
Gc32_249 0 n64 ns249 0 0.00024508731005
Gc32_250 0 n64 ns250 0 -0.00176264076799
Gc32_251 0 n64 ns251 0 -0.00494565018114
Gc32_252 0 n64 ns252 0 -0.0008953542289
Gc32_253 0 n64 ns253 0 0.000301642939754
Gc32_254 0 n64 ns254 0 -0.000182130444814
Gc32_255 0 n64 ns255 0 0.00117086883538
Gc32_256 0 n64 ns256 0 -0.00775374688019
Gc32_257 0 n64 ns257 0 -0.00535348667664
Gc32_258 0 n64 ns258 0 -0.00258913448344
Gc32_259 0 n64 ns259 0 0.0028024844783
Gc32_260 0 n64 ns260 0 0.0025259026744
Gc32_261 0 n64 ns261 0 0.000258791071758
Gc32_262 0 n64 ns262 0 -0.0779126412545
Gc32_263 0 n64 ns263 0 0.0700466854512
Gc32_264 0 n64 ns264 0 -0.0040795634876
Gc32_265 0 n64 ns265 0 -1.02536242632e-05
Gc32_266 0 n64 ns266 0 2.32140748394e-05
Gc32_267 0 n64 ns267 0 -0.00252990581467
Gc32_268 0 n64 ns268 0 -0.00229797949825
Gc32_269 0 n64 ns269 0 0.00509802700421
Gc32_270 0 n64 ns270 0 0.00114905517124
Gc32_271 0 n64 ns271 0 -0.00191477292344
Gc32_272 0 n64 ns272 0 0.00043118284702
Gc32_273 0 n64 ns273 0 0.00175783090414
Gc32_274 0 n64 ns274 0 -1.21808423352e-05
Gc32_275 0 n64 ns275 0 -0.000229868097143
Gc32_276 0 n64 ns276 0 0.000730929236207
Gc32_277 0 n64 ns277 0 -0.000489434122403
Gc32_278 0 n64 ns278 0 -0.000896645399407
Gc32_279 0 n64 ns279 0 0.000606334704405
Gc32_280 0 n64 ns280 0 -0.000330680960327
Gc32_281 0 n64 ns281 0 0.000223785607766
Gc32_282 0 n64 ns282 0 0.000458642229343
Gc32_283 0 n64 ns283 0 -0.00218337664829
Gc32_284 0 n64 ns284 0 0.000124372790658
Gc32_285 0 n64 ns285 0 -0.000396841558108
Gc32_286 0 n64 ns286 0 0.000148516524848
Gc32_287 0 n64 ns287 0 0.000290638150959
Gc32_288 0 n64 ns288 0 0.00223803244013
Gc32_289 0 n64 ns289 0 -0.00143213587614
Gc32_290 0 n64 ns290 0 -0.00176809241185
Gc32_291 0 n64 ns291 0 -0.000604151664896
Gc32_292 0 n64 ns292 0 -0.00062234792137
Gc32_293 0 n64 ns293 0 0.00125458503342
Gc32_294 0 n64 ns294 0 -0.00864890409202
Gc32_295 0 n64 ns295 0 -0.00273125838158
Gc32_296 0 n64 ns296 0 -0.000227920366627
Gc32_297 0 n64 ns297 0 0.000421860569915
Gc32_298 0 n64 ns298 0 0.00268752968996
Gc32_299 0 n64 ns299 0 0.000793246443957
Gc32_300 0 n64 ns300 0 -0.0266320987123
Gc32_301 0 n64 ns301 0 0.0308073186947
Gc32_302 0 n64 ns302 0 -0.00704877848809
Gc32_303 0 n64 ns303 0 -8.3843671072e-06
Gc32_304 0 n64 ns304 0 2.67720653075e-05
Gc32_305 0 n64 ns305 0 -0.0053359560001
Gc32_306 0 n64 ns306 0 -0.00344041312258
Gc32_307 0 n64 ns307 0 -0.00252791354294
Gc32_308 0 n64 ns308 0 0.00206919069808
Gc32_309 0 n64 ns309 0 -0.00350053951197
Gc32_310 0 n64 ns310 0 0.000328915513463
Gc32_311 0 n64 ns311 0 0.00329524931826
Gc32_312 0 n64 ns312 0 0.000137972728959
Gc32_313 0 n64 ns313 0 -0.000305843952294
Gc32_314 0 n64 ns314 0 -0.00115781231486
Gc32_315 0 n64 ns315 0 0.00292098488032
Gc32_316 0 n64 ns316 0 -0.000971244909464
Gc32_317 0 n64 ns317 0 -0.000281592306156
Gc32_318 0 n64 ns318 0 -0.000278030670026
Gc32_319 0 n64 ns319 0 6.11576757081e-05
Gc32_320 0 n64 ns320 0 0.00347081529396
Gc32_321 0 n64 ns321 0 -0.00168321784541
Gc32_322 0 n64 ns322 0 -8.46297576569e-06
Gc32_323 0 n64 ns323 0 -0.000806450760225
Gc32_324 0 n64 ns324 0 -9.45838896267e-05
Gc32_325 0 n64 ns325 0 9.07888944079e-05
Gc32_326 0 n64 ns326 0 0.00535095844485
Gc32_327 0 n64 ns327 0 0.00562704155996
Gc32_328 0 n64 ns328 0 -3.69728837616e-05
Gc32_329 0 n64 ns329 0 -0.00240200786753
Gc32_330 0 n64 ns330 0 -0.00165384800432
Gc32_331 0 n64 ns331 0 0.000796060982171
Gc32_332 0 n64 ns332 0 -0.00704167307323
Gc32_333 0 n64 ns333 0 0.000727962160795
Gc32_334 0 n64 ns334 0 0.00354664933336
Gc32_335 0 n64 ns335 0 -0.000171128618639
Gc32_336 0 n64 ns336 0 0.00212600715343
Gc32_337 0 n64 ns337 0 0.000407670824878
Gc32_338 0 n64 ns338 0 0.08503868335
Gc32_339 0 n64 ns339 0 -0.0659545436324
Gc32_340 0 n64 ns340 0 -0.00595872039261
Gc32_341 0 n64 ns341 0 -6.29923809911e-06
Gc32_342 0 n64 ns342 0 2.36587155423e-05
Gc32_343 0 n64 ns343 0 0.000151091630682
Gc32_344 0 n64 ns344 0 -0.000235568777316
Gc32_345 0 n64 ns345 0 -0.000619213094227
Gc32_346 0 n64 ns346 0 -0.00024254133318
Gc32_347 0 n64 ns347 0 0.000161202400712
Gc32_348 0 n64 ns348 0 8.36600024164e-05
Gc32_349 0 n64 ns349 0 0.000155832849269
Gc32_350 0 n64 ns350 0 2.98430435807e-05
Gc32_351 0 n64 ns351 0 -1.11211738579e-05
Gc32_352 0 n64 ns352 0 -0.000358826572165
Gc32_353 0 n64 ns353 0 -0.00037552567292
Gc32_354 0 n64 ns354 0 0.000284027253923
Gc32_355 0 n64 ns355 0 0.000356325152718
Gc32_356 0 n64 ns356 0 9.97615124481e-05
Gc32_357 0 n64 ns357 0 -0.000129913069543
Gc32_358 0 n64 ns358 0 -9.30427253912e-05
Gc32_359 0 n64 ns359 0 0.000770798498327
Gc32_360 0 n64 ns360 0 0.000478294893867
Gc32_361 0 n64 ns361 0 -0.000236248612758
Gc32_362 0 n64 ns362 0 -7.29086083656e-05
Gc32_363 0 n64 ns363 0 -0.000144488720108
Gc32_364 0 n64 ns364 0 0.000349406789571
Gc32_365 0 n64 ns365 0 -0.00034469714945
Gc32_366 0 n64 ns366 0 -0.000398435600297
Gc32_367 0 n64 ns367 0 0.000147774387192
Gc32_368 0 n64 ns368 0 0.000277733203321
Gc32_369 0 n64 ns369 0 1.16455936157e-05
Gc32_370 0 n64 ns370 0 0.000135713766254
Gc32_371 0 n64 ns371 0 0.000939421537668
Gc32_372 0 n64 ns372 0 0.000396808974144
Gc32_373 0 n64 ns373 0 -6.25539173088e-05
Gc32_374 0 n64 ns374 0 -5.82310791233e-05
Gc32_375 0 n64 ns375 0 -0.000233178929425
Gc32_376 0 n64 ns376 0 0.00856447890044
Gc32_377 0 n64 ns377 0 -0.00726118796446
Gc32_378 0 n64 ns378 0 0.000182978745541
Gc32_379 0 n64 ns379 0 4.90496629782e-06
Gc32_380 0 n64 ns380 0 -2.94957918382e-05
Gc32_381 0 n64 ns381 0 0.000210479083343
Gc32_382 0 n64 ns382 0 -0.000619366100688
Gc32_383 0 n64 ns383 0 0.00147141445919
Gc32_384 0 n64 ns384 0 -0.000108144650502
Gc32_385 0 n64 ns385 0 0.000202653930434
Gc32_386 0 n64 ns386 0 3.70035381429e-05
Gc32_387 0 n64 ns387 0 9.9421728171e-05
Gc32_388 0 n64 ns388 0 -3.73049874747e-06
Gc32_389 0 n64 ns389 0 -2.01471439086e-06
Gc32_390 0 n64 ns390 0 0.000572555090847
Gc32_391 0 n64 ns391 0 -0.00146794173341
Gc32_392 0 n64 ns392 0 -0.000410184917247
Gc32_393 0 n64 ns393 0 0.000756655299893
Gc32_394 0 n64 ns394 0 0.000284769358156
Gc32_395 0 n64 ns395 0 9.83069714049e-05
Gc32_396 0 n64 ns396 0 -0.000854064064329
Gc32_397 0 n64 ns397 0 -0.000181862709631
Gc32_398 0 n64 ns398 0 0.000452768083157
Gc32_399 0 n64 ns399 0 0.000458789887916
Gc32_400 0 n64 ns400 0 6.80492806214e-05
Gc32_401 0 n64 ns401 0 -0.00017946567508
Gc32_402 0 n64 ns402 0 0.000168261144586
Gc32_403 0 n64 ns403 0 -0.000965455438766
Gc32_404 0 n64 ns404 0 -0.00109393333409
Gc32_405 0 n64 ns405 0 -0.000104105668797
Gc32_406 0 n64 ns406 0 0.000602155474312
Gc32_407 0 n64 ns407 0 0.000410715056559
Gc32_408 0 n64 ns408 0 -0.00205752678329
Gc32_409 0 n64 ns409 0 4.98333251745e-05
Gc32_410 0 n64 ns410 0 0.00062890230416
Gc32_411 0 n64 ns411 0 0.000750815271753
Gc32_412 0 n64 ns412 0 0.000190534340523
Gc32_413 0 n64 ns413 0 -0.000408310045861
Gc32_414 0 n64 ns414 0 -0.0015547386838
Gc32_415 0 n64 ns415 0 0.00105291306258
Gc32_416 0 n64 ns416 0 -8.23371831344e-05
Gc32_417 0 n64 ns417 0 6.14973842352e-06
Gc32_418 0 n64 ns418 0 -2.82024282323e-05
Gc32_419 0 n64 ns419 0 0.000268589801478
Gc32_420 0 n64 ns420 0 -0.000714891994381
Gc32_421 0 n64 ns421 0 0.00415381395788
Gc32_422 0 n64 ns422 0 6.56716968395e-05
Gc32_423 0 n64 ns423 0 0.000215492034153
Gc32_424 0 n64 ns424 0 0.000165539906663
Gc32_425 0 n64 ns425 0 -0.000111113651601
Gc32_426 0 n64 ns426 0 -1.90774683705e-05
Gc32_427 0 n64 ns427 0 -3.98470272801e-05
Gc32_428 0 n64 ns428 0 0.000905910692051
Gc32_429 0 n64 ns429 0 -0.000825352808433
Gc32_430 0 n64 ns430 0 -0.000758259246377
Gc32_431 0 n64 ns431 0 -1.39104755308e-05
Gc32_432 0 n64 ns432 0 0.000160842304756
Gc32_433 0 n64 ns433 0 0.000324419160231
Gc32_434 0 n64 ns434 0 -0.000306502040645
Gc32_435 0 n64 ns435 0 -0.0018007818125
Gc32_436 0 n64 ns436 0 -0.000575029548872
Gc32_437 0 n64 ns437 0 0.00100665624056
Gc32_438 0 n64 ns438 0 0.000222530598994
Gc32_439 0 n64 ns439 0 -1.00954040886e-08
Gc32_440 0 n64 ns440 0 -0.00033647690489
Gc32_441 0 n64 ns441 0 -0.00135302620014
Gc32_442 0 n64 ns442 0 -0.00137146299299
Gc32_443 0 n64 ns443 0 -0.000880710641945
Gc32_444 0 n64 ns444 0 0.000572622401392
Gc32_445 0 n64 ns445 0 0.00107416318302
Gc32_446 0 n64 ns446 0 -0.00486836408029
Gc32_447 0 n64 ns447 0 -0.00202066137511
Gc32_448 0 n64 ns448 0 0.000525891905602
Gc32_449 0 n64 ns449 0 0.00218535256602
Gc32_450 0 n64 ns450 0 0.000726336198636
Gc32_451 0 n64 ns451 0 -0.000586798747213
Gc32_452 0 n64 ns452 0 -0.0180079112061
Gc32_453 0 n64 ns453 0 0.0146681039899
Gc32_454 0 n64 ns454 0 -0.000518806059244
Gc32_455 0 n64 ns455 0 2.69461292476e-06
Gc32_456 0 n64 ns456 0 -1.65579872041e-05
Gc32_457 0 n64 ns457 0 8.66372968454e-05
Gc32_458 0 n64 ns458 0 -0.000488246121332
Gc32_459 0 n64 ns459 0 0.00622191900567
Gc32_460 0 n64 ns460 0 0.000226926113961
Gc32_461 0 n64 ns461 0 0.000173148421784
Gc32_462 0 n64 ns462 0 0.000353920587507
Gc32_463 0 n64 ns463 0 4.91767870819e-06
Gc32_464 0 n64 ns464 0 5.63514335599e-06
Gc32_465 0 n64 ns465 0 -2.39731929372e-05
Gc32_466 0 n64 ns466 0 -0.000716868889704
Gc32_467 0 n64 ns467 0 -0.00101658440051
Gc32_468 0 n64 ns468 0 0.000259102443126
Gc32_469 0 n64 ns469 0 -0.000354798955686
Gc32_470 0 n64 ns470 0 1.12947980851e-05
Gc32_471 0 n64 ns471 0 0.000310488350255
Gc32_472 0 n64 ns472 0 0.00122395177185
Gc32_473 0 n64 ns473 0 -0.00129580116673
Gc32_474 0 n64 ns474 0 -0.00149507297743
Gc32_475 0 n64 ns475 0 8.59392705146e-05
Gc32_476 0 n64 ns476 0 0.000159168771301
Gc32_477 0 n64 ns477 0 0.000176330891904
Gc32_478 0 n64 ns478 0 -0.00136974834022
Gc32_479 0 n64 ns479 0 -0.00202985122228
Gc32_480 0 n64 ns480 0 -0.000681955049675
Gc32_481 0 n64 ns481 0 -0.00129735446132
Gc32_482 0 n64 ns482 0 3.24597723072e-05
Gc32_483 0 n64 ns483 0 0.00145408528588
Gc32_484 0 n64 ns484 0 -0.00645505530109
Gc32_485 0 n64 ns485 0 -0.00453368677642
Gc32_486 0 n64 ns486 0 -0.000462026753959
Gc32_487 0 n64 ns487 0 0.00353559865925
Gc32_488 0 n64 ns488 0 0.00148916151807
Gc32_489 0 n64 ns489 0 -0.000565899385097
Gc32_490 0 n64 ns490 0 -0.0377650884199
Gc32_491 0 n64 ns491 0 0.0317819218591
Gc32_492 0 n64 ns492 0 -0.00123802883822
Gc32_493 0 n64 ns493 0 -5.75434551903e-06
Gc32_494 0 n64 ns494 0 2.32574968483e-06
Gc32_495 0 n64 ns495 0 0.000455937954498
Gc32_496 0 n64 ns496 0 -0.00025098655099
Gc32_497 0 n64 ns497 0 0.00965770576479
Gc32_498 0 n64 ns498 0 0.000181324973241
Gc32_499 0 n64 ns499 0 0.000514579889742
Gc32_500 0 n64 ns500 0 0.000368826218796
Gc32_501 0 n64 ns501 0 -0.000213832808555
Gc32_502 0 n64 ns502 0 -9.15484774598e-05
Gc32_503 0 n64 ns503 0 2.0434040451e-05
Gc32_504 0 n64 ns504 0 -0.000871226098046
Gc32_505 0 n64 ns505 0 -0.00347368645343
Gc32_506 0 n64 ns506 0 0.000753710261108
Gc32_507 0 n64 ns507 0 0.00074122879561
Gc32_508 0 n64 ns508 0 -4.57023471953e-05
Gc32_509 0 n64 ns509 0 0.000297927468307
Gc32_510 0 n64 ns510 0 -0.00038010646535
Gc32_511 0 n64 ns511 0 -9.93553462138e-05
Gc32_512 0 n64 ns512 0 -0.000726635764333
Gc32_513 0 n64 ns513 0 -0.000630485202449
Gc32_514 0 n64 ns514 0 0.000195287489437
Gc32_515 0 n64 ns515 0 0.000215725918837
Gc32_516 0 n64 ns516 0 -0.00254251821468
Gc32_517 0 n64 ns517 0 -0.00421441299087
Gc32_518 0 n64 ns518 0 -0.000502354709222
Gc32_519 0 n64 ns519 0 -6.67802652669e-06
Gc32_520 0 n64 ns520 0 -0.000160768561172
Gc32_521 0 n64 ns521 0 0.00117824204406
Gc32_522 0 n64 ns522 0 -0.00766311486673
Gc32_523 0 n64 ns523 0 -0.00576974392512
Gc32_524 0 n64 ns524 0 -0.00226362623332
Gc32_525 0 n64 ns525 0 0.00357260643645
Gc32_526 0 n64 ns526 0 0.00235221314781
Gc32_527 0 n64 ns527 0 -3.14567256715e-05
Gc32_528 0 n64 ns528 0 -0.0713735836048
Gc32_529 0 n64 ns529 0 0.0625541260206
Gc32_530 0 n64 ns530 0 -0.0030316332881
Gc32_531 0 n64 ns531 0 -1.09922792272e-05
Gc32_532 0 n64 ns532 0 1.74227709081e-05
Gc32_533 0 n64 ns533 0 -0.000356311992374
Gc32_534 0 n64 ns534 0 -0.000458256526786
Gc32_535 0 n64 ns535 0 0.00564154717049
Gc32_536 0 n64 ns536 0 -0.000858356700488
Gc32_537 0 n64 ns537 0 -0.00091661505712
Gc32_538 0 n64 ns538 0 0.00141414051402
Gc32_539 0 n64 ns539 0 0.000414680755004
Gc32_540 0 n64 ns540 0 -0.000191670666863
Gc32_541 0 n64 ns541 0 -0.000148905202125
Gc32_542 0 n64 ns542 0 0.0015662256151
Gc32_543 0 n64 ns543 0 -0.0018989491211
Gc32_544 0 n64 ns544 0 -0.000389746934551
Gc32_545 0 n64 ns545 0 0.00101693501792
Gc32_546 0 n64 ns546 0 -0.000252394686517
Gc32_547 0 n64 ns547 0 0.000271492576452
Gc32_548 0 n64 ns548 0 -0.000997071206558
Gc32_549 0 n64 ns549 0 -0.00234546618352
Gc32_550 0 n64 ns550 0 -0.000273555701657
Gc32_551 0 n64 ns551 0 -0.000232398055856
Gc32_552 0 n64 ns552 0 0.000192144909112
Gc32_553 0 n64 ns553 0 0.000390499828801
Gc32_554 0 n64 ns554 0 0.000663950723968
Gc32_555 0 n64 ns555 0 -0.00466692048634
Gc32_556 0 n64 ns556 0 -0.00188821075493
Gc32_557 0 n64 ns557 0 8.28493137959e-05
Gc32_558 0 n64 ns558 0 -0.000225292679523
Gc32_559 0 n64 ns559 0 0.00126983524433
Gc32_560 0 n64 ns560 0 -0.00970501466022
Gc32_561 0 n64 ns561 0 -0.00419187653038
Gc32_562 0 n64 ns562 0 -0.00169740202109
Gc32_563 0 n64 ns563 0 0.0015051410044
Gc32_564 0 n64 ns564 0 0.00281817250274
Gc32_565 0 n64 ns565 0 0.000787772927862
Gc32_566 0 n64 ns566 0 -0.0651863405165
Gc32_567 0 n64 ns567 0 0.0630414246844
Gc32_568 0 n64 ns568 0 -0.00647697032826
Gc32_569 0 n64 ns569 0 -9.24216677865e-06
Gc32_570 0 n64 ns570 0 2.98256755671e-05
Gc32_571 0 n64 ns571 0 -0.0170579623574
Gc32_572 0 n64 ns572 0 0.00105433453332
Gc32_573 0 n64 ns573 0 0.0122104769372
Gc32_574 0 n64 ns574 0 0.00589584346354
Gc32_575 0 n64 ns575 0 0.00976504022711
Gc32_576 0 n64 ns576 0 0.00129512828012
Gc32_577 0 n64 ns577 0 -0.00331504560458
Gc32_578 0 n64 ns578 0 -0.000455430795771
Gc32_579 0 n64 ns579 0 3.27089030459e-06
Gc32_580 0 n64 ns580 0 -0.000675435993654
Gc32_581 0 n64 ns581 0 -0.0117784582286
Gc32_582 0 n64 ns582 0 0.000921255596338
Gc32_583 0 n64 ns583 0 0.00150536529407
Gc32_584 0 n64 ns584 0 6.02264646022e-05
Gc32_585 0 n64 ns585 0 8.60691749483e-06
Gc32_586 0 n64 ns586 0 0.000188466336458
Gc32_587 0 n64 ns587 0 0.000469965092085
Gc32_588 0 n64 ns588 0 0.000545534768096
Gc32_589 0 n64 ns589 0 0.00053957975549
Gc32_590 0 n64 ns590 0 0.000326369333747
Gc32_591 0 n64 ns591 0 0.000412467530149
Gc32_592 0 n64 ns592 0 -0.00971201862195
Gc32_593 0 n64 ns593 0 -0.00569563218777
Gc32_594 0 n64 ns594 0 -0.00303746563109
Gc32_595 0 n64 ns595 0 -0.000792257172176
Gc32_596 0 n64 ns596 0 -0.000230692544462
Gc32_597 0 n64 ns597 0 0.00152084880204
Gc32_598 0 n64 ns598 0 0.0131896280421
Gc32_599 0 n64 ns599 0 -0.00134834005557
Gc32_600 0 n64 ns600 0 0.00246119387927
Gc32_601 0 n64 ns601 0 -0.00133370921631
Gc32_602 0 n64 ns602 0 0.00225929160726
Gc32_603 0 n64 ns603 0 0.000461248683052
Gc32_604 0 n64 ns604 0 -0.0699640845063
Gc32_605 0 n64 ns605 0 0.0387979279192
Gc32_606 0 n64 ns606 0 -0.00815720616562
Gc32_607 0 n64 ns607 0 -8.17428535221e-06
Gc32_608 0 n64 ns608 0 2.78389749384e-05
Gc32_609 0 n64 ns609 0 -0.000159929340372
Gc32_610 0 n64 ns610 0 0.000762044302022
Gc32_611 0 n64 ns611 0 -0.00337857772092
Gc32_612 0 n64 ns612 0 -0.000306903223925
Gc32_613 0 n64 ns613 0 -0.000114005652306
Gc32_614 0 n64 ns614 0 -0.000216286349915
Gc32_615 0 n64 ns615 0 9.43463451949e-05
Gc32_616 0 n64 ns616 0 1.26310678223e-05
Gc32_617 0 n64 ns617 0 4.23335436596e-05
Gc32_618 0 n64 ns618 0 0.0011460851489
Gc32_619 0 n64 ns619 0 0.000768572219679
Gc32_620 0 n64 ns620 0 -0.000519651635949
Gc32_621 0 n64 ns621 0 -0.00012151152494
Gc32_622 0 n64 ns622 0 -3.38174879468e-05
Gc32_623 0 n64 ns623 0 0.000119608902758
Gc32_624 0 n64 ns624 0 0.000428023003634
Gc32_625 0 n64 ns625 0 0.000578607039174
Gc32_626 0 n64 ns626 0 0.000175490013276
Gc32_627 0 n64 ns627 0 -0.000317898026195
Gc32_628 0 n64 ns628 0 -6.25457923637e-05
Gc32_629 0 n64 ns629 0 -5.18256410892e-05
Gc32_630 0 n64 ns630 0 0.00109767491586
Gc32_631 0 n64 ns631 0 0.000353414860575
Gc32_632 0 n64 ns632 0 0.000181978231938
Gc32_633 0 n64 ns633 0 -0.000498313998357
Gc32_634 0 n64 ns634 0 -0.000257411073003
Gc32_635 0 n64 ns635 0 0.000174832149413
Gc32_636 0 n64 ns636 0 0.00152239581507
Gc32_637 0 n64 ns637 0 0.000832853190336
Gc32_638 0 n64 ns638 0 0.000165466169191
Gc32_639 0 n64 ns639 0 -0.000399360282227
Gc32_640 0 n64 ns640 0 -0.00015342771206
Gc32_641 0 n64 ns641 0 -0.000116796807463
Gc32_642 0 n64 ns642 0 0.0154919867494
Gc32_643 0 n64 ns643 0 -0.0130971930636
Gc32_644 0 n64 ns644 0 0.000458191398905
Gc32_645 0 n64 ns645 0 -8.19701310496e-06
Gc32_646 0 n64 ns646 0 -2.24996553458e-05
Gc32_647 0 n64 ns647 0 -9.81983940374e-05
Gc32_648 0 n64 ns648 0 0.000670664824983
Gc32_649 0 n64 ns649 0 -0.00349476509081
Gc32_650 0 n64 ns650 0 -0.0003468763533
Gc32_651 0 n64 ns651 0 -0.000132384442222
Gc32_652 0 n64 ns652 0 -0.000232357506405
Gc32_653 0 n64 ns653 0 5.63286886277e-05
Gc32_654 0 n64 ns654 0 6.45767446413e-06
Gc32_655 0 n64 ns655 0 4.63096079889e-05
Gc32_656 0 n64 ns656 0 0.00120370276162
Gc32_657 0 n64 ns657 0 0.0010748754647
Gc32_658 0 n64 ns658 0 -0.000577850962521
Gc32_659 0 n64 ns659 0 -0.000259226762988
Gc32_660 0 n64 ns660 0 -6.89343531286e-05
Gc32_661 0 n64 ns661 0 0.000141166906053
Gc32_662 0 n64 ns662 0 0.000437142731784
Gc32_663 0 n64 ns663 0 0.000788481907945
Gc32_664 0 n64 ns664 0 0.000292324368389
Gc32_665 0 n64 ns665 0 -0.00038098134721
Gc32_666 0 n64 ns666 0 -7.8109569073e-05
Gc32_667 0 n64 ns667 0 -8.68618925329e-05
Gc32_668 0 n64 ns668 0 0.00134118696361
Gc32_669 0 n64 ns669 0 0.000391305103814
Gc32_670 0 n64 ns670 0 0.000227926985367
Gc32_671 0 n64 ns671 0 -0.000616192144989
Gc32_672 0 n64 ns672 0 -0.000330574795022
Gc32_673 0 n64 ns673 0 0.000217838368066
Gc32_674 0 n64 ns674 0 0.00162597676534
Gc32_675 0 n64 ns675 0 0.000748631106091
Gc32_676 0 n64 ns676 0 0.00017240737605
Gc32_677 0 n64 ns677 0 -0.000367446605396
Gc32_678 0 n64 ns678 0 -0.000154738826188
Gc32_679 0 n64 ns679 0 -0.000139572455252
Gc32_680 0 n64 ns680 0 0.0162102730222
Gc32_681 0 n64 ns681 0 -0.0136702000015
Gc32_682 0 n64 ns682 0 0.000470321685669
Gc32_683 0 n64 ns683 0 -6.00706689893e-06
Gc32_684 0 n64 ns684 0 -2.47461441807e-05
Gc32_685 0 n64 ns685 0 0.000127402571085
Gc32_686 0 n64 ns686 0 -0.000235953893346
Gc32_687 0 n64 ns687 0 -0.0014235163331
Gc32_688 0 n64 ns688 0 -0.000129160035426
Gc32_689 0 n64 ns689 0 -8.51342263983e-05
Gc32_690 0 n64 ns690 0 2.35499947624e-06
Gc32_691 0 n64 ns691 0 -4.95153960343e-05
Gc32_692 0 n64 ns692 0 -1.20583072907e-05
Gc32_693 0 n64 ns693 0 -1.4638041274e-05
Gc32_694 0 n64 ns694 0 -8.23060037224e-05
Gc32_695 0 n64 ns695 0 0.00108071520115
Gc32_696 0 n64 ns696 0 -3.01561640094e-05
Gc32_697 0 n64 ns697 0 -0.000554068754924
Gc32_698 0 n64 ns698 0 -0.000160112967511
Gc32_699 0 n64 ns699 0 5.29787428716e-05
Gc32_700 0 n64 ns700 0 -0.000388342758671
Gc32_701 0 n64 ns701 0 0.000873475326263
Gc32_702 0 n64 ns702 0 0.000632336631881
Gc32_703 0 n64 ns703 0 -3.60649997541e-05
Gc32_704 0 n64 ns704 0 -1.17699736513e-05
Gc32_705 0 n64 ns705 0 -0.000174266806559
Gc32_706 0 n64 ns706 0 0.00108947995279
Gc32_707 0 n64 ns707 0 0.000945433719411
Gc32_708 0 n64 ns708 0 0.000641436743244
Gc32_709 0 n64 ns709 0 -0.000564826457034
Gc32_710 0 n64 ns710 0 -0.00055602412301
Gc32_711 0 n64 ns711 0 6.52269617988e-05
Gc32_712 0 n64 ns712 0 0.00112751336349
Gc32_713 0 n64 ns713 0 0.000637520949753
Gc32_714 0 n64 ns714 0 0.000242700171114
Gc32_715 0 n64 ns715 0 -6.94821076836e-05
Gc32_716 0 n64 ns716 0 -6.30302440218e-05
Gc32_717 0 n64 ns717 0 -0.00023232630898
Gc32_718 0 n64 ns718 0 0.013750534345
Gc32_719 0 n64 ns719 0 -0.0117744776428
Gc32_720 0 n64 ns720 0 0.000427244772631
Gc32_721 0 n64 ns721 0 -4.9159898174e-06
Gc32_722 0 n64 ns722 0 -3.03465718337e-05
Gc32_723 0 n64 ns723 0 0.000378245052056
Gc32_724 0 n64 ns724 0 -0.000870699293863
Gc32_725 0 n64 ns725 0 0.00248447921969
Gc32_726 0 n64 ns726 0 5.94276464002e-05
Gc32_727 0 n64 ns727 0 0.000203718479264
Gc32_728 0 n64 ns728 0 0.000284250306363
Gc32_729 0 n64 ns729 0 2.03694314893e-06
Gc32_730 0 n64 ns730 0 2.93457878299e-06
Gc32_731 0 n64 ns731 0 -3.50436055992e-05
Gc32_732 0 n64 ns732 0 -0.00120412872618
Gc32_733 0 n64 ns733 0 -0.000512941483603
Gc32_734 0 n64 ns734 0 0.000811792800854
Gc32_735 0 n64 ns735 0 -7.86907110345e-05
Gc32_736 0 n64 ns736 0 -0.000144621411786
Gc32_737 0 n64 ns737 0 -0.000162271645768
Gc32_738 0 n64 ns738 0 -0.00125585414454
Gc32_739 0 n64 ns739 0 -0.000661293180743
Gc32_740 0 n64 ns740 0 0.000241927370213
Gc32_741 0 n64 ns741 0 0.000920456376086
Gc32_742 0 n64 ns742 0 0.000183998281352
Gc32_743 0 n64 ns743 0 -0.000117381282865
Gc32_744 0 n64 ns744 0 -0.000803636654197
Gc32_745 0 n64 ns745 0 0.00100553127161
Gc32_746 0 n64 ns746 0 0.00103922405257
Gc32_747 0 n64 ns747 0 0.000384364240146
Gc32_748 0 n64 ns748 0 -0.000532765006407
Gc32_749 0 n64 ns749 0 -0.00053270437703
Gc32_750 0 n64 ns750 0 -0.0010647844664
Gc32_751 0 n64 ns751 0 0.000159766140994
Gc32_752 0 n64 ns752 0 0.000366167600072
Gc32_753 0 n64 ns753 0 0.000764305699407
Gc32_754 0 n64 ns754 0 0.000246850300187
Gc32_755 0 n64 ns755 0 -0.000393154377689
Gc32_756 0 n64 ns756 0 0.00260670525185
Gc32_757 0 n64 ns757 0 -0.00299253251998
Gc32_758 0 n64 ns758 0 0.000247322090433
Gc32_759 0 n64 ns759 0 -3.93967786624e-06
Gc32_760 0 n64 ns760 0 -2.51695500954e-05
Gc32_761 0 n64 ns761 0 -0.000373002261483
Gc32_762 0 n64 ns762 0 0.000611534900163
Gc32_763 0 n64 ns763 0 0.00103361357475
Gc32_764 0 n64 ns764 0 -4.85896740044e-05
Gc32_765 0 n64 ns765 0 0.000139837693324
Gc32_766 0 n64 ns766 0 -3.4144570783e-05
Gc32_767 0 n64 ns767 0 0.000141768053453
Gc32_768 0 n64 ns768 0 -3.00541442475e-06
Gc32_769 0 n64 ns769 0 2.22815829625e-06
Gc32_770 0 n64 ns770 0 1.53719601081e-05
Gc32_771 0 n64 ns771 0 -0.000605675223673
Gc32_772 0 n64 ns772 0 0.000485758184396
Gc32_773 0 n64 ns773 0 0.000630400068257
Gc32_774 0 n64 ns774 0 -2.54832386175e-05
Gc32_775 0 n64 ns775 0 -0.000318940413347
Gc32_776 0 n64 ns776 0 0.000425923218998
Gc32_777 0 n64 ns777 0 -0.00155467640755
Gc32_778 0 n64 ns778 0 -0.00090818163556
Gc32_779 0 n64 ns779 0 0.000801989078004
Gc32_780 0 n64 ns780 0 0.00025392577461
Gc32_781 0 n64 ns781 0 3.37100375104e-05
Gc32_782 0 n64 ns782 0 -0.00127934047034
Gc32_783 0 n64 ns783 0 -0.000451410529051
Gc32_784 0 n64 ns784 0 0.000425625375671
Gc32_785 0 n64 ns785 0 0.00148737836661
Gc32_786 0 n64 ns786 0 7.68054555178e-06
Gc32_787 0 n64 ns787 0 -0.0010786037296
Gc32_788 0 n64 ns788 0 -0.00216416082592
Gc32_789 0 n64 ns789 0 -0.000591073056331
Gc32_790 0 n64 ns790 0 0.000306845357386
Gc32_791 0 n64 ns791 0 0.00167394712531
Gc32_792 0 n64 ns792 0 0.000654430953891
Gc32_793 0 n64 ns793 0 -0.000646509683882
Gc32_794 0 n64 ns794 0 0.00543544599855
Gc32_795 0 n64 ns795 0 -0.00620828899186
Gc32_796 0 n64 ns796 0 0.000541497260354
Gc32_797 0 n64 ns797 0 -6.50448308753e-06
Gc32_798 0 n64 ns798 0 -6.32684282886e-06
Gc32_799 0 n64 ns799 0 -0.00128710292365
Gc32_800 0 n64 ns800 0 0.00259019810828
Gc32_801 0 n64 ns801 0 -0.00362931057204
Gc32_802 0 n64 ns802 0 -5.80049243095e-05
Gc32_803 0 n64 ns803 0 -0.000321750638347
Gc32_804 0 n64 ns804 0 -0.00016562842467
Gc32_805 0 n64 ns805 0 -0.000235209699722
Gc32_806 0 n64 ns806 0 -3.58067287154e-05
Gc32_807 0 n64 ns807 0 7.31497220174e-06
Gc32_808 0 n64 ns808 0 -0.00016361089893
Gc32_809 0 n64 ns809 0 0.00143970968316
Gc32_810 0 n64 ns810 0 -0.000350330845788
Gc32_811 0 n64 ns811 0 0.000156863115599
Gc32_812 0 n64 ns812 0 0.000122910095666
Gc32_813 0 n64 ns813 0 -0.00035362758912
Gc32_814 0 n64 ns814 0 0.00138060938257
Gc32_815 0 n64 ns815 0 0.0010772834556
Gc32_816 0 n64 ns816 0 -0.000804113592994
Gc32_817 0 n64 ns817 0 -0.000566647128254
Gc32_818 0 n64 ns818 0 0.000233517362235
Gc32_819 0 n64 ns819 0 5.0649820772e-05
Gc32_820 0 n64 ns820 0 0.0013120070457
Gc32_821 0 n64 ns821 0 0.000243062215802
Gc32_822 0 n64 ns822 0 -0.000545726377135
Gc32_823 0 n64 ns823 0 0.00106146484151
Gc32_824 0 n64 ns824 0 0.000530753561063
Gc32_825 0 n64 ns825 0 -0.00105772850844
Gc32_826 0 n64 ns826 0 0.00105505912902
Gc32_827 0 n64 ns827 0 -0.000692259135336
Gc32_828 0 n64 ns828 0 -0.00101738288599
Gc32_829 0 n64 ns829 0 0.00158867404707
Gc32_830 0 n64 ns830 0 0.00112282976941
Gc32_831 0 n64 ns831 0 -0.000556754532897
Gc32_832 0 n64 ns832 0 0.027772508756
Gc32_833 0 n64 ns833 0 -0.0259251551493
Gc32_834 0 n64 ns834 0 0.00152083064476
Gc32_835 0 n64 ns835 0 -7.382076624e-06
Gc32_836 0 n64 ns836 0 1.5663483562e-05
Gc32_837 0 n64 ns837 0 -0.00156500013777
Gc32_838 0 n64 ns838 0 0.000919551333015
Gc32_839 0 n64 ns839 0 -0.00146395099061
Gc32_840 0 n64 ns840 0 0.000689418765745
Gc32_841 0 n64 ns841 0 -0.000751144206154
Gc32_842 0 n64 ns842 0 0.000549389379385
Gc32_843 0 n64 ns843 0 -0.000124836056416
Gc32_844 0 n64 ns844 0 -0.000121359293686
Gc32_845 0 n64 ns845 0 -2.03627318289e-05
Gc32_846 0 n64 ns846 0 -0.00240447829353
Gc32_847 0 n64 ns847 0 0.000406320601112
Gc32_848 0 n64 ns848 0 0.000334431614834
Gc32_849 0 n64 ns849 0 -0.000584943387387
Gc32_850 0 n64 ns850 0 0.000337900552175
Gc32_851 0 n64 ns851 0 -0.000368837200863
Gc32_852 0 n64 ns852 0 -0.00163819691775
Gc32_853 0 n64 ns853 0 0.00102693844956
Gc32_854 0 n64 ns854 0 0.000245581258338
Gc32_855 0 n64 ns855 0 -0.000537267430409
Gc32_856 0 n64 ns856 0 0.000338385509213
Gc32_857 0 n64 ns857 0 0.000163151915742
Gc32_858 0 n64 ns858 0 -0.000557450098901
Gc32_859 0 n64 ns859 0 0.00321732021522
Gc32_860 0 n64 ns860 0 2.96463539032e-05
Gc32_861 0 n64 ns861 0 0.000115921933161
Gc32_862 0 n64 ns862 0 0.000694178708084
Gc32_863 0 n64 ns863 0 -0.000963347666426
Gc32_864 0 n64 ns864 0 0.00207160868274
Gc32_865 0 n64 ns865 0 0.00196897320545
Gc32_866 0 n64 ns866 0 -0.00230330709951
Gc32_867 0 n64 ns867 0 -4.91029446631e-05
Gc32_868 0 n64 ns868 0 0.00166808054371
Gc32_869 0 n64 ns869 0 6.20826709074e-05
Gc32_870 0 n64 ns870 0 0.0471008113851
Gc32_871 0 n64 ns871 0 -0.0462488667096
Gc32_872 0 n64 ns872 0 0.0036503708843
Gc32_873 0 n64 ns873 0 -4.66085222909e-07
Gc32_874 0 n64 ns874 0 2.8208732797e-05
Gc32_875 0 n64 ns875 0 -0.00452005689971
Gc32_876 0 n64 ns876 0 -0.00244006205053
Gc32_877 0 n64 ns877 0 -0.00116036911985
Gc32_878 0 n64 ns878 0 0.000834663278901
Gc32_879 0 n64 ns879 0 -0.00138829361981
Gc32_880 0 n64 ns880 0 -3.11808514131e-05
Gc32_881 0 n64 ns881 0 0.000940839924552
Gc32_882 0 n64 ns882 0 -9.21392244351e-05
Gc32_883 0 n64 ns883 0 -5.68087200004e-05
Gc32_884 0 n64 ns884 0 -0.000922309319597
Gc32_885 0 n64 ns885 0 0.000633509151309
Gc32_886 0 n64 ns886 0 0.000860580399467
Gc32_887 0 n64 ns887 0 -0.00056832195541
Gc32_888 0 n64 ns888 0 0.00033490606317
Gc32_889 0 n64 ns889 0 -0.000234185281825
Gc32_890 0 n64 ns890 0 -0.000832696284771
Gc32_891 0 n64 ns891 0 -0.0011599863573
Gc32_892 0 n64 ns892 0 0.000497638683391
Gc32_893 0 n64 ns893 0 -1.88750660092e-05
Gc32_894 0 n64 ns894 0 0.000274223524615
Gc32_895 0 n64 ns895 0 0.000289843755779
Gc32_896 0 n64 ns896 0 -0.00275150051185
Gc32_897 0 n64 ns897 0 0.00139063465089
Gc32_898 0 n64 ns898 0 0.0012438612663
Gc32_899 0 n64 ns899 0 0.00117057073562
Gc32_900 0 n64 ns900 0 0.00108175224391
Gc32_901 0 n64 ns901 0 -0.00126316333826
Gc32_902 0 n64 ns902 0 0.000449978869854
Gc32_903 0 n64 ns903 0 0.00214372244078
Gc32_904 0 n64 ns904 0 -1.02572098665e-05
Gc32_905 0 n64 ns905 0 -0.00130532619033
Gc32_906 0 n64 ns906 0 0.00222659770146
Gc32_907 0 n64 ns907 0 0.000640606876517
Gc32_908 0 n64 ns908 0 0.0171627052898
Gc32_909 0 n64 ns909 0 -0.0177825589103
Gc32_910 0 n64 ns910 0 0.00649635171908
Gc32_911 0 n64 ns911 0 -2.67759462931e-06
Gc32_912 0 n64 ns912 0 2.64843721745e-05
Gc32_913 0 n64 ns913 0 -0.00575442312921
Gc32_914 0 n64 ns914 0 -0.00343033791914
Gc32_915 0 n64 ns915 0 -0.00385116958433
Gc32_916 0 n64 ns916 0 0.000390783565614
Gc32_917 0 n64 ns917 0 -0.00152078968019
Gc32_918 0 n64 ns918 0 -0.000784934604684
Gc32_919 0 n64 ns919 0 0.000740030859058
Gc32_920 0 n64 ns920 0 -2.72514447368e-05
Gc32_921 0 n64 ns921 0 -5.98004761571e-05
Gc32_922 0 n64 ns922 0 -0.00036897467232
Gc32_923 0 n64 ns923 0 0.00268296066888
Gc32_924 0 n64 ns924 0 0.000559556130389
Gc32_925 0 n64 ns925 0 -0.000284917426868
Gc32_926 0 n64 ns926 0 0.000186079677712
Gc32_927 0 n64 ns927 0 -9.78786902131e-05
Gc32_928 0 n64 ns928 0 0.00155683670711
Gc32_929 0 n64 ns929 0 0.0007800530471
Gc32_930 0 n64 ns930 0 0.000744859327602
Gc32_931 0 n64 ns931 0 -9.87247662862e-05
Gc32_932 0 n64 ns932 0 0.000174613782784
Gc32_933 0 n64 ns933 0 0.000133219919817
Gc32_934 0 n64 ns934 0 0.00126833693226
Gc32_935 0 n64 ns935 0 -0.00115163792295
Gc32_936 0 n64 ns936 0 0.00112778291351
Gc32_937 0 n64 ns937 0 0.00203354145669
Gc32_938 0 n64 ns938 0 0.00119844075853
Gc32_939 0 n64 ns939 0 -0.00113549893545
Gc32_940 0 n64 ns940 0 0.000935794916551
Gc32_941 0 n64 ns941 0 -0.00195072510537
Gc32_942 0 n64 ns942 0 0.00314148621747
Gc32_943 0 n64 ns943 0 -0.000135347736733
Gc32_944 0 n64 ns944 0 0.00217586220698
Gc32_945 0 n64 ns945 0 0.00042075827605
Gc32_946 0 n64 ns946 0 -0.0408957710875
Gc32_947 0 n64 ns947 0 0.0422241343908
Gc32_948 0 n64 ns948 0 0.00599427628676
Gc32_949 0 n64 ns949 0 -4.82884858758e-06
Gc32_950 0 n64 ns950 0 2.16806720045e-05
Gc32_951 0 n64 ns951 0 -3.46941367661e-05
Gc32_952 0 n64 ns952 0 0.000214868700608
Gc32_953 0 n64 ns953 0 -0.00295984591313
Gc32_954 0 n64 ns954 0 -0.000248727815513
Gc32_955 0 n64 ns955 0 -0.0001792254086
Gc32_956 0 n64 ns956 0 -0.000162160645681
Gc32_957 0 n64 ns957 0 1.97632399155e-05
Gc32_958 0 n64 ns958 0 4.66689835598e-07
Gc32_959 0 n64 ns959 0 1.30169709245e-05
Gc32_960 0 n64 ns960 0 0.000647710493301
Gc32_961 0 n64 ns961 0 0.00129529266729
Gc32_962 0 n64 ns962 0 -0.000371265748113
Gc32_963 0 n64 ns963 0 -0.000472983930502
Gc32_964 0 n64 ns964 0 -0.00012502357601
Gc32_965 0 n64 ns965 0 0.000112454692029
Gc32_966 0 n64 ns966 0 6.86961970895e-05
Gc32_967 0 n64 ns967 0 0.00101092983923
Gc32_968 0 n64 ns968 0 0.000531336565282
Gc32_969 0 n64 ns969 0 -0.00027561080882
Gc32_970 0 n64 ns970 0 -5.54660677169e-05
Gc32_971 0 n64 ns971 0 -0.000147513749531
Gc32_972 0 n64 ns972 0 0.00144484579824
Gc32_973 0 n64 ns973 0 0.000781537908976
Gc32_974 0 n64 ns974 0 0.000483006010501
Gc32_975 0 n64 ns975 0 -0.000678763163787
Gc32_976 0 n64 ns976 0 -0.000493771571805
Gc32_977 0 n64 ns977 0 0.00016232076868
Gc32_978 0 n64 ns978 0 0.00176726963456
Gc32_979 0 n64 ns979 0 0.000819684534224
Gc32_980 0 n64 ns980 0 0.00019112232353
Gc32_981 0 n64 ns981 0 -0.000324215042466
Gc32_982 0 n64 ns982 0 -0.000145181492881
Gc32_983 0 n64 ns983 0 -0.000184629235928
Gc32_984 0 n64 ns984 0 0.0172831074867
Gc32_985 0 n64 ns985 0 -0.0145906122445
Gc32_986 0 n64 ns986 0 0.000495337703284
Gc32_987 0 n64 ns987 0 -5.21526198802e-06
Gc32_988 0 n64 ns988 0 -2.80085668223e-05
Gc32_989 0 n64 ns989 0 0.000362629668764
Gc32_990 0 n64 ns990 0 -0.00101527327383
Gc32_991 0 n64 ns991 0 0.000949373875745
Gc32_992 0 n64 ns992 0 9.15963313893e-05
Gc32_993 0 n64 ns993 0 -8.86512000289e-05
Gc32_994 0 n64 ns994 0 8.54230330976e-05
Gc32_995 0 n64 ns995 0 -5.2523360244e-05
Gc32_996 0 n64 ns996 0 1.05191893272e-05
Gc32_997 0 n64 ns997 0 -2.0719337361e-05
Gc32_998 0 n64 ns998 0 -0.00097664924671
Gc32_999 0 n64 ns999 0 0.000401985749395
Gc32_1000 0 n64 ns1000 0 0.000485457895935
Gc32_1001 0 n64 ns1001 0 -0.000416636291741
Gc32_1002 0 n64 ns1002 0 -0.000172670392686
Gc32_1003 0 n64 ns1003 0 -6.46126282734e-05
Gc32_1004 0 n64 ns1004 0 -0.00111387071706
Gc32_1005 0 n64 ns1005 0 0.000203897604009
Gc32_1006 0 n64 ns1006 0 0.000570196495311
Gc32_1007 0 n64 ns1007 0 0.00053666189941
Gc32_1008 0 n64 ns1008 0 0.000109559221972
Gc32_1009 0 n64 ns1009 0 -0.000168475485026
Gc32_1010 0 n64 ns1010 0 0.000132618069151
Gc32_1011 0 n64 ns1011 0 0.00128200053548
Gc32_1012 0 n64 ns1012 0 0.000972434113443
Gc32_1013 0 n64 ns1013 0 -0.000125298556022
Gc32_1014 0 n64 ns1014 0 -0.000614966852852
Gc32_1015 0 n64 ns1015 0 -0.000254539408265
Gc32_1016 0 n64 ns1016 0 0.00011008521758
Gc32_1017 0 n64 ns1017 0 0.000735145129152
Gc32_1018 0 n64 ns1018 0 0.000410208847734
Gc32_1019 0 n64 ns1019 0 0.000277542339062
Gc32_1020 0 n64 ns1020 0 5.45722338158e-05
Gc32_1021 0 n64 ns1021 0 -0.000352683352917
Gc32_1022 0 n64 ns1022 0 0.0100260601001
Gc32_1023 0 n64 ns1023 0 -0.00899656430688
Gc32_1024 0 n64 ns1024 0 0.000388594274756
Gc32_1025 0 n64 ns1025 0 -3.96423007891e-06
Gc32_1026 0 n64 ns1026 0 -3.03838804216e-05
Gc32_1027 0 n64 ns1027 0 0.00011366062027
Gc32_1028 0 n64 ns1028 0 -0.00075275832865
Gc32_1029 0 n64 ns1029 0 0.00273887755278
Gc32_1030 0 n64 ns1030 0 0.000121979859661
Gc32_1031 0 n64 ns1031 0 2.05392663336e-05
Gc32_1032 0 n64 ns1032 0 1.1776788815e-05
Gc32_1033 0 n64 ns1033 0 9.04823874552e-05
Gc32_1034 0 n64 ns1034 0 1.4595451519e-05
Gc32_1035 0 n64 ns1035 0 1.11530411925e-05
Gc32_1036 0 n64 ns1036 0 -0.000703259390222
Gc32_1037 0 n64 ns1037 0 -0.000658670788028
Gc32_1038 0 n64 ns1038 0 0.000748259213235
Gc32_1039 0 n64 ns1039 0 0.000339874733554
Gc32_1040 0 n64 ns1040 0 -8.94989442776e-05
Gc32_1041 0 n64 ns1041 0 -0.000269390448653
Gc32_1042 0 n64 ns1042 0 -0.000567066959712
Gc32_1043 0 n64 ns1043 0 -0.00143052080803
Gc32_1044 0 n64 ns1044 0 -0.000412555206257
Gc32_1045 0 n64 ns1045 0 0.00106144874918
Gc32_1046 0 n64 ns1046 0 0.000256403486521
Gc32_1047 0 n64 ns1047 0 -2.46411049828e-05
Gc32_1048 0 n64 ns1048 0 -0.00145982556574
Gc32_1049 0 n64 ns1049 0 0.000345438056688
Gc32_1050 0 n64 ns1050 0 0.000821243802391
Gc32_1051 0 n64 ns1051 0 0.00112709407069
Gc32_1052 0 n64 ns1052 0 -0.000252600674649
Gc32_1053 0 n64 ns1053 0 -0.000912944278489
Gc32_1054 0 n64 ns1054 0 -0.00200530815722
Gc32_1055 0 n64 ns1055 0 8.64122726708e-05
Gc32_1056 0 n64 ns1056 0 0.000499452569427
Gc32_1057 0 n64 ns1057 0 0.00126843898743
Gc32_1058 0 n64 ns1058 0 0.00045415122561
Gc32_1059 0 n64 ns1059 0 -0.000583457263693
Gc32_1060 0 n64 ns1060 0 0.00410225112675
Gc32_1061 0 n64 ns1061 0 -0.00484599943437
Gc32_1062 0 n64 ns1062 0 0.000418656871061
Gc32_1063 0 n64 ns1063 0 -5.00088917912e-06
Gc32_1064 0 n64 ns1064 0 -1.82156853869e-05
Gc32_1065 0 n64 ns1065 0 -0.000869835039956
Gc32_1066 0 n64 ns1066 0 0.00214763089906
Gc32_1067 0 n64 ns1067 0 -0.0023856821546
Gc32_1068 0 n64 ns1068 0 -0.000177500875877
Gc32_1069 0 n64 ns1069 0 -0.000146428036136
Gc32_1070 0 n64 ns1070 0 -0.000267340681804
Gc32_1071 0 n64 ns1071 0 -9.09801627441e-05
Gc32_1072 0 n64 ns1072 0 -1.98236681697e-05
Gc32_1073 0 n64 ns1073 0 1.72135912742e-05
Gc32_1074 0 n64 ns1074 0 0.000232382284456
Gc32_1075 0 n64 ns1075 0 0.000968749640578
Gc32_1076 0 n64 ns1076 0 -9.33339381032e-05
Gc32_1077 0 n64 ns1077 0 0.000405857859044
Gc32_1078 0 n64 ns1078 0 3.72598468993e-05
Gc32_1079 0 n64 ns1079 0 -0.000347194495704
Gc32_1080 0 n64 ns1080 0 0.00147118847745
Gc32_1081 0 n64 ns1081 0 5.17175712787e-05
Gc32_1082 0 n64 ns1082 0 -0.000965449021969
Gc32_1083 0 n64 ns1083 0 -7.83360737052e-05
Gc32_1084 0 n64 ns1084 0 0.000227919601005
Gc32_1085 0 n64 ns1085 0 3.69428062172e-05
Gc32_1086 0 n64 ns1086 0 0.000507977140642
Gc32_1087 0 n64 ns1087 0 -0.00041072793096
Gc32_1088 0 n64 ns1088 0 -0.000254387919264
Gc32_1089 0 n64 ns1089 0 0.00134781676957
Gc32_1090 0 n64 ns1090 0 0.000356014624643
Gc32_1091 0 n64 ns1091 0 -0.00109204725339
Gc32_1092 0 n64 ns1092 0 -0.000212225556241
Gc32_1093 0 n64 ns1093 0 -0.000868732201188
Gc32_1094 0 n64 ns1094 0 -0.000438475988767
Gc32_1095 0 n64 ns1095 0 0.00173403886099
Gc32_1096 0 n64 ns1096 0 0.000925100071605
Gc32_1097 0 n64 ns1097 0 -0.000630500628829
Gc32_1098 0 n64 ns1098 0 0.0191469346393
Gc32_1099 0 n64 ns1099 0 -0.0181569322821
Gc32_1100 0 n64 ns1100 0 0.00108122557113
Gc32_1101 0 n64 ns1101 0 -8.2042687369e-06
Gc32_1102 0 n64 ns1102 0 4.79644474677e-06
Gc32_1103 0 n64 ns1103 0 -0.00147283439973
Gc32_1104 0 n64 ns1104 0 0.00169542524186
Gc32_1105 0 n64 ns1105 0 -0.00274798312334
Gc32_1106 0 n64 ns1106 0 0.00046883300226
Gc32_1107 0 n64 ns1107 0 -0.000696871695608
Gc32_1108 0 n64 ns1108 0 0.000262058717215
Gc32_1109 0 n64 ns1109 0 -0.000246159240719
Gc32_1110 0 n64 ns1110 0 -6.43873481874e-05
Gc32_1111 0 n64 ns1111 0 -9.90269504148e-06
Gc32_1112 0 n64 ns1112 0 -0.00177507932779
Gc32_1113 0 n64 ns1113 0 0.000847732428591
Gc32_1114 0 n64 ns1114 0 -7.05450050392e-05
Gc32_1115 0 n64 ns1115 0 -0.00032585380282
Gc32_1116 0 n64 ns1116 0 0.000246311733756
Gc32_1117 0 n64 ns1117 0 -0.000360383716868
Gc32_1118 0 n64 ns1118 0 -0.00079762828709
Gc32_1119 0 n64 ns1119 0 0.0015796378868
Gc32_1120 0 n64 ns1120 0 -9.23247964806e-05
Gc32_1121 0 n64 ns1121 0 -0.000572689716725
Gc32_1122 0 n64 ns1122 0 0.000317301244506
Gc32_1123 0 n64 ns1123 0 0.000109976576407
Gc32_1124 0 n64 ns1124 0 0.000710096480159
Gc32_1125 0 n64 ns1125 0 0.00288163659705
Gc32_1126 0 n64 ns1126 0 -0.000246726990962
Gc32_1127 0 n64 ns1127 0 0.000373572842862
Gc32_1128 0 n64 ns1128 0 0.000614564002603
Gc32_1129 0 n64 ns1129 0 -0.000995498311639
Gc32_1130 0 n64 ns1130 0 0.00289447386451
Gc32_1131 0 n64 ns1131 0 0.00139956286748
Gc32_1132 0 n64 ns1132 0 -0.00203613344188
Gc32_1133 0 n64 ns1133 0 0.000535119811354
Gc32_1134 0 n64 ns1134 0 0.00143648639403
Gc32_1135 0 n64 ns1135 0 -0.000210746547713
Gc32_1136 0 n64 ns1136 0 0.0451098239572
Gc32_1137 0 n64 ns1137 0 -0.0426000999661
Gc32_1138 0 n64 ns1138 0 0.00272324728336
Gc32_1139 0 n64 ns1139 0 -3.10222633087e-06
Gc32_1140 0 n64 ns1140 0 2.2304790142e-05
Gc32_1141 0 n64 ns1141 0 -0.00176415106422
Gc32_1142 0 n64 ns1142 0 -0.00237909432639
Gc32_1143 0 n64 ns1143 0 0.0055867697957
Gc32_1144 0 n64 ns1144 0 0.00069655113424
Gc32_1145 0 n64 ns1145 0 -0.000469832922621
Gc32_1146 0 n64 ns1146 0 0.000727985713505
Gc32_1147 0 n64 ns1147 0 0.000343451917086
Gc32_1148 0 n64 ns1148 0 -0.000147225640287
Gc32_1149 0 n64 ns1149 0 -8.38362601153e-05
Gc32_1150 0 n64 ns1150 0 -0.00188282337391
Gc32_1151 0 n64 ns1151 0 -0.00100776075838
Gc32_1152 0 n64 ns1152 0 0.00088560080318
Gc32_1153 0 n64 ns1153 0 -0.00017429103871
Gc32_1154 0 n64 ns1154 0 0.000487728585519
Gc32_1155 0 n64 ns1155 0 -0.0002845557349
Gc32_1156 0 n64 ns1156 0 -0.000835254937184
Gc32_1157 0 n64 ns1157 0 -0.00159381944225
Gc32_1158 0 n64 ns1158 0 -1.9932339926e-06
Gc32_1159 0 n64 ns1159 0 -0.000251017503984
Gc32_1160 0 n64 ns1160 0 0.000246241821756
Gc32_1161 0 n64 ns1161 0 0.000341500535968
Gc32_1162 0 n64 ns1162 0 -0.00418518328651
Gc32_1163 0 n64 ns1163 0 -0.000446108326345
Gc32_1164 0 n64 ns1164 0 0.000264149952131
Gc32_1165 0 n64 ns1165 0 0.000768189462422
Gc32_1166 0 n64 ns1166 0 0.00117592221409
Gc32_1167 0 n64 ns1167 0 -0.000964873294033
Gc32_1168 0 n64 ns1168 0 -0.00501122032859
Gc32_1169 0 n64 ns1169 0 -0.000664955097771
Gc32_1170 0 n64 ns1170 0 -0.00177457439649
Gc32_1171 0 n64 ns1171 0 -9.81867423041e-05
Gc32_1172 0 n64 ns1172 0 0.00234272899684
Gc32_1173 0 n64 ns1173 0 0.000738170574075
Gc32_1174 0 n64 ns1174 0 0.0139863567431
Gc32_1175 0 n64 ns1175 0 -0.0226232510311
Gc32_1176 0 n64 ns1176 0 0.00537123157294
Gc32_1177 0 n64 ns1177 0 2.37573826306e-06
Gc32_1178 0 n64 ns1178 0 3.29894057094e-05
Gc32_1179 0 n64 ns1179 0 -0.00351421687038
Gc32_1180 0 n64 ns1180 0 -0.00165866761222
Gc32_1181 0 n64 ns1181 0 0.000420706009359
Gc32_1182 0 n64 ns1182 0 0.000730451935243
Gc32_1183 0 n64 ns1183 0 -0.000369257995368
Gc32_1184 0 n64 ns1184 0 0.000146899989399
Gc32_1185 0 n64 ns1185 0 0.000346584991276
Gc32_1186 0 n64 ns1186 0 -0.000195010022531
Gc32_1187 0 n64 ns1187 0 -0.000141519179621
Gc32_1188 0 n64 ns1188 0 -0.00255423888058
Gc32_1189 0 n64 ns1189 0 0.000754422338444
Gc32_1190 0 n64 ns1190 0 0.00142686579203
Gc32_1191 0 n64 ns1191 0 -8.75928734236e-05
Gc32_1192 0 n64 ns1192 0 0.000415840420666
Gc32_1193 0 n64 ns1193 0 -0.000271252253433
Gc32_1194 0 n64 ns1194 0 0.000497813127575
Gc32_1195 0 n64 ns1195 0 -0.000433926562769
Gc32_1196 0 n64 ns1196 0 0.000506982404362
Gc32_1197 0 n64 ns1197 0 0.000298305983398
Gc32_1198 0 n64 ns1198 0 0.000280273498257
Gc32_1199 0 n64 ns1199 0 0.000300532375528
Gc32_1200 0 n64 ns1200 0 -0.00134931976515
Gc32_1201 0 n64 ns1201 0 -0.00138949854354
Gc32_1202 0 n64 ns1202 0 0.00113570547661
Gc32_1203 0 n64 ns1203 0 0.00244555447891
Gc32_1204 0 n64 ns1204 0 0.00148147405041
Gc32_1205 0 n64 ns1205 0 -0.00137133103795
Gc32_1206 0 n64 ns1206 0 -0.00299841833862
Gc32_1207 0 n64 ns1207 0 -0.00261495718741
Gc32_1208 0 n64 ns1208 0 0.00270413275244
Gc32_1209 0 n64 ns1209 0 0.000502963575275
Gc32_1210 0 n64 ns1210 0 0.00272430449226
Gc32_1211 0 n64 ns1211 0 0.000598808649375
Gc32_1212 0 n64 ns1212 0 -0.0466636982869
Gc32_1213 0 n64 ns1213 0 0.0431744014397
Gc32_1214 0 n64 ns1214 0 0.00648544557908
Gc32_1215 0 n64 ns1215 0 9.10031659016e-06
Gc32_1216 0 n64 ns1216 0 2.97474071448e-05
Gd32_1 0 n64 ni1 0 -0.000129133697605
Gd32_2 0 n64 ni2 0 -0.000119510699236
Gd32_3 0 n64 ni3 0 -5.31801595773e-06
Gd32_4 0 n64 ni4 0 -7.28559331086e-05
Gd32_5 0 n64 ni5 0 4.96403338082e-05
Gd32_6 0 n64 ni6 0 0.000248536106564
Gd32_7 0 n64 ni7 0 -5.17842378153e-05
Gd32_8 0 n64 ni8 0 -0.00151685811098
Gd32_9 0 n64 ni9 0 -0.00317950285756
Gd32_10 0 n64 ni10 0 -1.04610348016e-05
Gd32_11 0 n64 ni11 0 -2.23527968012e-05
Gd32_12 0 n64 ni12 0 8.69271731313e-05
Gd32_13 0 n64 ni13 0 0.000149394300499
Gd32_14 0 n64 ni14 0 0.000574742870181
Gd32_15 0 n64 ni15 0 -0.000504684212556
Gd32_16 0 n64 ni16 0 -0.00654355875818
Gd32_17 0 n64 ni17 0 5.70718293973e-06
Gd32_18 0 n64 ni18 0 8.29698135492e-06
Gd32_19 0 n64 ni19 0 -4.09257768904e-05
Gd32_20 0 n64 ni20 0 0.000125431951029
Gd32_21 0 n64 ni21 0 0.000184338968316
Gd32_22 0 n64 ni22 0 0.000228911799937
Gd32_23 0 n64 ni23 0 -0.000626448581465
Gd32_24 0 n64 ni24 0 -0.00287726363626
Gd32_25 0 n64 ni25 0 -0.00275489025098
Gd32_26 0 n64 ni26 0 -8.00060686888e-05
Gd32_27 0 n64 ni27 0 -6.35752704889e-05
Gd32_28 0 n64 ni28 0 2.54710056933e-05
Gd32_29 0 n64 ni29 0 0.00034264850314
Gd32_30 0 n64 ni30 0 -0.00020360093053
Gd32_31 0 n64 ni31 0 -0.00171851844313
Gd32_32 0 n64 ni32 0 -0.000156625709476
.ends m16lines_HFSS_fws
